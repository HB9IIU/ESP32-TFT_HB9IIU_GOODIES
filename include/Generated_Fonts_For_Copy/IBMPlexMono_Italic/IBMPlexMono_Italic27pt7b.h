#ifndef _IBMPLEXMONO_ITALIC27PT7B_H_
#define _IBMPLEXMONO_ITALIC27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x31, 0xC7, 0x18, 0x61, 0x86, 0x10, 0x41, 0x04, 0x00, 0x00,
  0x1C, 0xF3, 0xCF, 0x00, 0x63, 0x66, 0xE6, 0xC6, 0xC6, 0xC6, 0xCE, 0x00,
  0xC6, 0x00, 0x63, 0x00, 0x63, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x18, 0xC0,
  0xFC, 0x7E, 0x7E, 0x3F, 0x06, 0x30, 0x03, 0x18, 0x01, 0x8C, 0x0F, 0x8F,
  0xCF, 0xC7, 0xE0, 0x63, 0x00, 0x63, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x18,
  0xC0, 0x0C, 0x60, 0x00, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x3F, 0x80,
  0xFF, 0x83, 0x93, 0x8E, 0x23, 0x98, 0xC0, 0x31, 0x80, 0x63, 0x00, 0xE6,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xCE, 0x01, 0x8C, 0x03, 0x19,
  0x04, 0x33, 0x08, 0xE7, 0xB3, 0x87, 0xFE, 0x03, 0xF0, 0x01, 0x80, 0x02,
  0x00, 0x04, 0x00, 0x07, 0x80, 0xE1, 0xF8, 0x18, 0x71, 0x86, 0x0C, 0x31,
  0x81, 0x86, 0x30, 0x20, 0xCC, 0x06, 0x33, 0x00, 0xFE, 0x40, 0x0F, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x01, 0x9F, 0x80, 0x66, 0x30, 0x19, 0x82,
  0x06, 0x30, 0xC0, 0xC6, 0x18, 0x30, 0xC7, 0x0C, 0x0F, 0xC3, 0x80, 0xF0,
  0x00, 0x01, 0xE0, 0x07, 0xF8, 0x0E, 0x38, 0x0C, 0x18, 0x0C, 0x18, 0x0C,
  0x18, 0x0C, 0x18, 0x06, 0x38, 0x0E, 0x70, 0x3F, 0xC0, 0x63, 0x00, 0xE1,
  0x80, 0xC1, 0x80, 0xC0, 0xC0, 0xC0, 0xC3, 0xC1, 0x66, 0xE1, 0x76, 0x7F,
  0x3C, 0x3E, 0x38, 0x6D, 0xBF, 0xB0, 0x01, 0xC1, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x03, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08,
  0x02, 0x00, 0x80, 0x30, 0x0C, 0x03, 0x00, 0x40, 0x18, 0x06, 0x00, 0xC0,
  0x1C, 0x00, 0x0E, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80,
  0x40, 0x30, 0x18, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x00, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x0C, 0x30, 0xFF, 0x7C, 0xFF, 0x81, 0xE0, 0x0F,
  0x00, 0xDC, 0x0C, 0x60, 0xE1, 0x8E, 0x0C, 0x00, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x83, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x3C, 0xE3, 0x9C, 0x61, 0x8C,
  0x30, 0x7F, 0xFF, 0x7F, 0xF7, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80,
  0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0x07, 0xE0, 0x7F, 0x87, 0x0E, 0x60, 0x37, 0x01,
  0xB0, 0x0D, 0x80, 0x7C, 0x03, 0xC7, 0x1E, 0x38, 0xF1, 0xC7, 0x80, 0x7C,
  0x03, 0x60, 0x1B, 0x01, 0xD8, 0x0C, 0xE1, 0xC3, 0xFC, 0x0F, 0xC0, 0x01,
  0xE0, 0x1F, 0x03, 0xF8, 0x3D, 0x83, 0x8C, 0x18, 0x60, 0x83, 0x00, 0x38,
  0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00,
  0x60, 0x03, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x3F, 0xE1, 0xC3, 0x8E,
  0x07, 0x30, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x03,
  0xFF, 0xEF, 0xFF, 0x00, 0x03, 0xE0, 0x3F, 0xE1, 0xC3, 0xC6, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0x80, 0x1C, 0x07, 0xE0, 0x1F, 0x80, 0x07, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0xE4, 0x03, 0x30, 0x0C, 0xE0, 0xE1, 0xFF, 0x01,
  0xF0, 0x00, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xF0, 0x07, 0x60, 0x0D, 0xC0,
  0x33, 0x00, 0xC6, 0x03, 0x0C, 0x0E, 0x18, 0x18, 0x30, 0x60, 0xE1, 0x81,
  0x86, 0x03, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x18, 0x00, 0x70, 0x00, 0xC0,
  0x01, 0x80, 0x0F, 0xFC, 0x3F, 0xF0, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x0C, 0xF8, 0x37, 0xF0, 0xE0, 0xE1, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x64, 0x03, 0x98, 0x0C, 0xF0, 0x70, 0xFF, 0x81, 0xF8, 0x00,
  0x00, 0xF0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x30, 0x07, 0x7C,
  0x6F, 0xEF, 0x07, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x06,
  0xE0, 0xE7, 0xFC, 0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x6C,
  0x06, 0x60, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0C,
  0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00,
  0x03, 0xF0, 0x3F, 0xE1, 0xC1, 0xC6, 0x03, 0x38, 0x0C, 0xC0, 0x33, 0x81,
  0xC7, 0x0E, 0x0F, 0xE0, 0x3F, 0x83, 0x83, 0x98, 0x06, 0xE0, 0x1B, 0x80,
  0x6C, 0x01, 0xB8, 0x0E, 0x70, 0x71, 0xFF, 0x81, 0xF8, 0x00, 0x07, 0xC0,
  0xFF, 0x8E, 0x0C, 0xE0, 0x36, 0x01, 0xB0, 0x0F, 0x80, 0x7C, 0x07, 0xE0,
  0x3B, 0x87, 0x9F, 0xEC, 0x3E, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x70,
  0x07, 0x00, 0xE0, 0x1E, 0x00, 0x1C, 0xF3, 0xCE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0xF3, 0xC7, 0x00, 0x0E, 0x3C, 0x78, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE3, 0x87, 0x1C, 0x30, 0x61, 0x83, 0x00, 0x00, 0x08,
  0x01, 0xC0, 0x1C, 0x03, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0x0C, 0x00, 0xF0,
  0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x80, 0x7F,
  0xFD, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xEF, 0xFF, 0x80,
  0x10, 0x00, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0,
  0x03, 0x00, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x30, 0x02, 0x00,
  0x00, 0x0F, 0xC3, 0xFE, 0x30, 0x76, 0x07, 0xE0, 0x30, 0x03, 0x00, 0x70,
  0x0E, 0x03, 0xC0, 0xF8, 0x0C, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x3C, 0x03, 0xC0, 0x38, 0x00, 0x07, 0xC0, 0xFF, 0x8E, 0x0E, 0x60,
  0x37, 0x01, 0xB0, 0x0D, 0x87, 0x78, 0xFF, 0xC6, 0x3E, 0x70, 0xF3, 0x05,
  0x98, 0x6C, 0xC3, 0x66, 0x1A, 0x31, 0xD1, 0xF6, 0xC7, 0xA6, 0x02, 0x30,
  0x01, 0xC0, 0x07, 0xF8, 0x0F, 0xC0, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00,
  0x6C, 0x01, 0xB0, 0x0C, 0xC0, 0x33, 0x81, 0x86, 0x06, 0x18, 0x38, 0x60,
  0xC1, 0x87, 0x06, 0x1F, 0xF8, 0xFF, 0xE3, 0x01, 0xDC, 0x07, 0x60, 0x0F,
  0x80, 0x3C, 0x00, 0xC0, 0x1F, 0xF0, 0x7F, 0xE1, 0x81, 0xC6, 0x03, 0x18,
  0x0C, 0xE0, 0x33, 0x01, 0xCC, 0x0E, 0x3F, 0xE0, 0xFF, 0xC3, 0x03, 0x9C,
  0x06, 0x70, 0x19, 0x80, 0x66, 0x01, 0x98, 0x0E, 0x60, 0x73, 0xFF, 0x8F,
  0xFC, 0x00, 0x03, 0xE0, 0x3F, 0xC1, 0xC3, 0x8E, 0x06, 0x30, 0x0D, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x8E, 0x03, 0x18, 0x1C, 0x70, 0xE0, 0xFF, 0x01, 0xF0, 0x00,
  0x0F, 0xE0, 0x7F, 0xC1, 0x83, 0x86, 0x07, 0x18, 0x0C, 0x60, 0x31, 0x80,
  0xCE, 0x03, 0x30, 0x0C, 0xC0, 0x33, 0x00, 0xCC, 0x07, 0x30, 0x19, 0xC0,
  0x66, 0x03, 0x98, 0x0C, 0x60, 0xE1, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xFE,
  0x3F, 0xFC, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0x1F, 0xFE,
  0x3F, 0xFC, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x03, 0xE0,
  0x7F, 0x87, 0x0E, 0x70, 0x37, 0x01, 0xB0, 0x01, 0x80, 0x1C, 0x00, 0xE0,
  0x06, 0x1F, 0xF0, 0xFD, 0x80, 0x6C, 0x03, 0x60, 0x1B, 0x01, 0xDC, 0x0E,
  0xE1, 0xE3, 0xFB, 0x0F, 0x98, 0x18, 0x06, 0x30, 0x1C, 0x60, 0x38, 0xC0,
  0x63, 0x80, 0xC6, 0x01, 0x8C, 0x03, 0x18, 0x0E, 0x3F, 0xFC, 0x7F, 0xF1,
  0xC0, 0x63, 0x00, 0xC6, 0x01, 0x8C, 0x07, 0x18, 0x0E, 0x30, 0x18, 0xE0,
  0x31, 0xC0, 0x63, 0x00, 0xC0, 0x1F, 0xFE, 0x3F, 0xFC, 0x03, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x06,
  0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0x0F, 0xF8, 0x7F, 0xC0, 0x0E, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x73, 0x03, 0x18, 0x18, 0xE1, 0xC3, 0xFC, 0x0F, 0x80,
  0x1C, 0x07, 0x18, 0x0E, 0x18, 0x1C, 0x18, 0x38, 0x18, 0x70, 0x38, 0xE0,
  0x31, 0xC0, 0x33, 0x80, 0x37, 0x80, 0x3F, 0x80, 0x3D, 0x80, 0x78, 0xC0,
  0x70, 0xC0, 0x60, 0xE0, 0x60, 0x60, 0x60, 0x70, 0x60, 0x30, 0xE0, 0x38,
  0xC0, 0x18, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xE0, 0x1C, 0x0E, 0x38, 0x1C, 0xF0,
  0x79, 0xA1, 0xB3, 0x63, 0x66, 0xCD, 0x8D, 0x9B, 0x19, 0x66, 0x63, 0xCC,
  0xC7, 0x19, 0x8C, 0x33, 0x08, 0xC6, 0x21, 0x8C, 0x03, 0x30, 0x06, 0x60,
  0x0C, 0xC0, 0x19, 0x80, 0x63, 0x00, 0xC0, 0x1E, 0x06, 0x3C, 0x0C, 0x78,
  0x18, 0xF0, 0x63, 0xE0, 0xC6, 0x61, 0x8C, 0xC3, 0x19, 0x86, 0x33, 0x0C,
  0x63, 0x31, 0xC6, 0x63, 0x0C, 0xC6, 0x19, 0x8C, 0x33, 0x18, 0x36, 0x30,
  0x78, 0xE0, 0xF1, 0x81, 0xE3, 0x03, 0xC0, 0x07, 0xE0, 0x7F, 0x87, 0x0E,
  0x60, 0x37, 0x01, 0xB0, 0x0D, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x7C, 0x03, 0x60, 0x1B, 0x01, 0xD8, 0x0C, 0xE1, 0xC3, 0xFC,
  0x0F, 0xC0, 0x1F, 0xF8, 0x3F, 0xF8, 0x60, 0x30, 0xC0, 0x71, 0x80, 0xE7,
  0x01, 0xCE, 0x03, 0x98, 0x06, 0x30, 0x1C, 0x7F, 0xF0, 0xFF, 0x83, 0x80,
  0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03,
  0x80, 0x00, 0x07, 0xE0, 0x7F, 0x87, 0x0E, 0x60, 0x37, 0x01, 0xB0, 0x0D,
  0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0x60,
  0x1B, 0x01, 0xD8, 0x0C, 0xE1, 0xC3, 0xFC, 0x0F, 0xC0, 0x1C, 0x00, 0x71,
  0x01, 0xBC, 0x0F, 0x80, 0x38, 0x1F, 0xF8, 0x3F, 0xF8, 0x60, 0x30, 0xC0,
  0x71, 0x80, 0xE7, 0x01, 0xCE, 0x03, 0x98, 0x06, 0x30, 0x1C, 0x7F, 0xF0,
  0xFF, 0x83, 0x8C, 0x07, 0x0C, 0x0C, 0x18, 0x18, 0x38, 0x30, 0x30, 0x60,
  0x61, 0xC0, 0x63, 0x80, 0xE0, 0x03, 0xF0, 0x1F, 0xF0, 0x70, 0x71, 0xC0,
  0x73, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x03, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x30, 0x06, 0x60, 0x1C, 0xF0,
  0x70, 0xFF, 0xC0, 0x7E, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0x80, 0x03,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x30, 0x0C, 0xC0, 0x33, 0x01,
  0xCC, 0x06, 0x70, 0x19, 0x80, 0x66, 0x01, 0x98, 0x0E, 0x60, 0x39, 0x80,
  0xCE, 0x03, 0x30, 0x0C, 0xC0, 0x33, 0x01, 0xCC, 0x06, 0x30, 0x18, 0xE1,
  0xE1, 0xFF, 0x03, 0xF0, 0x00, 0xC0, 0x0F, 0x00, 0x6C, 0x01, 0xB0, 0x0E,
  0x60, 0x31, 0x81, 0xC6, 0x06, 0x18, 0x38, 0x60, 0xC1, 0x83, 0x06, 0x18,
  0x18, 0x60, 0x33, 0x00, 0xCC, 0x03, 0x70, 0x0D, 0x80, 0x3E, 0x00, 0xF0,
  0x03, 0xC0, 0x00, 0x30, 0x03, 0x30, 0x03, 0x30, 0x03, 0x30, 0x06, 0x60,
  0x06, 0x61, 0x86, 0x63, 0xC6, 0x63, 0xCC, 0x62, 0xCC, 0x66, 0xCC, 0x66,
  0xCC, 0x6C, 0xD8, 0x6C, 0xD8, 0x6C, 0xD8, 0x78, 0xD8, 0x58, 0xD0, 0xD0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x1C, 0x03, 0x86, 0x01, 0x83, 0x81, 0x80,
  0xC1, 0xC0, 0x71, 0xC0, 0x19, 0xC0, 0x0C, 0xC0, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x6C, 0x00, 0x66, 0x00, 0x61, 0x80, 0x70,
  0xC0, 0x70, 0x70, 0x30, 0x18, 0x30, 0x0E, 0x38, 0x03, 0x00, 0xE0, 0x07,
  0x60, 0x0E, 0x70, 0x1C, 0x30, 0x38, 0x38, 0x30, 0x18, 0x70, 0x18, 0xE0,
  0x0C, 0xC0, 0x0D, 0x80, 0x0F, 0x80, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0F, 0xFF, 0x0F, 0xFF, 0x10, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xFF, 0xFC,
  0xFF, 0xFC, 0x0F, 0xF0, 0xFF, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x07, 0xF0, 0xFF, 0x00, 0xC1, 0x83, 0x02, 0x06, 0x0C, 0x18, 0x10, 0x20,
  0x60, 0xC1, 0x81, 0x03, 0x06, 0x0C, 0x18, 0x10, 0x30, 0x60, 0xC0, 0x81,
  0x03, 0x06, 0x0F, 0xF0, 0xFF, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x30, 0x03,
  0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xC0, 0x1E, 0x01, 0xB0, 0x1C, 0xC0, 0xC6,
  0x0C, 0x18, 0xE0, 0xC6, 0x06, 0x60, 0x1E, 0x00, 0xD0, 0x02, 0xFF, 0xFF,
  0xFF, 0xC0, 0xC6, 0x62, 0x30, 0x0F, 0x39, 0xFD, 0x9C, 0x1C, 0xC0, 0x6E,
  0x03, 0x60, 0x1B, 0x01, 0x98, 0x0C, 0xC0, 0x66, 0x07, 0x30, 0x39, 0xC7,
  0xCF, 0xE7, 0x1E, 0x38, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x9F, 0x06, 0xFE, 0x3E, 0x38, 0xE0, 0x73, 0x80, 0xCC,
  0x03, 0x30, 0x1C, 0xC0, 0x66, 0x01, 0x98, 0x06, 0x60, 0x31, 0xC1, 0xC6,
  0xFE, 0x39, 0xF0, 0x07, 0xC1, 0xFE, 0x38, 0x77, 0x03, 0x60, 0x0E, 0x00,
  0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x07, 0xE0, 0x67, 0x1C, 0x7F, 0x81, 0xF0,
  0x00, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0xF1,
  0x8F, 0xEE, 0x70, 0x71, 0x80, 0xCE, 0x03, 0x30, 0x0C, 0xC0, 0x33, 0x01,
  0xCC, 0x06, 0x30, 0x18, 0xC0, 0xE3, 0x85, 0x8F, 0xE6, 0x0F, 0x38, 0x07,
  0xC1, 0xFF, 0x38, 0x36, 0x03, 0x60, 0x3C, 0x1F, 0xFF, 0xCF, 0xE0, 0xC0,
  0x0C, 0x02, 0xE0, 0x77, 0x0E, 0x7F, 0xC1, 0xF0, 0x00, 0x1F, 0x80, 0x1F,
  0xC0, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x3F, 0xFC, 0x3F,
  0xFE, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0,
  0x18, 0x60, 0x0E, 0x30, 0x03, 0x98, 0x00, 0xEC, 0x00, 0x3E, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x8C, 0x7F, 0x73, 0xC3, 0x8C, 0x06, 0x70, 0x19, 0x80,
  0x66, 0x01, 0x98, 0x0E, 0x60, 0x31, 0x80, 0xC6, 0x07, 0x1C, 0x2C, 0x3F,
  0x30, 0x79, 0x80, 0x06, 0x00, 0x18, 0xC1, 0xC3, 0xFE, 0x03, 0xF0, 0x00,
  0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x33, 0xC3, 0x7E,
  0x7C, 0x77, 0x83, 0x70, 0x36, 0x03, 0x60, 0x36, 0x07, 0xE0, 0x6C, 0x06,
  0xC0, 0x6C, 0x06, 0xC0, 0x6C, 0x0E, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0xC1, 0x8F, 0x0C, 0xE0, 0xCE, 0x07,
  0xE0, 0x1C, 0x00, 0x00, 0x70, 0x07, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE1, 0xFE, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x8C, 0x30, 0xE3, 0x07, 0x30,
  0x3B, 0x01, 0xF0, 0x0E, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x00, 0x18, 0x00, 0xCF, 0x06, 0xFE, 0x7C, 0x73, 0xC1, 0x9C, 0x0C, 0xC0,
  0xC6, 0x0C, 0x33, 0xC3, 0xB0, 0x1C, 0xC1, 0xC7, 0x3E, 0x1B, 0xB0, 0xF9,
  0x83, 0x80, 0xFE, 0x1F, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x8C, 0x19, 0x8E,
  0x33, 0x86, 0xE0, 0xF8, 0x1C, 0x00, 0x1B, 0x9E, 0x6F, 0x7C, 0xE6, 0x99,
  0x86, 0x33, 0x0C, 0x66, 0x30, 0xCC, 0x61, 0xB0, 0xC3, 0x61, 0x84, 0xC3,
  0x19, 0x86, 0x33, 0x18, 0x66, 0x30, 0xD8, 0x61, 0x80, 0x33, 0xC3, 0x7E,
  0x7C, 0x77, 0x83, 0x70, 0x36, 0x03, 0x60, 0x36, 0x07, 0xE0, 0x6C, 0x06,
  0xC0, 0x6C, 0x06, 0xC0, 0x6C, 0x0E, 0x0F, 0xC1, 0xFE, 0x38, 0x76, 0x03,
  0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x6E, 0x0E,
  0x7F, 0xC1, 0xF0, 0x19, 0xF0, 0xEF, 0xE3, 0x63, 0x8E, 0x07, 0x38, 0x0C,
  0xC0, 0x33, 0x01, 0xDC, 0x06, 0x60, 0x19, 0x80, 0x66, 0x03, 0x1C, 0x1C,
  0x6F, 0xE3, 0x9F, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x00, 0x0F, 0x19, 0xFD, 0xDC, 0x1C, 0xC0, 0x6E, 0x03, 0x60, 0x1B, 0x00,
  0xD8, 0x0E, 0xC0, 0x66, 0x03, 0x30, 0x39, 0xC2, 0xCF, 0xEE, 0x1E, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0xFC, 0x7F, 0xEF, 0xC3,
  0xC0, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x07, 0xE0, 0xFF, 0xC6, 0x06,
  0x60, 0x03, 0x00, 0x1C, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x30, 0x01, 0x90,
  0x0D, 0xE0, 0xE7, 0xFE, 0x0F, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x0E, 0x0F, 0xFF, 0xFF, 0xF0, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80,
  0x18, 0x01, 0x82, 0x18, 0x71, 0x9E, 0x3B, 0xC3, 0xF0, 0x1C, 0x00, 0x30,
  0x39, 0x81, 0x98, 0x0C, 0xC0, 0x66, 0x03, 0x30, 0x19, 0x81, 0xCC, 0x0C,
  0xC0, 0x66, 0x07, 0x38, 0x59, 0xC2, 0xC7, 0xEE, 0x1E, 0x60, 0xF8, 0x37,
  0xC1, 0x86, 0x0C, 0x70, 0x73, 0x03, 0x98, 0x18, 0xC0, 0xC6, 0x06, 0x30,
  0x71, 0x87, 0x18, 0x70, 0xC7, 0x07, 0xF0, 0x1E, 0x00, 0x31, 0x8C, 0xC6,
  0x36, 0x18, 0xD8, 0x63, 0x61, 0x8D, 0x84, 0x36, 0x30, 0xD8, 0xC3, 0xC3,
  0x0F, 0x0C, 0x6C, 0x71, 0xB1, 0xCE, 0xFB, 0xF1, 0xC7, 0x80, 0x07, 0x1E,
  0x0F, 0x3F, 0x39, 0xA3, 0x71, 0xE3, 0x41, 0xC3, 0x01, 0xC4, 0x01, 0x80,
  0x01, 0x80, 0x41, 0x80, 0xC3, 0x84, 0xC3, 0x8E, 0xC7, 0x9C, 0xFC, 0xF8,
  0x78, 0xE0, 0x18, 0x1C, 0x60, 0x63, 0x81, 0x8C, 0x06, 0x30, 0x18, 0xC0,
  0x63, 0x03, 0x8C, 0x0C, 0x70, 0x31, 0x81, 0xC7, 0x07, 0x0C, 0x2C, 0x3F,
  0x70, 0x79, 0x80, 0x06, 0x00, 0x38, 0xC1, 0xC3, 0xFE, 0x03, 0xE0, 0x00,
  0x0F, 0x8C, 0x7F, 0xB3, 0x0F, 0xCC, 0x0E, 0x30, 0x60, 0x03, 0x00, 0x18,
  0x01, 0xC0, 0x0E, 0x30, 0x60, 0x63, 0x01, 0x9F, 0xE6, 0x6F, 0xFB, 0x87,
  0xC0, 0x03, 0xF8, 0x3F, 0x81, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC1, 0xFC, 0x0F, 0xC0, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x0C, 0x30, 0xC3, 0x0C, 0x21, 0x86,
  0x18, 0x61, 0x84, 0x30, 0xC3, 0x0C, 0x30, 0x86, 0x18, 0x61, 0x86, 0x10,
  0xC0, 0x0F, 0xC0, 0x7F, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x02, 0x00, 0x30, 0x00, 0xC0, 0x03, 0xF0, 0x3F, 0x83, 0x00,
  0x10, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x1F, 0xC0, 0xFC, 0x00, 0x1C, 0x04, 0xF8, 0x37, 0x30, 0xD8,
  0xE6, 0x41, 0xF3, 0x03, 0x80,
};

const GFXglyph IBMPlexMono_Italic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 6, 19, 16, 5, -19 },
  { 16, 8, 7, 16, 6, -20 },
  { 23, 17, 19, 16, 0, -19 },
  { 64, 15, 25, 16, 1, -22 },
  { 111, 19, 19, 16, -1, -19 },
  { 157, 16, 19, 16, 0, -19 },
  { 195, 3, 7, 16, 8, -20 },
  { 198, 10, 25, 16, 6, -21 },
  { 230, 10, 25, 16, 1, -21 },
  { 262, 13, 13, 16, 2, -15 },
  { 284, 13, 14, 16, 2, -15 },
  { 307, 6, 8, 16, 4, -4 },
  { 313, 8, 2, 16, 4, -9 },
  { 315, 4, 4, 16, 5, -4 },
  { 317, 15, 25, 16, 1, -21 },
  { 364, 13, 19, 16, 2, -19 },
  { 395, 13, 19, 16, 1, -19 },
  { 426, 14, 19, 16, 1, -19 },
  { 460, 14, 19, 16, 1, -19 },
  { 494, 15, 19, 16, 0, -19 },
  { 530, 14, 19, 16, 1, -19 },
  { 564, 12, 19, 16, 2, -19 },
  { 593, 13, 19, 16, 3, -19 },
  { 624, 14, 19, 16, 1, -19 },
  { 658, 13, 19, 16, 2, -19 },
  { 689, 6, 15, 16, 5, -15 },
  { 701, 7, 19, 16, 4, -15 },
  { 718, 13, 15, 16, 2, -16 },
  { 743, 14, 7, 16, 1, -12 },
  { 756, 13, 15, 16, 1, -16 },
  { 781, 12, 19, 16, 3, -19 },
  { 810, 13, 22, 16, 2, -19 },
  { 846, 14, 19, 16, 0, -19 },
  { 880, 14, 19, 16, 1, -19 },
  { 914, 14, 19, 16, 2, -19 },
  { 948, 14, 19, 16, 1, -19 },
  { 982, 15, 19, 16, 1, -19 },
  { 1018, 15, 19, 16, 1, -19 },
  { 1054, 13, 19, 16, 2, -19 },
  { 1085, 15, 19, 16, 1, -19 },
  { 1121, 15, 19, 16, 1, -19 },
  { 1157, 13, 19, 16, 2, -19 },
  { 1188, 16, 19, 16, 1, -19 },
  { 1226, 12, 19, 16, 2, -19 },
  { 1255, 15, 19, 16, 1, -19 },
  { 1291, 15, 19, 16, 1, -19 },
  { 1327, 13, 19, 16, 2, -19 },
  { 1358, 15, 19, 16, 1, -19 },
  { 1394, 13, 24, 16, 2, -19 },
  { 1433, 15, 19, 16, 1, -19 },
  { 1469, 15, 19, 16, 1, -19 },
  { 1505, 16, 19, 16, 2, -19 },
  { 1543, 14, 19, 16, 2, -19 },
  { 1577, 14, 19, 16, 3, -19 },
  { 1611, 16, 19, 16, 1, -19 },
  { 1649, 17, 19, 16, 0, -19 },
  { 1690, 16, 19, 16, 2, -19 },
  { 1728, 16, 19, 16, 0, -19 },
  { 1766, 12, 25, 16, 4, -21 },
  { 1804, 7, 25, 16, 5, -21 },
  { 1826, 12, 25, 16, 0, -21 },
  { 1864, 13, 11, 16, 2, -19 },
  { 1882, 13, 2, 16, 0, 3 },
  { 1886, 4, 5, 16, 6, -21 },
  { 1889, 13, 14, 16, 2, -14 },
  { 1912, 14, 20, 16, 1, -20 },
  { 1947, 12, 14, 16, 2, -14 },
  { 1968, 14, 20, 16, 2, -20 },
  { 2003, 12, 14, 16, 2, -14 },
  { 2024, 17, 25, 16, 0, -20 },
  { 2078, 14, 19, 16, 1, -14 },
  { 2112, 12, 20, 16, 2, -20 },
  { 2142, 13, 20, 16, 2, -20 },
  { 2175, 12, 25, 16, 2, -20 },
  { 2213, 13, 20, 16, 2, -20 },
  { 2246, 11, 20, 16, 3, -20 },
  { 2274, 15, 14, 16, 0, -14 },
  { 2301, 12, 14, 16, 2, -14 },
  { 2322, 12, 14, 16, 2, -14 },
  { 2343, 14, 19, 16, 1, -14 },
  { 2377, 13, 19, 16, 2, -14 },
  { 2408, 13, 14, 16, 3, -14 },
  { 2431, 13, 14, 16, 1, -14 },
  { 2454, 12, 19, 16, 2, -19 },
  { 2483, 13, 14, 16, 2, -14 },
  { 2506, 13, 14, 16, 2, -14 },
  { 2529, 14, 14, 16, 1, -14 },
  { 2554, 16, 14, 16, 0, -14 },
  { 2582, 14, 19, 16, 1, -14 },
  { 2616, 14, 14, 16, 1, -14 },
  { 2641, 13, 25, 16, 3, -21 },
  { 2682, 6, 25, 16, 5, -21 },
  { 2701, 13, 25, 16, 1, -21 },
  { 2742, 14, 6, 16, 1, -11 },
};

const GFXfont IBMPlexMono_Italic27pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic27pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic27pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _IBMPLEXMONO_ITALIC27PT7B_H_
