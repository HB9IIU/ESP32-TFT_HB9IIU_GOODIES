#ifndef _IBMPLEXMONO_ITALIC55PT7B_H_
#define _IBMPLEXMONO_ITALIC55PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic55pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x0E, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0x7C, 0x00,
  0x3C, 0x0F, 0x3C, 0x1F, 0x3C, 0x1E, 0x3C, 0x1E, 0x78, 0x1E, 0x78, 0x1E,
  0x78, 0x1E, 0x78, 0x3E, 0x78, 0x3C, 0x78, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C,
  0xF0, 0x3C, 0xF0, 0x7C, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1F, 0x03, 0xC0, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x07, 0xC0, 0xE0, 0x00,
  0x03, 0xC0, 0xF0, 0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xF0, 0x3F, 0xF8,
  0x7F, 0xF0, 0x3F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFE, 0x20, 0x7C, 0x0F, 0x00,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x03, 0xC0, 0xF0, 0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F,
  0xF8, 0x7F, 0xF0, 0x3F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFE, 0x00, 0x38, 0x1F,
  0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0E, 0x07,
  0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x07, 0x81,
  0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xF9,
  0xCF, 0xF0, 0x1F, 0x83, 0x87, 0xF0, 0x3E, 0x07, 0x03, 0xE0, 0xF8, 0x0E,
  0x03, 0x81, 0xF0, 0x3C, 0x04, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x80, 0xE0,
  0x00, 0x0F, 0x01, 0xC0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x3E, 0x07, 0x00,
  0x00, 0x7C, 0x1E, 0x00, 0x00, 0xFC, 0x3C, 0x00, 0x00, 0xFE, 0x70, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x39, 0xFE, 0x00,
  0x00, 0x70, 0x7E, 0x00, 0x00, 0xE0, 0x7C, 0x00, 0x01, 0xC0, 0xF8, 0x00,
  0x07, 0x81, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1C, 0x03, 0xC0, 0x00,
  0x38, 0x07, 0x81, 0x00, 0x70, 0x1F, 0x06, 0x00, 0xE0, 0x3E, 0x1E, 0x03,
  0xC0, 0xF8, 0x7E, 0x07, 0x83, 0xF0, 0x7F, 0x0E, 0x0F, 0xC0, 0x7F, 0x9C,
  0x7F, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xC0, 0x3F, 0xFC, 0x00, 0x3C, 0x03, 0xE1, 0xE0, 0x03, 0xC0,
  0x3C, 0x07, 0x80, 0x1E, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xE0,
  0x1E, 0x00, 0xF0, 0x07, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x0F, 0x00, 0x38,
  0x03, 0xC0, 0xF0, 0x03, 0xC0, 0x1E, 0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x78,
  0x00, 0x70, 0x07, 0x07, 0x80, 0x03, 0x80, 0x78, 0x78, 0x00, 0x1E, 0x07,
  0x83, 0xC0, 0x00, 0xF8, 0x7C, 0x3C, 0x00, 0x03, 0xFF, 0xC3, 0xC0, 0x00,
  0x0F, 0xFC, 0x1E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x78, 0x3F, 0xF0, 0x00, 0x07, 0x83, 0xFF, 0xC0, 0x00, 0x3C, 0x3E, 0x1E,
  0x00, 0x03, 0xC3, 0xC0, 0x78, 0x00, 0x3C, 0x1E, 0x01, 0xC0, 0x01, 0xE1,
  0xE0, 0x0E, 0x00, 0x1E, 0x0F, 0x00, 0x70, 0x01, 0xE0, 0x78, 0x03, 0x80,
  0x0F, 0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0xE0,
  0x0F, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x80, 0x38, 0x07, 0x80, 0x78,
  0x01, 0xE0, 0x78, 0x07, 0x80, 0x0F, 0x87, 0xC0, 0x3C, 0x00, 0x3F, 0xFC,
  0x03, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x78,
  0x03, 0xE0, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0xF0,
  0x01, 0xE0, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0xF8,
  0x01, 0xE0, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x3E, 0x1F, 0x80, 0x01, 0xFE,
  0x7E, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xCF, 0xF0, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x78, 0x03,
  0xC0, 0x00, 0x78, 0x03, 0xE0, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0xF8, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x04, 0xF8, 0x00,
  0xF8, 0x0F, 0xF8, 0x00, 0xFC, 0x0F, 0xF8, 0x00, 0xBC, 0x1E, 0x78, 0x01,
  0xBE, 0x1E, 0x7C, 0x03, 0x9E, 0x3C, 0x7E, 0x07, 0x1F, 0x7C, 0x3F, 0xFF,
  0x0F, 0xF8, 0x1F, 0xFE, 0x0F, 0xF0, 0x0F, 0xFC, 0x07, 0xF0, 0x03, 0xF0,
  0x03, 0xC0, 0x1E, 0x3C, 0xF9, 0xE3, 0xC7, 0x8F, 0x1E, 0x7C, 0xF1, 0xE3,
  0xC7, 0x8F, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x40, 0x07, 0x80, 0x27,
  0x80, 0x78, 0x0F, 0x7F, 0x0F, 0x07, 0xFF, 0xFE, 0xF7, 0xFF, 0x3F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x1F,
  0x3E, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x80, 0xF0,
  0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xC0, 0x03, 0x80, 0x0C,
  0x00, 0x20, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xF0,
  0xFE, 0x0F, 0xE0, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x03,
  0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3E, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x7C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFC,
  0x0F, 0xC0, 0x3F, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xE0, 0x7C, 0x00, 0x1F,
  0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0xF1, 0xF0,
  0x00, 0x0F, 0x1E, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x0F, 0x3E, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0xF7, 0xC0, 0xF8, 0x0F, 0x7C,
  0x1F, 0xC1, 0xF7, 0xC1, 0xFC, 0x1F, 0x7C, 0x1F, 0xC1, 0xF7, 0x81, 0xF8,
  0x1F, 0x78, 0x0F, 0x01, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x7C, 0xF8, 0x00,
  0x07, 0xC7, 0x80, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x87, 0x80, 0x00, 0xF0,
  0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x03, 0xF8,
  0x1F, 0xC0, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0xFC, 0xF0,
  0x00, 0x7F, 0x1E, 0x00, 0x1F, 0x83, 0xC0, 0x07, 0xE0, 0xF8, 0x01, 0xF8,
  0x1F, 0x00, 0x7E, 0x03, 0xC0, 0x03, 0x00, 0x78, 0x00, 0x40, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0x3E, 0x07, 0xE0,
  0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0x70, 0x00, 0x0F,
  0x01, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xE0, 0x7F,
  0x00, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xE0, 0x1C, 0x00, 0x1F, 0x00,
  0x40, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x02, 0x00,
  0x00, 0xF8, 0x78, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x7C, 0x1F, 0x80, 0x07,
  0xE0, 0x7F, 0x01, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1F, 0x3C,
  0x00, 0x01, 0xF1, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xF0, 0xF8, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0xF8, 0x3C, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0xF8,
  0x0F, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x78, 0x07, 0x80, 0x07, 0x80, 0x3C,
  0x00, 0x7C, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x03,
  0xC0, 0x07, 0xC0, 0x3C, 0x00, 0x3C, 0x03, 0xE0, 0x01, 0xE0, 0x3E, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0xC1, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x0F, 0xF0, 0x00, 0xF3, 0xFF, 0xC0, 0x0F, 0x7F, 0xFE,
  0x00, 0xEF, 0xFF, 0xF0, 0x1F, 0xE0, 0x7F, 0x81, 0xF8, 0x01, 0xF8, 0x1E,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x10, 0x00,
  0x0F, 0x87, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE0,
  0x7F, 0x01, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF8, 0x7F, 0x00, 0x3C, 0x7F, 0xF0, 0x1F, 0x7F,
  0xFE, 0x07, 0xBF, 0xFF, 0xC3, 0xFE, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x7F,
  0x00, 0x07, 0xDF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0x3D, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF9, 0xE0,
  0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x1F, 0x83, 0xF8, 0x1F, 0xC0,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xF7, 0x80, 0x00, 0x7C, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x03,
  0xE7, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x1F, 0x1E, 0x00, 0x07, 0xC3, 0xC0,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x03, 0xE0,
  0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x1E, 0x0F, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x0F, 0x83, 0xC0, 0x00,
  0x78, 0x1F, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x78, 0x03, 0xF0, 0x1F, 0x80,
  0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x7C, 0x3E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x1E, 0x7C, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x7E, 0x1F, 0x80, 0x07, 0xE0, 0x7F, 0x00, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8,
  0x0F, 0xE0, 0x3F, 0x07, 0xE0, 0x07, 0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x00,
  0x1E, 0x7C, 0x00, 0x07, 0xDE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xEF, 0x80, 0x03,
  0xF9, 0xF0, 0x01, 0xFC, 0x7F, 0x01, 0xEF, 0x0F, 0xFF, 0xF7, 0xC1, 0xFF,
  0xF9, 0xE0, 0x3F, 0xF8, 0xF8, 0x03, 0xF8, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xC1, 0xFC, 0x3F, 0x8F, 0xF1,
  0xFE, 0x3F, 0xC3, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x87, 0xF8, 0xFF, 0x1F, 0xE3, 0xF8, 0x7F, 0x07, 0xC0, 0x00, 0xF8,
  0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x3F,
  0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x3F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xC0, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x1F, 0x81,
  0xFC, 0x3E, 0x00, 0x7E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0xF8, 0x00,
  0x1E, 0x70, 0x00, 0x1F, 0x10, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xFC,
  0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xE0, 0x78,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x1F, 0x00, 0x00,
  0xF1, 0xE0, 0x0F, 0x0F, 0x1E, 0x03, 0xFC, 0xF1, 0xE0, 0x7F, 0xCF, 0x3C,
  0x0F, 0xFE, 0xE3, 0xC1, 0xF8, 0x6E, 0x3C, 0x1F, 0x03, 0xE3, 0xC3, 0xE0,
  0x1E, 0x7C, 0x3C, 0x01, 0xE7, 0x83, 0xC0, 0x1E, 0x78, 0x7C, 0x01, 0xE7,
  0x87, 0xC0, 0x3C, 0x78, 0x78, 0x03, 0xC7, 0x87, 0x80, 0x3C, 0x78, 0x78,
  0x03, 0xCF, 0x07, 0x80, 0x3C, 0xF0, 0x78, 0x07, 0xCF, 0x07, 0x80, 0x78,
  0xF0, 0x78, 0x0F, 0x8F, 0x07, 0xC1, 0xF8, 0xF0, 0x7E, 0x77, 0x8F, 0x03,
  0xFF, 0x78, 0xF0, 0x3F, 0xE7, 0x8F, 0x01, 0xFC, 0x70, 0xF0, 0x06, 0x08,
  0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0x0F, 0x7C, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0x78,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0xF8, 0x07, 0x80, 0x03, 0xC0, 0x1E, 0x00,
  0x1F, 0x00, 0x78, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x00, 0x1F, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0xF8, 0x1E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x3E,
  0x1F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFC, 0x07, 0xC0, 0x07, 0xE0, 0x78, 0x00, 0x3E, 0x07, 0x80, 0x01, 0xE0,
  0x78, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80,
  0x01, 0xE0, 0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x3C,
  0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x01, 0xF8, 0x1F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x3E, 0x00, 0x1F,
  0x83, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x7C, 0x3C,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0x7C, 0x7C, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x7C, 0x78, 0x00, 0x0F, 0x87,
  0x80, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xF0, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x00, 0x3E, 0x07, 0xE0, 0x03,
  0xE0, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x0C, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x04, 0x0F, 0x80, 0x00, 0x70, 0x78, 0x00, 0x0F,
  0x87, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0x3E,
  0x00, 0x7E, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xC0,
  0x1F, 0xC0, 0x3C, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3E,
  0x07, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xF0, 0xF8,
  0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x0F, 0x0F, 0x80, 0x01,
  0xF0, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x1F,
  0x00, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF1, 0xE0, 0x00,
  0x3E, 0x1E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x7C, 0x3C, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xF0,
  0x78, 0x00, 0x7E, 0x07, 0x80, 0x3F, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x80, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0x81, 0xFC,
  0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x00,
  0x01, 0xE3, 0xE0, 0x00, 0x30, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x7F, 0xFD, 0xF0, 0x0F, 0xFF, 0x3E, 0x01, 0xFF,
  0xE7, 0x80, 0x3F, 0xFC, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xF3, 0xC0,
  0x00, 0x3C, 0x78, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1E,
  0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x0F, 0x80,
  0x0F, 0xC1, 0xF8, 0x03, 0x78, 0x3F, 0x81, 0xEF, 0x03, 0xFF, 0xF9, 0xE0,
  0x3F, 0xFE, 0x7C, 0x03, 0xFF, 0x8F, 0x80, 0x1F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x78, 0x0F, 0x80, 0x00, 0xF0, 0x1F, 0x00,
  0x03, 0xE0, 0x3C, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x1E, 0x03, 0xE0, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x78, 0x0F, 0x80, 0x01,
  0xF0, 0x1E, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F,
  0x01, 0xF0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0xF8,
  0x0F, 0x00, 0x01, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xC0, 0x00, 0x7C, 0x07,
  0x80, 0x00, 0xF8, 0x0F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xC0, 0x7C,
  0x00, 0x07, 0x80, 0xF8, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3E, 0x03, 0xC0,
  0x00, 0x7C, 0x07, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xE0, 0x3E, 0x00,
  0x03, 0xC0, 0x7C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1F, 0x01, 0xE0, 0x00,
  0x3E, 0x03, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF0, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x30, 0x00, 0x78, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03,
  0xE0, 0x7C, 0x00, 0xFC, 0x0F, 0x80, 0x3F, 0x01, 0xFC, 0x0F, 0xC0, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0xF0, 0x00, 0x1F, 0x80, 0xF8, 0x00,
  0x1F, 0x80, 0x7C, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x1F, 0x80, 0x1E, 0x00,
  0x1F, 0x80, 0x0F, 0x00, 0x1F, 0x80, 0x07, 0x80, 0x1F, 0x80, 0x07, 0xC0,
  0x1F, 0x80, 0x03, 0xE0, 0x1F, 0x80, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0xF0,
  0x1F, 0x80, 0x00, 0x78, 0x1F, 0x80, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x3E,
  0x1F, 0x80, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x07,
  0x9F, 0xE0, 0x00, 0x03, 0xDF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xBE, 0x00, 0x00, 0xFF, 0x0F, 0x80, 0x00, 0x7F, 0x07, 0xC0, 0x00,
  0x3F, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x1F, 0x00, 0x07, 0xC0, 0x07, 0x80, 0x03, 0xE0, 0x03, 0xE0,
  0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x01,
  0xF0, 0x0F, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x3C, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x01, 0xF0, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFF,
  0x03, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFE,
  0x03, 0xFC, 0x03, 0xDE, 0x07, 0xDC, 0x07, 0xDE, 0x07, 0x9E, 0x07, 0x9E,
  0x07, 0x9E, 0x0F, 0x3E, 0x07, 0x9E, 0x0F, 0x3C, 0x07, 0x8E, 0x1E, 0x3C,
  0x07, 0x8F, 0x3E, 0x3C, 0x0F, 0x8F, 0x3C, 0x3C, 0x0F, 0x0F, 0x78, 0x3C,
  0x0F, 0x07, 0xF8, 0x7C, 0x0F, 0x07, 0xF0, 0x78, 0x0F, 0x07, 0xF0, 0x78,
  0x0F, 0x07, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x78,
  0x1E, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1E, 0x01, 0x00, 0xF0,
  0x1E, 0x02, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xF0,
  0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xE0,
  0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0,
  0xF8, 0x00, 0x03, 0xC0, 0x03, 0xF8, 0x00, 0x3E, 0x07, 0xF0, 0x00, 0x78,
  0x0F, 0xF0, 0x00, 0xF0, 0x1F, 0xE0, 0x01, 0xE0, 0x3F, 0xC0, 0x03, 0xC0,
  0x7F, 0x80, 0x0F, 0x81, 0xF7, 0x80, 0x1E, 0x03, 0xEF, 0x00, 0x3C, 0x07,
  0x9E, 0x00, 0x78, 0x0F, 0x3C, 0x00, 0xF0, 0x1E, 0x78, 0x01, 0xE0, 0x3C,
  0x78, 0x07, 0xC0, 0xF8, 0xF0, 0x0F, 0x01, 0xF1, 0xE0, 0x1E, 0x03, 0xC3,
  0xC0, 0x3C, 0x07, 0x83, 0xC0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x1E, 0x0F,
  0x03, 0xE0, 0x7C, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C,
  0x1E, 0x03, 0xC0, 0x78, 0x3C, 0x07, 0x80, 0xF0, 0x78, 0x0F, 0x01, 0xE1,
  0xF0, 0x3E, 0x01, 0xE3, 0xC0, 0x78, 0x03, 0xC7, 0x80, 0xF0, 0x07, 0x8F,
  0x01, 0xE0, 0x0F, 0x1E, 0x03, 0xC0, 0x1E, 0x3C, 0x07, 0x80, 0x1E, 0xF8,
  0x1F, 0x00, 0x3D, 0xE0, 0x3C, 0x00, 0x7B, 0xC0, 0x78, 0x00, 0xF7, 0x80,
  0xF0, 0x00, 0xFF, 0x01, 0xE0, 0x01, 0xFE, 0x03, 0xC0, 0x03, 0xFC, 0x0F,
  0x80, 0x07, 0xF0, 0x1E, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFC,
  0x0F, 0xC0, 0x3F, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xE0, 0x7C, 0x00, 0x1F,
  0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0xF1, 0xF0,
  0x00, 0x0F, 0x1E, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x0F, 0x3E, 0x00, 0x00,
  0xF3, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x1F, 0x7C,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x1F, 0x78, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x7C, 0xF8, 0x00,
  0x07, 0xC7, 0x80, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x87, 0x80, 0x00, 0xF0,
  0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x03, 0xF8,
  0x1F, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0x3F, 0x03, 0xE0,
  0x00, 0xFC, 0x1E, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x1F, 0x07, 0x80, 0x00,
  0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0,
  0xF0, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x7C, 0x3C, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x7F, 0x07, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xE0, 0x7C,
  0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x1F, 0x00, 0x00,
  0xF1, 0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x0F, 0x3E,
  0x00, 0x00, 0xF3, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0xF7, 0xC0, 0x00,
  0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x1F, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3E, 0xF8, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x7C,
  0xF8, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x87, 0x80,
  0x00, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x7C,
  0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x80, 0x01, 0xF0,
  0x1C, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0xFC,
  0x1E, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0xF8, 0x7C,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF0, 0x00,
  0x0F, 0x87, 0x80, 0x00, 0x7C, 0x3C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E,
  0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x7F, 0x07, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x00, 0xF8, 0x1F,
  0x00, 0x07, 0xC0, 0x78, 0x00, 0x3C, 0x03, 0xE0, 0x01, 0xE0, 0x0F, 0x00,
  0x0F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E,
  0x00, 0x7C, 0x01, 0xE0, 0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x7C, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3C,
  0x0F, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x0E, 0x07, 0xC0, 0x00, 0x10, 0x0F, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3E, 0x04, 0x00, 0x00, 0x7C, 0x1C, 0x00, 0x00, 0xF8,
  0x78, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x3F, 0x01,
  0xFE, 0x01, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x3C, 0x1E, 0x00,
  0x03, 0xE0, 0xF0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07,
  0x83, 0xE0, 0x00, 0x3C, 0x1F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1F, 0x07,
  0x80, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3C, 0x1F, 0x00,
  0x01, 0xE0, 0xF8, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF8, 0x3C, 0x00, 0x07,
  0xC1, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x0F, 0x07,
  0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x3E, 0x0F, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x78, 0x3E, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x0F, 0x03,
  0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x03, 0xE0,
  0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x3E, 0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1F, 0x0F, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x07,
  0xC0, 0x78, 0x00, 0x3E, 0x03, 0xC0, 0x03, 0xE0, 0x1E, 0x00, 0x1F, 0x00,
  0xF0, 0x00, 0xF0, 0x07, 0x80, 0x0F, 0x80, 0x3C, 0x00, 0x78, 0x01, 0xF0,
  0x07, 0xC0, 0x0F, 0x80, 0x3C, 0x00, 0x3C, 0x03, 0xE0, 0x01, 0xE0, 0x1E,
  0x00, 0x0F, 0x01, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0xF8, 0x00,
  0x1E, 0x07, 0xC0, 0x00, 0xF8, 0x3C, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C, 0xF8,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x0F, 0x1E,
  0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x07, 0xC0, 0x78, 0x3C,
  0x07, 0xC0, 0x78, 0x3C, 0x0F, 0xC0, 0x78, 0x3C, 0x0F, 0xC0, 0x78, 0x3C,
  0x1F, 0xE0, 0xF0, 0x38, 0x1F, 0xE0, 0xF0, 0x78, 0x1D, 0xE0, 0xF0, 0x78,
  0x3D, 0xE0, 0xF0, 0x78, 0x39, 0xE1, 0xE0, 0x78, 0x79, 0xE1, 0xE0, 0x78,
  0x79, 0xE1, 0xE0, 0x78, 0x71, 0xE1, 0xE0, 0x78, 0xF1, 0xE3, 0xC0, 0x78,
  0xF1, 0xE3, 0xC0, 0x78, 0xE1, 0xE3, 0xC0, 0x71, 0xE0, 0xE3, 0xC0, 0x71,
  0xC0, 0xE3, 0x80, 0xF3, 0xC0, 0xE7, 0x80, 0xF3, 0xC0, 0xE7, 0x80, 0xF3,
  0x80, 0xE7, 0x80, 0xF7, 0x80, 0xE7, 0x00, 0xF7, 0x80, 0xEF, 0x00, 0xF7,
  0x00, 0xEF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x00, 0x3C,
  0xF8, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x00,
  0x1F, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x00, 0x7E, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x78, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x00, 0x7E, 0xF0, 0x00, 0x00, 0xF9, 0xF0, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00,
  0x7C, 0x07, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xE0, 0x1F, 0x00, 0x0F,
  0x80, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3C, 0x03, 0xF0,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF0, 0x7C, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x03, 0xCF, 0x80, 0x00,
  0x07, 0xDE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00,
  0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x0F,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x7C, 0xF0,
  0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x3E,
  0x03, 0xC0, 0x07, 0x80, 0x78, 0x01, 0xF0, 0x07, 0x80, 0x7C, 0x00, 0xF0,
  0x0F, 0x00, 0x1F, 0x03, 0xC0, 0x01, 0xE0, 0xF8, 0x00, 0x3C, 0x3E, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x79, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1E, 0xC0, 0x00, 0x01, 0x80, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE0, 0x11, 0xE3, 0xC7,
  0xC7, 0x8F, 0x0F, 0x1E, 0x1C, 0x38, 0x68, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xF8, 0x7C, 0x0F, 0xFF, 0xCF, 0x03, 0xFF, 0xF9, 0xE0, 0xFE, 0x03, 0xBC,
  0x1F, 0x00, 0x37, 0x87, 0xC0, 0x03, 0xF1, 0xF0, 0x00, 0x3E, 0x3E, 0x00,
  0x07, 0x87, 0x80, 0x00, 0xF1, 0xF0, 0x00, 0x1E, 0x3E, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0xF8, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xC7, 0xC0, 0x00,
  0x78, 0xF8, 0x00, 0x0F, 0x1F, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x7C, 0x78,
  0x00, 0x0F, 0x8F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x1F,
  0x83, 0xC0, 0x06, 0xF0, 0x7C, 0x01, 0xBE, 0x0F, 0xE0, 0xF7, 0xF8, 0xFF,
  0xFC, 0xFF, 0x0F, 0xFF, 0x0F, 0xE0, 0xFF, 0xC0, 0xFC, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x1F, 0x80, 0x1F, 0x0F, 0xFC,
  0x03, 0xE7, 0xFF, 0xC0, 0x7C, 0xFF, 0xFC, 0x0F, 0x3C, 0x1F, 0xC1, 0xEE,
  0x00, 0xF8, 0x3D, 0x80, 0x0F, 0x0F, 0xE0, 0x01, 0xF1, 0xF8, 0x00, 0x3E,
  0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x1E, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x9E, 0x00, 0x01, 0xF3,
  0xC0, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x3E, 0x7C, 0x00, 0x07, 0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3C, 0x3E,
  0x00, 0x0F, 0x87, 0xE0, 0x03, 0xE1, 0xF7, 0x03, 0xFC, 0x3E, 0xFF, 0xFF,
  0x07, 0x8F, 0xFF, 0xC0, 0xF0, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x7E, 0x03, 0xF0, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0x3C, 0x3C, 0x00, 0x0F,
  0x3E, 0x00, 0x08, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x8F, 0x80, 0x00, 0xE7, 0xC0, 0x00, 0xF9, 0xE0, 0x00, 0xF8, 0xF8,
  0x00, 0xF8, 0x7E, 0x00, 0xF8, 0x1F, 0x81, 0xFC, 0x07, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x03, 0xF8, 0x1E, 0x00, 0x7F, 0xF0, 0xF0,
  0x0F, 0xFF, 0xCF, 0x80, 0xFF, 0xFF, 0x7C, 0x0F, 0xE0, 0x3B, 0xC0, 0x7C,
  0x00, 0x7E, 0x07, 0xC0, 0x01, 0xF0, 0x3C, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x7C, 0x1E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0xF0,
  0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x3E, 0x00, 0x01, 0xE1, 0xF0,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF0, 0x7C, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x3C, 0x1E, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF8,
  0x3E, 0x00, 0x1F, 0x80, 0xF0, 0x01, 0xBC, 0x07, 0xC0, 0x1D, 0xE0, 0x3F,
  0x83, 0xCF, 0x00, 0xFF, 0xFC, 0xF8, 0x03, 0xFF, 0xC7, 0xC0, 0x0F, 0xFC,
  0x3C, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0x03, 0xF8, 0x7C, 0x00,
  0x7C, 0x7C, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0x9E, 0x00,
  0x07, 0xDE, 0x00, 0x07, 0xEF, 0x00, 0x0F, 0xE7, 0x80, 0xFF, 0xE7, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x67,
  0xC0, 0x00, 0x79, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0x7E, 0x00, 0x7C,
  0x1F, 0x80, 0xFC, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x20, 0x03, 0xC0, 0x00, 0x03, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0x1F, 0x87, 0x80, 0x00, 0x00,
  0xFC, 0x78, 0x00, 0x00, 0x07, 0xE7, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0x0F, 0x01, 0xFF,
  0xF8, 0xF0, 0x3F, 0xFF, 0xDF, 0x07, 0xF8, 0x1D, 0xF0, 0x7C, 0x00, 0x7E,
  0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE1, 0xE0,
  0x00, 0x3E, 0x3E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x3C, 0x7C, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x7C, 0x7C,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0x78, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0xF8, 0x7C, 0x00, 0x1F, 0x87, 0xC0, 0x01, 0xF8, 0x3E, 0x00, 0x3F, 0x83,
  0xE0, 0x0E, 0xF0, 0x3F, 0x83, 0xCF, 0x01, 0xFF, 0xFC, 0xF0, 0x0F, 0xFF,
  0x8F, 0x00, 0x7F, 0xE1, 0xF0, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x20, 0x00, 0x7C, 0x07, 0x00, 0x1F, 0x80, 0xFC, 0x07, 0xF0,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x81, 0xF8, 0x01, 0xE1, 0xFF,
  0x80, 0x78, 0xFF, 0xF0, 0x3E, 0x7F, 0xFC, 0x0F, 0xBC, 0x1F, 0x83, 0xEC,
  0x03, 0xE0, 0xF6, 0x00, 0x78, 0x3D, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC7,
  0xE0, 0x01, 0xE1, 0xF0, 0x00, 0x78, 0x7C, 0x00, 0x1E, 0x1E, 0x00, 0x07,
  0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x3E, 0x00,
  0x0F, 0x0F, 0x80, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C,
  0x00, 0x1F, 0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0x78,
  0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x03, 0xE3, 0xE0, 0x00,
  0xF8, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x60,
  0x0F, 0x00, 0x78, 0x07, 0x80, 0x7E, 0x03, 0xC0, 0x7C, 0x03, 0xE0, 0xFC,
  0x01, 0xF0, 0xFC, 0x00, 0xF0, 0xFC, 0x00, 0x78, 0xFC, 0x00, 0x3C, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80,
  0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x02, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0xC0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x3F, 0x00, 0xF0, 0x07, 0xE0, 0x3C, 0x00, 0xFC, 0x1F,
  0x00, 0x1F, 0x87, 0xC0, 0x03, 0xE1, 0xE0, 0x00, 0x7C, 0x78, 0x00, 0x0F,
  0x9E, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x81, 0xF8,
  0x00, 0x78, 0x7F, 0xE0, 0x07, 0x8F, 0xFF, 0x00, 0xF9, 0xFF, 0xF8, 0x0F,
  0xBC, 0x1F, 0x80, 0xFF, 0x00, 0xF8, 0x0F, 0x60, 0x07, 0xC0, 0xFC, 0x00,
  0x7C, 0x0F, 0x80, 0x07, 0x81, 0xF8, 0x00, 0x78, 0x1F, 0x00, 0x07, 0x81,
  0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x1F, 0x01, 0xE0, 0x07, 0xE0, 0x1E, 0x00,
  0xF8, 0x03, 0xE0, 0x7F, 0x00, 0x3E, 0x7F, 0xC0, 0x03, 0xE3, 0xE0, 0x00,
  0x3C, 0x3C, 0x00, 0x03, 0xC3, 0xE0, 0x04, 0x3C, 0x1E, 0x00, 0x67, 0xC1,
  0xF0, 0x0F, 0x7C, 0x0F, 0x03, 0xF7, 0x80, 0xF8, 0x7E, 0x78, 0x07, 0x8F,
  0xC7, 0x80, 0x7D, 0xF8, 0x78, 0x03, 0xFF, 0x0F, 0x80, 0x3F, 0xE0, 0xF8,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x80, 0xF0, 0x03, 0x81, 0xE0, 0x0F, 0x83,
  0xC0, 0x3E, 0x0F, 0x80, 0xF8, 0x1F, 0x07, 0xE0, 0x3C, 0x1F, 0x80, 0x78,
  0x7E, 0x00, 0xF1, 0xF8, 0x01, 0xE7, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x01, 0xF0, 0x3C,
  0xFE, 0x1F, 0xE0, 0xF3, 0xFC, 0xFF, 0xC3, 0xDF, 0xF3, 0xFF, 0x0F, 0xE3,
  0xDC, 0x7C, 0x3E, 0x0F, 0x60, 0xF1, 0xF0, 0x1F, 0x03, 0xC7, 0xC0, 0x78,
  0x0F, 0x1E, 0x01, 0xE0, 0x3C, 0x78, 0x0F, 0x80, 0xF1, 0xE0, 0x3C, 0x03,
  0xC7, 0x80, 0xF0, 0x0F, 0x3C, 0x03, 0xC0, 0x78, 0xF0, 0x0F, 0x01, 0xE3,
  0xC0, 0x3C, 0x07, 0x8F, 0x01, 0xE0, 0x1E, 0x3C, 0x07, 0x80, 0x78, 0xF0,
  0x1E, 0x01, 0xE7, 0x80, 0x78, 0x0F, 0x1E, 0x01, 0xE0, 0x3C, 0x78, 0x07,
  0x80, 0xF1, 0xE0, 0x3C, 0x03, 0xC7, 0x80, 0xF0, 0x0F, 0x1E, 0x03, 0xC0,
  0x3C, 0xF0, 0x0F, 0x01, 0xE3, 0xC0, 0x3C, 0x07, 0x8F, 0x00, 0xF0, 0x1E,
  0x3C, 0x07, 0x80, 0x78, 0xF0, 0x1E, 0x01, 0xE0, 0x00, 0x01, 0xF8, 0x01,
  0xE1, 0xFF, 0x80, 0x78, 0xFF, 0xF0, 0x1E, 0x7F, 0xFC, 0x0F, 0xBC, 0x1F,
  0x83, 0xEC, 0x03, 0xE0, 0xF6, 0x00, 0x78, 0x3D, 0x00, 0x1F, 0x0F, 0x80,
  0x07, 0xC3, 0xE0, 0x01, 0xE1, 0xF0, 0x00, 0x78, 0x7C, 0x00, 0x1E, 0x1E,
  0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0xF8, 0x78, 0x00, 0x3E,
  0x3E, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00,
  0x3C, 0x3C, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xE1, 0xE0,
  0x00, 0x78, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x03, 0xE3,
  0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFE, 0x07, 0xF0, 0xFC,
  0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x7C, 0x00, 0x07, 0xBE,
  0x00, 0x03, 0xDE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xEF, 0x00, 0x01,
  0xF7, 0x80, 0x00, 0xFB, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0xF8, 0x7C, 0x00,
  0xFC, 0x3F, 0x81, 0xFC, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0x0F, 0xFC,
  0x00, 0xF9, 0xFF, 0xF0, 0x07, 0xCF, 0xFF, 0xC0, 0x3C, 0xF0, 0x7F, 0x01,
  0xEE, 0x00, 0xF8, 0x0F, 0x60, 0x03, 0xC0, 0x7E, 0x00, 0x1F, 0x07, 0xE0,
  0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE1,
  0xE0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1E, 0x0F, 0x80, 0x01,
  0xF0, 0x7C, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x80, 0x0F, 0x81,
  0xF7, 0x03, 0xFC, 0x0F, 0xBF, 0xFF, 0xC0, 0x78, 0xFF, 0xFC, 0x03, 0xC3,
  0xFF, 0x80, 0x1E, 0x07, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFC,
  0x3C, 0x0F, 0xFF, 0xC7, 0x83, 0xFF, 0xFD, 0xF0, 0xFE, 0x03, 0xBE, 0x1F,
  0x00, 0x1F, 0x87, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x07,
  0xC7, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x1E, 0x3E, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0x78, 0xF0, 0x00, 0x0F, 0x3E, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x7C,
  0xF8, 0x00, 0x0F, 0x1F, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x78, 0x00,
  0x0F, 0x8F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x83,
  0xC0, 0x06, 0xF0, 0x7C, 0x01, 0xDE, 0x0F, 0xE0, 0xF3, 0xC0, 0xFF, 0xFC,
  0xF8, 0x0F, 0xFF, 0x1F, 0x00, 0xFF, 0xC3, 0xC0, 0x07, 0xE0, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0x00, 0xF3,
  0x80, 0x00, 0x3D, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xE0, 0x1F, 0xC3, 0xE0, 0x01, 0xE0,
  0xF0, 0x00, 0x10, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC2, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x7C, 0xFC, 0x00,
  0x3E, 0x3F, 0xC0, 0x3F, 0x87, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x1F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x40, 0x3C, 0x00,
  0xF0, 0x1E, 0x00, 0xFC, 0x0F, 0x01, 0xFC, 0x0F, 0x81, 0xFC, 0x07, 0xC3,
  0xF8, 0x03, 0xC3, 0xF8, 0x01, 0xF7, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x0F, 0x9F,
  0x00, 0x07, 0xCF, 0x80, 0x03, 0xC7, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0xF1,
  0xE0, 0x00, 0x78, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1E,
  0x3C, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xC7, 0x80, 0x03,
  0xE7, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0xF1, 0xE0, 0x00, 0x78, 0xF0, 0x00,
  0x3C, 0x78, 0x00, 0x3E, 0x3C, 0x00, 0x1F, 0x1E, 0x00, 0x1F, 0x8F, 0x00,
  0x0F, 0x87, 0x80, 0x0B, 0xC3, 0xE0, 0x0D, 0xE1, 0xF0, 0x0C, 0xF0, 0xFC,
  0x1E, 0xF8, 0x3F, 0xFE, 0x7C, 0x1F, 0xFE, 0x3C, 0x07, 0xFE, 0x1E, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0x3F, 0xF0, 0x03, 0xEF, 0xFC, 0x00,
  0xFB, 0xFF, 0x00, 0x1E, 0xFF, 0xC0, 0x07, 0x80, 0xF0, 0x01, 0xF0, 0x7C,
  0x00, 0x7C, 0x1E, 0x00, 0x1F, 0x07, 0x80, 0x07, 0xC1, 0xE0, 0x01, 0xF0,
  0x78, 0x00, 0x7C, 0x1E, 0x00, 0x1E, 0x0F, 0x80, 0x07, 0x83, 0xC0, 0x01,
  0xE0, 0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x1F, 0x03, 0xC0,
  0x07, 0xC0, 0xF0, 0x03, 0xE0, 0x7C, 0x01, 0xF8, 0x1E, 0x00, 0x7C, 0x07,
  0x80, 0x7E, 0x01, 0xE0, 0x3F, 0x00, 0x78, 0x1F, 0xC0, 0x1E, 0x3F, 0xC0,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x78, 0x0F, 0x07, 0x83, 0xC0, 0x78,
  0x1E, 0x1C, 0x03, 0xC0, 0xF1, 0xE0, 0x1E, 0x07, 0x8F, 0x00, 0xE0, 0x3C,
  0x78, 0x0F, 0x01, 0xE3, 0xC0, 0x78, 0x0F, 0x1E, 0x03, 0xC0, 0x78, 0xE0,
  0x1E, 0x03, 0xCF, 0x00, 0xF0, 0x1E, 0x78, 0x0F, 0x00, 0xF3, 0xC0, 0x78,
  0x07, 0x9E, 0x03, 0xC0, 0x3C, 0xF0, 0x1E, 0x01, 0xE7, 0x00, 0xF0, 0x0F,
  0x78, 0x07, 0x80, 0xF3, 0xC0, 0x78, 0x07, 0x9E, 0x03, 0xC0, 0x3C, 0xF0,
  0x1E, 0x01, 0xE7, 0x80, 0xF0, 0x1E, 0x38, 0x0F, 0x80, 0xF3, 0xC0, 0x7C,
  0x0F, 0x9E, 0x03, 0xE0, 0x78, 0xF8, 0x37, 0x07, 0xC7, 0xC3, 0xBC, 0x7C,
  0x1F, 0xF9, 0xFF, 0xC0, 0xFF, 0x8F, 0xFC, 0x03, 0xF8, 0x3F, 0xC0, 0x0F,
  0x80, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x3F, 0xE1, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xE0, 0x7F, 0x3C, 0xF0, 0xF0,
  0x7E, 0x1E, 0x70, 0x7C, 0x7E, 0x0F, 0x70, 0x3E, 0x7C, 0x07, 0xB0, 0x0F,
  0x08, 0x03, 0xD8, 0x07, 0x80, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0xFC, 0x03,
  0xC0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x7E, 0x00, 0x87, 0x80, 0x6F, 0x00, 0xC3, 0xC0, 0x37,
  0x81, 0xF1, 0xF0, 0x3B, 0xC1, 0xF8, 0xF8, 0x39, 0xE3, 0xF0, 0x3C, 0x3C,
  0xF3, 0xF0, 0x1F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFE, 0x1F, 0xF0, 0x03, 0xFE,
  0x0F, 0xF0, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0xF8, 0x1F,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3E,
  0x07, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x0F,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x3E,
  0x03, 0xC0, 0x01, 0xF0, 0x1E, 0x00, 0x1F, 0x80, 0xF0, 0x01, 0xF8, 0x07,
  0xC0, 0x1B, 0xC0, 0x3E, 0x01, 0xDE, 0x01, 0xF8, 0x1C, 0xF0, 0x07, 0xFF,
  0xCF, 0x80, 0x3F, 0xFC, 0x7C, 0x00, 0xFF, 0xC3, 0xC0, 0x01, 0xFC, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x80, 0x03, 0xF0, 0x0E, 0x00,
  0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x1F, 0x07, 0xFF, 0xE1, 0xF0, 0xFF, 0xFF, 0x9E, 0x1F, 0x03,
  0xFD, 0xE1, 0xE0, 0x07, 0xFE, 0x1E, 0x00, 0x1F, 0xC1, 0xC0, 0x01, 0xF8,
  0x1C, 0x00, 0x3E, 0x01, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x10, 0x01,
  0xF0, 0x0F, 0x00, 0x3E, 0x00, 0x70, 0x07, 0xC0, 0x07, 0x80, 0xF8, 0x00,
  0x78, 0x1F, 0x00, 0x07, 0x83, 0xFC, 0x00, 0x3C, 0x7F, 0xFE, 0x03, 0xCF,
  0xBF, 0xFE, 0x3C, 0xF8, 0x7F, 0xFF, 0xCF, 0x00, 0xFF, 0xF8, 0xF0, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38,
  0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80,
  0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x60, 0x7F, 0x80, 0x0F, 0x0F, 0xFC, 0x00, 0xF1, 0xFF, 0xE0, 0x0E,
  0x3E, 0x3E, 0x01, 0xE3, 0xC1, 0xF0, 0x1E, 0x78, 0x0F, 0x83, 0xC7, 0x80,
  0x7C, 0x7C, 0xF0, 0x07, 0xFF, 0x8F, 0x00, 0x3F, 0xF0, 0xE0, 0x01, 0xFE,
  0x06, 0x00, 0x0F, 0x80,
};

const GFXglyph IBMPlexMono_Italic55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 33, 0, -1 },
  { 1, 12, 39, 33, 11, -38 },
  { 60, 16, 15, 33, 12, -41 },
  { 90, 33, 38, 33, 1, -38 },
  { 247, 31, 52, 33, 1, -45 },
  { 449, 37, 40, 33, -1, -39 },
  { 634, 32, 40, 33, 0, -39 },
  { 794, 7, 15, 33, 16, -41 },
  { 808, 21, 50, 33, 11, -42 },
  { 940, 21, 50, 33, 2, -42 },
  { 1072, 28, 27, 33, 3, -30 },
  { 1167, 26, 28, 33, 4, -31 },
  { 1258, 12, 15, 33, 8, -7 },
  { 1281, 16, 4, 33, 9, -19 },
  { 1289, 8, 7, 33, 11, -6 },
  { 1296, 32, 50, 33, 1, -42 },
  { 1496, 28, 40, 33, 3, -39 },
  { 1636, 27, 38, 33, 2, -38 },
  { 1765, 28, 39, 33, 2, -39 },
  { 1902, 29, 40, 33, 1, -39 },
  { 2047, 29, 38, 33, 1, -38 },
  { 2185, 28, 39, 33, 3, -38 },
  { 2322, 26, 39, 33, 3, -38 },
  { 2449, 27, 38, 33, 6, -38 },
  { 2578, 29, 40, 33, 2, -39 },
  { 2723, 26, 39, 33, 5, -39 },
  { 2850, 11, 29, 33, 11, -28 },
  { 2890, 14, 36, 33, 8, -28 },
  { 2953, 26, 32, 33, 5, -33 },
  { 3057, 28, 15, 33, 3, -24 },
  { 3110, 26, 32, 33, 3, -33 },
  { 3214, 24, 40, 33, 7, -39 },
  { 3334, 28, 45, 33, 3, -39 },
  { 3492, 30, 38, 33, -1, -38 },
  { 3635, 28, 38, 33, 3, -38 },
  { 3768, 28, 40, 33, 4, -39 },
  { 3908, 28, 38, 33, 3, -38 },
  { 4041, 30, 38, 33, 3, -38 },
  { 4184, 30, 38, 33, 3, -38 },
  { 4327, 27, 40, 33, 4, -39 },
  { 4462, 31, 38, 33, 2, -38 },
  { 4610, 30, 38, 33, 2, -38 },
  { 4753, 27, 39, 33, 3, -38 },
  { 4885, 33, 38, 33, 2, -38 },
  { 5042, 24, 38, 33, 4, -38 },
  { 5156, 32, 38, 33, 1, -38 },
  { 5308, 31, 38, 33, 2, -38 },
  { 5456, 28, 40, 33, 3, -39 },
  { 5596, 29, 38, 33, 3, -38 },
  { 5734, 28, 49, 33, 3, -39 },
  { 5906, 29, 38, 33, 3, -38 },
  { 6044, 31, 40, 33, 1, -39 },
  { 6199, 31, 38, 33, 5, -38 },
  { 6347, 29, 39, 33, 4, -38 },
  { 6489, 29, 38, 33, 6, -38 },
  { 6627, 32, 38, 33, 3, -38 },
  { 6779, 36, 38, 33, -1, -38 },
  { 6950, 31, 38, 33, 5, -38 },
  { 7098, 34, 38, 33, 0, -38 },
  { 7260, 23, 50, 33, 9, -42 },
  { 7404, 14, 50, 33, 10, -42 },
  { 7492, 23, 50, 33, 1, -42 },
  { 7636, 27, 22, 33, 4, -38 },
  { 7711, 27, 4, 33, 0, 5 },
  { 7725, 7, 11, 33, 13, -43 },
  { 7735, 27, 30, 33, 3, -29 },
  { 7837, 27, 42, 33, 3, -41 },
  { 7979, 25, 30, 33, 4, -29 },
  { 8073, 29, 42, 33, 3, -41 },
  { 8226, 25, 30, 33, 4, -29 },
  { 8320, 36, 53, 33, -1, -41 },
  { 8559, 28, 41, 33, 2, -29 },
  { 8703, 26, 41, 33, 3, -41 },
  { 8837, 25, 41, 33, 5, -40 },
  { 8966, 26, 52, 33, 3, -40 },
  { 9135, 28, 42, 33, 3, -41 },
  { 9282, 23, 42, 33, 6, -41 },
  { 9403, 30, 29, 33, 1, -29 },
  { 9512, 26, 29, 33, 3, -29 },
  { 9607, 25, 30, 33, 4, -29 },
  { 9701, 29, 40, 33, 1, -29 },
  { 9846, 27, 40, 33, 3, -29 },
  { 9981, 26, 28, 33, 6, -28 },
  { 10072, 26, 30, 33, 3, -29 },
  { 10170, 25, 39, 33, 4, -38 },
  { 10292, 25, 29, 33, 5, -28 },
  { 10383, 26, 29, 33, 4, -29 },
  { 10478, 29, 30, 33, 2, -29 },
  { 10587, 33, 30, 33, 0, -29 },
  { 10711, 29, 40, 33, 1, -28 },
  { 10856, 28, 30, 33, 3, -29 },
  { 10961, 26, 50, 33, 6, -42 },
  { 11124, 12, 50, 33, 11, -42 },
  { 11199, 26, 50, 33, 2, -42 },
  { 11362, 28, 12, 33, 3, -23 },
};

const GFXfont IBMPlexMono_Italic55pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic55pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic55pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _IBMPLEXMONO_ITALIC55PT7B_H_
