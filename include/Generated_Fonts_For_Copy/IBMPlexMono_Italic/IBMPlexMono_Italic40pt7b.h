#ifndef _IBMPLEXMONO_ITALIC40PT7B_H_
#define _IBMPLEXMONO_ITALIC40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0xFC, 0x7E, 0x3E, 0x1E, 0x00, 0x38, 0x73, 0x87,
  0x38, 0x73, 0x87, 0x38, 0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0x70, 0xE7, 0x0E,
  0xF1, 0xC0, 0x00, 0x0E, 0x1E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x07, 0x00,
  0x03, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x01, 0xC1, 0x80, 0x00, 0xE1, 0xC0,
  0x00, 0xF0, 0xE0, 0x0F, 0xF0, 0x7F, 0x8F, 0xF8, 0x7F, 0xC7, 0xFC, 0x3F,
  0xC0, 0x1C, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x07,
  0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x3F, 0xC1, 0xFE, 0x1F, 0xE1,
  0xFF, 0x0F, 0xF0, 0xFF, 0x88, 0x70, 0x70, 0x00, 0x38, 0x70, 0x00, 0x1C,
  0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x07,
  0x07, 0x00, 0x03, 0x87, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x7F,
  0xFF, 0x81, 0xF3, 0xBF, 0x0F, 0x0C, 0x3C, 0x78, 0x30, 0x61, 0xE0, 0xC1,
  0x07, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x78, 0x60, 0x01, 0xF1, 0x80, 0x03,
  0xE6, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x31, 0xF0, 0x00, 0xC3, 0xC0, 0x03, 0x07, 0x00, 0x1C, 0x1C,
  0x00, 0x70, 0x70, 0x81, 0x81, 0xCF, 0x06, 0x0F, 0x3E, 0x18, 0x78, 0x7E,
  0xE7, 0xE0, 0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF8, 0x00,
  0xE0, 0x7F, 0x80, 0x38, 0x1F, 0xF8, 0x07, 0x03, 0x87, 0x01, 0xC0, 0xE0,
  0x70, 0x70, 0x1C, 0x0E, 0x0C, 0x03, 0x81, 0xC3, 0x80, 0x60, 0x38, 0xE0,
  0x0C, 0x0E, 0x38, 0x01, 0x81, 0xC7, 0x00, 0x38, 0x79, 0xC0, 0x07, 0xFE,
  0x70, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0xE7, 0xFE, 0x00, 0x38, 0xE1, 0xC0, 0x07, 0x38,
  0x1C, 0x01, 0xC7, 0x03, 0x80, 0x70, 0xE0, 0x70, 0x0C, 0x18, 0x0E, 0x03,
  0x83, 0x01, 0x80, 0xE0, 0x60, 0x70, 0x38, 0x0E, 0x1E, 0x07, 0x01, 0xFF,
  0x81, 0xC0, 0x1F, 0xE0, 0x70, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xE1, 0xE0, 0x03, 0xC0, 0xF0, 0x03,
  0x80, 0x70, 0x03, 0x80, 0x70, 0x03, 0x80, 0x70, 0x03, 0x80, 0x70, 0x03,
  0x80, 0xF0, 0x01, 0xC0, 0xE0, 0x01, 0xC1, 0xE0, 0x01, 0xE7, 0xC0, 0x0F,
  0xFF, 0x00, 0x3E, 0xFC, 0x00, 0x78, 0x70, 0x00, 0x70, 0x38, 0x00, 0x70,
  0x38, 0x00, 0xF0, 0x1C, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x0E, 0x04, 0xE0,
  0x0F, 0x0F, 0xF0, 0x1F, 0x0E, 0xF0, 0x17, 0x9C, 0x78, 0x73, 0x9C, 0x7F,
  0xF3, 0xF8, 0x3F, 0xE1, 0xF8, 0x0F, 0x80, 0xE0, 0x3B, 0x9C, 0xE7, 0x39,
  0xDC, 0xE7, 0x38, 0x00, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x60, 0x70,
  0x17, 0xC7, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFC, 0x03, 0xFE, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x3B, 0x80, 0x07, 0x1C, 0x00, 0xF1, 0xE0, 0x1E,
  0x0E, 0x03, 0xC0, 0xF0, 0x38, 0x06, 0x01, 0x00, 0x40, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0x8F, 0x87, 0x87, 0xC3,
  0xC1, 0xC1, 0xE0, 0xE0, 0xF0, 0x70, 0x30, 0x00, 0x7F, 0xF7, 0xFF, 0xFF,
  0xF0, 0x7B, 0xFF, 0xFE, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0x83, 0xE0,
  0xF0, 0x0F, 0x07, 0x00, 0x38, 0x78, 0x01, 0xE3, 0x80, 0x07, 0x3C, 0x00,
  0x39, 0xC0, 0x01, 0xCE, 0x00, 0x0E, 0xF0, 0xF0, 0xF7, 0x8F, 0x87, 0xB8,
  0x7C, 0x3D, 0xC3, 0xE1, 0xCE, 0x0E, 0x0E, 0x70, 0x00, 0x77, 0x80, 0x07,
  0xBC, 0x00, 0x39, 0xE0, 0x01, 0xC7, 0x00, 0x1E, 0x38, 0x00, 0xE1, 0xC0,
  0x0F, 0x0F, 0x00, 0xF0, 0x3C, 0x1F, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x01, 0xF7,
  0x00, 0x7C, 0xE0, 0x1F, 0x1C, 0x07, 0xC7, 0x81, 0xF0, 0xE0, 0x1C, 0x1C,
  0x02, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0x83, 0xE0, 0xF8, 0x07, 0x87,
  0x80, 0x3C, 0x78, 0x00, 0xE0, 0x80, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x03, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0x81, 0xE0, 0xF8,
  0x07, 0x83, 0x00, 0x3C, 0x08, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x0F, 0xF8, 0x00, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x10, 0x00, 0xF1, 0x80, 0x07,
  0x9E, 0x00, 0x78, 0x7C, 0x0F, 0x81, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0E,
  0xE0, 0x00, 0xEF, 0x00, 0x0F, 0x70, 0x00, 0xF3, 0x80, 0x07, 0x1C, 0x00,
  0x70, 0xE0, 0x07, 0x07, 0x00, 0x70, 0x70, 0x07, 0x83, 0x80, 0x78, 0x1C,
  0x03, 0x80, 0xE0, 0x38, 0x07, 0x03, 0x80, 0x78, 0x38, 0x03, 0x83, 0x80,
  0x1C, 0x1C, 0x00, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x1F, 0x80, 0x3B, 0xFF, 0x01,
  0xFF, 0xFC, 0x0F, 0x83, 0xE0, 0xF0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x10,
  0x00, 0xE1, 0x80, 0x0F, 0x1E, 0x00, 0xF0, 0x7C, 0x0F, 0x81, 0xFF, 0xF8,
  0x07, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x71, 0xF8, 0x0E, 0xFF, 0xC3, 0xBF,
  0xFC, 0x7E, 0x07, 0xDF, 0x00, 0x7B, 0xC0, 0x07, 0x78, 0x00, 0xEE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0E, 0xE0, 0x03, 0xDC, 0x00,
  0xF3, 0xC0, 0x1C, 0x3C, 0x0F, 0x87, 0xFF, 0xE0, 0x7F, 0xF0, 0x03, 0xF8,
  0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0x00, 0x0E, 0x70,
  0x01, 0xE7, 0x00, 0x1C, 0xE0, 0x03, 0x8E, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x0F, 0xFF, 0x01, 0xFF, 0xFC, 0x1F, 0x03, 0xE0, 0xF0, 0x07,
  0x8F, 0x00, 0x3C, 0x70, 0x01, 0xE3, 0x80, 0x0F, 0x1C, 0x00, 0x70, 0xE0,
  0x03, 0x87, 0x80, 0x38, 0x1E, 0x07, 0x80, 0x7F, 0xF8, 0x00, 0xFF, 0x00,
  0x3F, 0xFE, 0x03, 0xC0, 0x78, 0x78, 0x01, 0xE3, 0x80, 0x07, 0x3C, 0x00,
  0x39, 0xC0, 0x01, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0xF3, 0x80, 0x07, 0x9E,
  0x00, 0x78, 0xFC, 0x0F, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x1F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0x0F, 0x81, 0xE3, 0xC0,
  0x1E, 0x70, 0x01, 0xDE, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x00, 0xEE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xF7, 0x00, 0x1E, 0xF0, 0x07, 0xDF, 0x03,
  0xF1, 0xFF, 0xEE, 0x1F, 0xFB, 0x80, 0xFC, 0xF0, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x1F, 0x3F, 0x3F,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0xFC, 0xFC, 0xF8, 0xF0, 0x03, 0xC1, 0xF0, 0xFC, 0x3F, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x87, 0xC1, 0xE0, 0xF8, 0x3C, 0x0E, 0x07, 0x81, 0xC0, 0xF0,
  0x38, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x3F, 0xFF,
  0xF9, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF8, 0x08, 0x00, 0x01, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x01, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x03, 0xF8,
  0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xC1, 0xE7, 0x80, 0x7B, 0x80, 0x1F, 0xC0,
  0x0E, 0x40, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0,
  0x03, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x0F, 0x80, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x78, 0x1F, 0x0F, 0x00, 0x70, 0xE0,
  0x07, 0x1C, 0x00, 0x71, 0xC0, 0x03, 0x38, 0x1E, 0x33, 0x83, 0xF3, 0x38,
  0x7F, 0xF3, 0x8F, 0x0F, 0x70, 0xE0, 0x77, 0x1E, 0x07, 0x71, 0xC0, 0x67,
  0x1C, 0x0E, 0x71, 0xC0, 0xE6, 0x1C, 0x0E, 0xE1, 0xC0, 0xEE, 0x1C, 0x1E,
  0xE1, 0xC2, 0xCE, 0x1F, 0xFC, 0xE1, 0xFD, 0xCE, 0x0F, 0x9C, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00, 0x1C, 0xE0, 0x00, 0xE7,
  0x00, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x07, 0x8F, 0x00, 0x38, 0x38, 0x03,
  0xC1, 0xC0, 0x1C, 0x0E, 0x01, 0xE0, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x1C,
  0x07, 0x00, 0xF0, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xE0,
  0x07, 0x0E, 0x00, 0x38, 0xF0, 0x01, 0xC7, 0x00, 0x0E, 0x78, 0x00, 0x7B,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x70, 0x0F, 0xFF, 0x80, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0xE0, 0x1F, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x1E,
  0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00, 0x71, 0xC0, 0x0F, 0x1C, 0x00, 0xE1,
  0xC0, 0x3C, 0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0x80, 0x3C,
  0x38, 0x01, 0xE3, 0x80, 0x0E, 0x78, 0x00, 0xE7, 0x80, 0x0E, 0x70, 0x00,
  0xE7, 0x00, 0x1E, 0x70, 0x01, 0xE7, 0x00, 0x3C, 0xF0, 0x07, 0x8F, 0xFF,
  0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x1F, 0xF8, 0x03,
  0xFF, 0xE0, 0x7C, 0x1E, 0x0F, 0x00, 0xF1, 0xE0, 0x07, 0x1C, 0x00, 0x73,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x10, 0xF0, 0x01, 0xCF, 0x00,
  0x3C, 0x70, 0x03, 0x87, 0x80, 0x78, 0x7C, 0x1F, 0x03, 0xFF, 0xE0, 0x1F,
  0xFC, 0x00, 0x7F, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0,
  0x1E, 0x07, 0xC0, 0xE0, 0x0F, 0x07, 0x00, 0x78, 0x38, 0x01, 0xC1, 0xC0,
  0x0E, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x00, 0x1E, 0x38, 0x00, 0xF1,
  0xC0, 0x07, 0x0E, 0x00, 0x38, 0xF0, 0x01, 0xC7, 0x80, 0x0E, 0x38, 0x00,
  0xF1, 0xC0, 0x07, 0x8E, 0x00, 0x38, 0x70, 0x01, 0xC7, 0x80, 0x1E, 0x3C,
  0x00, 0xE1, 0xC0, 0x0F, 0x0E, 0x00, 0xF0, 0x70, 0x1F, 0x03, 0xFF, 0xF0,
  0x3F, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x83, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x83, 0xFF, 0xFC, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0,
  0xF8, 0x3E, 0x1F, 0x00, 0xE1, 0xE0, 0x0F, 0x3C, 0x00, 0x73, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x3F, 0xCE, 0x07, 0xFC, 0xE0, 0x7F, 0xCE, 0x00,
  0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0xF0,
  0x07, 0x8F, 0x00, 0xF8, 0x78, 0x3B, 0x87, 0xFF, 0x38, 0x3F, 0xE7, 0x00,
  0xFC, 0x70, 0x0F, 0x00, 0x3C, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80,
  0x0E, 0x1E, 0x00, 0x38, 0x78, 0x01, 0xE1, 0xC0, 0x07, 0x87, 0x00, 0x1C,
  0x1C, 0x00, 0x70, 0x70, 0x01, 0xC3, 0xC0, 0x07, 0x0F, 0x00, 0x3C, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0E, 0x00, 0x38, 0x78, 0x00,
  0xE1, 0xE0, 0x07, 0x87, 0x00, 0x1E, 0x1C, 0x00, 0x70, 0x70, 0x01, 0xC1,
  0xC0, 0x07, 0x0F, 0x00, 0x1C, 0x3C, 0x00, 0xF0, 0xE0, 0x03, 0xC3, 0x80,
  0x0E, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xE0, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x80, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xC0, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0,
  0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x8F, 0x00, 0x70, 0xF0, 0x07, 0x07, 0x00, 0xF0,
  0x7C, 0x3E, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x00,
  0x1F, 0x0E, 0x00, 0x3C, 0x0E, 0x00, 0x78, 0x0E, 0x00, 0xF0, 0x0E, 0x01,
  0xE0, 0x1E, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x1C, 0x0F, 0x00, 0x1C, 0x1E,
  0x00, 0x1C, 0x3C, 0x00, 0x1C, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x3D, 0xF0,
  0x00, 0x3B, 0xF8, 0x00, 0x3F, 0xB8, 0x00, 0x3F, 0x3C, 0x00, 0x3E, 0x1C,
  0x00, 0x7C, 0x1C, 0x00, 0x78, 0x1E, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x0F,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x80, 0xF0, 0x03, 0x80, 0xF0, 0x03,
  0xC0, 0xE0, 0x03, 0xC0, 0xE0, 0x01, 0xE0, 0xE0, 0x01, 0xE0, 0x07, 0x00,
  0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x80,
  0x1E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x0F,
  0xC1, 0xF8, 0x1F, 0x83, 0xB0, 0x77, 0x0E, 0x70, 0xEE, 0x1C, 0xE3, 0x9C,
  0x39, 0xCE, 0x38, 0x71, 0x9C, 0xE0, 0xE3, 0xF1, 0xC1, 0xC7, 0xE3, 0x87,
  0x0F, 0x87, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x38, 0x30, 0x70, 0x70,
  0x60, 0xE0, 0xE0, 0x81, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x07, 0x0E, 0x00,
  0x0E, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE1, 0xC0, 0x01,
  0xC3, 0x80, 0x03, 0x87, 0x00, 0x07, 0x00, 0x0F, 0x80, 0x1C, 0x3E, 0x00,
  0xE0, 0xFC, 0x03, 0x83, 0xF0, 0x0E, 0x1F, 0xC0, 0x38, 0x77, 0x00, 0xE1,
  0xCC, 0x03, 0x87, 0x38, 0x1C, 0x1C, 0xE0, 0x70, 0x73, 0x81, 0xC3, 0xCE,
  0x07, 0x0E, 0x1C, 0x1C, 0x38, 0x70, 0x70, 0xE1, 0xC3, 0x83, 0x87, 0x0E,
  0x0E, 0x1C, 0x38, 0x78, 0x38, 0xE1, 0xC0, 0xE3, 0x87, 0x03, 0x8E, 0x1C,
  0x0E, 0x70, 0x70, 0x1D, 0xC1, 0xC0, 0x77, 0x0F, 0x01, 0xDC, 0x38, 0x07,
  0x70, 0xE0, 0x1F, 0xC3, 0x80, 0x3E, 0x0E, 0x00, 0xF8, 0x38, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0x83, 0xE0, 0xF0,
  0x0F, 0x07, 0x00, 0x38, 0x78, 0x01, 0xE3, 0x80, 0x0F, 0x3C, 0x00, 0x39,
  0xC0, 0x01, 0xCE, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xB8, 0x00,
  0x3D, 0xC0, 0x01, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0xF7, 0x80, 0x07, 0xBC,
  0x00, 0x39, 0xE0, 0x01, 0xC7, 0x00, 0x1E, 0x38, 0x00, 0xE1, 0xC0, 0x0F,
  0x0F, 0x00, 0xF0, 0x3C, 0x1F, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x1C, 0x01,
  0xF0, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x78, 0x00, 0xE3, 0xC0, 0x07, 0x1C,
  0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x1E, 0x38, 0x01, 0xE3, 0xC0, 0x1F,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xE0, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8,
  0x0F, 0x83, 0xE0, 0xF0, 0x0F, 0x07, 0x00, 0x38, 0x78, 0x01, 0xE3, 0x80,
  0x0F, 0x3C, 0x00, 0x39, 0xC0, 0x01, 0xCE, 0x00, 0x1E, 0xF0, 0x00, 0xF7,
  0x80, 0x07, 0xB8, 0x00, 0x3D, 0xC0, 0x01, 0xCE, 0x00, 0x0E, 0x70, 0x00,
  0xF7, 0x80, 0x07, 0xBC, 0x00, 0x39, 0xE0, 0x01, 0xC7, 0x00, 0x1E, 0x38,
  0x00, 0xE1, 0xC0, 0x0F, 0x0F, 0x00, 0xF0, 0x3C, 0x1F, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x30, 0x01,
  0xE3, 0xC0, 0x0F, 0x3C, 0x00, 0x3F, 0xC0, 0x00, 0xF8, 0x00, 0x03, 0x80,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x1C, 0x01, 0xF0, 0xE0,
  0x03, 0x87, 0x00, 0x1C, 0x78, 0x00, 0xE3, 0xC0, 0x07, 0x1C, 0x00, 0x38,
  0xE0, 0x01, 0xC7, 0x00, 0x1E, 0x38, 0x00, 0xE3, 0xC0, 0x1F, 0x1F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xC0, 0x38, 0x38, 0x01, 0xC1, 0xE0, 0x1E,
  0x07, 0x00, 0xF0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x3C,
  0x0E, 0x00, 0xE0, 0xF0, 0x07, 0x87, 0x80, 0x3C, 0x38, 0x00, 0xE1, 0xC0,
  0x07, 0x80, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xF0,
  0x3E, 0x0F, 0x00, 0x3C, 0x38, 0x00, 0x61, 0xE0, 0x01, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x80, 0x01, 0xC7, 0x00, 0x0F, 0x3E, 0x00, 0x78, 0x7E, 0x07, 0xC0, 0xFF,
  0xFF, 0x00, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x78, 0xE0, 0x03, 0x87, 0x00, 0x1C,
  0x38, 0x00, 0xE3, 0xC0, 0x07, 0x1E, 0x00, 0x78, 0xE0, 0x03, 0xC7, 0x00,
  0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x1E, 0x00, 0x38, 0xE0, 0x03, 0xC7,
  0x00, 0x1E, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0xF0, 0x01,
  0xC7, 0x00, 0x1E, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x70,
  0x03, 0xC3, 0x80, 0x1C, 0x1E, 0x01, 0xE0, 0x78, 0x1E, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xF0, 0x00, 0x3B, 0x80, 0x03, 0xDC,
  0x00, 0x1C, 0xE0, 0x01, 0xE7, 0x00, 0x0E, 0x38, 0x00, 0xF1, 0xC0, 0x07,
  0x0E, 0x00, 0x38, 0x78, 0x03, 0xC1, 0xC0, 0x1C, 0x0E, 0x01, 0xE0, 0x70,
  0x0E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x00, 0xE0, 0x78, 0x07, 0x03, 0x80,
  0x1C, 0x1C, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0xE0, 0x01, 0xC7,
  0x00, 0x0E, 0x78, 0x00, 0x73, 0x80, 0x03, 0xBC, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x38, 0x00, 0x0E, 0x70,
  0x00, 0x1C, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x73, 0x80, 0x01, 0xC7, 0x00,
  0x03, 0x8E, 0x00, 0x07, 0x1C, 0x1E, 0x0E, 0x30, 0x7C, 0x38, 0xE0, 0xF8,
  0x71, 0xC3, 0xF0, 0xE3, 0x87, 0xE1, 0xC7, 0x0D, 0xC3, 0x0E, 0x3B, 0x8E,
  0x1C, 0x77, 0x1C, 0x38, 0xCE, 0x38, 0x73, 0x9C, 0x60, 0xE6, 0x39, 0xC1,
  0x9C, 0x73, 0x83, 0x38, 0x67, 0x0E, 0x60, 0xCC, 0x1D, 0xC1, 0xB8, 0x3B,
  0x83, 0x70, 0x76, 0x06, 0xE0, 0xFC, 0x0D, 0xC1, 0xF8, 0x1F, 0x03, 0xE0,
  0x3E, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0x80, 0x03, 0xE0, 0x78, 0x00, 0x78,
  0x07, 0x00, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x0E, 0x01, 0xE0, 0x01, 0xE0,
  0x38, 0x00, 0x1C, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x38, 0xF0, 0x00,
  0x07, 0x3C, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF0, 0xE0,
  0x00, 0x3C, 0x1E, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x78,
  0x03, 0x80, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x07, 0x00, 0xE0, 0x00, 0xF0,
  0x7C, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xE7, 0x00, 0x07,
  0x1C, 0x00, 0x3C, 0x78, 0x01, 0xE0, 0xE0, 0x0F, 0x03, 0xC0, 0x3C, 0x07,
  0x01, 0xE0, 0x1C, 0x0F, 0x00, 0x78, 0x38, 0x00, 0xE1, 0xE0, 0x03, 0x8F,
  0x00, 0x07, 0x38, 0x00, 0x1D, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0xFF, 0xE0, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F,
  0xFE, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x0C, 0x01,
  0x80, 0x38, 0x07, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x60,
  0x0C, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x38, 0x03,
  0x00, 0x60, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x70, 0x0E, 0x01, 0xC0,
  0x18, 0x03, 0x00, 0x70, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x00, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x0E, 0xE0, 0x01, 0xC7, 0x00, 0x3C, 0x70,
  0x03, 0x87, 0x00, 0x70, 0x38, 0x0F, 0x03, 0x81, 0xE0, 0x1C, 0x1C, 0x01,
  0xC3, 0x80, 0x1C, 0x78, 0x00, 0xE7, 0x00, 0x0E, 0xE0, 0x00, 0x74, 0x00,
  0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x27, 0x9C, 0xE3,
  0x1C, 0xE2, 0x01, 0xF8, 0xF0, 0x7F, 0xCE, 0x0F, 0xFE, 0xE1, 0xF0, 0x6E,
  0x3C, 0x01, 0xE3, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x00, 0x1C, 0x70, 0x01,
  0xC7, 0x00, 0x1C, 0xF0, 0x01, 0xCF, 0x00, 0x1C, 0xE0, 0x03, 0xCE, 0x00,
  0x38, 0xE0, 0x07, 0x8F, 0x00, 0x78, 0x70, 0x0B, 0x87, 0x83, 0xB8, 0x7F,
  0xF7, 0xE3, 0xFE, 0x3E, 0x0F, 0x81, 0xE0, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE1, 0xF0, 0x1E, 0x7F, 0xC1, 0xCF,
  0xFC, 0x1D, 0xC3, 0xE1, 0xF0, 0x0E, 0x1E, 0x00, 0xF3, 0xC0, 0x0F, 0x3C,
  0x00, 0x73, 0x80, 0x07, 0x38, 0x00, 0xF3, 0x80, 0x0F, 0x38, 0x00, 0xE3,
  0x80, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x1E, 0x70, 0x03, 0xC7, 0x80, 0x3C,
  0x7C, 0x0F, 0x87, 0x7F, 0xF0, 0xE3, 0xFE, 0x0E, 0x1F, 0x80, 0x01, 0xFC,
  0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7C, 0x1E, 0x3C, 0x03, 0xCE, 0x00, 0x67,
  0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x4E, 0x00, 0x3B, 0xC0, 0x1E, 0x70, 0x0F,
  0x1F, 0x0F, 0x83, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x0F, 0xC3,
  0x81, 0xFF, 0x1C, 0x1F, 0xFD, 0xE1, 0xF0, 0x3E, 0x1E, 0x00, 0xF0, 0xF0,
  0x03, 0x8F, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x0F, 0x1C, 0x00, 0x71,
  0xE0, 0x03, 0x8F, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x0F, 0x1C, 0x00,
  0x78, 0xF0, 0x07, 0x83, 0x80, 0x7C, 0x1E, 0x0E, 0xE0, 0xFF, 0xE7, 0x03,
  0xFE, 0x38, 0x07, 0xE3, 0xC0, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xF8,
  0x7C, 0x0F, 0x3C, 0x01, 0xCE, 0x00, 0x77, 0x00, 0x1D, 0xC0, 0x1F, 0xF0,
  0x3F, 0xBF, 0xFF, 0xCF, 0xFF, 0xC3, 0xFF, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x1B, 0xC0, 0x0F, 0x70, 0x07, 0x9F, 0x07, 0xC3, 0xFF, 0xE0,
  0x7F, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x40, 0x70, 0x00, 0x1C, 0x0E,
  0x00, 0x07, 0xC1, 0xC0, 0x00, 0x3C, 0x38, 0x00, 0x03, 0xC7, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x38, 0x1F, 0xF1, 0xC1, 0xFF, 0xDC, 0x1F, 0x07,
  0xE1, 0xF0, 0x0F, 0x0F, 0x00, 0x38, 0xF0, 0x01, 0xC7, 0x00, 0x0E, 0x38,
  0x00, 0xE1, 0xC0, 0x07, 0x1E, 0x00, 0x38, 0xF0, 0x01, 0xC7, 0x80, 0x0E,
  0x38, 0x00, 0xF1, 0xE0, 0x07, 0x0F, 0x00, 0x78, 0x38, 0x07, 0xC1, 0xF0,
  0xEE, 0x07, 0xFE, 0x70, 0x3F, 0xE3, 0x80, 0x7E, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x20, 0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xFF,
  0x80, 0x7F, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC3, 0xE0, 0x39, 0xFE, 0x0F, 0x7F, 0xE1,
  0xEC, 0x3C, 0x3A, 0x03, 0xC7, 0xC0, 0x78, 0xF0, 0x07, 0x1C, 0x00, 0xE7,
  0x80, 0x3C, 0xF0, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x03, 0x8E,
  0x00, 0x73, 0xC0, 0x1E, 0x70, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x0E, 0x38,
  0x01, 0xC7, 0x00, 0x39, 0xE0, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFE, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x01, 0x00,
  0xE0, 0x70, 0x1C, 0x1F, 0x07, 0x87, 0x80, 0xE1, 0xE0, 0x1C, 0x78, 0x03,
  0xBE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x40, 0x38, 0x1C, 0x0F, 0x07, 0x81,
  0xC0, 0x78, 0x38, 0x07, 0x87, 0x00, 0x78, 0xE0, 0x07, 0x9C, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0xF8, 0x03, 0x9F, 0xE0, 0x3D,
  0xFF, 0x81, 0xDC, 0x3E, 0x0E, 0x80, 0xF0, 0x7C, 0x03, 0x83, 0xC0, 0x3C,
  0x1C, 0x01, 0xC1, 0xE0, 0x1E, 0x0E, 0x01, 0xE0, 0x70, 0x7C, 0x03, 0x9F,
  0x80, 0x1C, 0xE0, 0x00, 0xE3, 0x80, 0x8F, 0x1C, 0x06, 0x70, 0x70, 0x7B,
  0x83, 0xCF, 0x9C, 0x0E, 0xF8, 0xE0, 0x7F, 0x87, 0x01, 0xF8, 0x78, 0x07,
  0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x10, 0x70, 0x18,
  0x38, 0x3E, 0x1C, 0x3E, 0x1C, 0x3C, 0x0E, 0x3C, 0x07, 0x3C, 0x03, 0xFC,
  0x01, 0xFC, 0x00, 0x78, 0x00, 0x0E, 0x78, 0x78, 0x1D, 0xF9, 0xF8, 0x77,
  0xF7, 0xF8, 0xE8, 0xF8, 0xF1, 0xE1, 0xE0, 0xE3, 0x83, 0xC1, 0xC7, 0x07,
  0x03, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x70, 0x38, 0x38, 0xE0, 0x70,
  0x71, 0xC1, 0xC0, 0xE3, 0x83, 0x81, 0x87, 0x07, 0x07, 0x0C, 0x0E, 0x0E,
  0x38, 0x1C, 0x1C, 0x70, 0x38, 0x38, 0xE0, 0xE0, 0x71, 0xC1, 0xC0, 0xC3,
  0x83, 0x83, 0x8E, 0x07, 0x07, 0x00, 0x0E, 0x1F, 0x01, 0xCF, 0xF0, 0x7B,
  0xFF, 0x0E, 0x61, 0xE1, 0xD0, 0x1E, 0x3E, 0x03, 0xC7, 0x80, 0x38, 0xE0,
  0x07, 0x3C, 0x01, 0xE7, 0x80, 0x38, 0xE0, 0x07, 0x1C, 0x00, 0xE3, 0x80,
  0x1C, 0x70, 0x03, 0x9E, 0x00, 0xF3, 0x80, 0x1C, 0x70, 0x03, 0x8E, 0x00,
  0x71, 0xC0, 0x0E, 0x38, 0x01, 0xCF, 0x00, 0x78, 0x01, 0xF8, 0x01, 0xFF,
  0x80, 0xFF, 0xF8, 0x78, 0x1E, 0x3C, 0x03, 0xDE, 0x00, 0x77, 0x00, 0x1F,
  0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3B, 0x80, 0x1E, 0xF0, 0x0F, 0x1E, 0x07,
  0x87, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xE0, 0x00, 0x0F, 0x0F, 0x80, 0x71,
  0xFF, 0x03, 0x9F, 0xF8, 0x1D, 0xC3, 0xE0, 0xF8, 0x07, 0x07, 0x80, 0x3C,
  0x78, 0x01, 0xE3, 0xC0, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x03, 0xC7, 0x00,
  0x1E, 0x38, 0x00, 0xE3, 0xC0, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x03, 0xC7,
  0x00, 0x3C, 0x3C, 0x01, 0xE1, 0xF0, 0x3E, 0x1E, 0xFF, 0xE0, 0xE3, 0xFE,
  0x07, 0x0F, 0xC0, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x70, 0x7F, 0xC7, 0x0F, 0xFE, 0xE1, 0xF0, 0x3E, 0x3C,
  0x01, 0xE3, 0xC0, 0x0E, 0x78, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x01, 0xC7,
  0x00, 0x1C, 0xF0, 0x01, 0xCF, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x3C,
  0xE0, 0x03, 0x8F, 0x00, 0x78, 0x70, 0x0F, 0x87, 0x83, 0xB8, 0x7F, 0xF3,
  0x83, 0xFE, 0x78, 0x0F, 0x87, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x7F, 0xC3, 0xF7, 0xF8, 0xFE, 0xFF, 0x9F, 0xE0, 0x3B, 0x80,
  0x03, 0xA0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0,
  0x3F, 0xFF, 0x87, 0x80, 0xF1, 0xC0, 0x0C, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0x80, 0x00, 0x72, 0x00, 0x0E, 0x70, 0x03, 0xDF,
  0x81, 0xF1, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x3C, 0x02, 0x0E, 0x03, 0x83, 0x81, 0xF0, 0xE1,
  0xF8, 0x38, 0xF8, 0x0E, 0xFC, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x1E, 0x00,
  0x1C, 0x01, 0xE7, 0x80, 0x38, 0xE0, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x1C,
  0x70, 0x03, 0x8E, 0x00, 0xF3, 0xC0, 0x1E, 0x70, 0x03, 0x8E, 0x00, 0x71,
  0xC0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x03, 0xC7,
  0x80, 0x78, 0xF0, 0x17, 0x0F, 0x0E, 0xE1, 0xFF, 0xBC, 0x1F, 0xE7, 0x81,
  0xF8, 0xE0, 0xFF, 0x00, 0xDF, 0xC0, 0x7B, 0xF8, 0x07, 0x07, 0x00, 0xE0,
  0xE0, 0x1E, 0x1C, 0x03, 0xC7, 0x80, 0x78, 0xE0, 0x0F, 0x1C, 0x01, 0xC3,
  0x80, 0x38, 0x70, 0x07, 0x0E, 0x01, 0xE1, 0xC0, 0x38, 0x70, 0x0F, 0x0E,
  0x03, 0xC1, 0xC0, 0xF0, 0x38, 0x3E, 0x07, 0x1F, 0x80, 0xFF, 0xC0, 0x1F,
  0xF0, 0x01, 0xF0, 0x00, 0x38, 0x38, 0x31, 0xC1, 0xC3, 0x8E, 0x0E, 0x0C,
  0x70, 0x70, 0x73, 0x03, 0x83, 0xB8, 0x18, 0x1D, 0xC1, 0xC0, 0xEE, 0x0E,
  0x07, 0x70, 0x70, 0x3B, 0x83, 0x81, 0x98, 0x1C, 0x1D, 0xC0, 0xC0, 0xEE,
  0x0E, 0x07, 0x70, 0x70, 0x3B, 0x83, 0x83, 0x9C, 0x1C, 0x1C, 0xE1, 0x61,
  0xC7, 0x1B, 0x1E, 0x3F, 0x9F, 0xE1, 0xFC, 0xFE, 0x07, 0x83, 0xE0, 0x00,
  0x00, 0xE0, 0x7C, 0x03, 0xF0, 0xFE, 0x07, 0xF9, 0xFE, 0x0F, 0x3B, 0x8F,
  0x3E, 0x3B, 0x07, 0x38, 0x3B, 0x07, 0x10, 0x3E, 0x07, 0x00, 0x1E, 0x07,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0xE0, 0x78, 0x00, 0xE0, 0x7C, 0x08, 0xE0, 0xDC, 0x3C,
  0xE0, 0xDC, 0x78, 0xF1, 0xDD, 0xF0, 0x7F, 0x9F, 0xE0, 0x7F, 0x0F, 0xC0,
  0x3E, 0x0F, 0x00, 0x07, 0x00, 0x78, 0x78, 0x03, 0x83, 0x80, 0x1C, 0x1C,
  0x00, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x38, 0x01, 0xC3, 0xC0, 0x1C,
  0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x38, 0x01, 0xC1, 0xC0,
  0x1E, 0x1E, 0x00, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x1C, 0x05, 0xC0,
  0xF0, 0xEE, 0x07, 0xFE, 0xF0, 0x1F, 0xE7, 0x00, 0x7E, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x20, 0x0F, 0x03, 0xC1, 0xF0, 0x3F,
  0xFF, 0x00, 0x7F, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x70, 0xFF,
  0xE7, 0x1F, 0xFF, 0x71, 0xC1, 0xFF, 0x38, 0x03, 0xE3, 0x80, 0x3C, 0x38,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x80, 0x70, 0x1C, 0x0E, 0x01, 0xC3, 0xC0, 0x0E,
  0x7F, 0x80, 0xEF, 0xFF, 0xCE, 0xF7, 0xFF, 0xEE, 0x0F, 0xFC, 0xE0, 0x1F,
  0x80, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x7F, 0xE0, 0x0F, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0x03, 0x81, 0x80, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0C,
  0x06, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x01, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x0C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xC0, 0x60, 0x70, 0x38, 0x1C, 0x00, 0x03, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0xC0, 0x07,
  0xF0, 0x0F, 0xFC, 0x07, 0x80, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x07, 0x80, 0x30, 0xFE, 0x01, 0xCF, 0xF8,
  0x1C, 0x71, 0xC0, 0xE7, 0x07, 0x0E, 0x38, 0x3C, 0xF3, 0x80, 0xFF, 0x1C,
  0x03, 0xF0, 0x40, 0x0F, 0x00,
};

const GFXglyph IBMPlexMono_Italic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 9, 28, 24, 8, -28 },
  { 33, 12, 11, 24, 8, -30 },
  { 50, 25, 28, 24, 0, -28 },
  { 138, 22, 36, 24, 1, -32 },
  { 237, 27, 28, 24, -1, -28 },
  { 332, 24, 28, 24, 0, -28 },
  { 416, 5, 11, 24, 12, -30 },
  { 423, 15, 36, 24, 8, -30 },
  { 491, 15, 36, 24, 2, -30 },
  { 559, 20, 20, 24, 2, -22 },
  { 609, 19, 19, 24, 3, -22 },
  { 655, 9, 11, 24, 6, -5 },
  { 668, 12, 3, 24, 6, -14 },
  { 673, 6, 5, 24, 8, -5 },
  { 677, 23, 36, 24, 1, -30 },
  { 781, 21, 28, 24, 2, -28 },
  { 855, 19, 28, 24, 2, -28 },
  { 922, 21, 28, 24, 1, -28 },
  { 996, 21, 28, 24, 1, -28 },
  { 1070, 21, 28, 24, 1, -28 },
  { 1144, 21, 28, 24, 2, -28 },
  { 1218, 19, 28, 24, 2, -28 },
  { 1285, 20, 28, 24, 4, -28 },
  { 1355, 21, 28, 24, 2, -28 },
  { 1429, 19, 28, 24, 3, -28 },
  { 1496, 8, 21, 24, 8, -21 },
  { 1517, 10, 27, 24, 6, -21 },
  { 1551, 19, 23, 24, 4, -24 },
  { 1606, 21, 11, 24, 2, -18 },
  { 1635, 19, 23, 24, 2, -24 },
  { 1690, 17, 28, 24, 5, -28 },
  { 1750, 20, 32, 24, 2, -28 },
  { 1830, 21, 28, 24, 0, -28 },
  { 1904, 20, 28, 24, 2, -28 },
  { 1974, 20, 28, 24, 3, -28 },
  { 2044, 21, 28, 24, 2, -28 },
  { 2118, 22, 28, 24, 2, -28 },
  { 2195, 22, 28, 24, 2, -28 },
  { 2272, 20, 28, 24, 3, -28 },
  { 2342, 22, 28, 24, 2, -28 },
  { 2419, 22, 28, 24, 2, -28 },
  { 2496, 20, 28, 24, 2, -28 },
  { 2566, 24, 28, 24, 2, -28 },
  { 2650, 17, 28, 24, 3, -28 },
  { 2710, 23, 28, 24, 1, -28 },
  { 2791, 22, 28, 24, 2, -28 },
  { 2868, 21, 28, 24, 2, -28 },
  { 2942, 21, 28, 24, 2, -28 },
  { 3016, 21, 35, 24, 2, -28 },
  { 3108, 21, 28, 24, 2, -28 },
  { 3182, 22, 28, 24, 1, -28 },
  { 3259, 23, 28, 24, 3, -28 },
  { 3340, 21, 28, 24, 3, -28 },
  { 3414, 21, 28, 24, 4, -28 },
  { 3488, 23, 28, 24, 2, -28 },
  { 3569, 27, 28, 24, -1, -28 },
  { 3664, 22, 28, 24, 4, -28 },
  { 3741, 24, 28, 24, 0, -28 },
  { 3825, 17, 36, 24, 6, -30 },
  { 3902, 11, 36, 24, 7, -30 },
  { 3952, 17, 36, 24, 0, -30 },
  { 4029, 20, 16, 24, 3, -28 },
  { 4069, 20, 3, 24, 0, 4 },
  { 4077, 5, 8, 24, 9, -31 },
  { 4082, 20, 21, 24, 2, -21 },
  { 4135, 20, 30, 24, 2, -30 },
  { 4210, 18, 21, 24, 3, -21 },
  { 4258, 21, 30, 24, 2, -30 },
  { 4337, 18, 21, 24, 3, -21 },
  { 4385, 27, 38, 24, -1, -30 },
  { 4514, 21, 29, 24, 1, -21 },
  { 4591, 19, 30, 24, 2, -30 },
  { 4663, 19, 31, 24, 3, -31 },
  { 4737, 19, 39, 24, 2, -31 },
  { 4830, 21, 30, 24, 2, -30 },
  { 4909, 17, 30, 24, 4, -30 },
  { 4973, 23, 21, 24, 0, -21 },
  { 5034, 19, 21, 24, 2, -21 },
  { 5084, 18, 21, 24, 3, -21 },
  { 5132, 21, 29, 24, 1, -21 },
  { 5209, 20, 29, 24, 2, -21 },
  { 5282, 20, 21, 24, 4, -21 },
  { 5335, 19, 21, 24, 2, -21 },
  { 5385, 18, 28, 24, 3, -28 },
  { 5448, 19, 21, 24, 3, -21 },
  { 5498, 19, 21, 24, 3, -21 },
  { 5548, 21, 21, 24, 2, -21 },
  { 5604, 24, 21, 24, 0, -21 },
  { 5667, 21, 29, 24, 1, -21 },
  { 5744, 20, 21, 24, 2, -21 },
  { 5797, 19, 36, 24, 4, -30 },
  { 5883, 9, 36, 24, 8, -30 },
  { 5924, 18, 36, 24, 2, -30 },
  { 6005, 21, 9, 24, 2, -17 },
};

const GFXfont IBMPlexMono_Italic40pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic40pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic40pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _IBMPLEXMONO_ITALIC40PT7B_H_
