#ifndef _IBMPLEXMONO_ITALIC54PT7B_H_
#define _IBMPLEXMONO_ITALIC54PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic54pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x7F, 0x03, 0xF8, 0x3F, 0xC1, 0xFE, 0x07,
  0xF0, 0x3F, 0x00, 0x1E, 0x0F, 0x1E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C,
  0x1F, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78,
  0x3E, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0xF0, 0x3C, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x81, 0xC0, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x0F, 0xFF, 0x03, 0xFF, 0x0F, 0xFE, 0x07,
  0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0x1F, 0xFE, 0x07, 0xFF, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0xFF, 0xE0, 0x7F,
  0xF0, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xF0, 0x03, 0xC0, 0xF0,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0x81, 0xF0, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x07, 0x03, 0xE0, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xF8, 0xE7, 0xF0, 0x0F, 0xC1, 0xC3, 0xF0,
  0x1F, 0x07, 0x83, 0xF0, 0x7C, 0x0F, 0x03, 0x80, 0xF0, 0x1C, 0x02, 0x01,
  0xE0, 0x38, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x1F, 0x07, 0x00, 0x00, 0x3E, 0x0E, 0x00, 0x00, 0x7F,
  0x1C, 0x00, 0x00, 0x7F, 0xB8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1C, 0x7F, 0x00, 0x00, 0x38, 0x3E, 0x00, 0x00, 0xF0,
  0x3E, 0x00, 0x01, 0xC0, 0x7C, 0x00, 0x03, 0x80, 0xF8, 0x00, 0x07, 0x01,
  0xF0, 0x00, 0x0E, 0x03, 0xE0, 0x40, 0x1C, 0x07, 0xC1, 0x80, 0x78, 0x0F,
  0x07, 0x80, 0xE0, 0x3E, 0x1F, 0x81, 0xC0, 0xF8, 0x1F, 0x83, 0x83, 0xF0,
  0x1F, 0xE7, 0x1F, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x07, 0xFC, 0x00, 0x1E,
  0x00, 0xFF, 0xE0, 0x01, 0xE0, 0x1E, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x70,
  0x07, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x00, 0x78,
  0x07, 0x81, 0xE0, 0x07, 0x00, 0x78, 0x1E, 0x00, 0xF0, 0x07, 0x83, 0xC0,
  0x0F, 0x00, 0x78, 0x78, 0x00, 0xF0, 0x07, 0x07, 0x00, 0x0F, 0x00, 0xF0,
  0xF0, 0x00, 0x70, 0x0F, 0x1E, 0x00, 0x07, 0x01, 0xE3, 0xC0, 0x00, 0x78,
  0x3C, 0x3C, 0x00, 0x03, 0xFF, 0xC4, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3E, 0x1F, 0xFC, 0x00, 0x03,
  0xC3, 0xC1, 0xE0, 0x00, 0x78, 0x78, 0x0E, 0x00, 0x0F, 0x07, 0x00, 0xF0,
  0x00, 0xF0, 0xF0, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0xE0,
  0x0F, 0x00, 0x3C, 0x1E, 0x00, 0xF0, 0x07, 0x81, 0xE0, 0x0E, 0x00, 0xF0,
  0x1E, 0x01, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x3C, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x78, 0x00, 0x7F,
  0xF0, 0x0F, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0xF8, 0x03, 0xE0, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0xF0, 0x01, 0xE0, 0x00,
  0xF0, 0x01, 0xE0, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0xF0, 0x03, 0xE0, 0x00,
  0xF8, 0x03, 0xE0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x78, 0x07, 0xC0, 0x00,
  0x7C, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0xFE, 0x3F, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0xF8,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF0, 0x0C, 0xF8, 0x00, 0xF8, 0x0E, 0xF8,
  0x00, 0xF8, 0x1F, 0xF8, 0x01, 0xBC, 0x1E, 0xF8, 0x01, 0xBC, 0x3C, 0x7C,
  0x03, 0xBE, 0x7C, 0x7E, 0x0F, 0x1E, 0x78, 0x3F, 0xFF, 0x1F, 0xF8, 0x1F,
  0xFE, 0x0F, 0xF0, 0x0F, 0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x03, 0xC0, 0x3E,
  0x78, 0xF1, 0xE3, 0xC7, 0x9E, 0x3C, 0x78, 0xF1, 0xE3, 0xCF, 0x1E, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x60, 0x0F, 0x00, 0x2F, 0x81, 0xE0, 0x3F, 0xFC,
  0x3C, 0x3F, 0xFF, 0xF7, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xCF, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x1E, 0x00,
  0x1F, 0x03, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00,
  0x78, 0x03, 0x80, 0x06, 0x00, 0x20, 0x01, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF8,
  0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x1F,
  0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x00, 0x7F,
  0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0xDF, 0xFF, 0xE0, 0x3E, 0x7F, 0x7F, 0xFF,
  0xFF, 0x7F, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x01,
  0xFC, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00,
  0x1E, 0x0F, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF1,
  0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x3C, 0x00,
  0x01, 0xF3, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0xF8, 0x1F,
  0x7C, 0x1F, 0xC1, 0xE7, 0xC1, 0xFC, 0x1E, 0x78, 0x1F, 0x83, 0xE7, 0x81,
  0xF8, 0x3E, 0xF8, 0x1F, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03,
  0xCF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x78, 0xF8,
  0x00, 0x0F, 0x87, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x1F, 0x07, 0x80, 0x01,
  0xE0, 0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x03, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x78, 0x00, 0x3F, 0x9E, 0x00, 0x1F, 0x8F,
  0x80, 0x0F, 0xC3, 0xE0, 0x07, 0xE0, 0xF0, 0x03, 0xF0, 0x3C, 0x01, 0xF0,
  0x0F, 0x00, 0x38, 0x03, 0xC0, 0x04, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x07, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xF8, 0x1F, 0xC0,
  0x3F, 0x00, 0x7E, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x0F, 0x80,
  0x01, 0xF0, 0x70, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0,
  0x7F, 0x00, 0xFC, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xE0, 0x18, 0x00, 0x1F,
  0x00, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x40, 0x00, 0x1F, 0x0F,
  0x00, 0x01, 0xF0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3E, 0xF0, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x1E, 0x7C, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x1F, 0x1E, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0xF0, 0x7C, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0xF8, 0x1E, 0x00,
  0x0F, 0x80, 0xF0, 0x00, 0x78, 0x07, 0x80, 0x07, 0x80, 0x3C, 0x00, 0x78,
  0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x3E, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0xF8, 0x1E, 0x00, 0x07, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFE, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x0F, 0xE0, 0x00, 0xF3, 0xFF, 0x80, 0x0E, 0x7F, 0xFE, 0x01, 0xEF,
  0xFF, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF0, 0x01, 0xF8, 0x1E, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x10, 0x00, 0x0F, 0x07,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xE0, 0x7F, 0x01,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x7F, 0x00, 0x7C, 0xFF, 0xF0, 0x1E, 0x7F, 0xFE, 0x0F,
  0xBF, 0xFF, 0xC3, 0xDE, 0x03, 0xF8, 0xFE, 0x00, 0x7E, 0x7F, 0x00, 0x0F,
  0x9F, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xBE, 0x00, 0x03, 0xE7, 0x80, 0x00, 0xF9, 0xE0, 0x00, 0x7C,
  0x7C, 0x00, 0x3E, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x1F, 0xC0, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xE7, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x3C, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0xF8, 0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x07, 0xC3, 0xC0, 0x01, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xC0, 0x7F, 0x01, 0xF8, 0x00, 0xF8, 0x1F, 0x80, 0x03, 0xE0, 0xF8, 0x00,
  0x1F, 0x07, 0x80, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3C,
  0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x1F, 0x03, 0xC0, 0x01, 0xF0, 0x1F,
  0x00, 0x1F, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7E, 0x03, 0xF8,
  0x07, 0xC0, 0x07, 0xE0, 0x78, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x78, 0x7C,
  0x00, 0x03, 0xE3, 0xC0, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0xF9, 0xF0, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0x3E, 0x7C, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F,
  0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0xFC, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC1, 0xFE, 0x07, 0xF0, 0xF8, 0x00,
  0xF8, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xBF, 0x00, 0x1B, 0xCF, 0xE0, 0x3B, 0xE3, 0xFF, 0xF9, 0xE1,
  0xFF, 0xF9, 0xF0, 0x3F, 0xF8, 0xF0, 0x07, 0xF0, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFE, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x7F, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0x7F, 0x07, 0xC0, 0x00,
  0x7C, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80,
  0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3C,
  0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x80,
  0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0x80, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xF8, 0x1F,
  0xC7, 0xC0, 0x0F, 0x9F, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3E,
  0x60, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xE0, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0x3F, 0x80, 0xFC, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x00, 0xF8,
  0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x78, 0x00,
  0x03, 0x8F, 0x00, 0xF8, 0x71, 0xE0, 0x7F, 0x9E, 0x78, 0x1F, 0xFB, 0xCF,
  0x03, 0xFF, 0x79, 0xE0, 0xF8, 0x3F, 0x3C, 0x3E, 0x03, 0xEF, 0x87, 0x80,
  0x79, 0xE0, 0xF0, 0x0F, 0x3C, 0x3E, 0x01, 0xE7, 0x87, 0x80, 0x3C, 0xF0,
  0xF0, 0x07, 0x9E, 0x1E, 0x00, 0xF7, 0x83, 0xC0, 0x1C, 0xF0, 0x78, 0x07,
  0x9E, 0x0F, 0x00, 0xF3, 0xC1, 0xE0, 0x3E, 0x78, 0x3C, 0x07, 0xCF, 0x07,
  0x81, 0x79, 0xE0, 0xFC, 0xEE, 0x3C, 0x1F, 0xFB, 0xC7, 0x81, 0xFF, 0x78,
  0xF0, 0x1F, 0xCF, 0x1E, 0x00, 0x40, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x1E, 0x0F,
  0x00, 0x01, 0xF0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x3C, 0x07, 0xC0, 0x03, 0xC0, 0x3E, 0x00, 0x1E,
  0x00, 0xF0, 0x01, 0xF0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x01,
  0xE0, 0x07, 0x80, 0x0F, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0x00, 0x03, 0xC0, 0xF8,
  0x00, 0x1E, 0x0F, 0x80, 0x00, 0xF0, 0x7C, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x3E, 0x3E, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7C,
  0xF0, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x7C, 0x01,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFE, 0x03, 0xC0, 0x07, 0xE0, 0x3C, 0x00, 0x1F, 0x03, 0xC0, 0x01, 0xF0,
  0x3C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0x80,
  0x01, 0xF0, 0x78, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x3E,
  0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x01, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x1F,
  0x81, 0xF0, 0x00, 0x7C, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x1E,
  0x00, 0x03, 0xE1, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x3E, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x7C, 0x3C, 0x00, 0x07, 0xC3,
  0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x87, 0xC0, 0x07, 0xF0, 0x7F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xC0, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x0F, 0x81, 0xF0, 0x00, 0xF8,
  0x3E, 0x00, 0x0F, 0x0F, 0x80, 0x01, 0xE3, 0xE0, 0x00, 0x30, 0x7C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x60, 0xF0, 0x00, 0x1F, 0x1E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8,
  0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x80, 0xFE, 0x07, 0xE0, 0x0F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF8, 0x03, 0xC0, 0x3F, 0x80, 0x7C, 0x00, 0xFC, 0x07, 0xC0, 0x07,
  0xC0, 0x78, 0x00, 0x3E, 0x07, 0x80, 0x03, 0xE0, 0x78, 0x00, 0x1E, 0x07,
  0x80, 0x01, 0xE0, 0xF8, 0x00, 0x1E, 0x0F, 0x80, 0x01, 0xF0, 0xF0, 0x00,
  0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE1,
  0xF0, 0x00, 0x1E, 0x1F, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x3E, 0x1E, 0x00,
  0x03, 0xE1, 0xE0, 0x00, 0x3E, 0x1E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3C,
  0x3E, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x7C, 0x3C, 0x00, 0x07, 0xC3, 0xC0,
  0x00, 0xF8, 0x3C, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F,
  0x07, 0x80, 0x03, 0xE0, 0x78, 0x00, 0xFC, 0x07, 0x80, 0x3F, 0x80, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x80, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0x81, 0xF8, 0x0F,
  0xC0, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x1E, 0x1F, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x20, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x03,
  0xFF, 0xCF, 0x80, 0x7F, 0xF9, 0xE0, 0x0F, 0xFF, 0x3C, 0x03, 0xFF, 0xC7,
  0x80, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x3C, 0x78, 0x00, 0x0F, 0x8F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x3E,
  0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x7E, 0x0F, 0x80, 0x3B,
  0xC1, 0xFC, 0x0E, 0xF8, 0x1F, 0xFF, 0xDE, 0x01, 0xFF, 0xF3, 0xC0, 0x1F,
  0xF8, 0x78, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80,
  0x01, 0xF0, 0x3C, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x78, 0x1F, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E,
  0x07, 0x80, 0x00, 0xF8, 0x1E, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x03,
  0xE0, 0x00, 0x3C, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF0,
  0x00, 0x1F, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0x7F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xE0, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0xF0,
  0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x7C, 0x0F,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1E, 0x07, 0xC0,
  0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x0F, 0x81, 0xE0, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x20, 0x00, 0xF8, 0x3E, 0x00, 0x1F,
  0x07, 0xC0, 0x03, 0xE0, 0x78, 0x00, 0xF8, 0x0F, 0x80, 0x3F, 0x01, 0xFC,
  0x1F, 0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x1F,
  0x00, 0x07, 0xC0, 0x1F, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x01, 0xE0, 0x1F,
  0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x0F, 0x1F,
  0x80, 0x00, 0x07, 0x9F, 0xC0, 0x00, 0x03, 0xDF, 0xF0, 0x00, 0x03, 0xFF,
  0x78, 0x00, 0x01, 0xFF, 0x3E, 0x00, 0x00, 0xFF, 0x1F, 0x00, 0x00, 0x7F,
  0x07, 0xC0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x1E, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0xFE, 0x03,
  0xF8, 0x01, 0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFE, 0x07,
  0xBC, 0x03, 0xFC, 0x07, 0xBC, 0x07, 0xBC, 0x07, 0x9C, 0x0F, 0xBC, 0x07,
  0x9E, 0x0F, 0x3C, 0x07, 0x9E, 0x1E, 0x3C, 0x07, 0x9E, 0x1E, 0x3C, 0x0F,
  0x0E, 0x3C, 0x78, 0x0F, 0x0F, 0x3C, 0x78, 0x0F, 0x0F, 0x78, 0x78, 0x0F,
  0x0F, 0xF0, 0x78, 0x0F, 0x07, 0xF0, 0x78, 0x0F, 0x07, 0xE0, 0x78, 0x1F,
  0x07, 0xE0, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1E,
  0x03, 0x80, 0xF0, 0x1E, 0x03, 0x00, 0xF0, 0x1E, 0x03, 0x00, 0xF0, 0x3E,
  0x02, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x7C,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0xF8,
  0x00, 0x07, 0x80, 0x03, 0xF8, 0x00, 0x3C, 0x0F, 0xE0, 0x00, 0xF0, 0x3F,
  0x80, 0x07, 0xC0, 0xFF, 0x00, 0x1E, 0x03, 0xFC, 0x00, 0x78, 0x1F, 0xF0,
  0x01, 0xE0, 0x7B, 0xC0, 0x07, 0x81, 0xE7, 0x00, 0x1E, 0x07, 0x9E, 0x00,
  0xF8, 0x1E, 0x78, 0x03, 0xC0, 0x79, 0xE0, 0x0F, 0x03, 0xE7, 0x80, 0x3C,
  0x0F, 0x0F, 0x00, 0xF0, 0x3C, 0x3C, 0x03, 0xC0, 0xF0, 0xF0, 0x1F, 0x03,
  0xC3, 0xC0, 0x78, 0x0F, 0x07, 0x01, 0xE0, 0x7C, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0x78, 0x0F,
  0x0F, 0x01, 0xE0, 0x3C, 0x3C, 0x0F, 0x80, 0xF0, 0xF0, 0x3C, 0x03, 0xC3,
  0xC0, 0xF0, 0x0F, 0x0F, 0x03, 0xC0, 0x1E, 0x7C, 0x0F, 0x00, 0x79, 0xE0,
  0x3C, 0x01, 0xE7, 0x80, 0xF0, 0x07, 0x9E, 0x07, 0x80, 0x0F, 0x78, 0x1E,
  0x00, 0x3D, 0xE0, 0x78, 0x00, 0xFF, 0x81, 0xE0, 0x03, 0xFC, 0x07, 0x80,
  0x0F, 0xF0, 0x1E, 0x00, 0x1F, 0xC0, 0xF0, 0x00, 0x7F, 0x03, 0xC0, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF8, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x07,
  0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x1E, 0x0F, 0x80, 0x01, 0xE0, 0xF0, 0x00,
  0x1F, 0x1F, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x1F, 0x7C, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x1E,
  0x78, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x3E, 0xF8, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0x78, 0xF8, 0x00, 0x0F, 0x87, 0x80, 0x00, 0xF0, 0x78,
  0x00, 0x1F, 0x07, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x0F,
  0xC0, 0x3F, 0x03, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7C, 0x00,
  0x3F, 0x03, 0xC0, 0x00, 0xF8, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E,
  0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3C, 0x1E,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF8, 0x7C, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xE0, 0xF0, 0x00, 0x7E,
  0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xFF, 0xF8, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x07, 0xE0,
  0x03, 0xE0, 0x7C, 0x00, 0x1E, 0x0F, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x1F,
  0x1F, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x1F, 0x3E, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x1E, 0x78,
  0x00, 0x03, 0xE7, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x3E, 0xF8, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x78, 0xF8, 0x00, 0x0F, 0x87, 0x80, 0x00, 0xF0, 0x78, 0x00,
  0x1F, 0x07, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x0F, 0xC0,
  0x3F, 0x03, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x10, 0x00, 0x3E, 0x01,
  0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x7D, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x7C, 0x00, 0x3F, 0x03, 0xC0, 0x00, 0xF8, 0x1E,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x1F,
  0x00, 0x07, 0xE0, 0xF0, 0x00, 0x7E, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x00, 0xF8, 0x1E, 0x00,
  0x07, 0x80, 0xF8, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x1F, 0x00, 0x1F,
  0x00, 0x78, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00,
  0x78, 0x01, 0xE0, 0x03, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x7C,
  0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x7C, 0x0F,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFC,
  0x03, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x0E, 0x07, 0xC0, 0x00, 0x10, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x83,
  0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x07, 0xC1, 0xFC,
  0x00, 0x3F, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x1E, 0x0F,
  0x00, 0x01, 0xE1, 0xF0, 0x00, 0x1E, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x3E, 0x1E, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC3,
  0xE0, 0x00, 0x3C, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3C, 0x00,
  0x07, 0xC3, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x78,
  0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x78, 0x00, 0x0F, 0x87, 0x80,
  0x00, 0xF0, 0x78, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x1F,
  0x0F, 0x80, 0x01, 0xF0, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x1E, 0x0F, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x07,
  0xC0, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x80, 0x7E, 0x03, 0xF8, 0x03,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x7C, 0x78,
  0x00, 0x07, 0x87, 0x80, 0x00, 0xF8, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x01,
  0xF0, 0x78, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x3E, 0x03,
  0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x7C, 0x03, 0xC0, 0x07, 0x80, 0x3C, 0x00,
  0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x03, 0xE0, 0x1E, 0x00,
  0x1E, 0x03, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xE0,
  0x7C, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x1E, 0x0F, 0x00,
  0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x0F,
  0x3C, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x03, 0xE0, 0x3C, 0x1E,
  0x07, 0xE0, 0x3C, 0x1E, 0x07, 0xE0, 0x78, 0x1C, 0x07, 0xE0, 0x78, 0x1C,
  0x0F, 0xE0, 0x78, 0x3C, 0x0E, 0xE0, 0x78, 0x3C, 0x1E, 0xE0, 0xF0, 0x3C,
  0x1E, 0xE0, 0xF0, 0x3C, 0x1C, 0xE0, 0xF0, 0x3C, 0x3C, 0xE0, 0xF0, 0x3C,
  0x38, 0xE0, 0xE0, 0x3C, 0x38, 0xE1, 0xE0, 0x3C, 0x78, 0xF1, 0xE0, 0x3C,
  0x70, 0xF1, 0xE0, 0x38, 0xF0, 0xF1, 0xC0, 0x38, 0xF0, 0xF3, 0xC0, 0x78,
  0xE0, 0xF3, 0xC0, 0x79, 0xE0, 0xF3, 0xC0, 0x79, 0xE0, 0xF3, 0x80, 0x79,
  0xC0, 0xF7, 0x80, 0x7B, 0xC0, 0xF7, 0x80, 0x7B, 0x80, 0xF7, 0x80, 0x7F,
  0x80, 0xF7, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x00, 0x3C,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00,
  0x1F, 0x1E, 0x00, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0x7C, 0x0F, 0x00,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x1F, 0x9F, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x7C, 0x07, 0x80, 0x03, 0xE0, 0x1F, 0x00, 0x1F, 0x00,
  0x3C, 0x00, 0xFC, 0x00, 0xF8, 0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x07,
  0x80, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0xF0,
  0xF8, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x1E, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xE0, 0x03, 0xC0, 0x0F,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80,
  0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x0F,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0xFF, 0xFE, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F,
  0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x7C, 0xF0, 0x00, 0x1F,
  0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x3E, 0x07, 0xC0,
  0x0F, 0x80, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x00, 0xF0, 0x1F, 0x00,
  0x1E, 0x07, 0xC0, 0x03, 0xE0, 0xF0, 0x00, 0x3C, 0x3E, 0x00, 0x07, 0x8F,
  0x80, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1E, 0x40, 0x00, 0x02, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x39, 0xF1, 0xE3, 0xE3, 0xC7, 0x87,
  0x0F, 0x0E, 0x18, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xF0, 0xF0, 0x3F, 0xFE,
  0x3C, 0x1F, 0xFF, 0xDF, 0x0F, 0xE0, 0x77, 0xC7, 0xE0, 0x07, 0xE1, 0xF0,
  0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x8F, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0xF9, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x03,
  0xCF, 0x80, 0x00, 0xF3, 0xE0, 0x00, 0x3C, 0xF8, 0x00, 0x1F, 0x3C, 0x00,
  0x07, 0x8F, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0xF8, 0xF0, 0x00, 0x3E, 0x3C,
  0x00, 0x1F, 0x8F, 0x80, 0x07, 0xE3, 0xE0, 0x03, 0xF0, 0x7C, 0x01, 0xBC,
  0x1F, 0x81, 0xCF, 0xF3, 0xFF, 0xF3, 0xFC, 0xFF, 0xF8, 0x7F, 0x1F, 0xFC,
  0x0F, 0x81, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x0F, 0xE0, 0x0F, 0x8F, 0xFE, 0x03,
  0xE7, 0xFF, 0xC0, 0xF3, 0xFF, 0xF8, 0x3C, 0xE0, 0x7E, 0x0F, 0x70, 0x0F,
  0xC3, 0xF0, 0x01, 0xF1, 0xF8, 0x00, 0x3C, 0x7E, 0x00, 0x0F, 0x1F, 0x00,
  0x03, 0xC7, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x3E,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x1F,
  0x3C, 0x00, 0x07, 0xCF, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x79, 0xF0, 0x00,
  0x3E, 0x78, 0x00, 0x0F, 0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x03, 0xE1, 0xF8,
  0x01, 0xF8, 0xFB, 0x81, 0xFC, 0x3E, 0xFF, 0xFE, 0x0F, 0x1F, 0xFF, 0x03,
  0xC3, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xE0, 0x7E, 0x0F, 0x80,
  0x1F, 0x1F, 0x00, 0x0F, 0x3E, 0x00, 0x0E, 0x3E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x08, 0xF0, 0x00, 0x1E, 0xF8, 0x00,
  0x1E, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0x3F, 0x03,
  0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0xFC, 0x3E,
  0x01, 0xFF, 0xF9, 0xE0, 0x1F, 0xFF, 0xCF, 0x01, 0xFC, 0x0F, 0x78, 0x0F,
  0x80, 0x1B, 0xC0, 0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x78, 0x3E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E,
  0x0F, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x78, 0x3E,
  0x00, 0x03, 0xC1, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x0F, 0x83, 0xC0, 0x00, 0x7C, 0x1E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3E,
  0x07, 0xC0, 0x02, 0xF0, 0x3E, 0x00, 0x37, 0x80, 0xF8, 0x03, 0x7C, 0x07,
  0xF0, 0x7B, 0xC0, 0x1F, 0xFF, 0x9E, 0x00, 0xFF, 0xF8, 0xF0, 0x01, 0xFF,
  0x87, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0x03, 0xF0, 0x7C, 0x00,
  0xF8, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3C, 0x00, 0x0F, 0xBE, 0x00,
  0x07, 0x9F, 0x00, 0x03, 0xCF, 0x00, 0x07, 0xEF, 0x80, 0x0F, 0xE7, 0xC0,
  0xFF, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xC7,
  0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x78, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0xFC,
  0x1F, 0x81, 0xFC, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x20, 0x03, 0xC0, 0x00, 0x03,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x78, 0x00,
  0x00, 0x7E, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x78, 0x00, 0x00, 0x1F, 0x87,
  0x80, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xFE,
  0x1F, 0x01, 0xFF, 0xF9, 0xE0, 0x3F, 0xFF, 0x9E, 0x07, 0xF0, 0x3D, 0xE0,
  0x7C, 0x00, 0xDE, 0x0F, 0x80, 0x07, 0xE1, 0xF0, 0x00, 0x3C, 0x1F, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x3E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C,
  0x3C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x78, 0x7C, 0x00, 0x07, 0x87, 0xC0,
  0x00, 0x78, 0x7C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF8, 0x78, 0x00, 0x0F,
  0x87, 0x80, 0x00, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xF0, 0x3C,
  0x00, 0x6F, 0x03, 0xE0, 0x0E, 0xF0, 0x3F, 0x83, 0xDF, 0x01, 0xFF, 0xF9,
  0xE0, 0x0F, 0xFF, 0x1E, 0x00, 0x7F, 0xE1, 0xE0, 0x03, 0xF8, 0x1E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x7C, 0x02, 0x00, 0x0F, 0x80, 0x70, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x00,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x3E, 0x00, 0x78, 0x7F, 0xC0, 0x3C, 0x7F, 0xF0, 0x3E, 0x7F,
  0xFC, 0x1F, 0x70, 0x7E, 0x0F, 0x70, 0x0F, 0x87, 0xB0, 0x07, 0xC3, 0xF0,
  0x03, 0xE1, 0xF0, 0x00, 0xF1, 0xF0, 0x00, 0x78, 0xF8, 0x00, 0x3C, 0x7C,
  0x00, 0x1E, 0x3C, 0x00, 0x1F, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x8F,
  0x80, 0x03, 0xC7, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0xF8,
  0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x7C, 0x00, 0x1E, 0x3C, 0x00, 0x0F,
  0x1E, 0x00, 0x07, 0x8F, 0x00, 0x07, 0xC7, 0x80, 0x03, 0xC3, 0xC0, 0x01,
  0xE3, 0xE0, 0x00, 0xF1, 0xE0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x20, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x7E, 0x03, 0xE0, 0x7E, 0x01,
  0xE0, 0x7E, 0x00, 0xF0, 0x7E, 0x00, 0x78, 0x7E, 0x00, 0x3C, 0x7E, 0x00,
  0x1E, 0x7E, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x80, 0x0F, 0x00, 0x60, 0x07, 0x80, 0x78, 0x03, 0xC0,
  0x7E, 0x03, 0xE0, 0x0F, 0x81, 0xE0, 0x03, 0xE0, 0xF0, 0x01, 0xF8, 0x78,
  0x00, 0x7E, 0x3C, 0x00, 0x1F, 0x9E, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x1F, 0x80, 0x07, 0x87, 0xFE, 0x00, 0x78, 0xFF, 0xF0, 0x0F, 0x9F, 0xFF,
  0x00, 0xFB, 0x81, 0xF8, 0x0F, 0x70, 0x0F, 0x80, 0xF6, 0x00, 0xF8, 0x0F,
  0xC0, 0x07, 0x80, 0xF8, 0x00, 0x78, 0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0xF0, 0x1F, 0x00, 0x1F, 0x01, 0xE0, 0x03, 0xE0, 0x1E, 0x00, 0x7C, 0x01,
  0xE0, 0x1F, 0x80, 0x3E, 0x07, 0xE0, 0x03, 0xE7, 0xF8, 0x00, 0x3C, 0x7C,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x3E, 0x00, 0x43, 0xC1, 0xE0, 0x0C,
  0x7C, 0x1F, 0x01, 0xE7, 0xC0, 0xF0, 0x3F, 0x78, 0x0F, 0x07, 0xC7, 0x80,
  0xF8, 0xF8, 0x78, 0x07, 0x9F, 0x07, 0x80, 0x7F, 0xE0, 0xF8, 0x03, 0xFC,
  0x0F, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFE, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x18, 0x1E, 0x00, 0xF0, 0x78, 0x07, 0xC3, 0xE0, 0x7E,
  0x0F, 0x03, 0xF0, 0x3C, 0x1F, 0x80, 0xF0, 0xFC, 0x03, 0xC7, 0xE0, 0x1F,
  0x7E, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x03, 0xE0, 0x3C, 0xFE, 0x1F, 0xE0, 0xF7, 0xFC, 0xFF,
  0x83, 0xDF, 0xF7, 0xFE, 0x0F, 0xC3, 0xDC, 0x7C, 0x3E, 0x0F, 0xC1, 0xF1,
  0xF0, 0x3F, 0x03, 0xC7, 0xC0, 0xF8, 0x0F, 0x1E, 0x03, 0xE0, 0x38, 0x78,
  0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x07, 0x87, 0x00, 0xF0, 0x1E, 0x3C, 0x03,
  0xC0, 0x78, 0xF0, 0x0E, 0x01, 0xE3, 0xC0, 0x78, 0x07, 0x0F, 0x01, 0xE0,
  0x3C, 0x3C, 0x07, 0x80, 0xF0, 0xE0, 0x1E, 0x03, 0xC7, 0x80, 0x78, 0x0F,
  0x1E, 0x01, 0xC0, 0x3C, 0x78, 0x0F, 0x00, 0xE1, 0xE0, 0x3C, 0x07, 0x87,
  0x80, 0xF0, 0x1E, 0x1C, 0x03, 0xC0, 0x78, 0xF0, 0x0F, 0x01, 0xE3, 0xC0,
  0x38, 0x07, 0x8F, 0x01, 0xE0, 0x1C, 0x3C, 0x07, 0x80, 0xF0, 0xF0, 0x1E,
  0x03, 0xC0, 0x00, 0x01, 0xF0, 0x03, 0xC3, 0xFE, 0x01, 0xE3, 0xFF, 0x81,
  0xF3, 0xFF, 0xE0, 0xFB, 0x83, 0xF0, 0x7B, 0x80, 0x7C, 0x3D, 0x80, 0x3E,
  0x1F, 0x80, 0x1F, 0x0F, 0x80, 0x07, 0x8F, 0x80, 0x03, 0xC7, 0xC0, 0x01,
  0xE3, 0xE0, 0x00, 0xF1, 0xE0, 0x00, 0xF8, 0xF0, 0x00, 0x78, 0x78, 0x00,
  0x3C, 0x7C, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x8F, 0x00,
  0x07, 0xC7, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE3, 0xE0, 0x00, 0xF1, 0xE0,
  0x00, 0x78, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x3E, 0x3C, 0x00, 0x1E, 0x1E,
  0x00, 0x0F, 0x1F, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xF0,
  0x3F, 0x03, 0xF0, 0x03, 0xE1, 0xF8, 0x00, 0x78, 0x7C, 0x00, 0x1E, 0x3E,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x3D, 0xF0, 0x00, 0x0F,
  0x7C, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x7D, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x7B, 0xE0,
  0x00, 0x3E, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0xC7, 0x80, 0x01, 0xF1,
  0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x0F, 0xE0, 0x7E, 0x01, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x3E, 0x3F, 0xF8, 0x03, 0xC7, 0xFF, 0xC0, 0x3C, 0xFF,
  0xFE, 0x03, 0xCE, 0x07, 0xE0, 0x3D, 0xC0, 0x3F, 0x03, 0xF0, 0x01, 0xF0,
  0x7E, 0x00, 0x0F, 0x07, 0xE0, 0x00, 0xF0, 0x7C, 0x00, 0x0F, 0x07, 0xC0,
  0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xF0, 0xF0,
  0x00, 0x1F, 0x0F, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x1E, 0x1F, 0x00, 0x03,
  0xE1, 0xE0, 0x00, 0x3C, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x1F,
  0x80, 0x1F, 0x83, 0xEE, 0x07, 0xF0, 0x3E, 0xFF, 0xFE, 0x03, 0xC7, 0xFF,
  0xC0, 0x3C, 0x3F, 0xF8, 0x03, 0xC0, 0xFE, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xF8, 0x7C, 0x0F, 0xFF, 0xCF, 0x03, 0xFF, 0xF9, 0xE0, 0xFE, 0x07, 0xBC,
  0x1F, 0x00, 0x37, 0x87, 0xC0, 0x03, 0xF1, 0xF0, 0x00, 0x3C, 0x3E, 0x00,
  0x07, 0x87, 0x80, 0x00, 0xF1, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0xF8, 0xF0, 0x00, 0x1E, 0x3E, 0x00, 0x03, 0xC7, 0xC0, 0x00,
  0x78, 0xF8, 0x00, 0x0F, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x7C, 0x78,
  0x00, 0x0F, 0x0F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x1F,
  0x87, 0xC0, 0x06, 0xF0, 0x7C, 0x01, 0xBE, 0x0F, 0xE0, 0xF7, 0x80, 0xFF,
  0xFC, 0xF0, 0x1F, 0xFF, 0x1E, 0x00, 0xFF, 0xC3, 0xC0, 0x0F, 0xE0, 0x78,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x1F, 0xFB, 0xFF, 0xCF, 0xFE, 0x00,
  0xF7, 0x80, 0x00, 0x7D, 0x80, 0x00, 0x1E, 0xC0, 0x00, 0x07, 0xA0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xE0, 0x1F, 0xC3, 0xE0, 0x01,
  0xE0, 0xF0, 0x00, 0x30, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC2, 0x00, 0x01, 0xF1, 0xC0, 0x00, 0x78, 0xFC,
  0x00, 0x3E, 0x3F, 0xC0, 0x3F, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7C, 0x00, 0x1F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xF8, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0xC0, 0x3C,
  0x00, 0xE0, 0x1E, 0x01, 0xF8, 0x1F, 0x01, 0xFC, 0x0F, 0x83, 0xF8, 0x07,
  0x83, 0xF8, 0x03, 0xC7, 0xF0, 0x01, 0xE7, 0xF0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x07,
  0x8F, 0x80, 0x03, 0xC7, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0xF1, 0xE0, 0x00,
  0xF8, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x7C, 0x00, 0x1E, 0x3C, 0x00,
  0x0F, 0x1E, 0x00, 0x07, 0x8F, 0x00, 0x07, 0xC7, 0x80, 0x03, 0xC3, 0xC0,
  0x01, 0xE3, 0xE0, 0x00, 0xF1, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x78,
  0x00, 0x3E, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x1F, 0x00, 0x0F, 0x8F,
  0x80, 0x0F, 0xC7, 0xC0, 0x07, 0xE1, 0xE0, 0x07, 0xF0, 0xF8, 0x06, 0xF0,
  0x7E, 0x0E, 0x78, 0x3F, 0xFF, 0x3C, 0x0F, 0xFF, 0x1E, 0x03, 0xFF, 0x0F,
  0x00, 0x7E, 0x08, 0x00, 0xFF, 0xC0, 0x03, 0x7F, 0xE0, 0x0F, 0xBF, 0xF0,
  0x03, 0xDF, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E,
  0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC3,
  0xE0, 0x01, 0xE1, 0xE0, 0x01, 0xF0, 0xF0, 0x00, 0xF8, 0x78, 0x00, 0x78,
  0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x3E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1F,
  0x07, 0x80, 0x1F, 0x03, 0xC0, 0x1F, 0x81, 0xE0, 0x1F, 0x80, 0xF0, 0x1F,
  0x80, 0x78, 0x3F, 0x80, 0x7C, 0x7F, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x60,
  0x70, 0x0E, 0x07, 0x87, 0x80, 0x70, 0x3C, 0x3C, 0x07, 0x81, 0xE1, 0xE0,
  0x3C, 0x07, 0x0F, 0x01, 0xE0, 0x38, 0x78, 0x0F, 0x01, 0xE3, 0x80, 0x70,
  0x0F, 0x3C, 0x03, 0x80, 0x79, 0xE0, 0x3C, 0x03, 0xCF, 0x01, 0xE0, 0x1E,
  0x78, 0x0F, 0x00, 0xE3, 0xC0, 0x78, 0x07, 0x1C, 0x03, 0xC0, 0x79, 0xE0,
  0x1C, 0x03, 0xCF, 0x01, 0xE0, 0x1E, 0x78, 0x0F, 0x00, 0xF3, 0xC0, 0x78,
  0x07, 0x9E, 0x03, 0xC0, 0x78, 0xE0, 0x1E, 0x03, 0xC7, 0x01, 0xE0, 0x3E,
  0x78, 0x0F, 0x01, 0xE3, 0xC0, 0xF8, 0x1F, 0x1F, 0x07, 0xE0, 0xF0, 0xF8,
  0xEF, 0x1F, 0x83, 0xFF, 0x7F, 0xF8, 0x1F, 0xF1, 0xFF, 0x80, 0x7F, 0x0F,
  0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x7F,
  0x03, 0xFC, 0x00, 0xFF, 0x87, 0xFE, 0x01, 0xFF, 0x8F, 0xFF, 0x07, 0xF7,
  0x8F, 0x1F, 0x0F, 0xC3, 0x9C, 0x0F, 0x1F, 0x03, 0x9C, 0x0F, 0x3E, 0x03,
  0xB8, 0x0F, 0x08, 0x03, 0xF0, 0x0F, 0x00, 0x03, 0xF0, 0x0F, 0x00, 0x03,
  0xF0, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x07,
  0xC0, 0x00, 0xF0, 0x0D, 0xC0, 0x10, 0xF0, 0x0D, 0xC0, 0x38, 0xF0, 0x1D,
  0xC0, 0x78, 0xF0, 0x1D, 0xE0, 0xFC, 0xF8, 0x39, 0xE3, 0xF0, 0x78, 0x79,
  0xE7, 0xE0, 0x7F, 0xF1, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0x80, 0x3F, 0xC0,
  0xFE, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x3E, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xF0,
  0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xE0, 0x7C, 0x00, 0x1E, 0x07, 0x80,
  0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xE0, 0x78, 0x00, 0x3C,
  0x07, 0x80, 0x03, 0xC0, 0xF8, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x7C, 0x0F, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x0F,
  0x80, 0xF0, 0x00, 0xF8, 0x0F, 0x00, 0x17, 0x80, 0xF0, 0x03, 0xF8, 0x0F,
  0x80, 0x6F, 0x80, 0xFC, 0x1E, 0xF0, 0x07, 0xFF, 0xCF, 0x00, 0x7F, 0xF8,
  0xF0, 0x03, 0xFF, 0x0F, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x10, 0x00,
  0x7C, 0x03, 0x80, 0x0F, 0xC0, 0x7E, 0x03, 0xF8, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x3C, 0x1F, 0xFF, 0x07, 0x87, 0xFF, 0xF8,
  0xF1, 0xF0, 0x3F, 0xFE, 0x3C, 0x00, 0xFF, 0x87, 0x00, 0x07, 0xE0, 0xE0,
  0x00, 0xF8, 0x1C, 0x00, 0x3E, 0x03, 0x80, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x40,
  0x07, 0xC0, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x7C, 0x00, 0xF0, 0x1F, 0x00,
  0x0F, 0x07, 0xC0, 0x01, 0xE1, 0xFE, 0x00, 0x3C, 0xFF, 0xFE, 0x07, 0x9F,
  0x7F, 0xFC, 0x73, 0xC1, 0xFF, 0xFE, 0x78, 0x07, 0xFF, 0xCF, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x78, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E,
  0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x60, 0x1F, 0xE0, 0x03,
  0xC1, 0xFF, 0x80, 0x3C, 0x1F, 0xFC, 0x01, 0xE1, 0xF1, 0xF0, 0x0E, 0x0F,
  0x07, 0xC0, 0xF0, 0xF0, 0x1E, 0x0F, 0x87, 0x80, 0xF8, 0xF8, 0x78, 0x03,
  0xFF, 0x83, 0xC0, 0x0F, 0xFC, 0x1C, 0x00, 0x3F, 0xC1, 0x60, 0x00, 0xF8,
  0x00,
};

const GFXglyph IBMPlexMono_Italic54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 13, 38, 32, 10, -38 },
  { 63, 16, 15, 32, 11, -40 },
  { 93, 32, 38, 32, 1, -38 },
  { 245, 31, 49, 32, 1, -43 },
  { 435, 36, 39, 32, -1, -38 },
  { 611, 32, 39, 32, 0, -38 },
  { 767, 7, 15, 32, 16, -40 },
  { 781, 20, 48, 32, 11, -41 },
  { 901, 20, 48, 32, 2, -41 },
  { 1021, 27, 27, 32, 3, -30 },
  { 1113, 26, 26, 32, 4, -29 },
  { 1198, 13, 15, 32, 7, -7 },
  { 1223, 17, 4, 32, 8, -18 },
  { 1232, 8, 7, 32, 10, -7 },
  { 1239, 31, 48, 32, 1, -41 },
  { 1425, 28, 39, 32, 3, -38 },
  { 1562, 26, 38, 32, 2, -38 },
  { 1686, 28, 38, 32, 2, -38 },
  { 1819, 29, 39, 32, 1, -38 },
  { 1961, 29, 38, 32, 1, -38 },
  { 2099, 28, 39, 32, 3, -38 },
  { 2236, 26, 39, 32, 3, -38 },
  { 2363, 27, 38, 32, 6, -38 },
  { 2492, 29, 39, 32, 2, -38 },
  { 2634, 25, 38, 32, 5, -38 },
  { 2753, 12, 28, 32, 10, -28 },
  { 2795, 15, 36, 32, 7, -28 },
  { 2863, 26, 31, 32, 5, -32 },
  { 2964, 28, 15, 32, 3, -24 },
  { 3017, 26, 31, 32, 3, -32 },
  { 3118, 23, 38, 32, 7, -38 },
  { 3228, 27, 44, 32, 3, -38 },
  { 3377, 29, 38, 32, 0, -38 },
  { 3515, 28, 38, 32, 2, -38 },
  { 3648, 27, 39, 32, 4, -38 },
  { 3780, 28, 38, 32, 3, -38 },
  { 3913, 29, 38, 32, 3, -38 },
  { 4051, 30, 38, 32, 3, -38 },
  { 4194, 27, 39, 32, 4, -38 },
  { 4326, 30, 38, 32, 2, -38 },
  { 4469, 30, 38, 32, 2, -38 },
  { 4612, 27, 39, 32, 3, -38 },
  { 4744, 33, 38, 32, 2, -38 },
  { 4901, 23, 38, 32, 4, -38 },
  { 5011, 32, 38, 32, 1, -38 },
  { 5163, 30, 38, 32, 2, -38 },
  { 5306, 28, 39, 32, 3, -38 },
  { 5443, 29, 38, 32, 3, -38 },
  { 5581, 28, 48, 32, 3, -38 },
  { 5749, 29, 38, 32, 3, -38 },
  { 5887, 30, 39, 32, 1, -38 },
  { 6034, 30, 38, 32, 5, -38 },
  { 6177, 28, 39, 32, 4, -38 },
  { 6314, 28, 38, 32, 6, -38 },
  { 6447, 32, 38, 32, 2, -38 },
  { 6599, 36, 38, 32, -1, -38 },
  { 6770, 30, 38, 32, 5, -38 },
  { 6913, 33, 38, 32, 0, -38 },
  { 7070, 23, 48, 32, 9, -41 },
  { 7208, 14, 48, 32, 10, -41 },
  { 7292, 23, 48, 32, 1, -41 },
  { 7430, 27, 22, 32, 4, -38 },
  { 7505, 26, 4, 32, 0, 5 },
  { 7518, 7, 10, 32, 12, -42 },
  { 7527, 26, 30, 32, 3, -29 },
  { 7625, 26, 41, 32, 3, -40 },
  { 7759, 24, 30, 32, 4, -29 },
  { 7849, 29, 41, 32, 3, -40 },
  { 7998, 25, 30, 32, 4, -29 },
  { 8092, 36, 51, 32, -1, -40 },
  { 8322, 28, 40, 32, 2, -29 },
  { 8462, 25, 40, 32, 3, -40 },
  { 8587, 25, 41, 32, 4, -40 },
  { 8716, 25, 51, 32, 3, -40 },
  { 8876, 28, 41, 32, 3, -40 },
  { 9020, 22, 41, 32, 6, -40 },
  { 9133, 30, 29, 32, 1, -29 },
  { 9242, 25, 29, 32, 3, -29 },
  { 9333, 26, 30, 32, 3, -29 },
  { 9431, 28, 40, 32, 1, -29 },
  { 9571, 27, 40, 32, 3, -29 },
  { 9706, 26, 28, 32, 6, -28 },
  { 9797, 26, 30, 32, 3, -29 },
  { 9895, 25, 39, 32, 4, -38 },
  { 10017, 25, 29, 32, 4, -28 },
  { 10108, 25, 28, 32, 4, -28 },
  { 10196, 29, 29, 32, 2, -28 },
  { 10302, 32, 30, 32, 0, -29 },
  { 10422, 28, 39, 32, 1, -28 },
  { 10559, 27, 30, 32, 3, -29 },
  { 10661, 25, 48, 32, 6, -41 },
  { 10811, 12, 48, 32, 11, -41 },
  { 10883, 25, 48, 32, 2, -41 },
  { 11033, 29, 12, 32, 2, -22 },
};

const GFXfont IBMPlexMono_Italic54pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic54pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic54pt7bGlyphs,
  0x20, 0x7E, 70
};

#endif // _IBMPLEXMONO_ITALIC54PT7B_H_
