#ifndef _IBMPLEXMONO_ITALIC31PT7B_H_
#define _IBMPLEXMONO_ITALIC31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x1C, 0x38, 0x60, 0xC3, 0x87, 0x0E, 0x18, 0x30, 0x60, 0xC1,
  0x02, 0x04, 0x00, 0x00, 0x01, 0xC7, 0xCF, 0x1E, 0x00, 0x63, 0xB1, 0x98,
  0xDC, 0x6E, 0x36, 0x3B, 0x1D, 0x8C, 0xC6, 0x00, 0x00, 0x71, 0x80, 0x0C,
  0x30, 0x01, 0x8E, 0x00, 0x71, 0x80, 0x0C, 0x30, 0x01, 0x8E, 0x00, 0x71,
  0x80, 0xFC, 0x3F, 0x1F, 0x8F, 0xE0, 0x71, 0x80, 0x0C, 0x30, 0x01, 0x8E,
  0x00, 0x71, 0x80, 0xFC, 0x3F, 0x3F, 0x8F, 0xE0, 0x71, 0x80, 0x0C, 0x30,
  0x01, 0x8E, 0x00, 0x71, 0x80, 0x0C, 0x30, 0x01, 0x8E, 0x00, 0x71, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x3F, 0x00, 0x7F, 0xE0,
  0xF3, 0x3C, 0x71, 0x8E, 0x70, 0xC2, 0x38, 0x60, 0x1C, 0x20, 0x0E, 0x30,
  0x03, 0x98, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x03, 0x3C, 0x01,
  0x8E, 0x00, 0xC3, 0x00, 0x61, 0xC0, 0x30, 0xC4, 0x18, 0xE7, 0x08, 0x71,
  0xEC, 0xF0, 0x7F, 0xF0, 0x0F, 0xE0, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x03, 0xC0, 0x18, 0x3F, 0x81, 0x83, 0x8C, 0x1C, 0x18, 0x60, 0xC1,
  0x83, 0x0C, 0x0C, 0x18, 0xE0, 0x60, 0xC6, 0x03, 0x06, 0x60, 0x1C, 0x66,
  0x00, 0x7F, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xFC, 0x01,
  0xDC, 0x60, 0x1C, 0xC1, 0x80, 0xCE, 0x0C, 0x0C, 0x60, 0xE0, 0xE3, 0x06,
  0x06, 0x18, 0x30, 0x60, 0xE3, 0x87, 0x03, 0xF8, 0x70, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0xFF, 0x00, 0x70, 0xE0, 0x18, 0x18, 0x06, 0x06, 0x01, 0x81,
  0x80, 0x60, 0x60, 0x18, 0x18, 0x07, 0x0E, 0x00, 0xC7, 0x01, 0xFF, 0x80,
  0xE7, 0x00, 0x71, 0xC0, 0x18, 0x30, 0x0E, 0x0E, 0x03, 0x81, 0x80, 0xE0,
  0x70, 0xF8, 0x1C, 0x3E, 0x0F, 0x99, 0xC6, 0x6E, 0x7F, 0x9F, 0x07, 0x83,
  0x80, 0x37, 0x76, 0x66, 0x6E, 0xE0, 0x00, 0x70, 0x1C, 0x03, 0x80, 0x70,
  0x06, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x60,
  0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0C, 0x00, 0x18, 0x1C, 0x30, 0xFF, 0x7F, 0x9F, 0xFC, 0x07, 0xC0, 0x0F,
  0x00, 0x3F, 0x00, 0xE7, 0x03, 0x86, 0x0E, 0x0E, 0x08, 0x08, 0x00, 0x00,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x7F, 0xFF, 0xFF, 0xFE, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x00, 0x1E, 0x38, 0xF1, 0xC3, 0x8E, 0x18, 0x70,
  0xFF, 0xFF, 0xC0, 0x77, 0xFD, 0xE0, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x0E, 0x1E,
  0x1C, 0x0E, 0x38, 0x06, 0x30, 0x07, 0x70, 0x07, 0x70, 0x07, 0x60, 0x07,
  0xE3, 0xC7, 0xE3, 0xC6, 0xE3, 0xC6, 0xE3, 0x8E, 0xC0, 0x0E, 0xC0, 0x0E,
  0xC0, 0x0C, 0xC0, 0x1C, 0xE0, 0x18, 0xE0, 0x38, 0x70, 0x70, 0x3F, 0xE0,
  0x1F, 0x80, 0x00, 0xF8, 0x03, 0xE0, 0x0E, 0xC0, 0x79, 0x81, 0xE7, 0x07,
  0x8E, 0x04, 0x1C, 0x10, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xF8, 0x07, 0xFC,
  0x0E, 0x0E, 0x1C, 0x07, 0x38, 0x07, 0x08, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0xFF, 0xFE, 0xFF, 0xFC, 0x01, 0xF8, 0x07, 0xFE, 0x0E, 0x0E, 0x1C, 0x07,
  0x08, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C,
  0x03, 0xF0, 0x07, 0xF0, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x40, 0x0C, 0xE0, 0x1C, 0xF0, 0x78, 0x7F, 0xF0, 0x1F, 0xC0,
  0x00, 0x07, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0x70, 0x03,
  0x38, 0x03, 0x98, 0x03, 0x8C, 0x03, 0x86, 0x01, 0x83, 0x01, 0x83, 0x81,
  0xC1, 0xC1, 0xC0, 0xC1, 0xC0, 0x60, 0xC0, 0x30, 0xE0, 0x18, 0x7F, 0xFF,
  0xBF, 0xFF, 0xE0, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x07,
  0xFF, 0x83, 0xFF, 0x83, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x19, 0xF0, 0x0D, 0xFE, 0x0F, 0x07, 0x87, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x10,
  0x07, 0x1C, 0x07, 0x1F, 0x07, 0x03, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x33, 0xF0, 0xEF, 0xF1, 0xB0, 0xF7, 0x80, 0xEE, 0x00, 0xDC, 0x01,
  0xF8, 0x03, 0xE0, 0x06, 0xC0, 0x1D, 0xC0, 0x3B, 0x80, 0xE3, 0x83, 0x83,
  0xFE, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0x7F, 0xFE, 0x60, 0x0E, 0x60, 0x0E,
  0xE0, 0x1C, 0xE0, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x01, 0xFC, 0x03, 0xFF, 0x03, 0xC1, 0xC3, 0x80, 0x71, 0xC0, 0x38, 0xC0,
  0x1C, 0x60, 0x0C, 0x38, 0x0E, 0x0E, 0x0E, 0x03, 0xFC, 0x01, 0xFE, 0x03,
  0x83, 0x83, 0x00, 0xE3, 0x80, 0x31, 0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x06,
  0x70, 0x07, 0x1C, 0x03, 0x8F, 0x07, 0x83, 0xFF, 0x80, 0x7E, 0x00, 0x07,
  0xE0, 0x7F, 0xE3, 0x83, 0x9C, 0x07, 0x60, 0x0F, 0x80, 0x3E, 0x00, 0xF0,
  0x03, 0xC0, 0x1F, 0x80, 0x7E, 0x03, 0xFC, 0x1E, 0x7F, 0xF8, 0x7C, 0xC0,
  0x07, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x01,
  0xE0, 0x00, 0x1C, 0x7C, 0xF1, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x1F, 0x3C, 0x78, 0x07, 0x07, 0xC3, 0xC1, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0xE0, 0xF0, 0x70, 0x38, 0x38,
  0x18, 0x1C, 0x00, 0x00, 0x02, 0x00, 0x18, 0x00, 0xF0, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x20, 0x7F, 0xFF, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0xFF, 0xFC, 0x20, 0x00, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0C, 0x00,
  0x70, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3C, 0x00, 0xC0,
  0x02, 0x00, 0x00, 0x0F, 0xC1, 0xFF, 0x9E, 0x1C, 0xC0, 0x7E, 0x01, 0xA0,
  0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x07, 0x80, 0xF8, 0x1F, 0x80, 0xE0,
  0x06, 0x00, 0x70, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x07,
  0xC0, 0x1C, 0x00, 0x03, 0xF0, 0x1F, 0xF8, 0x78, 0x78, 0xC0, 0x33, 0x80,
  0x66, 0x00, 0xDC, 0x3D, 0xB0, 0xFB, 0x63, 0x8E, 0xC6, 0x0F, 0x9C, 0x1F,
  0x30, 0x7C, 0x60, 0xD8, 0xC1, 0xB1, 0x83, 0x63, 0x0E, 0xC6, 0x2D, 0x8F,
  0xFB, 0x0F, 0x66, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1F, 0xF0,
  0x0F, 0xE0, 0x00, 0x38, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xCC,
  0x01, 0xCC, 0x01, 0x8C, 0x03, 0x8C, 0x03, 0x0E, 0x03, 0x0E, 0x06, 0x0E,
  0x06, 0x0E, 0x0E, 0x06, 0x0F, 0xFE, 0x1F, 0xFE, 0x18, 0x06, 0x38, 0x07,
  0x30, 0x07, 0x70, 0x07, 0x60, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0x0F, 0xFC,
  0x0F, 0xFE, 0x0C, 0x07, 0x1C, 0x07, 0x1C, 0x03, 0x1C, 0x03, 0x1C, 0x07,
  0x18, 0x07, 0x18, 0x06, 0x38, 0x0E, 0x3F, 0xF8, 0x3F, 0xF8, 0x38, 0x0E,
  0x30, 0x06, 0x30, 0x06, 0x70, 0x06, 0x70, 0x06, 0x70, 0x0E, 0x70, 0x0E,
  0x60, 0x1C, 0x7F, 0xF8, 0xFF, 0xE0, 0x01, 0xF8, 0x07, 0xFE, 0x0F, 0x0E,
  0x1C, 0x07, 0x18, 0x07, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x60, 0x0C, 0x60, 0x1C, 0x70, 0x1C, 0x38, 0x78, 0x3F, 0xF0,
  0x0F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF8, 0x18, 0x1C, 0x18, 0x0E, 0x18, 0x06,
  0x38, 0x06, 0x38, 0x06, 0x38, 0x07, 0x30, 0x06, 0x30, 0x06, 0x30, 0x06,
  0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x60, 0x0C, 0x60, 0x1C,
  0xE0, 0x18, 0xE0, 0x38, 0xE0, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0x0F, 0xFF,
  0x87, 0xFF, 0xC3, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC3,
  0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x07, 0xFF, 0xC7, 0xFF, 0xE0, 0x0F, 0xFF, 0xC3,
  0xFF, 0xE0, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0xE0, 0xFF, 0xF8,
  0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xF8, 0x07, 0xFC, 0x0E, 0x0E, 0x1C, 0x06, 0x38, 0x07, 0x30, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0xFE, 0xE0,
  0xFC, 0xE1, 0x0C, 0xE0, 0x0C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0x60,
  0x38, 0x70, 0x58, 0x3F, 0x98, 0x1F, 0x18, 0x0C, 0x01, 0x86, 0x00, 0xC7,
  0x00, 0xE3, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x18, 0x60, 0x0C, 0x30, 0x06,
  0x38, 0x07, 0x1C, 0x03, 0x8F, 0xFF, 0xC7, 0xFF, 0xC3, 0x00, 0x61, 0x80,
  0x31, 0xC0, 0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x06, 0x18, 0x03, 0x0C,
  0x01, 0x8E, 0x01, 0xC7, 0x00, 0xE0, 0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x07, 0xFF, 0xC7, 0xFF, 0xE0, 0x07, 0xFE, 0x1F, 0xFC, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x31, 0x80, 0xE3, 0x81, 0xC7, 0x87, 0x07, 0xFC, 0x03, 0xF0, 0x00, 0x0E,
  0x01, 0xE1, 0x80, 0x78, 0x30, 0x1E, 0x0E, 0x07, 0x81, 0xC1, 0xE0, 0x38,
  0x78, 0x06, 0x1E, 0x00, 0xC7, 0x80, 0x19, 0xE0, 0x07, 0x38, 0x00, 0xEF,
  0x00, 0x1F, 0xF0, 0x03, 0xEE, 0x00, 0x78, 0xE0, 0x0E, 0x1C, 0x03, 0x81,
  0xC0, 0x70, 0x38, 0x0E, 0x03, 0x01, 0x80, 0x70, 0x30, 0x06, 0x06, 0x00,
  0xE1, 0xC0, 0x1C, 0x00, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1E, 0x03, 0xC7, 0x80, 0xF1,
  0xE0, 0x78, 0x78, 0x3E, 0x1F, 0x0D, 0x86, 0xC7, 0x63, 0xB1, 0xB8, 0xCC,
  0xCE, 0x33, 0xB3, 0x0C, 0x78, 0xC3, 0x1E, 0x30, 0xC7, 0x0C, 0x71, 0xC7,
  0x1C, 0x21, 0xC6, 0x10, 0x61, 0x80, 0x18, 0x60, 0x06, 0x18, 0x01, 0x8E,
  0x00, 0xE3, 0x80, 0x38, 0xC0, 0x0C, 0x30, 0x03, 0x00, 0x0F, 0x01, 0x87,
  0x80, 0xC7, 0xC0, 0x63, 0xE0, 0x71, 0xB8, 0x38, 0xDC, 0x18, 0x66, 0x0C,
  0x33, 0x06, 0x39, 0x83, 0x1C, 0xE3, 0x8C, 0x31, 0xC6, 0x18, 0xC3, 0x0C,
  0x61, 0x86, 0x31, 0xC3, 0x98, 0xE0, 0xDC, 0x60, 0x6E, 0x30, 0x36, 0x18,
  0x1F, 0x0C, 0x0F, 0x8E, 0x03, 0xC7, 0x01, 0xE0, 0x01, 0xF0, 0x07, 0xFC,
  0x0E, 0x1E, 0x1C, 0x0E, 0x38, 0x06, 0x30, 0x07, 0x70, 0x07, 0x70, 0x07,
  0x60, 0x07, 0xE0, 0x07, 0xE0, 0x06, 0xE0, 0x06, 0xE0, 0x0E, 0xE0, 0x0E,
  0xC0, 0x0E, 0xC0, 0x0C, 0xE0, 0x1C, 0xE0, 0x18, 0xE0, 0x38, 0x70, 0x70,
  0x3F, 0xE0, 0x1F, 0x80, 0x0F, 0xFE, 0x07, 0xFF, 0x83, 0x01, 0xE3, 0x80,
  0x71, 0xC0, 0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x30, 0x07, 0x18, 0x03, 0x1C,
  0x07, 0x8F, 0xFF, 0x87, 0xFF, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x0E, 0x1E, 0x1C, 0x0E, 0x38,
  0x06, 0x30, 0x07, 0x70, 0x07, 0x70, 0x07, 0x60, 0x07, 0xE0, 0x07, 0xE0,
  0x06, 0xE0, 0x06, 0xE0, 0x0E, 0xE0, 0x0E, 0xC0, 0x0E, 0xC0, 0x0C, 0xE0,
  0x1C, 0xE0, 0x18, 0xE0, 0x38, 0x70, 0x70, 0x3F, 0xE0, 0x1F, 0x80, 0x07,
  0x00, 0x03, 0x84, 0x01, 0x8E, 0x01, 0xDC, 0x00, 0xF8, 0x00, 0x60, 0x0F,
  0xFC, 0x07, 0xFF, 0x83, 0x01, 0xE3, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x1C,
  0x70, 0x0E, 0x30, 0x07, 0x18, 0x03, 0x1C, 0x07, 0x8F, 0xFF, 0x87, 0xFF,
  0x03, 0x0E, 0x01, 0x83, 0x00, 0xC1, 0xC0, 0x60, 0xE0, 0x70, 0x30, 0x38,
  0x1C, 0x1C, 0x0E, 0x0C, 0x03, 0x86, 0x01, 0xC7, 0x00, 0x70, 0x01, 0xF8,
  0x03, 0xFF, 0x03, 0x81, 0xC3, 0x80, 0x73, 0x80, 0x11, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x20, 0x07,
  0x38, 0x03, 0x8F, 0x07, 0x83, 0xFF, 0x80, 0x7F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x03, 0x18, 0x03,
  0x38, 0x07, 0x38, 0x07, 0x38, 0x07, 0x30, 0x06, 0x30, 0x06, 0x30, 0x06,
  0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x0C,
  0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x18, 0xE0, 0x18, 0xE0, 0x38, 0x70, 0x70,
  0x3F, 0xE0, 0x1F, 0xC0, 0xE0, 0x03, 0xB0, 0x03, 0x98, 0x01, 0xCC, 0x01,
  0xC6, 0x00, 0xE3, 0x00, 0x61, 0xC0, 0x70, 0xE0, 0x30, 0x70, 0x38, 0x18,
  0x18, 0x0C, 0x1C, 0x06, 0x0C, 0x03, 0x0E, 0x01, 0x87, 0x00, 0xE3, 0x00,
  0x73, 0x80, 0x19, 0x80, 0x0D, 0xC0, 0x06, 0xC0, 0x03, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0xE6, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00,
  0x63, 0x00, 0x1C, 0x60, 0x03, 0x0C, 0x38, 0x61, 0x87, 0x0C, 0x31, 0xE3,
  0x8E, 0x3C, 0x61, 0xCD, 0x8C, 0x39, 0xB1, 0x86, 0x36, 0x30, 0xCC, 0xCE,
  0x19, 0x99, 0x83, 0x33, 0x30, 0x6C, 0x76, 0x0D, 0x87, 0xC1, 0xE0, 0xF0,
  0x3C, 0x1E, 0x07, 0x83, 0xC1, 0xE0, 0x78, 0x00, 0x06, 0x00, 0x38, 0x38,
  0x03, 0x80, 0xC0, 0x38, 0x07, 0x03, 0x80, 0x18, 0x38, 0x00, 0xE1, 0xC0,
  0x03, 0x1C, 0x00, 0x1D, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xEE, 0x00, 0x0E, 0x70, 0x00,
  0x71, 0xC0, 0x07, 0x0E, 0x00, 0x70, 0x30, 0x07, 0x01, 0xC0, 0x70, 0x06,
  0x03, 0x80, 0x38, 0x78, 0x00, 0xE0, 0xE0, 0x03, 0xF0, 0x03, 0x98, 0x01,
  0xCE, 0x01, 0xC3, 0x01, 0xC1, 0xC1, 0xC0, 0xE0, 0xE0, 0x30, 0xE0, 0x1C,
  0xE0, 0x06, 0x60, 0x03, 0x70, 0x01, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0F, 0xFF, 0xF1, 0xFF, 0xFE, 0x00, 0x07, 0xF8,
  0x7F, 0xC3, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x06, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0xC0, 0xC0, 0xC0, 0xC0,
  0x60, 0x60, 0x60, 0x60, 0x20, 0x30, 0x30, 0x30, 0x30, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x0C, 0x0C, 0x0C, 0x0C, 0x06, 0x06, 0x06, 0x06, 0x06, 0x03,
  0x07, 0xFC, 0x1F, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x07, 0xF8, 0x3F,
  0xE0, 0x00, 0xE0, 0x01, 0xF0, 0x01, 0xB0, 0x03, 0x30, 0x07, 0x38, 0x0E,
  0x18, 0x0C, 0x1C, 0x18, 0x0C, 0x38, 0x0C, 0x70, 0x0E, 0x60, 0x06, 0xE0,
  0x07, 0x40, 0x04, 0xFF, 0xFF, 0xFF, 0xFC, 0x6E, 0x66, 0x33, 0x07, 0xCE,
  0x3F, 0xD8, 0xF0, 0xF3, 0x80, 0xE7, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0x70,
  0x0C, 0xC0, 0x19, 0x80, 0x33, 0x00, 0xE6, 0x01, 0xCE, 0x07, 0x9E, 0x17,
  0x1F, 0xCF, 0x9F, 0x0E, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0xF8, 0x3B, 0xFC, 0x6C, 0x38, 0xF0,
  0x39, 0xC0, 0x77, 0x00, 0xEE, 0x01, 0xD8, 0x03, 0xB0, 0x07, 0x60, 0x0C,
  0xC0, 0x1B, 0x80, 0x77, 0x01, 0xCD, 0x07, 0x9B, 0xFE, 0x31, 0xF0, 0x00,
  0x03, 0xE0, 0x3F, 0xE1, 0xC1, 0xCE, 0x03, 0x70, 0x11, 0xC0, 0x06, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x98, 0x07, 0x60, 0x39, 0xC1,
  0xC3, 0xFE, 0x03, 0xE0, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x07, 0xCE, 0x1F, 0xEE, 0x3C, 0x3E,
  0x70, 0x1C, 0x60, 0x0C, 0xE0, 0x0C, 0xE0, 0x1C, 0xE0, 0x1C, 0xC0, 0x1C,
  0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x38, 0xE0, 0x78, 0xF0, 0xB8, 0x7F, 0xB8,
  0x3E, 0x30, 0x03, 0xF0, 0x3F, 0xF1, 0xC1, 0xCE, 0x03, 0x70, 0x0D, 0x80,
  0x76, 0x0F, 0xBF, 0xFC, 0xFF, 0x03, 0x80, 0x0E, 0x01, 0x38, 0x07, 0x60,
  0x19, 0xC1, 0xC3, 0xFE, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x83, 0x80, 0x1E, 0x18, 0x00, 0x38, 0xC0, 0x01,
  0xC6, 0x00, 0x07, 0x30, 0x00, 0x1F, 0x80, 0x00, 0x38, 0x00, 0x00, 0x03,
  0xE7, 0x0F, 0xF7, 0x1E, 0x1F, 0x38, 0x0E, 0x38, 0x06, 0x70, 0x06, 0x70,
  0x0E, 0x70, 0x0E, 0x60, 0x0E, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x1C, 0x70,
  0x3C, 0x78, 0x7C, 0x3F, 0xDC, 0x1F, 0x18, 0x00, 0x18, 0x00, 0x38, 0x40,
  0x30, 0xE0, 0xF0, 0x7F, 0xE0, 0x3F, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x7C, 0x3B, 0xF8, 0xF8,
  0x73, 0x41, 0xCE, 0x03, 0x30, 0x0D, 0xC0, 0x77, 0x01, 0xDC, 0x07, 0x60,
  0x19, 0x80, 0x66, 0x01, 0xB8, 0x0E, 0xE0, 0x3B, 0x80, 0xEC, 0x03, 0x00,
  0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x00, 0x0C, 0x18, 0x30, 0xF1, 0xC7, 0x07, 0x38, 0x1D,
  0xC0, 0x7E, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0xC0, 0x03,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x04, 0x0C, 0x38, 0x70, 0x71,
  0xC0, 0xE7, 0x01, 0xD8, 0x03, 0xE0, 0x07, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0xF0,
  0x3B, 0xF8, 0x3E, 0x1C, 0x34, 0x1C, 0x38, 0x0C, 0x30, 0x1C, 0x70, 0x18,
  0x70, 0x70, 0x73, 0xC0, 0x67, 0x00, 0x63, 0x04, 0x63, 0x86, 0xE1, 0x8F,
  0xE1, 0xDC, 0xE0, 0xF8, 0xC0, 0xE0, 0x7F, 0x87, 0xFC, 0x00, 0xC0, 0x06,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x18, 0xC1, 0xC6,
  0x1C, 0x33, 0x83, 0xB8, 0x1F, 0x80, 0x78, 0x00, 0x19, 0xC7, 0x86, 0xFB,
  0xE1, 0xC7, 0x9C, 0xE1, 0xC7, 0x38, 0x61, 0x8C, 0x18, 0x63, 0x0E, 0x18,
  0xC3, 0x86, 0x30, 0xC1, 0x9C, 0x30, 0xE7, 0x0C, 0x31, 0x83, 0x0C, 0x61,
  0xC3, 0x18, 0x70, 0xC6, 0x18, 0x33, 0x86, 0x1C, 0x39, 0xF0, 0xEF, 0xE3,
  0xE1, 0xCD, 0x07, 0x38, 0x0C, 0xC0, 0x37, 0x01, 0xDC, 0x07, 0x70, 0x1D,
  0x80, 0x66, 0x01, 0x98, 0x06, 0xE0, 0x3B, 0x80, 0xEE, 0x03, 0xB0, 0x0C,
  0x03, 0xE0, 0x1F, 0xF0, 0xF0, 0xF1, 0x80, 0x67, 0x00, 0xCC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0D, 0x80, 0x1B, 0x00, 0x77, 0x00, 0xCE, 0x03,
  0x8E, 0x0E, 0x0F, 0xF8, 0x0F, 0xC0, 0x1C, 0xF8, 0x1D, 0xFE, 0x1B, 0x0E,
  0x1E, 0x07, 0x1C, 0x07, 0x38, 0x07, 0x38, 0x07, 0x30, 0x07, 0x30, 0x07,
  0x30, 0x06, 0x30, 0x06, 0x70, 0x0E, 0x70, 0x1C, 0x68, 0x3C, 0x6F, 0xF8,
  0x63, 0xE0, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x07, 0xCE, 0x3F, 0xDC, 0xF0, 0xFB, 0x80, 0xE6, 0x00, 0xDC,
  0x01, 0xB8, 0x07, 0x70, 0x0E, 0xC0, 0x1D, 0x80, 0x33, 0x00, 0x66, 0x01,
  0xCE, 0x07, 0x9E, 0x17, 0x1F, 0xEE, 0x1F, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x7F, 0x3F, 0xFC, 0xFC,
  0x1B, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x03, 0xF8, 0x0F, 0xFE, 0x1E, 0x0F, 0x18, 0x04, 0x18, 0x00,
  0x18, 0x00, 0x1E, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x0C, 0x60, 0x0C, 0xF8, 0x3C, 0x3F, 0xF8, 0x0F, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x07, 0xFF, 0xDF, 0xFF,
  0x86, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0,
  0x03, 0x02, 0x0C, 0x1C, 0x70, 0xE1, 0xCF, 0x07, 0x78, 0x1F, 0x80, 0x38,
  0x00, 0x70, 0x1D, 0xC0, 0x76, 0x01, 0x98, 0x06, 0x60, 0x1B, 0x80, 0xEE,
  0x03, 0xB8, 0x0E, 0xC0, 0x33, 0x00, 0xCC, 0x07, 0x30, 0x1C, 0xC0, 0xF3,
  0x85, 0xCF, 0xF6, 0x0F, 0x18, 0xFC, 0x0D, 0xF8, 0x38, 0x70, 0x38, 0xE0,
  0x71, 0x80, 0xE3, 0x01, 0xC6, 0x03, 0x8C, 0x06, 0x38, 0x0C, 0x70, 0x38,
  0xE0, 0xE1, 0x81, 0xC3, 0x0F, 0x06, 0x3C, 0x0F, 0xE0, 0x1F, 0x00, 0x38,
  0x63, 0x18, 0x71, 0x8C, 0x30, 0xC6, 0x18, 0x73, 0x0C, 0x3B, 0x86, 0x1D,
  0x83, 0x0E, 0xC3, 0x86, 0x61, 0x83, 0x30, 0xC1, 0x98, 0x61, 0xDC, 0x30,
  0xCE, 0x38, 0xE7, 0x2C, 0x61, 0xF3, 0xE0, 0xF1, 0xE0, 0x03, 0x87, 0x83,
  0xF3, 0xF1, 0xCD, 0x8D, 0xE3, 0x43, 0x20, 0xF0, 0xC0, 0x38, 0x30, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x0E, 0x1C, 0x03, 0x85, 0x06,
  0xE3, 0x63, 0xB9, 0x9B, 0xC7, 0xE7, 0xC1, 0xE0, 0xE0, 0x1C, 0x07, 0x1C,
  0x07, 0x18, 0x06, 0x18, 0x06, 0x18, 0x06, 0x38, 0x0E, 0x38, 0x0E, 0x38,
  0x0E, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x1C, 0x30, 0x1C, 0x30, 0x3C, 0x38,
  0x5C, 0x1F, 0x98, 0x0F, 0x18, 0x00, 0x38, 0x00, 0x38, 0x40, 0x70, 0xE0,
  0xF0, 0xFF, 0xE0, 0x3F, 0x80, 0x0F, 0x86, 0x7F, 0xCC, 0xC3, 0xFB, 0x00,
  0xE6, 0x03, 0x8C, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x10,
  0x70, 0x71, 0xC0, 0x67, 0x80, 0xDF, 0xF9, 0xB3, 0xFF, 0x60, 0xFC, 0x00,
  0xFE, 0x03, 0xFC, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x38, 0x0F,
  0xE0, 0x1F, 0x80, 0x41, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x7F, 0x80, 0xFE, 0x00, 0x06, 0x0C, 0x38, 0x60, 0xC1, 0x83, 0x06, 0x1C,
  0x30, 0x60, 0xC1, 0x83, 0x0E, 0x18, 0x30, 0x60, 0xC1, 0x87, 0x0C, 0x18,
  0x30, 0x60, 0xC3, 0x86, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0xE0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x1F, 0xC0, 0x7F, 0x81, 0xC0, 0x07,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x0E, 0x01,
  0x0F, 0x81, 0xCC, 0x60, 0xC6, 0x38, 0xE6, 0x0C, 0x63, 0x03, 0xE3, 0x00,
  0xE0,
};

const GFXglyph IBMPlexMono_Italic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 7, 22, 19, 6, -22 },
  { 21, 9, 9, 19, 7, -23 },
  { 32, 19, 22, 19, 0, -22 },
  { 85, 17, 28, 19, 1, -25 },
  { 145, 21, 22, 19, -1, -22 },
  { 203, 18, 22, 19, 0, -22 },
  { 253, 4, 9, 19, 9, -23 },
  { 258, 12, 28, 19, 6, -24 },
  { 300, 12, 28, 19, 1, -24 },
  { 342, 15, 15, 19, 2, -17 },
  { 371, 15, 16, 19, 2, -17 },
  { 401, 7, 8, 19, 4, -4 },
  { 408, 9, 2, 19, 5, -10 },
  { 411, 5, 4, 19, 6, -4 },
  { 414, 17, 28, 19, 1, -24 },
  { 474, 16, 22, 19, 2, -22 },
  { 518, 15, 22, 19, 1, -22 },
  { 560, 16, 22, 19, 1, -22 },
  { 604, 16, 22, 19, 1, -22 },
  { 648, 17, 22, 19, 0, -22 },
  { 695, 17, 22, 19, 1, -22 },
  { 742, 15, 22, 19, 2, -22 },
  { 784, 16, 22, 19, 3, -22 },
  { 828, 17, 22, 19, 1, -22 },
  { 875, 14, 22, 19, 3, -22 },
  { 914, 7, 16, 19, 6, -16 },
  { 928, 9, 20, 19, 4, -16 },
  { 951, 15, 18, 19, 3, -19 },
  { 985, 16, 9, 19, 2, -14 },
  { 1003, 14, 18, 19, 2, -19 },
  { 1035, 13, 22, 19, 4, -22 },
  { 1071, 15, 25, 19, 2, -22 },
  { 1118, 16, 22, 19, 0, -22 },
  { 1162, 16, 22, 19, 1, -22 },
  { 1206, 16, 22, 19, 2, -22 },
  { 1250, 16, 22, 19, 2, -22 },
  { 1294, 17, 22, 19, 1, -22 },
  { 1341, 18, 22, 19, 1, -22 },
  { 1391, 16, 22, 19, 2, -22 },
  { 1435, 17, 22, 19, 1, -22 },
  { 1482, 17, 22, 19, 1, -22 },
  { 1529, 15, 22, 19, 2, -22 },
  { 1571, 19, 22, 19, 1, -22 },
  { 1624, 14, 22, 19, 2, -22 },
  { 1663, 18, 22, 19, 1, -22 },
  { 1713, 17, 22, 19, 1, -22 },
  { 1760, 16, 22, 19, 2, -22 },
  { 1804, 17, 22, 19, 1, -22 },
  { 1851, 16, 28, 19, 2, -22 },
  { 1907, 17, 22, 19, 1, -22 },
  { 1954, 17, 22, 19, 1, -22 },
  { 2001, 17, 22, 19, 3, -22 },
  { 2048, 16, 22, 19, 2, -22 },
  { 2092, 17, 22, 19, 3, -22 },
  { 2139, 19, 22, 19, 1, -22 },
  { 2192, 21, 22, 19, -1, -22 },
  { 2250, 17, 22, 19, 3, -22 },
  { 2297, 19, 22, 19, 0, -22 },
  { 2350, 13, 28, 19, 5, -24 },
  { 2396, 8, 28, 19, 6, -24 },
  { 2424, 14, 28, 19, 0, -24 },
  { 2473, 16, 13, 19, 2, -22 },
  { 2499, 15, 2, 19, 0, 3 },
  { 2503, 4, 6, 19, 7, -24 },
  { 2506, 15, 16, 19, 2, -16 },
  { 2536, 15, 23, 19, 2, -23 },
  { 2580, 14, 16, 19, 2, -16 },
  { 2608, 16, 23, 19, 2, -23 },
  { 2654, 14, 16, 19, 2, -16 },
  { 2682, 21, 29, 19, -1, -23 },
  { 2759, 16, 22, 19, 1, -16 },
  { 2803, 14, 23, 19, 2, -23 },
  { 2844, 14, 23, 19, 3, -23 },
  { 2885, 14, 29, 19, 2, -23 },
  { 2936, 16, 23, 19, 2, -23 },
  { 2982, 13, 23, 19, 3, -23 },
  { 3020, 18, 16, 19, 0, -16 },
  { 3056, 14, 16, 19, 2, -16 },
  { 3084, 15, 16, 19, 2, -16 },
  { 3114, 16, 22, 19, 1, -16 },
  { 3158, 15, 22, 19, 2, -16 },
  { 3200, 15, 16, 19, 3, -16 },
  { 3230, 16, 16, 19, 1, -16 },
  { 3262, 14, 22, 19, 2, -22 },
  { 3301, 14, 16, 19, 3, -16 },
  { 3329, 15, 16, 19, 2, -16 },
  { 3359, 17, 16, 19, 1, -16 },
  { 3393, 18, 16, 19, 0, -16 },
  { 3429, 16, 22, 19, 1, -16 },
  { 3473, 15, 16, 19, 2, -16 },
  { 3503, 15, 28, 19, 3, -24 },
  { 3556, 7, 28, 19, 6, -24 },
  { 3581, 15, 28, 19, 1, -24 },
  { 3634, 17, 7, 19, 1, -13 },
};

const GFXfont IBMPlexMono_Italic31pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic31pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic31pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _IBMPLEXMONO_ITALIC31PT7B_H_
