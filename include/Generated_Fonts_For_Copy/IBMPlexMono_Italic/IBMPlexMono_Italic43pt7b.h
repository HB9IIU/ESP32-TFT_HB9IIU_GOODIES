#ifndef _IBMPLEXMONO_ITALIC43PT7B_H_
#define _IBMPLEXMONO_ITALIC43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x1F, 0x8F, 0xE3, 0xF8,
  0xFC, 0x1E, 0x00, 0x38, 0x79, 0xC3, 0x8E, 0x1C, 0xF0, 0xE7, 0x87, 0x38,
  0x39, 0xC3, 0xCE, 0x1C, 0x70, 0xE7, 0x87, 0x38, 0x39, 0xC1, 0xC0, 0x00,
  0x0E, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x70,
  0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x01, 0xE1,
  0xE0, 0x00, 0x70, 0x70, 0x07, 0xFC, 0x1F, 0xF1, 0xFF, 0x0F, 0xF8, 0x7F,
  0x83, 0xFE, 0x20, 0xE0, 0xE0, 0x00, 0x38, 0x78, 0x00, 0x1C, 0x1C, 0x00,
  0x07, 0x07, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0xE0, 0xE0, 0x0F, 0xF8, 0x3F,
  0xE3, 0xFE, 0x1F, 0xF0, 0xFF, 0x07, 0xFC, 0x01, 0xC1, 0xC0, 0x00, 0x70,
  0xF0, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x87, 0x80, 0x01,
  0xC1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x3C, 0x3C, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xE7,
  0x7E, 0x0F, 0x87, 0x1F, 0x0F, 0x06, 0x06, 0x0E, 0x06, 0x04, 0x1E, 0x0E,
  0x00, 0x1E, 0x0E, 0x00, 0x1E, 0x0E, 0x00, 0x0E, 0x0C, 0x00, 0x0F, 0x0C,
  0x00, 0x0F, 0xEC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x18, 0xF8, 0x00, 0x18, 0x3C, 0x00, 0x38,
  0x3C, 0x00, 0x38, 0x3C, 0x00, 0x38, 0x3C, 0x00, 0x30, 0x3C, 0x20, 0x30,
  0x3C, 0xF0, 0x30, 0x78, 0xF8, 0x70, 0xF8, 0x7E, 0x73, 0xF0, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x38, 0x0F,
  0xF0, 0x03, 0x80, 0xFF, 0xC0, 0x38, 0x0F, 0x0E, 0x01, 0xC0, 0x70, 0x38,
  0x1C, 0x07, 0x01, 0xC1, 0xC0, 0x38, 0x0E, 0x0E, 0x01, 0xC0, 0x70, 0xE0,
  0x0E, 0x07, 0x8E, 0x00, 0x70, 0x38, 0xF0, 0x03, 0x81, 0xC7, 0x00, 0x1C,
  0x1C, 0x70, 0x00, 0xFF, 0xE7, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x03, 0x8F, 0xFC,
  0x00, 0x38, 0xF0, 0xE0, 0x03, 0x8F, 0x07, 0x00, 0x1C, 0x70, 0x18, 0x01,
  0xC3, 0x80, 0xC0, 0x1C, 0x38, 0x0E, 0x01, 0xE1, 0xC0, 0x70, 0x0E, 0x0E,
  0x03, 0x80, 0xE0, 0x30, 0x3C, 0x0F, 0x01, 0xC3, 0xC0, 0x70, 0x0F, 0xFC,
  0x07, 0x00, 0x3F, 0xC0, 0x70, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0x1F, 0x00, 0x1E, 0x07, 0x80,
  0x0E, 0x01, 0xC0, 0x0F, 0x00, 0xE0, 0x07, 0x80, 0x70, 0x03, 0xC0, 0x38,
  0x00, 0xE0, 0x1C, 0x00, 0x70, 0x1E, 0x00, 0x3C, 0x0E, 0x00, 0x0E, 0x0F,
  0x00, 0x0F, 0x9F, 0x00, 0x3F, 0xFE, 0x00, 0x3C, 0xFC, 0x00, 0x3C, 0x38,
  0x00, 0x3C, 0x1E, 0x00, 0x1C, 0x07, 0x00, 0x1E, 0x03, 0xC0, 0x0F, 0x00,
  0xE0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1C, 0x0F, 0xE0, 0x0F, 0x07, 0xF0,
  0x0B, 0x87, 0x38, 0x0D, 0xE7, 0x9E, 0x0E, 0x7B, 0x87, 0xFE, 0x3F, 0xC3,
  0xFE, 0x0F, 0xC0, 0x7E, 0x03, 0xC0, 0x3B, 0xDE, 0xE7, 0x39, 0xDE, 0xF7,
  0x39, 0xC0, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x1E, 0x0E, 0x07,
  0x7F, 0x39, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3D, 0xE0, 0x01, 0xE3, 0x80, 0x0F, 0x0F,
  0x00, 0x3C, 0x1C, 0x01, 0xE0, 0x78, 0x0F, 0x00, 0xE0, 0x18, 0x03, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xC3, 0xE1, 0xF0,
  0x7C, 0x1E, 0x0F, 0x83, 0xC0, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0x80, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFC, 0x3C, 0xFF, 0xFF, 0xFF, 0xCF, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xF0, 0x7C, 0x0F,
  0x00, 0x78, 0x78, 0x01, 0xE1, 0xC0, 0x03, 0x8F, 0x00, 0x0E, 0x38, 0x00,
  0x39, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xDC, 0x00, 0x0E, 0x70, 0x78, 0x3B,
  0xC3, 0xE0, 0xEF, 0x0F, 0x87, 0xBC, 0x3E, 0x1E, 0xF0, 0xF0, 0x7B, 0x80,
  0x01, 0xEE, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0xF3, 0x80, 0x03,
  0x8E, 0x00, 0x1E, 0x38, 0x00, 0x70, 0xF0, 0x03, 0xC1, 0xC0, 0x1E, 0x07,
  0xC1, 0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0x70, 0x03, 0xE7, 0x00,
  0x7C, 0x70, 0x0F, 0x8F, 0x03, 0xF0, 0xF0, 0x1C, 0x0F, 0x01, 0x80, 0xE0,
  0x10, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F,
  0x07, 0xE0, 0x78, 0x03, 0xC1, 0xE0, 0x03, 0x83, 0xC0, 0x07, 0x83, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0xE0, 0x1F, 0x03, 0xE0, 0x78, 0x03, 0xC0, 0xE0, 0x03, 0xC0, 0x80,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x10,
  0x00, 0x78, 0xF0, 0x00, 0xF1, 0xF0, 0x03, 0xC1, 0xF8, 0x1F, 0x01, 0xFF,
  0xFC, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7B, 0x80, 0x00,
  0xE7, 0x00, 0x03, 0x9E, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0x70, 0x00, 0xF0,
  0xE0, 0x01, 0xC1, 0xC0, 0x07, 0x03, 0x80, 0x1C, 0x0F, 0x00, 0x78, 0x1E,
  0x01, 0xE0, 0x38, 0x07, 0x80, 0x70, 0x0E, 0x00, 0xE0, 0x38, 0x01, 0xC0,
  0xE0, 0x07, 0x83, 0xC0, 0x0F, 0x0F, 0x00, 0x1C, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3C, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x71, 0xF8, 0x01, 0xCF, 0xFC,
  0x03, 0xBF, 0xFC, 0x07, 0xC0, 0xFC, 0x0F, 0x00, 0x78, 0x08, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x3C, 0x10, 0x00, 0x78, 0x70, 0x01, 0xE1, 0xF0,
  0x07, 0xC1, 0xF8, 0x1F, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC7, 0xE0, 0x39, 0xFF, 0x87, 0xBF,
  0xFC, 0x77, 0x03, 0xE7, 0xC0, 0x1E, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xEE,
  0x00, 0x1E, 0xF0, 0x01, 0xCF, 0x00, 0x3C, 0x7C, 0x0F, 0x83, 0xFF, 0xF0,
  0x1F, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0x9C, 0x00, 0x1E, 0x70, 0x00, 0x79, 0xC0, 0x03, 0xC7, 0x00, 0x0E,
  0x1C, 0x00, 0x78, 0x70, 0x03, 0xC2, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x3E, 0x07, 0xE0, 0xF8, 0x03, 0xC1, 0xE0, 0x03, 0x87, 0x80, 0x07,
  0x8F, 0x00, 0x0E, 0x1E, 0x00, 0x1C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xE0,
  0x70, 0x03, 0xC0, 0xF8, 0x1F, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFF, 0xE0, 0x1F, 0x01, 0xE0, 0x78, 0x01, 0xE1, 0xE0, 0x01, 0xE3, 0x80,
  0x03, 0xCF, 0x00, 0x07, 0x9E, 0x00, 0x0F, 0x38, 0x00, 0x1E, 0x78, 0x00,
  0x3C, 0xF0, 0x00, 0xF1, 0xF0, 0x03, 0xE1, 0xF0, 0x1F, 0x83, 0xFF, 0xFE,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF8,
  0x0F, 0xFF, 0xC1, 0xF0, 0x3E, 0x3C, 0x01, 0xE7, 0x80, 0x0F, 0x70, 0x00,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xE7, 0xC0, 0xFE, 0x7F,
  0xFD, 0xC3, 0xFF, 0xBC, 0x0F, 0xE3, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x83,
  0xE1, 0xFC, 0x7E, 0x1F, 0x83, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x07, 0xE3, 0xF8, 0xFE,
  0x3F, 0x07, 0x80, 0x01, 0xE0, 0x3E, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xE0,
  0x3E, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x38, 0x00,
  0x01, 0x00, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x08,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x1C,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xFE,
  0x1F, 0x83, 0xE3, 0xC0, 0x3C, 0xF0, 0x03, 0xDC, 0x00, 0x7D, 0x80, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x7E, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0xF0, 0x3E, 0x07, 0x80, 0x38, 0x3C, 0x00, 0x70, 0xE0, 0x01,
  0xC7, 0x80, 0x07, 0x1C, 0x0F, 0x9C, 0x70, 0x7F, 0x73, 0x83, 0xFD, 0xCE,
  0x1E, 0x17, 0x38, 0x70, 0x3C, 0xE3, 0xC0, 0xE7, 0x8E, 0x03, 0x9E, 0x38,
  0x0E, 0x71, 0xE0, 0x39, 0xC7, 0x80, 0xE7, 0x1E, 0x07, 0x9C, 0x70, 0x1C,
  0x71, 0xC0, 0x73, 0xC7, 0x03, 0xCF, 0x1E, 0x1F, 0x38, 0x3F, 0xDC, 0xE0,
  0xFE, 0x71, 0x81, 0xFB, 0x87, 0x01, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xEE, 0x00, 0x03, 0x9C, 0x00,
  0x07, 0x38, 0x00, 0x1E, 0x78, 0x00, 0x38, 0xF0, 0x00, 0xF1, 0xE0, 0x01,
  0xC1, 0xC0, 0x07, 0x83, 0x80, 0x0E, 0x07, 0x00, 0x3C, 0x0E, 0x00, 0x70,
  0x1E, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xC0, 0x07, 0x87, 0x80, 0x0F,
  0x0E, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x70, 0x00, 0x79, 0xE0, 0x00, 0x73,
  0xC0, 0x00, 0xEF, 0x00, 0x01, 0xDE, 0x00, 0x03, 0xC0, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0x3C, 0x3C,
  0x00, 0xF0, 0xE0, 0x03, 0xC3, 0x80, 0x0F, 0x0E, 0x00, 0x3C, 0x78, 0x00,
  0xF1, 0xE0, 0x07, 0x87, 0x80, 0x1C, 0x1C, 0x01, 0xF0, 0x7F, 0xFF, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x3C, 0x01, 0xF0, 0xF0, 0x01, 0xC3, 0x80,
  0x07, 0x8E, 0x00, 0x1E, 0x38, 0x00, 0x79, 0xE0, 0x01, 0xE7, 0x80, 0x07,
  0x9E, 0x00, 0x1C, 0x70, 0x00, 0xF1, 0xC0, 0x07, 0x87, 0x00, 0x3E, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x03,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xF8, 0x3E, 0x07, 0x80, 0x78, 0x3C, 0x00,
  0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x04, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x01, 0x07, 0x00, 0x0F, 0x1C,
  0x00, 0x38, 0x78, 0x01, 0xE1, 0xF0, 0x0F, 0x03, 0xE0, 0xF8, 0x07, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x7F, 0xFF, 0x01, 0xC0, 0x7C, 0x07, 0x00, 0x78, 0x3C, 0x00, 0xF0,
  0xF0, 0x03, 0xC3, 0xC0, 0x07, 0x0F, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0,
  0x01, 0xC7, 0x80, 0x07, 0x1E, 0x00, 0x1C, 0x78, 0x00, 0xF1, 0xE0, 0x03,
  0xC7, 0x00, 0x0F, 0x1C, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0x8F,
  0x00, 0x1E, 0x3C, 0x00, 0x78, 0xE0, 0x01, 0xE3, 0x80, 0x0F, 0x1E, 0x00,
  0x3C, 0x78, 0x01, 0xE1, 0xE0, 0x0F, 0x07, 0x80, 0xF8, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF8, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x07, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01,
  0xF0, 0x7C, 0x0F, 0x00, 0x78, 0x78, 0x00, 0xE1, 0xE0, 0x03, 0x8F, 0x00,
  0x09, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x0F, 0xFC, 0xF0,
  0x3F, 0xF3, 0xC0, 0xFF, 0xCF, 0x00, 0x0F, 0x38, 0x00, 0x38, 0xE0, 0x00,
  0xE3, 0xC0, 0x03, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x03, 0xE1,
  0xE0, 0x1F, 0x07, 0xC1, 0xDC, 0x0F, 0xFE, 0x70, 0x1F, 0xF1, 0xC0, 0x1F,
  0x0F, 0x00, 0x07, 0x00, 0x0E, 0x1E, 0x00, 0x1C, 0x3C, 0x00, 0x78, 0x78,
  0x00, 0xF0, 0xE0, 0x01, 0xE1, 0xC0, 0x03, 0xC3, 0x80, 0x07, 0x0F, 0x00,
  0x0E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x70, 0x00, 0xF0, 0xE0, 0x01,
  0xE1, 0xC0, 0x03, 0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC,
  0x38, 0x00, 0x78, 0x70, 0x00, 0xF0, 0xE0, 0x01, 0xC3, 0xC0, 0x03, 0x87,
  0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1C, 0x00, 0x3C, 0x38, 0x00, 0x78, 0x70,
  0x00, 0xE1, 0xE0, 0x01, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0E, 0x00,
  0x1E, 0x1C, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF8, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x07, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x01, 0x00, 0x3C, 0x3C,
  0x00, 0xF0, 0x70, 0x03, 0x81, 0xE0, 0x1E, 0x07, 0xC1, 0xF0, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0x00, 0x07, 0xC1, 0xC0,
  0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x3C, 0x00, 0xE0, 0x1E, 0x00, 0x38, 0x0F, 0x00, 0x1E, 0x07, 0x80,
  0x07, 0x83, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0x70, 0xF0, 0x00, 0x1C, 0x78,
  0x00, 0x07, 0x3E, 0x00, 0x03, 0xDF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0x9E, 0x00, 0x0F, 0xC7, 0x80, 0x03, 0xE0, 0xF0, 0x00, 0xF0, 0x3C, 0x00,
  0x78, 0x07, 0x00, 0x1E, 0x01, 0xE0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0F,
  0x00, 0x70, 0x03, 0xC0, 0x1C, 0x00, 0x78, 0x0F, 0x00, 0x1E, 0x03, 0xC0,
  0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0x3F, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x80, 0x07, 0xC0, 0x0F,
  0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xE0, 0xF8, 0x03, 0xE0, 0xFE, 0x03,
  0xF0, 0x77, 0x03, 0xF8, 0x3B, 0x81, 0xDC, 0x1D, 0xC1, 0xCE, 0x0E, 0x60,
  0xEF, 0x07, 0x38, 0xE7, 0x07, 0x9C, 0x73, 0x83, 0x8E, 0x71, 0xC1, 0xC7,
  0x70, 0xE0, 0xE1, 0xF8, 0x70, 0x70, 0xF8, 0x78, 0x38, 0x7C, 0x38, 0x3C,
  0x3C, 0x1C, 0x1C, 0x0E, 0x0E, 0x0E, 0x06, 0x07, 0x07, 0x02, 0x03, 0x83,
  0x81, 0x03, 0xC1, 0xC0, 0x01, 0xC1, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x70,
  0x70, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x1E, 0x0E, 0x00, 0x0E,
  0x0F, 0x00, 0x07, 0x07, 0x00, 0x03, 0x80, 0x07, 0xC0, 0x0E, 0x1F, 0x80,
  0x1C, 0x3F, 0x00, 0x38, 0x7F, 0x00, 0x70, 0xEE, 0x01, 0xE1, 0xDC, 0x03,
  0xC3, 0xB8, 0x07, 0x0F, 0x70, 0x0E, 0x1E, 0x70, 0x1C, 0x38, 0xE0, 0x38,
  0x71, 0xC0, 0xF0, 0xE3, 0x81, 0xE1, 0xC7, 0x83, 0x87, 0x87, 0x07, 0x0F,
  0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x78, 0x70, 0x38, 0xF0, 0xE0,
  0x71, 0xC3, 0xC0, 0xE3, 0x87, 0x81, 0xC7, 0x0E, 0x03, 0xCE, 0x1C, 0x03,
  0xBC, 0x38, 0x07, 0x78, 0x70, 0x0E, 0xE1, 0xE0, 0x1D, 0xC3, 0xC0, 0x1F,
  0x87, 0x00, 0x3F, 0x0E, 0x00, 0x7E, 0x1C, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xF0, 0x7C, 0x0F, 0x00, 0x78,
  0x78, 0x01, 0xE1, 0xE0, 0x03, 0x8F, 0x00, 0x0E, 0x38, 0x00, 0x39, 0xE0,
  0x00, 0xF7, 0x80, 0x03, 0xDC, 0x00, 0x0E, 0xF0, 0x00, 0x3B, 0xC0, 0x00,
  0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0x80, 0x01, 0xEE,
  0x00, 0x07, 0x38, 0x00, 0x3C, 0xE0, 0x00, 0xF3, 0x80, 0x03, 0x8E, 0x00,
  0x1E, 0x38, 0x00, 0x70, 0xF0, 0x03, 0xC1, 0xC0, 0x1E, 0x07, 0xC1, 0xF0,
  0x0F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x01, 0xE1,
  0xE0, 0x03, 0xC3, 0x80, 0x07, 0x87, 0x00, 0x0F, 0x0E, 0x00, 0x1E, 0x3C,
  0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x01, 0xE1, 0xC0, 0x03, 0xC3, 0x80,
  0x1F, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xF0, 0x7C, 0x0F,
  0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x03, 0x8F, 0x00, 0x0E, 0x38, 0x00,
  0x39, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xDC, 0x00, 0x0E, 0xF0, 0x00, 0x3B,
  0xC0, 0x00, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0x80,
  0x01, 0xEE, 0x00, 0x07, 0x38, 0x00, 0x3C, 0xE0, 0x00, 0xF3, 0x80, 0x03,
  0x8E, 0x00, 0x1E, 0x38, 0x00, 0x70, 0xF0, 0x03, 0xC1, 0xC0, 0x1E, 0x07,
  0xC1, 0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x08, 0x00, 0xF0, 0x70, 0x01, 0xE3, 0xC0, 0x03, 0x9E,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x38, 0x00, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x01, 0xE1,
  0xE0, 0x03, 0xC3, 0x80, 0x07, 0x87, 0x00, 0x0F, 0x0E, 0x00, 0x1E, 0x3C,
  0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xE1, 0xC0, 0x03, 0xC3, 0x80,
  0x1F, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x78, 0x38,
  0x00, 0xE0, 0x78, 0x01, 0xC0, 0x70, 0x03, 0x80, 0xF0, 0x0F, 0x01, 0xE0,
  0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x70, 0x03, 0x80, 0xE0, 0x07, 0x81,
  0xC0, 0x0F, 0x07, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xE0, 0x7E,
  0x07, 0x80, 0x1F, 0x0F, 0x00, 0x0E, 0x0E, 0x00, 0x04, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x20, 0x00, 0x38,
  0xF0, 0x00, 0x78, 0x78, 0x00, 0xF8, 0x7E, 0x03, 0xF0, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x1C, 0x78, 0x00, 0x71, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1C,
  0x00, 0x3C, 0x70, 0x00, 0xF3, 0xC0, 0x03, 0x8F, 0x00, 0x0E, 0x3C, 0x00,
  0x78, 0xF0, 0x01, 0xE3, 0x80, 0x07, 0x8E, 0x00, 0x1E, 0x78, 0x00, 0x71,
  0xE0, 0x01, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x70, 0x00, 0xF1, 0xC0,
  0x03, 0x8F, 0x00, 0x0E, 0x3C, 0x00, 0x38, 0xF0, 0x01, 0xE3, 0xC0, 0x07,
  0x8F, 0x00, 0x1C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC1, 0xC0, 0x1E, 0x07,
  0xC0, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xB8, 0x00, 0x1E, 0xF0, 0x00,
  0x73, 0xC0, 0x03, 0xC7, 0x00, 0x0E, 0x1C, 0x00, 0x78, 0x70, 0x01, 0xC1,
  0xC0, 0x0F, 0x07, 0x00, 0x38, 0x1C, 0x01, 0xE0, 0x78, 0x07, 0x81, 0xE0,
  0x1C, 0x03, 0x80, 0xF0, 0x0E, 0x03, 0x80, 0x38, 0x1E, 0x00, 0xE0, 0x70,
  0x03, 0x83, 0xC0, 0x0F, 0x0E, 0x00, 0x3C, 0x78, 0x00, 0x71, 0xC0, 0x01,
  0xCF, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x77, 0x80, 0x01, 0xDC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00,
  0x03, 0x9E, 0x00, 0x01, 0xCF, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xF3, 0x80,
  0x00, 0x71, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x1E, 0x38,
  0x3E, 0x0E, 0x1C, 0x1F, 0x07, 0x0E, 0x0F, 0x83, 0x87, 0x0F, 0xC3, 0xC7,
  0x87, 0xE1, 0xC3, 0x87, 0x70, 0xE1, 0xC3, 0xB8, 0x70, 0xE1, 0xDC, 0x78,
  0x71, 0xCE, 0x38, 0x38, 0xE7, 0x1C, 0x1C, 0x63, 0x8E, 0x0E, 0x71, 0xC7,
  0x07, 0x38, 0xE7, 0x03, 0xB8, 0x33, 0x81, 0xDC, 0x19, 0xC0, 0xEE, 0x0C,
  0xE0, 0xEE, 0x06, 0xE0, 0x77, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0x80,
  0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x0E, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x78, 0x00, 0x38, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x0F, 0x0E, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x07,
  0x80, 0x38, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x07, 0x00, 0x78, 0x00,
  0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x7C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x38, 0x00, 0x78,
  0x3C, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xC0,
  0x0E, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x0F, 0x00, 0x07, 0x1E, 0x00,
  0x07, 0xBC, 0x00, 0x03, 0xBC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x30, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x30, 0x07, 0x00, 0xE0,
  0x1C, 0x01, 0x80, 0x30, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x07,
  0x00, 0xE0, 0x0C, 0x01, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x60, 0x0E,
  0x01, 0xC0, 0x38, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFC, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1D, 0xE0, 0x00,
  0xF3, 0x80, 0x07, 0x8E, 0x00, 0x1C, 0x3C, 0x00, 0xE0, 0x70, 0x07, 0x81,
  0xE0, 0x3C, 0x03, 0x80, 0xE0, 0x0E, 0x07, 0x80, 0x3C, 0x3C, 0x00, 0x70,
  0xE0, 0x01, 0xE7, 0x00, 0x03, 0xBC, 0x00, 0x0E, 0x60, 0x00, 0x3C, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x67, 0x9C, 0xE7, 0x1C, 0xE2,
  0x00, 0xFC, 0x38, 0x1F, 0xF1, 0xC3, 0xFF, 0xDE, 0x1F, 0x07, 0xF1, 0xE0,
  0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x01, 0xCF, 0x00, 0x0E, 0x78, 0x00, 0xF3,
  0x80, 0x07, 0x9C, 0x00, 0x38, 0xE0, 0x01, 0xCF, 0x00, 0x0E, 0x78, 0x00,
  0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x7C, 0x70, 0x03, 0xC3, 0xC0, 0x2E, 0x1F,
  0x07, 0x70, 0x7F, 0xF3, 0xF1, 0xFF, 0x1F, 0x87, 0xE0, 0x7C, 0x03, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x83, 0xE0, 0x1C, 0x7F, 0xC0, 0xE7, 0xFF, 0x0F, 0x70, 0x7C, 0x7E,
  0x01, 0xE3, 0xE0, 0x07, 0x1E, 0x00, 0x38, 0xF0, 0x01, 0xC7, 0x00, 0x0E,
  0x78, 0x00, 0x73, 0xC0, 0x03, 0x9C, 0x00, 0x3C, 0xE0, 0x01, 0xE7, 0x00,
  0x0F, 0x38, 0x00, 0x73, 0xC0, 0x07, 0x9E, 0x00, 0x38, 0xF8, 0x03, 0xC7,
  0x60, 0x7C, 0x3B, 0xFF, 0xC1, 0xCF, 0xFC, 0x1E, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xC1, 0xF1, 0xE0, 0x1E, 0x78, 0x01,
  0xCE, 0x00, 0x23, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x37, 0x80, 0x0F,
  0x70, 0x03, 0xCF, 0x00, 0xF0, 0xF0, 0x7C, 0x1F, 0xFF, 0x01, 0xFF, 0xC0,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x03, 0xF0, 0xE0, 0x1F,
  0xF9, 0xC0, 0x7F, 0xF3, 0x81, 0xF0, 0x37, 0x07, 0x80, 0x3E, 0x1E, 0x00,
  0x3C, 0x3C, 0x00, 0x70, 0xF0, 0x00, 0xE1, 0xE0, 0x01, 0xC3, 0x80, 0x03,
  0x87, 0x00, 0x0F, 0x0E, 0x00, 0x1E, 0x3C, 0x00, 0x38, 0x78, 0x00, 0x70,
  0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC1, 0xC0, 0x0F, 0x83, 0xC0, 0x2F, 0x07,
  0xC1, 0xDC, 0x07, 0xFF, 0x38, 0x07, 0xFC, 0x70, 0x07, 0xE1, 0xE0, 0x00,
  0x7F, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0xF8, 0x1E, 0x1E, 0x00, 0xF3,
  0xC0, 0x0F, 0x38, 0x00, 0xF7, 0x80, 0x0F, 0x70, 0x03, 0xEF, 0x03, 0xFC,
  0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xC0, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x0C, 0x70, 0x01, 0xE7, 0x80, 0x3C, 0x7C, 0x0F, 0x83, 0xFF,
  0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x04, 0x03,
  0x80, 0x00, 0x70, 0x1C, 0x00, 0x07, 0xC0, 0xE0, 0x00, 0x0F, 0x07, 0x00,
  0x00, 0x7C, 0x78, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x07, 0xDC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x1E, 0x03, 0xFF, 0x38, 0x0F, 0xFE, 0x70, 0x3E, 0x06, 0xE0, 0xF0,
  0x07, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0E, 0x1E, 0x00, 0x1C, 0x3C, 0x00,
  0x38, 0x78, 0x00, 0x70, 0xE0, 0x01, 0xE1, 0xC0, 0x03, 0xC7, 0x80, 0x07,
  0x0F, 0x00, 0x0E, 0x1E, 0x00, 0x3C, 0x1C, 0x00, 0x78, 0x38, 0x01, 0xF0,
  0x78, 0x07, 0xE0, 0xF8, 0x3B, 0x80, 0xFF, 0xE7, 0x00, 0xFF, 0x8E, 0x00,
  0xFC, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x80, 0x80, 0x1E, 0x03, 0xC0, 0xFC, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x03, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x7C, 0x0E, 0x3F, 0xE1, 0xCF, 0xFC,
  0x3B, 0x87, 0xCF, 0x40, 0x79, 0xF0, 0x07, 0x3E, 0x00, 0xE7, 0x80, 0x1C,
  0xE0, 0x03, 0x9C, 0x00, 0x77, 0x80, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x73,
  0x80, 0x0E, 0x70, 0x01, 0xCE, 0x00, 0x3B, 0xC0, 0x0F, 0x78, 0x01, 0xEF,
  0x00, 0x39, 0xC0, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x10, 0x3C, 0x0F, 0x07, 0x83, 0xE0, 0xE0, 0xF0, 0x1C,
  0x3C, 0x03, 0x9F, 0x00, 0xF7, 0xC0, 0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x04, 0x03,
  0xC0, 0x70, 0x1E, 0x07, 0xC0, 0xE0, 0x0F, 0x07, 0x00, 0x3C, 0x38, 0x00,
  0xF1, 0xC0, 0x03, 0xDE, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE1, 0xF0, 0x07, 0x1F, 0xF0, 0x1C, 0xFF,
  0xE0, 0x77, 0x0F, 0x83, 0xD0, 0x0E, 0x0F, 0x80, 0x38, 0x3E, 0x00, 0xE0,
  0xF0, 0x07, 0x83, 0x80, 0x1C, 0x0E, 0x00, 0xF0, 0x78, 0x0F, 0x01, 0xE1,
  0xF8, 0x07, 0xBF, 0x00, 0x1C, 0x78, 0x00, 0x70, 0xE0, 0x11, 0xC3, 0xC0,
  0xEF, 0x07, 0x07, 0xFC, 0x1E, 0x3C, 0xF0, 0x39, 0xE3, 0x80, 0xFF, 0x0E,
  0x01, 0xF8, 0x38, 0x03, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x18, 0x78, 0x1F, 0x1E,
  0x0F, 0x87, 0x07, 0x81, 0xC3, 0xC0, 0x71, 0xE0, 0x3D, 0xF0, 0x07, 0xF8,
  0x01, 0xFC, 0x00, 0x3C, 0x00, 0x1C, 0x78, 0x3C, 0x3B, 0xF1, 0xFC, 0x77,
  0xF7, 0xF8, 0xF8, 0xEC, 0x73, 0xE1, 0xF0, 0xE7, 0x83, 0xC1, 0xCF, 0x07,
  0x83, 0x9C, 0x0E, 0x07, 0x38, 0x1C, 0x0E, 0x70, 0x38, 0x1D, 0xE0, 0x70,
  0x7B, 0x81, 0xC0, 0xE7, 0x03, 0x81, 0xCE, 0x07, 0x03, 0x9C, 0x0E, 0x07,
  0x38, 0x1C, 0x0E, 0xF0, 0x78, 0x3D, 0xC0, 0xE0, 0x73, 0x81, 0xC0, 0xE7,
  0x03, 0x81, 0xCE, 0x07, 0x03, 0x9C, 0x1E, 0x0F, 0x00, 0x1E, 0x1F, 0x03,
  0x8F, 0xF8, 0x73, 0xFF, 0x0E, 0xE1, 0xF3, 0xD0, 0x1E, 0x7C, 0x01, 0xCF,
  0x80, 0x39, 0xE0, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x1D, 0xE0, 0x07, 0xBC,
  0x00, 0xF7, 0x80, 0x1C, 0xE0, 0x03, 0x9C, 0x00, 0x73, 0x80, 0x0E, 0xF0,
  0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x0E, 0x70, 0x01, 0xCE, 0x00, 0x39, 0xC0,
  0x0F, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0xC1, 0xF0, 0x3E,
  0x3E, 0x01, 0xE3, 0xC0, 0x0F, 0x78, 0x00, 0xF7, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0E, 0xE0, 0x01, 0xEE, 0x00, 0x1E, 0xF0, 0x03, 0xC7, 0x00, 0x78, 0x7C,
  0x0F, 0x83, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0x07, 0xC0,
  0x1C, 0x7F, 0xC0, 0x73, 0xFF, 0x83, 0xDC, 0x1F, 0x0F, 0xC0, 0x3C, 0x3A,
  0x00, 0x70, 0xF0, 0x01, 0xC3, 0xC0, 0x07, 0x0E, 0x00, 0x1C, 0x78, 0x00,
  0x71, 0xE0, 0x01, 0xC7, 0x00, 0x0F, 0x1C, 0x00, 0x3C, 0x70, 0x00, 0xF1,
  0xC0, 0x03, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x70, 0xF8, 0x03, 0xC3, 0xB0,
  0x3E, 0x0E, 0xFF, 0xF0, 0x39, 0xFF, 0x81, 0xE1, 0xF8, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x3C, 0x0F, 0xFC, 0xE0, 0x7F, 0xF3, 0x83, 0xE0, 0x6E, 0x1E, 0x00,
  0xF8, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x1E, 0x00, 0x1C, 0x78, 0x00, 0x71,
  0xC0, 0x01, 0xC7, 0x00, 0x0F, 0x1C, 0x00, 0x3C, 0xF0, 0x00, 0xE3, 0xC0,
  0x03, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0x70, 0x03, 0xE1, 0xE0, 0x1F,
  0x87, 0xC1, 0xDC, 0x0F, 0xFE, 0x70, 0x1F, 0xF1, 0xC0, 0x3F, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0xFF, 0x9F, 0xF0, 0x3B, 0x80, 0x03,
  0xA0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x1F,
  0xFF, 0x01, 0xFF, 0xFC, 0x1F, 0x01, 0xF0, 0xE0, 0x03, 0x0F, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x20, 0x00, 0xE3, 0x80, 0x0F, 0x3F, 0x01, 0xF0, 0xFF, 0xFF,
  0x01, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x04, 0x07, 0x01, 0xE0, 0x70, 0x3F, 0x0F, 0x0F, 0xC0, 0xF1, 0xF0, 0x0E,
  0x7E, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7C, 0x00, 0x38, 0x00, 0xE7,
  0x00, 0x1C, 0xE0, 0x03, 0xBC, 0x00, 0xF7, 0x80, 0x1E, 0xE0, 0x03, 0x9C,
  0x00, 0x73, 0x80, 0x0E, 0x70, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x0F, 0x70,
  0x01, 0xCE, 0x00, 0x39, 0xC0, 0x0F, 0x38, 0x01, 0xE7, 0x00, 0x7C, 0xE0,
  0x0F, 0x9E, 0x02, 0xE3, 0xE1, 0xDC, 0x7F, 0xF3, 0x87, 0xFC, 0x70, 0x3E,
  0x1E, 0x00, 0xFF, 0x00, 0x6F, 0xF0, 0x0E, 0xFF, 0x00, 0xF0, 0xF0, 0x07,
  0x0F, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00,
  0x70, 0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x0E, 0x1C, 0x01, 0xE1, 0xC0,
  0x1E, 0x1C, 0x03, 0xC1, 0xC0, 0x78, 0x3C, 0x0F, 0x83, 0xC1, 0xF0, 0x38,
  0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xF8, 0x00, 0x1C, 0x1C, 0x18,
  0xE0, 0x70, 0xF3, 0x81, 0xC1, 0xCE, 0x07, 0x07, 0x38, 0x1C, 0x1C, 0xE0,
  0x70, 0x73, 0x83, 0x81, 0xDC, 0x0E, 0x07, 0x70, 0x38, 0x1D, 0xC0, 0xE0,
  0x77, 0x03, 0x81, 0xDC, 0x1E, 0x07, 0x70, 0x70, 0x1F, 0x81, 0xC0, 0xEE,
  0x07, 0x03, 0xB8, 0x1C, 0x1E, 0xE0, 0xF0, 0x73, 0x83, 0xC3, 0xCF, 0x37,
  0x1E, 0x3F, 0xCF, 0xF8, 0x7E, 0x3F, 0x80, 0xF0, 0x7C, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x7E, 0x1F, 0xE0, 0x7F, 0xCF, 0xF8, 0x3E, 0x73, 0x8E, 0x1F,
  0x1D, 0xC3, 0x8F, 0x07, 0x60, 0xF1, 0x01, 0xF0, 0x38, 0x00, 0x7C, 0x0E,
  0x00, 0x1E, 0x02, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x04, 0x0F, 0x80, 0x0F, 0x03, 0xC0, 0x03, 0x80,
  0xB8, 0x18, 0xE0, 0x6E, 0x1F, 0x3C, 0x3B, 0x8F, 0x8F, 0x1C, 0xE7, 0x81,
  0xFF, 0x3F, 0xC0, 0x7F, 0x87, 0xE0, 0x0F, 0x80, 0xE0, 0x00, 0x07, 0x00,
  0x1C, 0x1C, 0x00, 0x70, 0x70, 0x01, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C,
  0x3C, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x38, 0x78,
  0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1C, 0x1C, 0x00, 0x70, 0x70, 0x03,
  0xC1, 0xC0, 0x0F, 0x07, 0x00, 0x7C, 0x1C, 0x01, 0xF0, 0x78, 0x0B, 0x81,
  0xF0, 0xEE, 0x03, 0xFF, 0x38, 0x0F, 0xF8, 0xE0, 0x0F, 0xC7, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x02, 0x00, 0x78,
  0x1E, 0x07, 0xC0, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xF8, 0x1C, 0x1F, 0xFC, 0xF0, 0xFF, 0xFB, 0xC7, 0x83, 0xFF, 0x1C,
  0x01, 0xF8, 0x60, 0x03, 0xC3, 0x80, 0x3C, 0x0E, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x03, 0x80, 0x78, 0x07, 0x03, 0xC0, 0x1C, 0x3C, 0x00, 0x71, 0xFF,
  0x01, 0xC7, 0xFF, 0xE3, 0xBC, 0xFF, 0xFC, 0xF0, 0x7F, 0xF3, 0xC0, 0x3F,
  0x80, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0xFF, 0xE0,
  0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x0F, 0xF8, 0x00, 0x03, 0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0x03,
  0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xC0, 0x0C, 0x3F, 0x80, 0x71, 0xFF, 0x01, 0xCF, 0x1C, 0x0E,
  0x38, 0x78, 0x39, 0xC0, 0xF1, 0xC7, 0x01, 0xFF, 0x38, 0x03, 0xF8, 0x60,
  0x07, 0x80,
};

const GFXglyph IBMPlexMono_Italic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 10, 30, 26, 8, -30 },
  { 39, 13, 12, 26, 9, -32 },
  { 59, 26, 30, 26, 1, -30 },
  { 157, 24, 38, 26, 1, -34 },
  { 271, 29, 30, 26, -1, -30 },
  { 380, 25, 30, 26, 0, -30 },
  { 474, 5, 12, 26, 13, -32 },
  { 482, 16, 39, 26, 9, -33 },
  { 560, 16, 39, 26, 2, -33 },
  { 638, 22, 21, 26, 2, -24 },
  { 696, 21, 21, 26, 3, -24 },
  { 752, 10, 12, 26, 6, -6 },
  { 767, 13, 3, 26, 7, -15 },
  { 772, 7, 6, 26, 8, -6 },
  { 778, 25, 39, 26, 1, -33 },
  { 900, 22, 30, 26, 3, -30 },
  { 983, 20, 30, 26, 2, -30 },
  { 1058, 23, 30, 26, 1, -30 },
  { 1145, 23, 30, 26, 1, -30 },
  { 1232, 23, 30, 26, 1, -30 },
  { 1319, 23, 30, 26, 2, -30 },
  { 1406, 20, 30, 26, 3, -30 },
  { 1481, 22, 30, 26, 4, -30 },
  { 1564, 23, 30, 26, 2, -30 },
  { 1651, 20, 30, 26, 4, -30 },
  { 1726, 10, 23, 26, 8, -23 },
  { 1755, 12, 29, 26, 6, -23 },
  { 1799, 20, 25, 26, 4, -26 },
  { 1862, 22, 12, 26, 2, -19 },
  { 1895, 21, 25, 26, 2, -26 },
  { 1961, 19, 30, 26, 5, -30 },
  { 2033, 22, 35, 26, 2, -30 },
  { 2130, 23, 30, 26, 0, -30 },
  { 2217, 22, 30, 26, 2, -30 },
  { 2300, 22, 30, 26, 3, -30 },
  { 2383, 22, 30, 26, 2, -30 },
  { 2466, 23, 30, 26, 2, -30 },
  { 2553, 24, 30, 26, 2, -30 },
  { 2643, 22, 30, 26, 3, -30 },
  { 2726, 23, 30, 26, 2, -30 },
  { 2813, 23, 30, 26, 2, -30 },
  { 2900, 22, 30, 26, 2, -30 },
  { 2983, 26, 30, 26, 2, -30 },
  { 3081, 19, 30, 26, 3, -30 },
  { 3153, 25, 30, 26, 1, -30 },
  { 3247, 23, 30, 26, 2, -30 },
  { 3334, 22, 30, 26, 3, -30 },
  { 3417, 23, 30, 26, 2, -30 },
  { 3504, 22, 38, 26, 3, -30 },
  { 3609, 23, 30, 26, 2, -30 },
  { 3696, 24, 30, 26, 1, -30 },
  { 3786, 24, 30, 26, 4, -30 },
  { 3876, 22, 30, 26, 3, -30 },
  { 3959, 22, 30, 26, 5, -30 },
  { 4042, 25, 30, 26, 2, -30 },
  { 4136, 29, 30, 26, -1, -30 },
  { 4245, 24, 30, 26, 4, -30 },
  { 4335, 26, 30, 26, 0, -30 },
  { 4433, 18, 39, 26, 7, -33 },
  { 4521, 11, 39, 26, 8, -33 },
  { 4575, 19, 39, 26, 0, -33 },
  { 4668, 22, 17, 26, 3, -30 },
  { 4715, 21, 3, 26, 0, 4 },
  { 4723, 5, 8, 26, 10, -33 },
  { 4728, 21, 22, 26, 2, -22 },
  { 4786, 21, 32, 26, 2, -32 },
  { 4870, 19, 22, 26, 3, -22 },
  { 4923, 23, 32, 26, 2, -32 },
  { 5015, 20, 22, 26, 3, -22 },
  { 5070, 29, 41, 26, -1, -32 },
  { 5219, 23, 31, 26, 1, -22 },
  { 5309, 19, 32, 26, 3, -32 },
  { 5385, 19, 32, 26, 4, -32 },
  { 5461, 21, 41, 26, 2, -32 },
  { 5569, 22, 32, 26, 3, -32 },
  { 5657, 18, 32, 26, 5, -32 },
  { 5729, 23, 22, 26, 1, -22 },
  { 5793, 19, 22, 26, 3, -22 },
  { 5846, 20, 22, 26, 3, -22 },
  { 5901, 22, 31, 26, 1, -22 },
  { 5987, 22, 31, 26, 2, -22 },
  { 6073, 20, 22, 26, 5, -22 },
  { 6128, 21, 22, 26, 2, -22 },
  { 6186, 20, 30, 26, 3, -30 },
  { 6261, 19, 22, 26, 4, -22 },
  { 6314, 20, 22, 26, 3, -22 },
  { 6369, 22, 22, 26, 2, -22 },
  { 6430, 26, 22, 26, 0, -22 },
  { 6502, 22, 31, 26, 1, -22 },
  { 6588, 22, 22, 26, 2, -22 },
  { 6649, 20, 39, 26, 5, -33 },
  { 6747, 9, 39, 26, 9, -33 },
  { 6791, 20, 39, 26, 2, -33 },
  { 6889, 22, 9, 26, 2, -18 },
};

const GFXfont IBMPlexMono_Italic43pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic43pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic43pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _IBMPLEXMONO_ITALIC43PT7B_H_
