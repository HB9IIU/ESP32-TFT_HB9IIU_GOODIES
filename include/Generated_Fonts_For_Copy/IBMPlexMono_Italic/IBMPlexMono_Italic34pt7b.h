#ifndef _IBMPLEXMONO_ITALIC34PT7B_H_
#define _IBMPLEXMONO_ITALIC34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x1C, 0x38, 0x71, 0xC3, 0x87, 0x0E, 0x1C, 0x30, 0x60, 0xC1,
  0x82, 0x04, 0x08, 0x00, 0x00, 0x03, 0x8F, 0x9F, 0x3C, 0x78, 0x30, 0xDC,
  0x77, 0x1D, 0xC7, 0x71, 0x98, 0x66, 0x1B, 0x8E, 0xE3, 0x80, 0x00, 0x38,
  0xE0, 0x01, 0x87, 0x00, 0x0C, 0x30, 0x00, 0xE3, 0x80, 0x06, 0x1C, 0x00,
  0x30, 0xC0, 0x03, 0x8E, 0x00, 0x18, 0x70, 0x1F, 0xC3, 0xF8, 0xFE, 0x3F,
  0xC0, 0x61, 0xC0, 0x03, 0x0C, 0x00, 0x38, 0xE0, 0x01, 0x87, 0x01, 0xFC,
  0x3F, 0x9F, 0xE3, 0xF8, 0x06, 0x18, 0x00, 0x70, 0xC0, 0x03, 0x8E, 0x00,
  0x18, 0x60, 0x01, 0xC3, 0x00, 0x0E, 0x38, 0x00, 0x61, 0xC0, 0x07, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0xFF, 0x00, 0x7F,
  0xF8, 0x1E, 0x67, 0x87, 0x8C, 0x78, 0xE1, 0x86, 0x18, 0x30, 0x07, 0x06,
  0x00, 0xE1, 0x80, 0x0E, 0x30, 0x01, 0xE6, 0x00, 0x1F, 0xC0, 0x01, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0xCF, 0x00, 0x18, 0xF0, 0x03, 0x0E, 0x00, 0x61,
  0xC0, 0x0C, 0x38, 0x01, 0x87, 0x18, 0x60, 0xE7, 0x8C, 0x38, 0x79, 0x9E,
  0x07, 0xFF, 0x80, 0x3F, 0xC0, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x01, 0xE0, 0x0E, 0x0F, 0xF0, 0x18, 0x38, 0x60, 0x70, 0x60, 0xC1,
  0xC1, 0xC1, 0x83, 0x03, 0x83, 0x0C, 0x06, 0x06, 0x38, 0x0C, 0x0C, 0x60,
  0x18, 0x39, 0x80, 0x18, 0xE7, 0x00, 0x3F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xFC, 0x00, 0x77, 0x1C, 0x01, 0xCC, 0x18, 0x07,
  0x38, 0x30, 0x0C, 0x70, 0x60, 0x30, 0xC0, 0xC0, 0xE1, 0x81, 0x81, 0x83,
  0x07, 0x06, 0x07, 0x1C, 0x1C, 0x07, 0xF0, 0x70, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x1F, 0xE0, 0x03, 0x87, 0x00, 0x70, 0x38, 0x07, 0x03, 0x80, 0x70,
  0x38, 0x07, 0x03, 0x80, 0x70, 0x38, 0x07, 0x03, 0x00, 0x38, 0x70, 0x03,
  0x8E, 0x00, 0xFF, 0xC0, 0x39, 0xE0, 0x07, 0x0E, 0x00, 0x60, 0xE0, 0x0E,
  0x07, 0x00, 0xE0, 0x70, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x3E, 0x03, 0xC6,
  0xE0, 0x5C, 0xE7, 0x0C, 0xEC, 0x3F, 0x8F, 0xC1, 0xF0, 0x78, 0x37, 0x77,
  0x66, 0x6E, 0xE0, 0x00, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00,
  0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x70,
  0x01, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x30, 0x01,
  0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80,
  0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x02, 0x06, 0x07, 0xE3, 0x1E,
  0xFF, 0xFF, 0x1F, 0xFC, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xE7,
  0x00, 0xE1, 0x80, 0xE0, 0xE0, 0xE0, 0x30, 0x20, 0x10, 0x00, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x1E, 0x3C, 0xF1, 0xE3,
  0x8E, 0x1C, 0x30, 0xE1, 0x80, 0x7F, 0xFF, 0xF8, 0x77, 0xFF, 0xEF, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x01, 0xC1, 0xC1, 0xC0, 0x71, 0xC0,
  0x39, 0xC0, 0x0C, 0xE0, 0x06, 0x60, 0x03, 0x70, 0x01, 0xB8, 0x00, 0xDC,
  0x78, 0xFC, 0x3C, 0x7E, 0x1E, 0x3F, 0x0E, 0x1F, 0x80, 0x0F, 0xC0, 0x0E,
  0xE0, 0x07, 0x70, 0x03, 0xB8, 0x03, 0x9C, 0x01, 0xC7, 0x01, 0xC3, 0xC3,
  0xC0, 0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0xF7, 0x00,
  0xF3, 0x00, 0xF3, 0x80, 0xF1, 0xC0, 0xE0, 0xE0, 0x20, 0x70, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFC, 0x01, 0xFF,
  0xC0, 0xF0, 0x78, 0x78, 0x0E, 0x1C, 0x01, 0xC2, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0xF3,
  0xFF, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0xF0, 0x78, 0x38, 0x0E, 0x04,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x71, 0x80, 0x1C, 0xE0,
  0x0E, 0x1E, 0x0F, 0x03, 0xFF, 0x80, 0x3F, 0x80, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0xEE, 0x00, 0x3B, 0x00, 0x1D, 0xC0, 0x0E, 0x70,
  0x07, 0x1C, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x70, 0x60, 0x38, 0x18, 0x1C,
  0x0E, 0x0E, 0x03, 0x87, 0x80, 0xE1, 0xC0, 0x38, 0xE0, 0x0C, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0x00, 0x01, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0xF8, 0x0E,
  0xFF, 0x06, 0x83, 0xC3, 0x80, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x88, 0x01, 0xCE, 0x01, 0xC7, 0xC1,
  0xC1, 0xFF, 0xC0, 0x3F, 0x80, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x39,
  0xF8, 0x37, 0xFC, 0x7C, 0x1E, 0x78, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0E, 0x70, 0x1C, 0x78,
  0x38, 0x3F, 0xF0, 0x0F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xE0,
  0x0E, 0xC0, 0x0E, 0xC0, 0x1C, 0xC0, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xE0, 0x78, 0x3C,
  0x38, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x07, 0x1C,
  0x03, 0x83, 0x81, 0xC0, 0x7F, 0xC0, 0x1F, 0xF0, 0x1E, 0x0F, 0x0E, 0x00,
  0xE7, 0x00, 0x39, 0xC0, 0x0E, 0x70, 0x03, 0xB8, 0x00, 0xEE, 0x00, 0x39,
  0xC0, 0x1E, 0x70, 0x07, 0x1E, 0x07, 0x83, 0xFF, 0xC0, 0x3F, 0x80, 0x03,
  0xF0, 0x0F, 0xFC, 0x1C, 0x1E, 0x38, 0x06, 0x70, 0x07, 0x60, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x1E, 0x78,
  0x3E, 0x3F, 0xEE, 0x1F, 0x9C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x1C,
  0x7C, 0xF9, 0xF3, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x7C, 0xF9, 0xE3, 0xC0, 0x07, 0x07, 0xC3, 0xE1, 0xF0, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x3C, 0x3C, 0x1E,
  0x0E, 0x0E, 0x07, 0x03, 0x03, 0x81, 0x80, 0x00, 0x01, 0x00, 0x07, 0x00,
  0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x18, 0x00, 0x08, 0x7F, 0xFF, 0xBF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFE, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x18, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x07, 0xE0, 0x3F, 0xF0, 0xF0,
  0xF3, 0x80, 0xE7, 0x00, 0xFC, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C,
  0x00, 0x78, 0x01, 0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xC1, 0xC3, 0x80,
  0x71, 0x80, 0x39, 0xC0, 0x0C, 0xC0, 0x06, 0x60, 0xF3, 0x70, 0xFD, 0xB8,
  0xE3, 0xD8, 0xE0, 0xEC, 0x70, 0x66, 0x30, 0x37, 0x18, 0x1B, 0x9C, 0x0D,
  0xCE, 0x0E, 0xC7, 0x07, 0x63, 0x83, 0x30, 0xC3, 0x98, 0x7E, 0xCC, 0x1E,
  0x66, 0x00, 0x43, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0xFC, 0x00, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01,
  0xD8, 0x00, 0x66, 0x00, 0x39, 0x80, 0x0E, 0x70, 0x07, 0x1C, 0x01, 0xC7,
  0x00, 0xE1, 0xC0, 0x38, 0x70, 0x0C, 0x1C, 0x07, 0x03, 0x01, 0xC0, 0xE0,
  0xE0, 0x38, 0x3F, 0xFE, 0x1F, 0xFF, 0x87, 0x00, 0xE3, 0x80, 0x38, 0xE0,
  0x0E, 0x70, 0x01, 0x9C, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0x1F, 0xFC,
  0x0F, 0xFF, 0x07, 0x01, 0xC3, 0x80, 0x71, 0xC0, 0x38, 0xC0, 0x1C, 0xE0,
  0x0E, 0x70, 0x07, 0x38, 0x07, 0x1C, 0x03, 0x8E, 0x03, 0x87, 0xFF, 0x07,
  0xFF, 0xC3, 0x80, 0x71, 0xC0, 0x1C, 0xE0, 0x0E, 0x70, 0x07, 0x30, 0x03,
  0xB8, 0x01, 0xDC, 0x00, 0xCE, 0x00, 0xE7, 0x00, 0xE3, 0xFF, 0xE1, 0xFF,
  0xC0, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xC3, 0xC3, 0x80, 0xE3, 0x80, 0x39,
  0xC0, 0x11, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x04, 0x38, 0x03, 0x9C, 0x03, 0xC7, 0x01, 0xC3, 0xC3, 0xC0,
  0xFF, 0xC0, 0x1F, 0x80, 0x0F, 0xF8, 0x07, 0xFF, 0x07, 0x03, 0xC3, 0x80,
  0xE1, 0xC0, 0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x30, 0x07, 0x38, 0x03, 0x9C,
  0x01, 0xCE, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x39, 0x80, 0x1D, 0xC0, 0x0E,
  0xE0, 0x0E, 0x70, 0x07, 0x38, 0x03, 0x9C, 0x03, 0x8C, 0x01, 0xCE, 0x01,
  0xC7, 0x03, 0xC3, 0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFC, 0x7F, 0xFF,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0xFF, 0xE3, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xFF, 0xFC, 0x7F, 0xFE, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x81,
  0xC1, 0xE1, 0xC0, 0x71, 0xC0, 0x39, 0xC0, 0x08, 0xE0, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x07, 0xF7, 0x07,
  0xFB, 0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x03, 0x38, 0x03, 0x8E,
  0x01, 0xC7, 0x01, 0xE1, 0xC3, 0x70, 0xFF, 0x38, 0x1F, 0x18, 0x0E, 0x00,
  0xE1, 0xC0, 0x1C, 0x38, 0x03, 0x87, 0x00, 0x70, 0xC0, 0x0C, 0x38, 0x03,
  0x87, 0x00, 0x70, 0xE0, 0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x60, 0x06,
  0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x70, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x1C,
  0x30, 0x03, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x03, 0x87, 0x00, 0x70,
  0xE0, 0x0E, 0x18, 0x01, 0x87, 0x00, 0x70, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x1F,
  0xFF, 0x87, 0xFF, 0xF0, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x08, 0x07, 0x1C, 0x07, 0x0E, 0x03,
  0x83, 0x83, 0x80, 0xFF, 0x80, 0x3F, 0x00, 0x0E, 0x00, 0x78, 0x70, 0x07,
  0x03, 0x80, 0x70, 0x1C, 0x07, 0x00, 0xE0, 0x70, 0x06, 0x07, 0x00, 0x70,
  0x70, 0x03, 0x87, 0x00, 0x1C, 0x70, 0x00, 0xE7, 0x00, 0x07, 0x78, 0x00,
  0x37, 0xC0, 0x03, 0xF7, 0x00, 0x1F, 0x38, 0x00, 0xF0, 0xE0, 0x07, 0x07,
  0x00, 0x38, 0x1C, 0x01, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x07,
  0x00, 0xE0, 0x38, 0x03, 0x81, 0xC0, 0x1C, 0x1C, 0x00, 0x70, 0x0C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0x0E, 0x00, 0xF0, 0xF0, 0x1E, 0x1F, 0x01, 0xE1,
  0xF0, 0x3E, 0x1F, 0x03, 0xE1, 0xB8, 0x6E, 0x1B, 0x8E, 0xE1, 0x98, 0xCC,
  0x39, 0x9C, 0xC3, 0x99, 0x9C, 0x39, 0xF9, 0xC3, 0x0F, 0x1C, 0x30, 0xE1,
  0xC3, 0x0E, 0x18, 0x70, 0xC1, 0x87, 0x04, 0x38, 0x70, 0x83, 0x87, 0x00,
  0x38, 0x60, 0x03, 0x86, 0x00, 0x30, 0xE0, 0x03, 0x0E, 0x00, 0x70, 0xE0,
  0x07, 0x0E, 0x00, 0x70, 0x0F, 0x00, 0xE1, 0xF0, 0x1C, 0x3E, 0x03, 0x86,
  0xC0, 0x70, 0xD8, 0x0C, 0x3B, 0x81, 0x87, 0x70, 0x70, 0xEE, 0x0E, 0x18,
  0xC1, 0xC3, 0x18, 0x38, 0x63, 0x86, 0x1C, 0x70, 0xC3, 0x86, 0x38, 0x70,
  0xC7, 0x0E, 0x1C, 0xE1, 0x83, 0x9C, 0x30, 0x73, 0x0E, 0x06, 0x61, 0xC0,
  0xDC, 0x38, 0x1F, 0x87, 0x03, 0xF0, 0xC0, 0x3E, 0x18, 0x07, 0x87, 0x00,
  0xF0, 0x00, 0xFC, 0x01, 0xFF, 0x03, 0xC1, 0xC1, 0xC0, 0x71, 0xC0, 0x39,
  0xC0, 0x1C, 0xE0, 0x06, 0xE0, 0x03, 0x70, 0x01, 0xB8, 0x01, 0xDC, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0E, 0xE0,
  0x07, 0x70, 0x03, 0xB8, 0x03, 0x9C, 0x01, 0xC7, 0x01, 0xC3, 0xC3, 0xC0,
  0xFF, 0xC0, 0x1F, 0x80, 0x1F, 0xFE, 0x07, 0xFF, 0xC1, 0xC0, 0x38, 0x70,
  0x07, 0x1C, 0x01, 0xC6, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x03,
  0x8E, 0x00, 0xE3, 0x80, 0x70, 0xFF, 0xF8, 0x7F, 0xF8, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0x00, 0xFC,
  0x01, 0xFF, 0x03, 0xC1, 0xC1, 0xC0, 0x71, 0xC0, 0x39, 0xC0, 0x1C, 0xE0,
  0x06, 0x60, 0x03, 0x70, 0x01, 0xB8, 0x01, 0xDC, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x03,
  0xB8, 0x03, 0x9C, 0x01, 0xC7, 0x01, 0xC3, 0xC3, 0xC0, 0xFF, 0xC0, 0x1F,
  0x80, 0x03, 0x80, 0x00, 0xE1, 0x80, 0x71, 0xE0, 0x1D, 0xC0, 0x07, 0xC0,
  0x01, 0xC0, 0x1F, 0xFE, 0x07, 0xFF, 0xC1, 0xC0, 0x38, 0x70, 0x07, 0x1C,
  0x01, 0xC6, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x03, 0x8E, 0x00,
  0xE3, 0x80, 0x70, 0xFF, 0xF8, 0x7F, 0xF8, 0x1C, 0x38, 0x07, 0x06, 0x01,
  0xC1, 0xC0, 0x70, 0x70, 0x18, 0x0C, 0x0E, 0x03, 0x83, 0x80, 0xE0, 0xE0,
  0x1C, 0x38, 0x07, 0x0E, 0x01, 0xC3, 0x00, 0x38, 0x00, 0xFE, 0x00, 0xFF,
  0xF0, 0x3C, 0x0F, 0x0F, 0x00, 0xF1, 0xC0, 0x0C, 0x38, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x30, 0x01, 0xCF, 0x00, 0x70, 0xF0, 0x3C,
  0x0F, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x1C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0x60, 0x07, 0x38,
  0x01, 0x8E, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x8C, 0x00,
  0xE7, 0x00, 0x31, 0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x71,
  0x80, 0x18, 0x60, 0x06, 0x38, 0x03, 0x8E, 0x00, 0xE1, 0x80, 0x30, 0x70,
  0x1C, 0x1E, 0x0E, 0x03, 0xFF, 0x00, 0x3F, 0x80, 0xC0, 0x03, 0xF8, 0x00,
  0xEE, 0x00, 0x33, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x03, 0x86, 0x00, 0xE1,
  0x80, 0x70, 0x60, 0x1C, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xC0, 0x70,
  0x70, 0x1C, 0x18, 0x03, 0x0E, 0x00, 0xC3, 0x80, 0x31, 0xC0, 0x0E, 0x70,
  0x03, 0xB8, 0x00, 0xEE, 0x00, 0x3B, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x30, 0x00, 0x77, 0x00, 0x06, 0x70, 0x00, 0x67, 0x00, 0x0E,
  0x70, 0x00, 0xE7, 0x00, 0x0C, 0x70, 0xE0, 0xC6, 0x1E, 0x1C, 0x61, 0xE1,
  0xC6, 0x1E, 0x18, 0x63, 0xE1, 0x86, 0x36, 0x38, 0x63, 0x63, 0x8E, 0x67,
  0x30, 0xE6, 0x73, 0x0E, 0xE7, 0x70, 0xEC, 0x77, 0x0E, 0xC3, 0x60, 0xDC,
  0x36, 0x0D, 0x83, 0x60, 0xD8, 0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0x07, 0x00, 0x1E, 0x07, 0x00, 0x78, 0x0E, 0x00, 0xE0, 0x0C,
  0x03, 0x80, 0x1C, 0x0E, 0x00, 0x38, 0x3C, 0x00, 0x38, 0x70, 0x00, 0x71,
  0xC0, 0x00, 0x77, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3B, 0x80, 0x00, 0xE7, 0x00,
  0x03, 0xC7, 0x00, 0x07, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x70, 0x1C, 0x01,
  0xC0, 0x1C, 0x07, 0x80, 0x38, 0x0E, 0x00, 0x70, 0x78, 0x00, 0x70, 0xE0,
  0x00, 0xEE, 0x00, 0x39, 0xC0, 0x0F, 0x38, 0x01, 0xC3, 0x80, 0x70, 0x70,
  0x1C, 0x07, 0x07, 0x80, 0xE0, 0xE0, 0x1C, 0x38, 0x01, 0xCE, 0x00, 0x39,
  0xC0, 0x03, 0x70, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x07, 0xFF, 0xF8, 0x7F,
  0xFF, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x07,
  0xFE, 0x0F, 0xFC, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03,
  0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0xC0, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0E, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x38, 0x0C, 0x06, 0x07, 0xFE, 0x0F,
  0xFC, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x36, 0x00, 0x3B, 0x80, 0x39, 0xC0, 0x38, 0x70, 0x18, 0x38, 0x1C,
  0x0C, 0x1C, 0x07, 0x1C, 0x01, 0x8E, 0x00, 0xEE, 0x00, 0x7E, 0x00, 0x1A,
  0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x4E, 0xE6, 0x73, 0x30, 0x07,
  0xE3, 0x0F, 0xF7, 0x1C, 0x1F, 0x38, 0x0F, 0x70, 0x07, 0x70, 0x06, 0x60,
  0x06, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0,
  0x1C, 0xE0, 0x1C, 0xE0, 0x3C, 0x70, 0xDC, 0x7F, 0x9F, 0x1F, 0x0F, 0x0E,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x31, 0xF8, 0x19, 0xFE, 0x1D, 0x87, 0x8F, 0x01, 0xC7, 0x80,
  0x63, 0x80, 0x31, 0xC0, 0x18, 0xC0, 0x0E, 0xE0, 0x06, 0x70, 0x07, 0x38,
  0x03, 0x9C, 0x01, 0xCC, 0x00, 0xC6, 0x00, 0xE7, 0x80, 0xE3, 0xE0, 0xF1,
  0xDF, 0xF0, 0xE7, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x70, 0x71, 0xC0,
  0x77, 0x00, 0x8C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0xDC, 0x03, 0xB8, 0x0E, 0x38, 0x38, 0x3F,
  0xE0, 0x3F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x1F, 0x8E, 0x0F, 0xF3, 0x07,
  0x86, 0xC3, 0x80, 0x71, 0xC0, 0x1C, 0x70, 0x07, 0x18, 0x01, 0xCE, 0x00,
  0x63, 0x80, 0x18, 0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x78,
  0xE0, 0x1C, 0x38, 0x0B, 0x07, 0x0F, 0xC1, 0xFF, 0x70, 0x1F, 0x1C, 0x00,
  0x01, 0xF8, 0x07, 0xFE, 0x0E, 0x0F, 0x1C, 0x07, 0x38, 0x07, 0x30, 0x07,
  0x70, 0x0F, 0x70, 0x7E, 0x7F, 0xF8, 0x7F, 0x80, 0xE0, 0x00, 0xE0, 0x00,
  0x60, 0x06, 0x70, 0x0E, 0x70, 0x1C, 0x38, 0x3C, 0x1F, 0xF0, 0x0F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x40, 0x70, 0x01,
  0xC0, 0xC0, 0x01, 0xC1, 0x80, 0x01, 0xC7, 0x00, 0x01, 0xCE, 0x00, 0x01,
  0xDC, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xF1, 0xC1, 0xFE,
  0x60, 0xF0, 0xD8, 0x70, 0x1E, 0x38, 0x03, 0x8E, 0x00, 0xE3, 0x00, 0x39,
  0xC0, 0x0C, 0x70, 0x03, 0x1C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0x70,
  0x0F, 0x1C, 0x03, 0x87, 0x01, 0x60, 0xE0, 0xD8, 0x1F, 0xEE, 0x03, 0xE3,
  0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x10, 0x06, 0x0F, 0x07, 0x81,
  0xFF, 0x80, 0x1F, 0x80, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x78, 0x19, 0xFE, 0x1B,
  0x0E, 0x3A, 0x06, 0x3C, 0x07, 0x38, 0x07, 0x38, 0x07, 0x30, 0x06, 0x30,
  0x06, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x60, 0x0C, 0x60,
  0x0C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x06, 0x00, 0x1C, 0x08, 0x38, 0x38, 0x70, 0xE0, 0xE3, 0x81, 0x8E,
  0x03, 0x38, 0x07, 0xE0, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x0F, 0xFC,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x40, 0x60, 0xE0, 0xE0, 0x70, 0xE0,
  0x38, 0xE0, 0x1C, 0xE0, 0x0E, 0xC0, 0x07, 0xC0, 0x03, 0x80, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0xF0, 0x19, 0xFE, 0x0D, 0x87, 0x0F, 0x81, 0xC7, 0x80, 0xE3,
  0x80, 0x61, 0xC0, 0x70, 0xC0, 0x30, 0x60, 0x70, 0x70, 0xE0, 0x39, 0xC0,
  0x1C, 0xE0, 0x0E, 0x30, 0x36, 0x1C, 0x3B, 0x06, 0x3B, 0x83, 0xB9, 0xC0,
  0xF8, 0xE0, 0x78, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x30, 0x00, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x21,
  0x81, 0xCE, 0x0E, 0x38, 0xE0, 0xE7, 0x03, 0xB8, 0x0F, 0xC0, 0x1C, 0x00,
  0x1C, 0xE3, 0xC3, 0xBE, 0xFC, 0x79, 0xD3, 0x8E, 0x1C, 0x31, 0x83, 0x06,
  0x70, 0x60, 0xCE, 0x1C, 0x39, 0xC3, 0x87, 0x30, 0x70, 0xE6, 0x0C, 0x18,
  0xC1, 0x83, 0x38, 0x30, 0x67, 0x0E, 0x1C, 0xE1, 0xC3, 0x98, 0x38, 0x73,
  0x06, 0x0C, 0x60, 0xC1, 0x9C, 0x18, 0x30, 0x1C, 0x78, 0x19, 0xFE, 0x1B,
  0x0E, 0x3A, 0x06, 0x3C, 0x07, 0x38, 0x07, 0x38, 0x07, 0x30, 0x06, 0x30,
  0x06, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x60, 0x0C, 0x60,
  0x0C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0x03, 0xF0, 0x0F, 0xFC, 0x1E,
  0x0E, 0x38, 0x06, 0x38, 0x07, 0x70, 0x07, 0x70, 0x03, 0x60, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0E, 0x60, 0x0E, 0x70,
  0x1C, 0x78, 0x38, 0x3F, 0xF0, 0x0F, 0xC0, 0x0C, 0x7E, 0x07, 0x3F, 0xC1,
  0xD8, 0x78, 0x78, 0x0E, 0x1E, 0x01, 0x87, 0x00, 0x61, 0xC0, 0x18, 0xE0,
  0x07, 0x38, 0x01, 0x8E, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x30, 0x03,
  0x1C, 0x01, 0xC7, 0x80, 0xE1, 0xF0, 0x78, 0x77, 0xFC, 0x1C, 0xFC, 0x06,
  0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x00, 0x07, 0xE3, 0x87, 0xF9, 0x87, 0x86, 0xC7, 0x00,
  0xE7, 0x00, 0x73, 0x80, 0x39, 0x80, 0x1D, 0xC0, 0x0C, 0xE0, 0x06, 0x70,
  0x07, 0x38, 0x03, 0x9C, 0x01, 0xCE, 0x01, 0xE7, 0x00, 0xE3, 0x80, 0xB0,
  0xE1, 0xB8, 0x7F, 0xDC, 0x0F, 0x8E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0xFF, 0x1F,
  0xFE, 0x7F, 0x06, 0xC0, 0x0E, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x03, 0xF8,
  0x0F, 0xFE, 0x1C, 0x0F, 0x38, 0x02, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E,
  0x40, 0x0E, 0xE0, 0x0C, 0xF0, 0x3C, 0x7F, 0xF8, 0x1F, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x08, 0x70, 0x78, 0xE1, 0xC1,
  0x8F, 0x03, 0x38, 0x07, 0xE0, 0x0F, 0x00, 0x30, 0x06, 0x60, 0x0D, 0xC0,
  0x3B, 0x80, 0x77, 0x00, 0xEE, 0x01, 0xD8, 0x03, 0x30, 0x06, 0xE0, 0x1D,
  0xC0, 0x3B, 0x80, 0x77, 0x00, 0xEE, 0x03, 0x9C, 0x07, 0x38, 0x1E, 0x78,
  0xDC, 0x7F, 0x38, 0x7C, 0x70, 0x7E, 0x03, 0xFE, 0x07, 0x0E, 0x07, 0x0C,
  0x03, 0x0C, 0x03, 0x1C, 0x03, 0x1C, 0x03, 0x1C, 0x07, 0x1C, 0x07, 0x1C,
  0x07, 0x18, 0x0E, 0x18, 0x0E, 0x38, 0x1C, 0x38, 0x38, 0x38, 0x78, 0x39,
  0xE0, 0x3F, 0xC0, 0x1F, 0x00, 0x18, 0x30, 0xCE, 0x1C, 0x73, 0x87, 0x0C,
  0xE1, 0x83, 0x30, 0x60, 0xCC, 0x18, 0x33, 0x06, 0x0D, 0xC3, 0x83, 0x70,
  0xE0, 0xDC, 0x38, 0x76, 0x0C, 0x1D, 0x83, 0x06, 0x61, 0xC1, 0xB8, 0x70,
  0xEE, 0x1C, 0x31, 0x8B, 0x1C, 0x7C, 0xFE, 0x0E, 0x1E, 0x00, 0x03, 0xC1,
  0xE0, 0xFE, 0x7F, 0x1E, 0xE6, 0x73, 0x86, 0xC3, 0x70, 0x68, 0x30, 0x07,
  0x83, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0xE0, 0xE0, 0x4E, 0x1F, 0x0C, 0xE1, 0x71, 0xEE,
  0x33, 0x78, 0x7E, 0x3F, 0x03, 0xC1, 0xC0, 0x0C, 0x01, 0x86, 0x00, 0xC7,
  0x00, 0xE3, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x1C, 0x60, 0x0C, 0x30, 0x06,
  0x38, 0x07, 0x1C, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0xE1, 0xC0,
  0xB0, 0xE0, 0x78, 0x78, 0x5C, 0x1F, 0xCE, 0x07, 0xC7, 0x00, 0x03, 0x00,
  0x03, 0x80, 0x01, 0xC2, 0x01, 0xC3, 0x81, 0xE0, 0xFF, 0xC0, 0x3F, 0x80,
  0x00, 0x0F, 0xC3, 0x8F, 0xF9, 0xCE, 0x1F, 0xE6, 0x03, 0xE3, 0x00, 0xE3,
  0x80, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC1,
  0x01, 0xC1, 0xC1, 0xC0, 0x61, 0xC0, 0x39, 0xF8, 0x1D, 0xFF, 0xCE, 0xE3,
  0xFE, 0x70, 0x3E, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0x80, 0xFF, 0x00, 0xFE, 0x00,
  0x03, 0x80, 0x03, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x06, 0x0C, 0x38, 0x70, 0xC1, 0x83,
  0x06, 0x1C, 0x38, 0x70, 0xC1, 0x83, 0x0E, 0x1C, 0x38, 0x60, 0xC1, 0x83,
  0x0E, 0x1C, 0x30, 0x60, 0xC1, 0x87, 0x0E, 0x18, 0x30, 0x00, 0x07, 0xF8,
  0x07, 0xFC, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0xC0,
  0x01, 0xC0, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x7F, 0x80, 0xFF, 0x00,
  0x1E, 0x01, 0x9F, 0x80, 0xDC, 0xE0, 0xEC, 0x38, 0x6E, 0x0E, 0x66, 0x03,
  0xF3, 0x00, 0xE0,
};

const GFXglyph IBMPlexMono_Italic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 7, 24, 20, 7, -24 },
  { 22, 10, 9, 20, 7, -25 },
  { 34, 21, 24, 20, 0, -24 },
  { 97, 19, 30, 20, 1, -27 },
  { 169, 23, 24, 20, -1, -24 },
  { 238, 20, 24, 20, 0, -24 },
  { 298, 4, 9, 20, 10, -25 },
  { 303, 13, 31, 20, 7, -26 },
  { 354, 13, 31, 20, 1, -26 },
  { 405, 17, 17, 20, 2, -19 },
  { 442, 17, 16, 20, 2, -18 },
  { 476, 7, 10, 20, 5, -5 },
  { 485, 11, 2, 20, 5, -11 },
  { 488, 5, 5, 20, 7, -5 },
  { 492, 19, 31, 20, 1, -26 },
  { 566, 17, 24, 20, 2, -24 },
  { 617, 17, 24, 20, 1, -24 },
  { 668, 18, 24, 20, 1, -24 },
  { 722, 18, 24, 20, 1, -24 },
  { 776, 18, 24, 20, 1, -24 },
  { 830, 17, 24, 20, 2, -24 },
  { 881, 16, 24, 20, 2, -24 },
  { 929, 16, 24, 20, 4, -24 },
  { 977, 18, 24, 20, 1, -24 },
  { 1031, 16, 24, 20, 3, -24 },
  { 1079, 7, 19, 20, 7, -19 },
  { 1096, 9, 24, 20, 5, -19 },
  { 1123, 16, 19, 20, 3, -20 },
  { 1161, 17, 9, 20, 2, -15 },
  { 1181, 16, 19, 20, 2, -20 },
  { 1219, 15, 24, 20, 4, -24 },
  { 1264, 17, 28, 20, 2, -24 },
  { 1324, 18, 24, 20, 0, -24 },
  { 1378, 17, 24, 20, 2, -24 },
  { 1429, 17, 24, 20, 3, -24 },
  { 1480, 17, 24, 20, 2, -24 },
  { 1531, 18, 24, 20, 2, -24 },
  { 1585, 18, 24, 20, 2, -24 },
  { 1639, 17, 24, 20, 2, -24 },
  { 1690, 19, 24, 20, 1, -24 },
  { 1747, 19, 24, 20, 1, -24 },
  { 1804, 17, 24, 20, 2, -24 },
  { 1855, 21, 24, 20, 1, -24 },
  { 1918, 14, 24, 20, 3, -24 },
  { 1960, 20, 24, 20, 1, -24 },
  { 2020, 19, 24, 20, 1, -24 },
  { 2077, 17, 24, 20, 2, -24 },
  { 2128, 18, 24, 20, 2, -24 },
  { 2182, 17, 30, 20, 2, -24 },
  { 2246, 18, 24, 20, 2, -24 },
  { 2300, 19, 24, 20, 1, -24 },
  { 2357, 19, 24, 20, 3, -24 },
  { 2414, 18, 24, 20, 2, -24 },
  { 2468, 18, 24, 20, 4, -24 },
  { 2522, 20, 24, 20, 2, -24 },
  { 2582, 23, 24, 20, -1, -24 },
  { 2651, 19, 24, 20, 3, -24 },
  { 2708, 21, 24, 20, 0, -24 },
  { 2771, 15, 31, 20, 5, -26 },
  { 2830, 9, 31, 20, 6, -26 },
  { 2865, 15, 31, 20, 0, -26 },
  { 2924, 17, 14, 20, 2, -24 },
  { 2954, 17, 2, 20, 0, 3 },
  { 2959, 4, 7, 20, 8, -27 },
  { 2963, 16, 18, 20, 2, -18 },
  { 2999, 17, 25, 20, 2, -25 },
  { 3053, 15, 18, 20, 3, -18 },
  { 3087, 18, 25, 20, 2, -25 },
  { 3144, 16, 18, 20, 2, -18 },
  { 3180, 23, 32, 20, -1, -25 },
  { 3272, 18, 25, 20, 1, -18 },
  { 3329, 16, 25, 20, 2, -25 },
  { 3379, 15, 25, 20, 3, -25 },
  { 3426, 16, 32, 20, 2, -25 },
  { 3490, 17, 25, 20, 2, -25 },
  { 3544, 14, 25, 20, 4, -25 },
  { 3588, 19, 18, 20, 0, -18 },
  { 3631, 16, 18, 20, 2, -18 },
  { 3667, 16, 18, 20, 2, -18 },
  { 3703, 18, 25, 20, 1, -18 },
  { 3760, 17, 25, 20, 2, -18 },
  { 3814, 16, 18, 20, 4, -18 },
  { 3850, 16, 18, 20, 2, -18 },
  { 3886, 15, 24, 20, 3, -24 },
  { 3931, 15, 18, 20, 3, -18 },
  { 3965, 16, 18, 20, 2, -18 },
  { 4001, 18, 18, 20, 1, -18 },
  { 4042, 20, 18, 20, 0, -18 },
  { 4087, 17, 25, 20, 1, -18 },
  { 4141, 17, 18, 20, 2, -18 },
  { 4180, 16, 31, 20, 4, -26 },
  { 4242, 7, 31, 20, 7, -26 },
  { 4270, 16, 31, 20, 1, -26 },
  { 4332, 17, 7, 20, 2, -14 },
};

const GFXfont IBMPlexMono_Italic34pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic34pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic34pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _IBMPLEXMONO_ITALIC34PT7B_H_
