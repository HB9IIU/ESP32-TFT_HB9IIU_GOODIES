#ifndef _IBMPLEXMONO_ITALIC39PT7B_H_
#define _IBMPLEXMONO_ITALIC39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x81, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x0E, 0x0F, 0x07,
  0x03, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0xF8, 0x7C, 0x7E, 0x1E, 0x00, 0x38, 0x73, 0x86, 0x38,
  0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0x70, 0xE7, 0x0C, 0x71, 0xCE, 0x1C, 0xE1,
  0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x18, 0x00, 0x1C, 0x38, 0x00, 0x1C,
  0x38, 0x00, 0x38, 0x30, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x70,
  0x60, 0x0F, 0xF0, 0xFF, 0x1F, 0xF0, 0xFF, 0x1F, 0xE1, 0xFF, 0x00, 0xE1,
  0xC0, 0x00, 0xC1, 0xC0, 0x01, 0xC3, 0x80, 0x01, 0xC3, 0x80, 0x01, 0x83,
  0x80, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x07, 0xF8, 0x87, 0x0E,
  0x00, 0x07, 0x0E, 0x00, 0x06, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C,
  0x00, 0x0C, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x7F, 0x00,
  0x07, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xE3, 0x3E, 0x0F, 0x0C, 0x3C, 0x78,
  0x70, 0x61, 0xC1, 0xC0, 0x07, 0x06, 0x00, 0x1C, 0x18, 0x00, 0x78, 0x60,
  0x01, 0xF1, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x0C, 0xF8, 0x00, 0x70, 0xF0, 0x01, 0xC3, 0xC0, 0x06,
  0x07, 0x00, 0x18, 0x3C, 0x20, 0x60, 0xF3, 0x81, 0x83, 0x8F, 0x8E, 0x1E,
  0x1F, 0x39, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x3F, 0x80, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xF8, 0x01, 0xE0, 0x7F, 0x80, 0x38, 0x1F, 0xF8, 0x0E, 0x07, 0x87, 0x03,
  0x80, 0xE0, 0x60, 0x60, 0x1C, 0x0C, 0x1C, 0x03, 0x03, 0x87, 0x00, 0xE0,
  0x70, 0xC0, 0x1C, 0x0E, 0x38, 0x01, 0xC3, 0x8E, 0x00, 0x3F, 0xF3, 0x80,
  0x03, 0xFC, 0x70, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x07, 0x1F, 0xE0, 0x01, 0xC7, 0xFE, 0x00, 0x31, 0xE1, 0xC0,
  0x0E, 0x38, 0x18, 0x03, 0x86, 0x03, 0x00, 0x61, 0xC0, 0xE0, 0x1C, 0x38,
  0x1C, 0x07, 0x07, 0x03, 0x81, 0xC0, 0xF0, 0xE0, 0x38, 0x0F, 0xFC, 0x0E,
  0x01, 0xFF, 0x03, 0x80, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x1E, 0x0F, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x1C,
  0x00, 0xE0, 0x38, 0x01, 0xC0, 0x70, 0x03, 0x80, 0xE0, 0x07, 0x01, 0xC0,
  0x07, 0x07, 0x80, 0x0E, 0x1E, 0x00, 0xFE, 0xF8, 0x03, 0xFF, 0xC0, 0x0F,
  0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0x38, 0x01, 0xE0, 0x70, 0x03, 0x80,
  0x70, 0x07, 0x00, 0xF0, 0x4E, 0x00, 0xE0, 0xFC, 0x02, 0xE3, 0xBC, 0x0D,
  0xC7, 0x3C, 0x3B, 0xDC, 0x7F, 0xE3, 0xF8, 0x7F, 0x87, 0xE0, 0x3E, 0x07,
  0x80, 0x77, 0x77, 0x7E, 0xEE, 0xEE, 0xE0, 0x00, 0x1E, 0x00, 0xF0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0,
  0x03, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x60, 0x70, 0x37, 0xC7, 0x1F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xF8, 0x00,
  0x7B, 0x80, 0x0F, 0x1C, 0x01, 0xE1, 0xC0, 0x3C, 0x0E, 0x03, 0x80, 0xE0,
  0x10, 0x05, 0x00, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x87,
  0x87, 0xC3, 0xC1, 0xE1, 0xE0, 0xF0, 0x70, 0x70, 0x38, 0x38, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3D, 0xF7, 0xFF, 0x78, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7C, 0x1E, 0x0F, 0x00, 0xF1, 0xE0, 0x07,
  0x1C, 0x00, 0x73, 0xC0, 0x07, 0x38, 0x00, 0x73, 0x80, 0x07, 0x78, 0x00,
  0x77, 0x87, 0x07, 0x70, 0xF8, 0x77, 0x0F, 0x8F, 0x70, 0xF8, 0xF7, 0x0F,
  0x0E, 0xF0, 0x00, 0xEF, 0x00, 0x0E, 0xF0, 0x01, 0xEF, 0x00, 0x1C, 0x70,
  0x03, 0xC7, 0x00, 0x38, 0x78, 0x07, 0x87, 0xC1, 0xF0, 0x3F, 0xFE, 0x01,
  0xFF, 0x80, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0x80, 0x1F, 0xE0,
  0x0F, 0xB8, 0x07, 0xDC, 0x03, 0xE7, 0x01, 0xE1, 0xC0, 0xF0, 0x70, 0x38,
  0x1C, 0x04, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x03,
  0xFF, 0xE0, 0x7C, 0x1F, 0x0F, 0x00, 0xF0, 0xE0, 0x07, 0x1E, 0x00, 0x70,
  0x40, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xE0, 0x7C, 0x1F,
  0x0F, 0x00, 0x70, 0x60, 0x07, 0x04, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x1F, 0xF8, 0x01, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x20, 0x01, 0xC6, 0x00, 0x3C, 0xF0, 0x03, 0xC7,
  0xC0, 0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xEE, 0x00,
  0x0E, 0x70, 0x00, 0xE3, 0x80, 0x0F, 0x38, 0x00, 0x71, 0xC0, 0x07, 0x0E,
  0x00, 0x70, 0x70, 0x07, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x81, 0xC0, 0x38,
  0x0E, 0x03, 0x80, 0x70, 0x38, 0x03, 0x83, 0x80, 0x1C, 0x38, 0x00, 0xE1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x7C,
  0x01, 0xDF, 0xF0, 0x1B, 0xFF, 0x83, 0xE0, 0x7C, 0x3C, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x20,
  0x01, 0xC6, 0x00, 0x3C, 0xF0, 0x07, 0x87, 0xC1, 0xF0, 0x3F, 0xFE, 0x01,
  0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0x71, 0xF8, 0x1E, 0xFF, 0xC3, 0xBF, 0xFC,
  0xFE, 0x0F, 0x9F, 0x00, 0x7B, 0xC0, 0x0F, 0x70, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1C, 0xE0, 0x07, 0x9C, 0x01, 0xE3,
  0xE0, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xB8, 0x00, 0xF7, 0x00, 0x1D, 0xC0, 0x07,
  0x38, 0x01, 0xE7, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0xF8,
  0x1F, 0x1E, 0x00, 0xF1, 0xC0, 0x07, 0x1C, 0x00, 0x71, 0xC0, 0x07, 0x1C,
  0x00, 0xE1, 0xC0, 0x0E, 0x0F, 0x03, 0xC0, 0x7F, 0xF8, 0x03, 0xFC, 0x00,
  0xFF, 0xF0, 0x3E, 0x07, 0xC7, 0x80, 0x1C, 0x70, 0x01, 0xEE, 0x00, 0x0E,
  0xE0, 0x00, 0xEE, 0x00, 0x1E, 0xE0, 0x01, 0xEE, 0x00, 0x3C, 0xF0, 0x03,
  0xCF, 0x80, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0x83, 0xE3, 0xC0, 0x1C, 0xF0,
  0x03, 0xDC, 0x00, 0x3B, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x01, 0xE7, 0x80, 0x7C, 0xF8, 0x1B, 0x8F, 0xFE, 0xE0, 0xFF,
  0x9C, 0x0F, 0xC7, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x0F, 0xC7, 0xE3, 0xF0, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x3E,
  0x1F, 0x1F, 0x87, 0x80, 0x03, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x01,
  0xC0, 0x70, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x70, 0x00, 0x02, 0x00, 0x3F,
  0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC,
  0x10, 0x00, 0x03, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x0E,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x07, 0xFE, 0x07, 0xFF, 0x87,
  0x83, 0xE7, 0x80, 0x77, 0x80, 0x3F, 0x80, 0x1E, 0x40, 0x0F, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0xC0, 0x3F, 0xC0, 0x1F,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0x78,
  0x1E, 0x0E, 0x00, 0xE1, 0xE0, 0x07, 0x1C, 0x00, 0x71, 0x80, 0x07, 0x38,
  0x1E, 0x73, 0x87, 0xF7, 0x38, 0x7F, 0x77, 0x0F, 0x0E, 0x71, 0xE0, 0xE7,
  0x1C, 0x0E, 0x71, 0xC0, 0xE7, 0x1C, 0x0E, 0x63, 0xC0, 0xEE, 0x38, 0x0C,
  0xE3, 0x81, 0xCE, 0x38, 0x1C, 0xE1, 0xC3, 0xCE, 0x1F, 0xDC, 0xE1, 0xFD,
  0xCE, 0x0F, 0x98, 0x60, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xB8, 0x00, 0x1C,
  0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00,
  0x78, 0x70, 0x03, 0x83, 0x80, 0x1C, 0x1E, 0x01, 0xC0, 0x70, 0x0E, 0x03,
  0x80, 0xE0, 0x1C, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x38,
  0x01, 0xE1, 0xC0, 0x0F, 0x1E, 0x00, 0x38, 0xE0, 0x01, 0xCF, 0x00, 0x0E,
  0x70, 0x00, 0x77, 0x80, 0x03, 0xB8, 0x00, 0x1E, 0x0F, 0xFF, 0x00, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0xE0, 0x1E, 0x0E, 0x00, 0xE1, 0xE0, 0x0F, 0x1C,
  0x00, 0xF1, 0xC0, 0x0F, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x01, 0xE3,
  0xC0, 0x3C, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0x80, 0x3C,
  0x38, 0x01, 0xC7, 0x80, 0x1E, 0x70, 0x01, 0xE7, 0x00, 0x1E, 0x70, 0x01,
  0xE7, 0x00, 0x1C, 0x70, 0x03, 0xCF, 0x00, 0x78, 0xFF, 0xFF, 0x0F, 0xFF,
  0xE0, 0xFF, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0,
  0xF8, 0x3E, 0x0F, 0x00, 0xE1, 0xE0, 0x0E, 0x3C, 0x00, 0x73, 0x80, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x18, 0xF0, 0x03, 0xCF, 0x00, 0x78, 0x78,
  0x0F, 0x07, 0xC1, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xE0, 0x3E, 0x0E, 0x01,
  0xE0, 0xE0, 0x0F, 0x0E, 0x00, 0x71, 0xE0, 0x07, 0x1C, 0x00, 0x71, 0xC0,
  0x07, 0x1C, 0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00, 0xF3, 0xC0, 0x0F, 0x38,
  0x00, 0xF3, 0x80, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x01, 0xE7,
  0x80, 0x1C, 0x70, 0x03, 0xC7, 0x00, 0x38, 0x70, 0x07, 0x87, 0x01, 0xF0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFE, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFF,
  0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xC3, 0xFF, 0xFE, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1F,
  0xFF, 0x07, 0xC1, 0xE1, 0xE0, 0x1E, 0x38, 0x01, 0xCE, 0x00, 0x39, 0xC0,
  0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0xFF, 0xB8, 0x1F, 0xF7, 0x03, 0xFE, 0xE0, 0x03, 0x9C, 0x00,
  0x73, 0x80, 0x0E, 0x70, 0x01, 0xCE, 0x00, 0x79, 0xC0, 0x0F, 0x3C, 0x03,
  0xC3, 0xC1, 0xF8, 0x7F, 0xF7, 0x07, 0xFC, 0xE0, 0x3E, 0x1C, 0x00, 0x0E,
  0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07,
  0x0E, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0xF1, 0xE0,
  0x07, 0x8F, 0x00, 0x38, 0x70, 0x01, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x8F, 0x00, 0x38, 0x78, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00,
  0x70, 0xE0, 0x03, 0x87, 0x00, 0x3C, 0x78, 0x01, 0xC3, 0x80, 0x0E, 0x1C,
  0x00, 0x70, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x01, 0xE0, 0x0F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0xE0,
  0x07, 0x0F, 0x00, 0xF0, 0x70, 0x0E, 0x07, 0x83, 0xE0, 0x3F, 0xFC, 0x01,
  0xFF, 0x80, 0x07, 0xE0, 0x00, 0x0E, 0x00, 0x1E, 0x1C, 0x00, 0x78, 0x38,
  0x01, 0xE0, 0x70, 0x07, 0x81, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x07, 0x03,
  0xE0, 0x0E, 0x0F, 0x80, 0x1C, 0x3E, 0x00, 0x38, 0x78, 0x00, 0xF1, 0xE0,
  0x01, 0xE7, 0x80, 0x03, 0x9F, 0x00, 0x07, 0x7E, 0x00, 0x0F, 0xCE, 0x00,
  0x1F, 0x1C, 0x00, 0x7C, 0x3C, 0x00, 0xF0, 0x38, 0x01, 0xC0, 0x78, 0x03,
  0x80, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x3C, 0x01, 0xE0, 0x70,
  0x01, 0xC0, 0xE0, 0x03, 0xC1, 0xC0, 0x07, 0x83, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xC0, 0x0F, 0x80, 0x3E,
  0x1F, 0x00, 0x78, 0x3E, 0x01, 0xF0, 0x7C, 0x07, 0xE0, 0xFC, 0x0F, 0xC1,
  0xF8, 0x3B, 0x87, 0x70, 0x77, 0x0E, 0x61, 0xDC, 0x1C, 0xC3, 0xB8, 0x39,
  0xCE, 0x70, 0x73, 0x98, 0xE0, 0xE3, 0x71, 0xC3, 0x87, 0xC3, 0x87, 0x0F,
  0x8E, 0x0E, 0x1E, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x30, 0x70, 0x70, 0x40,
  0xE1, 0xC0, 0x81, 0x83, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1C,
  0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0xE0, 0x00, 0xC1, 0xC0, 0x03, 0x83,
  0x80, 0x07, 0x00, 0x0F, 0x80, 0x38, 0x7C, 0x01, 0xC3, 0xE0, 0x0E, 0x3F,
  0x80, 0x71, 0xDC, 0x07, 0x0E, 0xE0, 0x38, 0x77, 0x01, 0xC3, 0x98, 0x0E,
  0x1C, 0xE0, 0x71, 0xC7, 0x07, 0x8E, 0x38, 0x38, 0x71, 0xC1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x8E, 0x0E, 0x38, 0x70, 0x31, 0xC3,
  0x81, 0xCE, 0x1C, 0x0E, 0x70, 0xE0, 0x73, 0x87, 0x03, 0x9C, 0x70, 0x0F,
  0xC3, 0x80, 0x7E, 0x1C, 0x03, 0xF0, 0xE0, 0x1F, 0x87, 0x00, 0x7C, 0x38,
  0x03, 0xE0, 0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7C, 0x1E,
  0x0F, 0x00, 0xF1, 0xE0, 0x07, 0x1C, 0x00, 0x73, 0xC0, 0x07, 0x38, 0x00,
  0x73, 0x80, 0x07, 0x78, 0x00, 0x77, 0x80, 0x07, 0x70, 0x00, 0x77, 0x00,
  0x0F, 0x70, 0x00, 0xF7, 0x00, 0x0F, 0xF0, 0x00, 0xEF, 0x00, 0x0E, 0xF0,
  0x01, 0xEF, 0x00, 0x1C, 0x70, 0x03, 0xC7, 0x00, 0x38, 0x78, 0x07, 0x87,
  0xC1, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x0F, 0xFF,
  0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x1C, 0x01, 0xE0, 0xE0, 0x07, 0x8F,
  0x00, 0x3C, 0x78, 0x01, 0xE3, 0x80, 0x0F, 0x1C, 0x00, 0x78, 0xE0, 0x03,
  0x87, 0x00, 0x1C, 0x78, 0x01, 0xE3, 0xC0, 0x1E, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFE, 0x07, 0xFF, 0xC0, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7C, 0x1E, 0x0F, 0x00, 0xF1, 0xE0, 0x07,
  0x1C, 0x00, 0x73, 0xC0, 0x07, 0x38, 0x00, 0x73, 0x80, 0x07, 0x78, 0x00,
  0x77, 0x80, 0x07, 0x70, 0x00, 0x77, 0x00, 0x0F, 0x70, 0x00, 0xF7, 0x00,
  0x0E, 0xF0, 0x00, 0xEF, 0x00, 0x0E, 0xF0, 0x01, 0xEF, 0x00, 0x1C, 0x70,
  0x03, 0xC7, 0x00, 0x38, 0x78, 0x07, 0x87, 0xC1, 0xF0, 0x3F, 0xFE, 0x01,
  0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x40, 0x07, 0x1E,
  0x00, 0x7B, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x0F, 0xFF,
  0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x1C, 0x01, 0xE0, 0xE0, 0x07, 0x8F,
  0x00, 0x3C, 0x78, 0x01, 0xE3, 0x80, 0x0F, 0x1C, 0x00, 0x78, 0xE0, 0x03,
  0x87, 0x00, 0x1C, 0x78, 0x01, 0xE3, 0xC0, 0x1E, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFE, 0x07, 0xFF, 0xC0, 0x38, 0x38, 0x03, 0xC1, 0xC0, 0x1E, 0x0F, 0x00,
  0xE0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x3C, 0x1E, 0x00,
  0xE0, 0xE0, 0x07, 0x07, 0x00, 0x3C, 0x38, 0x00, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xF0, 0x3E, 0x0F, 0x00, 0x3C, 0x78,
  0x00, 0x61, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x20, 0x00, 0xF1, 0x80, 0x03, 0x8F, 0x80, 0x1E,
  0x1F, 0x01, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1C, 0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00, 0xF3, 0xC0,
  0x0F, 0x38, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x0E, 0x38,
  0x01, 0xE7, 0x80, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x01, 0xC7,
  0x00, 0x1C, 0xF0, 0x03, 0xCF, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x38,
  0xE0, 0x03, 0x8E, 0x00, 0x78, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xF0, 0x0F,
  0x0F, 0x83, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0x9C, 0x00, 0x3C, 0xE0, 0x01, 0xC7, 0x00, 0x1E,
  0x38, 0x00, 0xE1, 0xC0, 0x0F, 0x0E, 0x00, 0x70, 0x70, 0x03, 0x81, 0xC0,
  0x38, 0x0E, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x0E, 0x00,
  0xE0, 0x70, 0x07, 0x07, 0x80, 0x38, 0x38, 0x00, 0xE3, 0xC0, 0x07, 0x1C,
  0x00, 0x38, 0xE0, 0x01, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0x77, 0x00, 0x03,
  0xB8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00,
  0x0E, 0x70, 0x00, 0x18, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0xE3, 0x80, 0x01,
  0xC7, 0x00, 0x03, 0x0C, 0x00, 0x0E, 0x38, 0x3C, 0x1C, 0x70, 0x78, 0x38,
  0xE1, 0xF0, 0x71, 0xC3, 0xE1, 0xC3, 0x86, 0xC3, 0x87, 0x1D, 0x87, 0x0E,
  0x3B, 0x0E, 0x1C, 0x66, 0x38, 0x39, 0xCE, 0x70, 0x63, 0x1C, 0xE0, 0xCE,
  0x39, 0xC1, 0x9C, 0x77, 0x07, 0x30, 0xEE, 0x0E, 0xE1, 0xDC, 0x1D, 0xC3,
  0xB8, 0x3B, 0x07, 0x60, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x3F,
  0x03, 0xE0, 0x7C, 0x00, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x1C,
  0x00, 0xF0, 0x07, 0x80, 0x38, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x0F, 0x00,
  0x07, 0x07, 0x80, 0x01, 0xC3, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x70,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x3C, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x07, 0x00, 0x03, 0x81, 0xE0,
  0x01, 0xE0, 0x38, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x3C, 0x00,
  0x78, 0x0E, 0x00, 0x0E, 0x0F, 0x80, 0x03, 0xC0, 0xE0, 0x00, 0x7F, 0xC0,
  0x01, 0xC7, 0x00, 0x0F, 0x1C, 0x00, 0x78, 0x78, 0x03, 0xC0, 0xE0, 0x0E,
  0x03, 0xC0, 0x78, 0x07, 0x03, 0xC0, 0x1C, 0x1E, 0x00, 0x78, 0x70, 0x00,
  0xE3, 0xC0, 0x03, 0x9E, 0x00, 0x07, 0x70, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0xFF, 0xE0, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0xE0,
  0x38, 0x06, 0x01, 0x80, 0x70, 0x1C, 0x03, 0x00, 0xC0, 0x30, 0x0E, 0x03,
  0x80, 0x60, 0x18, 0x07, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xE0, 0x38,
  0x06, 0x01, 0x80, 0x70, 0x1C, 0x07, 0x00, 0xC0, 0x30, 0x0E, 0x03, 0x80,
  0x60, 0x18, 0x07, 0x01, 0xC0, 0x70, 0x0C, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF8, 0x00, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xF7, 0x00, 0x1C, 0xE0, 0x07, 0x0E,
  0x01, 0xE1, 0xC0, 0x38, 0x38, 0x0E, 0x03, 0x83, 0x80, 0x70, 0xF0, 0x07,
  0x1C, 0x00, 0xE7, 0x00, 0x1D, 0xC0, 0x01, 0xF8, 0x00, 0x3A, 0x00, 0x04,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x27, 0x38, 0xE7, 0x18,
  0xE2, 0x01, 0xF0, 0xE0, 0xFF, 0x9C, 0x3F, 0xFB, 0x8F, 0x83, 0xE3, 0xC0,
  0x3C, 0x70, 0x03, 0x9E, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x01, 0xDE, 0x00,
  0x73, 0xC0, 0x0E, 0x70, 0x01, 0xCE, 0x00, 0x39, 0xC0, 0x0F, 0x3C, 0x03,
  0xE7, 0x80, 0xF8, 0x78, 0x37, 0x0F, 0xFE, 0xFC, 0xFF, 0x9F, 0x87, 0xC1,
  0xF0, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x87,
  0xE0, 0x71, 0xFE, 0x0E, 0x7F, 0xE1, 0xD8, 0x3E, 0x3E, 0x03, 0xCF, 0x80,
  0x39, 0xE0, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x1C, 0xE0, 0x03, 0x9C, 0x00,
  0x77, 0x80, 0x1E, 0xE0, 0x03, 0x9C, 0x00, 0x73, 0x80, 0x1E, 0x78, 0x07,
  0x8F, 0x81, 0xF3, 0x9F, 0xFC, 0x73, 0xFF, 0x0E, 0x1F, 0x80, 0x01, 0xF8,
  0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xC0, 0xF3, 0xC0, 0x3B, 0xC0, 0x1D, 0xC0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x27, 0x00, 0x1F, 0x80, 0x1C, 0xE0, 0x1C, 0x78, 0x3E, 0x1F, 0xFE,
  0x07, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x0F, 0x87, 0x01, 0xFF, 0x38, 0x1F, 0xFD,
  0xC1, 0xF0, 0x6E, 0x1E, 0x00, 0xF0, 0xE0, 0x07, 0x0F, 0x00, 0x38, 0x70,
  0x01, 0xC3, 0x80, 0x0E, 0x3C, 0x00, 0x71, 0xE0, 0x03, 0x8E, 0x00, 0x38,
  0x70, 0x01, 0xC3, 0x80, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x0B, 0x83, 0xC1,
  0xFC, 0x1F, 0xFD, 0xC0, 0x7F, 0xCE, 0x00, 0xF8, 0x70, 0x00, 0x01, 0xFC,
  0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x78, 0x1F, 0x38, 0x01, 0xDC, 0x00, 0x77,
  0x00, 0x3B, 0x80, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0x0F, 0xF8, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0xCE, 0x00, 0x7B, 0xC0, 0x3C, 0x78, 0x1E,
  0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x20, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x0F, 0x83, 0x80, 0x00,
  0xF0, 0xE0, 0x00, 0x1E, 0x70, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x70, 0x3F,
  0xE7, 0x07, 0xFF, 0x70, 0xF8, 0x37, 0x1E, 0x00, 0xF1, 0xC0, 0x0E, 0x3C,
  0x00, 0xE3, 0x80, 0x0E, 0x38, 0x00, 0xE7, 0x80, 0x0E, 0x78, 0x00, 0xE7,
  0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x3C, 0x78, 0x03, 0xC3, 0x80, 0x5C,
  0x3C, 0x1D, 0xC3, 0xFF, 0xB8, 0x1F, 0xF3, 0x80, 0x7C, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x02, 0x00, 0xF0, 0x78, 0x3E, 0x0F, 0xFF,
  0xC0, 0x3F, 0xF8, 0x00, 0xFE, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x8F, 0x81, 0xE7, 0xF8, 0x73, 0xFF, 0x1D, 0xC3, 0xC7,
  0x40, 0x71, 0xE0, 0x1C, 0x70, 0x07, 0x3C, 0x01, 0xCE, 0x00, 0x73, 0x80,
  0x1C, 0xE0, 0x07, 0x38, 0x03, 0x8E, 0x00, 0xE7, 0x80, 0x39, 0xC0, 0x0E,
  0x70, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0x71, 0xC0, 0x1C, 0xE0, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x60, 0x70, 0x3C, 0x1C, 0x1E, 0x07, 0x0F, 0x01, 0xCF, 0x80, 0x77,
  0xC0, 0x1F, 0xE0, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0xC0, 0x70, 0x1C, 0x0E, 0x07, 0xC1, 0xC0,
  0x3C, 0x38, 0x03, 0xCF, 0x00, 0x3D, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE3, 0xF0, 0x1E, 0x7F, 0x81, 0xCF, 0xFC, 0x1D, 0xC3, 0xC1,
  0xD0, 0x1C, 0x1E, 0x01, 0xC1, 0xC0, 0x1C, 0x3C, 0x03, 0xC3, 0x80, 0x78,
  0x38, 0x1F, 0x03, 0x8F, 0xC0, 0x39, 0xF0, 0x03, 0x9C, 0x00, 0x78, 0xE0,
  0x67, 0x0F, 0x0F, 0x70, 0x71, 0xE7, 0x07, 0xBC, 0x70, 0x3F, 0x87, 0x03,
  0xF0, 0xE0, 0x1E, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x40, 0xE0,
  0x70, 0x70, 0x7C, 0x70, 0x78, 0x38, 0x78, 0x1C, 0x78, 0x0E, 0xF8, 0x07,
  0xF8, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0x0E, 0x70, 0x78, 0x33, 0xE7, 0xF1,
  0xDF, 0xDF, 0xC7, 0xC7, 0xC7, 0x1E, 0x1E, 0x1C, 0x70, 0x70, 0x71, 0xC1,
  0xC1, 0xC7, 0x07, 0x07, 0x38, 0x18, 0x1C, 0xE0, 0xE0, 0x63, 0x83, 0x83,
  0x8E, 0x0E, 0x0E, 0x38, 0x38, 0x38, 0xC0, 0xE0, 0xE7, 0x03, 0x03, 0x1C,
  0x1C, 0x0C, 0x70, 0x70, 0x71, 0xC1, 0xC1, 0xC7, 0x07, 0x07, 0x38, 0x1C,
  0x1C, 0x0E, 0x3E, 0x07, 0x9F, 0xE1, 0xCF, 0xFC, 0x77, 0x0F, 0x1D, 0x01,
  0xC7, 0x80, 0x71, 0xC0, 0x1C, 0xF0, 0x07, 0x38, 0x01, 0xCE, 0x00, 0x73,
  0x80, 0x1C, 0xE0, 0x0E, 0x38, 0x03, 0x9E, 0x00, 0xE7, 0x00, 0x39, 0xC0,
  0x0E, 0x70, 0x03, 0x9C, 0x01, 0xC7, 0x00, 0x73, 0x80, 0x1C, 0x00, 0xFC,
  0x00, 0x7F, 0xE0, 0x3F, 0xFE, 0x0F, 0x81, 0xE1, 0xC0, 0x1C, 0x78, 0x01,
  0xDE, 0x00, 0x3B, 0xC0, 0x07, 0x70, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x07,
  0xF8, 0x00, 0xF7, 0x00, 0x1C, 0xE0, 0x07, 0x9C, 0x00, 0xE3, 0x80, 0x3C,
  0x3C, 0x1F, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xF8, 0x00, 0x0E, 0x1F,
  0x80, 0xE3, 0xFC, 0x0E, 0x7F, 0xE0, 0xEC, 0x1F, 0x0F, 0x80, 0xF1, 0xF0,
  0x07, 0x1E, 0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00, 0x71, 0xC0, 0x07, 0x1C,
  0x00, 0x73, 0xC0, 0x0F, 0x38, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x01, 0xE3,
  0xC0, 0x3C, 0x3E, 0x07, 0xC7, 0x3F, 0xF8, 0x73, 0xFF, 0x07, 0x0F, 0xC0,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xF0, 0xE0, 0xFF,
  0x9C, 0x3F, 0xFB, 0x8F, 0x83, 0x73, 0xC0, 0x1E, 0x70, 0x03, 0x9E, 0x00,
  0x73, 0x80, 0x0E, 0x70, 0x01, 0xDE, 0x00, 0x3B, 0xC0, 0x07, 0x70, 0x01,
  0xCE, 0x00, 0x39, 0xC0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x5C, 0x78, 0x3F,
  0x8F, 0xFE, 0xE0, 0xFF, 0x9C, 0x07, 0xC3, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x7F, 0x87, 0xFF, 0xF1, 0xFF, 0xFE, 0x7F, 0x81, 0xD8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0x81,
  0xF1, 0xC0, 0x08, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0xE0,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE3, 0x00, 0x1C, 0xF8, 0x0F, 0x8F, 0xFF, 0xE0, 0xFF, 0xF8,
  0x03, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xE0, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x10, 0x38, 0x0E,
  0x0E, 0x07, 0x83, 0x87, 0xF0, 0xE3, 0xE0, 0x73, 0xF0, 0x1F, 0xF0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x1C, 0xE0,
  0x07, 0x38, 0x03, 0x8E, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x0E, 0x70, 0x03,
  0x9C, 0x01, 0xE7, 0x00, 0x71, 0xC0, 0x1C, 0xE0, 0x07, 0x38, 0x03, 0xCE,
  0x01, 0xF3, 0xC0, 0xFC, 0xF8, 0x6E, 0x1F, 0xFB, 0x83, 0xFC, 0xE0, 0x7C,
  0x38, 0xFE, 0x01, 0xBF, 0x80, 0xEF, 0xE0, 0x1C, 0x38, 0x07, 0x0E, 0x01,
  0xC7, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0xF1,
  0xC0, 0x38, 0x60, 0x1E, 0x38, 0x07, 0x0E, 0x03, 0xC3, 0x81, 0xE0, 0xE0,
  0xF0, 0x39, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x7C, 0x00, 0x38, 0x38,
  0x63, 0x83, 0x8F, 0x38, 0x38, 0x73, 0x03, 0x07, 0x70, 0x70, 0x77, 0x07,
  0x07, 0x70, 0x70, 0x77, 0x07, 0x07, 0x60, 0x60, 0x76, 0x06, 0x07, 0xE0,
  0xE0, 0x7E, 0x0E, 0x06, 0xE0, 0xE0, 0xEE, 0x0E, 0x0E, 0xE1, 0xE1, 0xEE,
  0x1E, 0x1C, 0xE3, 0xE3, 0xCF, 0xEF, 0xF8, 0xFE, 0x7F, 0x07, 0x83, 0xC0,
  0x00, 0xE0, 0x78, 0x07, 0xE3, 0xF8, 0x1F, 0xC7, 0xF8, 0x79, 0xDC, 0x73,
  0xE3, 0xB0, 0xE7, 0x07, 0xC1, 0xC8, 0x0F, 0x03, 0x80, 0x1E, 0x07, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x0E, 0x07,
  0x80, 0x1C, 0x0B, 0x03, 0x38, 0x36, 0x0E, 0x70, 0x6C, 0x3C, 0xF1, 0x9D,
  0xE0, 0xFF, 0x3F, 0x81, 0xFC, 0x7E, 0x01, 0xF0, 0x78, 0x00, 0x0F, 0x00,
  0x70, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0xE0, 0xE0,
  0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x1C,
  0x01, 0xC1, 0xC0, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x3C, 0x3C, 0x05, 0xC3,
  0xC0, 0xFC, 0x1E, 0x1B, 0x81, 0xFF, 0xB8, 0x0F, 0xF3, 0x80, 0x7C, 0x38,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x02, 0x00, 0xF0, 0xF0, 0x3E,
  0x0F, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x70, 0xFF,
  0xCF, 0x1F, 0xFF, 0xF3, 0xC1, 0xFE, 0x38, 0x07, 0xE3, 0x80, 0x38, 0x30,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x08, 0x07, 0x81, 0x80, 0xE0, 0x1C, 0x3C, 0x01, 0xC7, 0xF0, 0x1C,
  0xFF, 0xF8, 0xCE, 0xFF, 0xFC, 0xE1, 0xFF, 0xCE, 0x03, 0xF8, 0x00, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x7F, 0xC0, 0x0F, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0x07,
  0x07, 0x07, 0x07, 0x06, 0x06, 0x0E, 0x0E, 0x0E, 0x0E, 0x0C, 0x0C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x18, 0x18, 0x38, 0x38, 0x38, 0x38, 0x30, 0x30, 0x70,
  0x70, 0x70, 0x70, 0x60, 0x60, 0xE0, 0xE0, 0xE0, 0xE0, 0x07, 0xFC, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xC0,
  0x07, 0xF0, 0x0F, 0xFC, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x0F, 0xF8, 0x00, 0x0F, 0x00, 0x21, 0xFC, 0x07, 0x3F, 0xC0, 0x73,
  0x8E, 0x0E, 0x70, 0xF0, 0xE7, 0x07, 0x1C, 0xE0, 0x3F, 0xCE, 0x03, 0xF8,
  0x40, 0x0F, 0x00,
};

const GFXglyph IBMPlexMono_Italic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 9, 27, 23, 7, -27 },
  { 32, 12, 11, 23, 8, -29 },
  { 49, 24, 27, 23, 0, -27 },
  { 130, 22, 35, 23, 1, -31 },
  { 227, 27, 27, 23, -1, -27 },
  { 319, 23, 27, 23, 0, -27 },
  { 397, 4, 11, 23, 12, -29 },
  { 403, 15, 35, 23, 8, -30 },
  { 469, 14, 35, 23, 2, -30 },
  { 531, 20, 19, 23, 2, -21 },
  { 579, 18, 19, 23, 3, -21 },
  { 622, 9, 11, 23, 5, -5 },
  { 635, 12, 3, 23, 6, -13 },
  { 640, 6, 5, 23, 7, -5 },
  { 644, 22, 35, 23, 1, -30 },
  { 741, 20, 27, 23, 2, -27 },
  { 809, 18, 27, 23, 2, -27 },
  { 870, 20, 27, 23, 1, -27 },
  { 938, 20, 27, 23, 1, -27 },
  { 1006, 21, 27, 23, 1, -27 },
  { 1077, 20, 27, 23, 2, -27 },
  { 1145, 19, 27, 23, 2, -27 },
  { 1210, 19, 27, 23, 4, -27 },
  { 1275, 20, 27, 23, 2, -27 },
  { 1343, 19, 27, 23, 3, -27 },
  { 1408, 9, 21, 23, 7, -21 },
  { 1432, 11, 27, 23, 5, -21 },
  { 1470, 19, 22, 23, 3, -23 },
  { 1523, 20, 10, 23, 2, -17 },
  { 1548, 19, 22, 23, 2, -23 },
  { 1601, 17, 27, 23, 5, -27 },
  { 1659, 20, 31, 23, 2, -27 },
  { 1737, 21, 27, 23, 0, -27 },
  { 1808, 20, 27, 23, 2, -27 },
  { 1876, 20, 27, 23, 3, -27 },
  { 1944, 20, 27, 23, 2, -27 },
  { 2012, 21, 27, 23, 2, -27 },
  { 2083, 21, 27, 23, 2, -27 },
  { 2154, 19, 27, 23, 3, -27 },
  { 2219, 21, 27, 23, 2, -27 },
  { 2290, 21, 27, 23, 2, -27 },
  { 2361, 20, 27, 23, 2, -27 },
  { 2429, 23, 27, 23, 2, -27 },
  { 2507, 17, 27, 23, 3, -27 },
  { 2565, 23, 27, 23, 1, -27 },
  { 2643, 21, 27, 23, 2, -27 },
  { 2714, 20, 27, 23, 2, -27 },
  { 2782, 21, 27, 23, 2, -27 },
  { 2853, 20, 34, 23, 2, -27 },
  { 2938, 21, 27, 23, 2, -27 },
  { 3009, 22, 27, 23, 1, -27 },
  { 3084, 22, 27, 23, 3, -27 },
  { 3159, 20, 27, 23, 3, -27 },
  { 3227, 21, 27, 23, 4, -27 },
  { 3298, 23, 27, 23, 2, -27 },
  { 3376, 26, 27, 23, -1, -27 },
  { 3464, 22, 27, 23, 4, -27 },
  { 3539, 24, 27, 23, 0, -27 },
  { 3620, 17, 35, 23, 6, -30 },
  { 3695, 10, 35, 23, 7, -30 },
  { 3739, 17, 35, 23, 0, -30 },
  { 3814, 19, 16, 23, 3, -27 },
  { 3852, 19, 3, 23, 0, 4 },
  { 3860, 5, 8, 23, 9, -31 },
  { 3865, 19, 20, 23, 2, -20 },
  { 3913, 19, 29, 23, 2, -29 },
  { 3982, 17, 20, 23, 3, -20 },
  { 4025, 21, 29, 23, 2, -29 },
  { 4102, 18, 20, 23, 3, -20 },
  { 4147, 26, 37, 23, -1, -29 },
  { 4268, 20, 28, 23, 1, -20 },
  { 4338, 18, 29, 23, 2, -29 },
  { 4404, 18, 30, 23, 3, -30 },
  { 4472, 19, 38, 23, 2, -30 },
  { 4563, 20, 29, 23, 2, -29 },
  { 4636, 17, 29, 23, 4, -29 },
  { 4698, 22, 20, 23, 0, -20 },
  { 4753, 18, 20, 23, 2, -20 },
  { 4798, 19, 20, 23, 2, -20 },
  { 4846, 20, 28, 23, 1, -20 },
  { 4916, 19, 28, 23, 2, -20 },
  { 4983, 19, 20, 23, 4, -20 },
  { 5031, 19, 20, 23, 2, -20 },
  { 5079, 18, 27, 23, 3, -27 },
  { 5140, 18, 20, 23, 3, -20 },
  { 5185, 18, 20, 23, 3, -20 },
  { 5230, 20, 20, 23, 2, -20 },
  { 5280, 23, 20, 23, 0, -20 },
  { 5338, 20, 28, 23, 1, -20 },
  { 5408, 20, 20, 23, 2, -20 },
  { 5458, 19, 35, 23, 4, -30 },
  { 5542, 8, 35, 23, 8, -30 },
  { 5577, 18, 35, 23, 2, -30 },
  { 5656, 20, 9, 23, 2, -16 },
};

const GFXfont IBMPlexMono_Italic39pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic39pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic39pt7bGlyphs,
  0x20, 0x7E, 51
};

#endif // _IBMPLEXMONO_ITALIC39PT7B_H_
