#ifndef _IBMPLEXMONO_ITALIC22PT7B_H_
#define _IBMPLEXMONO_ITALIC22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xC6, 0x33, 0x18, 0xC4, 0x20, 0x00, 0x06, 0x7B, 0x80, 0x4F,
  0x3C, 0xF3, 0xCA, 0x60, 0x01, 0x10, 0x0C, 0xC0, 0x22, 0x01, 0x88, 0x3E,
  0x7C, 0xF1, 0xE0, 0xC4, 0x03, 0x30, 0x08, 0x83, 0xE7, 0xCF, 0x9F, 0x04,
  0x60, 0x13, 0x00, 0xCC, 0x06, 0x20, 0x00, 0x00, 0x80, 0x04, 0x01, 0xF0,
  0x3F, 0xE1, 0x93, 0x98, 0x88, 0xC4, 0x07, 0x20, 0x1F, 0x00, 0x7E, 0x00,
  0xF8, 0x04, 0x60, 0x23, 0x23, 0x1B, 0xD9, 0x87, 0xF8, 0x1F, 0x80, 0x20,
  0x01, 0x00, 0x0F, 0x06, 0x3F, 0x08, 0x62, 0x31, 0x84, 0xC3, 0x19, 0x03,
  0xE6, 0x07, 0x98, 0x00, 0x00, 0x06, 0x70, 0x19, 0xF0, 0x26, 0x30, 0xC8,
  0x43, 0x11, 0x84, 0x3F, 0x30, 0x3C, 0x00, 0x07, 0x80, 0x7E, 0x07, 0x18,
  0x30, 0xC1, 0x86, 0x04, 0x30, 0x77, 0x0F, 0xF0, 0x66, 0x06, 0x10, 0x30,
  0xC5, 0x87, 0x3C, 0x3B, 0x3E, 0x78, 0xE3, 0x80, 0xFF, 0xA0, 0x07, 0x0C,
  0x18, 0x30, 0x20, 0x60, 0x40, 0xC0, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x18, 0x04, 0x06, 0x02, 0x03, 0x03,
  0x01, 0x01, 0x01, 0x03, 0x03, 0x03, 0x02, 0x06, 0x04, 0x0C, 0x08, 0x10,
  0x30, 0xC0, 0x02, 0x00, 0x40, 0x18, 0x43, 0x1F, 0x7E, 0x7F, 0x03, 0x80,
  0xD8, 0x33, 0x0C, 0x30, 0x84, 0x00, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00,
  0x60, 0xFF, 0xDF, 0xFC, 0x20, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0x39,
  0x9C, 0xC4, 0x60, 0x7F, 0xFC, 0x6F, 0xE0, 0x00, 0x30, 0x02, 0x00, 0x60,
  0x04, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00,
  0xC0, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x08,
  0x00, 0x07, 0xC1, 0xFE, 0x38, 0x63, 0x02, 0x60, 0x36, 0x03, 0x60, 0x24,
  0x66, 0xC6, 0x6C, 0x06, 0xC0, 0x6C, 0x0C, 0x61, 0x87, 0xF8, 0x3E, 0x00,
  0x07, 0x83, 0xC1, 0xD0, 0xEC, 0x73, 0x08, 0xC0, 0x30, 0x08, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x04, 0x3F, 0xFF, 0xFC, 0x07, 0x83, 0xF8, 0xE3, 0x98,
  0x36, 0x06, 0x00, 0xC0, 0x30, 0x0E, 0x03, 0x81, 0xE0, 0x70, 0x18, 0x06,
  0x01, 0xFF, 0xBF, 0xF0, 0x07, 0x83, 0xFC, 0xE1, 0x88, 0x30, 0x06, 0x01,
  0x83, 0xE0, 0x7C, 0x10, 0xC0, 0x18, 0x03, 0x40, 0x6C, 0x18, 0xFF, 0x0F,
  0x80, 0x00, 0x70, 0x0E, 0x01, 0xA0, 0x36, 0x02, 0x60, 0x46, 0x08, 0x61,
  0x84, 0x30, 0xC6, 0x0C, 0x7F, 0xFF, 0xFF, 0x00, 0xC0, 0x08, 0x01, 0x80,
  0x1F, 0xF1, 0xFE, 0x10, 0x03, 0x00, 0x30, 0x02, 0x78, 0x3F, 0xC7, 0x0C,
  0x00, 0x60, 0x06, 0x00, 0x44, 0x0C, 0xE1, 0xC7, 0xF8, 0x1E, 0x00, 0x01,
  0xC0, 0xE0, 0x30, 0x0C, 0x01, 0x00, 0x6F, 0x1B, 0xF3, 0x87, 0x60, 0x78,
  0x0F, 0x01, 0xE0, 0x66, 0x1C, 0xFF, 0x0F, 0x80, 0x7F, 0xEF, 0xFD, 0x01,
  0x20, 0x6C, 0x18, 0x03, 0x00, 0xC0, 0x10, 0x06, 0x01, 0x80, 0x30, 0x0C,
  0x03, 0x00, 0x60, 0x18, 0x00, 0x0F, 0xC1, 0xFE, 0x38, 0x63, 0x03, 0x20,
  0x63, 0x06, 0x1F, 0x81, 0xF8, 0x60, 0xCC, 0x06, 0xC0, 0x6C, 0x06, 0xE1,
  0xC7, 0xF8, 0x3F, 0x00, 0x1F, 0x0F, 0xE7, 0x0F, 0x03, 0xC0, 0x70, 0x3C,
  0x0F, 0x87, 0x7F, 0x8F, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x07, 0x00, 0x39,
  0xCE, 0x00, 0x00, 0x00, 0x03, 0x3D, 0xC0, 0x1C, 0x71, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0xE3, 0x1C, 0x61, 0x0C, 0x00, 0x00, 0x60, 0x18, 0x0E, 0x07,
  0x03, 0x80, 0xE0, 0x30, 0x07, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0xC0,
  0x10, 0x7F, 0xEF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x20, 0x06,
  0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x18, 0x0E, 0x07, 0x03, 0x81,
  0xE0, 0x70, 0x08, 0x00, 0x1E, 0x3F, 0xD8, 0x78, 0x38, 0x18, 0x0C, 0x1C,
  0x38, 0x30, 0x18, 0x00, 0x00, 0x07, 0x03, 0x81, 0xC0, 0x0F, 0x83, 0xFC,
  0xE1, 0x98, 0x16, 0x3A, 0xCF, 0x5B, 0x1A, 0x63, 0x4C, 0x79, 0x0F, 0x23,
  0x67, 0xAC, 0xFD, 0x80, 0x18, 0x03, 0xF8, 0x1F, 0x00, 0x01, 0xC0, 0x3C,
  0x03, 0xC0, 0x6C, 0x06, 0xC0, 0xC4, 0x0C, 0x41, 0x86, 0x18, 0x63, 0xFE,
  0x3F, 0xE7, 0x06, 0x60, 0x64, 0x02, 0xC0, 0x30, 0x1F, 0xC7, 0xFC, 0xC1,
  0x98, 0x33, 0x06, 0x41, 0xDF, 0xE3, 0xFC, 0x60, 0xCC, 0x0D, 0x81, 0xA0,
  0x6C, 0x0D, 0xFF, 0x3F, 0xC0, 0x0F, 0x83, 0xF8, 0xC3, 0x30, 0x36, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x02, 0x60, 0xEE, 0x38, 0xFE,
  0x0F, 0x00, 0x1F, 0x83, 0xF8, 0xC3, 0x98, 0x33, 0x02, 0x60, 0x48, 0x0B,
  0x03, 0x60, 0x6C, 0x0D, 0x81, 0xB0, 0x64, 0x1D, 0xFF, 0x3F, 0x80, 0x1F,
  0xF3, 0xFF, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x7F, 0xE7, 0xFC, 0x60,
  0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0F, 0xFC, 0xFF, 0xC0, 0x1F, 0xF3,
  0xFF, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x7F, 0xC7, 0xFC, 0x60, 0x06,
  0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x07, 0x81, 0xFC,
  0x38, 0x63, 0x02, 0x60, 0x16, 0x00, 0x60, 0x06, 0x3E, 0x43, 0xEC, 0x04,
  0xC0, 0x46, 0x0C, 0x61, 0xC7, 0xEC, 0x3C, 0xC0, 0x30, 0x33, 0x03, 0x30,
  0x33, 0x02, 0x20, 0x66, 0x06, 0x7F, 0xE7, 0xFE, 0x60, 0x66, 0x04, 0x40,
  0xCC, 0x0C, 0xC0, 0xCC, 0x0C, 0xC0, 0xC0, 0x3F, 0xF3, 0xFF, 0x03, 0x00,
  0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00,
  0xC0, 0x0C, 0x0F, 0xFC, 0xFF, 0x80, 0x0F, 0xE1, 0xFC, 0x01, 0x80, 0x30,
  0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x60, 0xC6, 0x38,
  0xFE, 0x0F, 0x80, 0x30, 0x39, 0x83, 0x8C, 0x38, 0x63, 0x83, 0x38, 0x13,
  0x81, 0xB8, 0x0F, 0xC0, 0x73, 0x03, 0x18, 0x18, 0x60, 0x83, 0x0C, 0x08,
  0x60, 0x63, 0x03, 0x80, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x20, 0x30, 0x18, 0x0C, 0x07, 0xFF, 0xFE, 0x30, 0x33, 0x87,
  0x38, 0xF2, 0x8F, 0x6D, 0xB6, 0xD2, 0x6F, 0x26, 0x66, 0x44, 0x64, 0x46,
  0xC0, 0x6C, 0x04, 0xC0, 0x48, 0x0C, 0x80, 0xC0, 0x38, 0x33, 0x83, 0x3C,
  0x33, 0xC2, 0x2C, 0x26, 0x46, 0x66, 0x66, 0x66, 0x66, 0x64, 0x24, 0x42,
  0x4C, 0x3C, 0xC3, 0xCC, 0x3C, 0xC1, 0xC0, 0x07, 0xC1, 0xFE, 0x38, 0x63,
  0x02, 0x60, 0x36, 0x03, 0x60, 0x26, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0x6C,
  0x0C, 0x61, 0xC7, 0xF8, 0x3E, 0x00, 0x1F, 0xC3, 0xFE, 0x30, 0x33, 0x03,
  0x30, 0x32, 0x03, 0x60, 0x67, 0xFE, 0x7F, 0x86, 0x00, 0x60, 0x04, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x07, 0xC1, 0xFE, 0x38, 0x63, 0x02, 0x60,
  0x36, 0x03, 0x60, 0x26, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0x6C, 0x0C, 0x61,
  0xC7, 0xF8, 0x3E, 0x00, 0xC4, 0x06, 0xE0, 0x3C, 0x03, 0x80, 0x1F, 0xC3,
  0xFE, 0x30, 0x33, 0x03, 0x30, 0x32, 0x03, 0x60, 0x67, 0xFE, 0x7F, 0x86,
  0x20, 0x63, 0x04, 0x10, 0xC1, 0x8C, 0x18, 0xC0, 0xC0, 0x0F, 0x83, 0xFE,
  0x30, 0x76, 0x02, 0x60, 0x07, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xC0, 0x06,
  0x00, 0x68, 0x06, 0xE1, 0xC7, 0xF8, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0x06,
  0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x00, 0x60, 0x6C, 0x0D, 0x81, 0xB0,
  0x24, 0x0D, 0x81, 0xB0, 0x36, 0x06, 0xC0, 0xD0, 0x32, 0x06, 0x40, 0xCC,
  0x31, 0xFE, 0x1F, 0x80, 0xC0, 0x34, 0x06, 0x40, 0x66, 0x0C, 0x60, 0xC6,
  0x08, 0x61, 0x86, 0x10, 0x23, 0x02, 0x20, 0x26, 0x03, 0x60, 0x3C, 0x03,
  0xC0, 0x38, 0x00, 0x60, 0x1B, 0x00, 0xD8, 0x04, 0xC0, 0x26, 0x73, 0x23,
  0x99, 0x3C, 0x89, 0xE4, 0x4B, 0x62, 0xDB, 0x34, 0xD1, 0xA6, 0x8F, 0x1C,
  0x70, 0xE3, 0x86, 0x00, 0x18, 0x0C, 0x60, 0x60, 0xC3, 0x03, 0x18, 0x06,
  0xC0, 0x1B, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x80, 0x36, 0x01, 0x8C, 0x06,
  0x30, 0x30, 0x61, 0x81, 0x8C, 0x03, 0x00, 0xC0, 0x36, 0x06, 0x60, 0xC6,
  0x0C, 0x31, 0x83, 0x30, 0x1E, 0x01, 0xE0, 0x0C, 0x00, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x1F, 0x8F, 0xCC, 0x06, 0x03,
  0x01, 0x00, 0x80, 0x40, 0x60, 0x30, 0x18, 0x08, 0x04, 0x02, 0x03, 0x01,
  0x80, 0xC0, 0x40, 0x3F, 0x1F, 0x80, 0x83, 0x04, 0x10, 0x41, 0x86, 0x08,
  0x20, 0x83, 0x04, 0x10, 0x41, 0x86, 0x08, 0x20, 0x83, 0x1F, 0xC7, 0xE0,
  0x08, 0x02, 0x01, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0x40, 0x30, 0x0C,
  0x03, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x8F, 0xE3, 0xF0, 0x03, 0x00,
  0x78, 0x04, 0x80, 0xCC, 0x18, 0xC3, 0x04, 0x20, 0x66, 0x02, 0xC0, 0x30,
  0xFF, 0xFF, 0xFC, 0xC9, 0x30, 0x1E, 0x67, 0xED, 0xC3, 0x30, 0x24, 0x0D,
  0x81, 0xB0, 0x36, 0x0E, 0xE2, 0x8F, 0xDC, 0xF3, 0x80, 0x18, 0x02, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x6F, 0x0F, 0xF1, 0x43, 0x70, 0x6C, 0x0D, 0x81,
  0xB0, 0x34, 0x0C, 0xC3, 0xB7, 0xE6, 0x78, 0x1E, 0x1F, 0xD8, 0x78, 0x1C,
  0x06, 0x02, 0x05, 0x03, 0xC3, 0x3F, 0x0F, 0x00, 0x00, 0x30, 0x03, 0x00,
  0x20, 0x02, 0x00, 0x61, 0xE6, 0x3F, 0x67, 0x0E, 0x60, 0x44, 0x04, 0xC0,
  0xCC, 0x0C, 0xC0, 0xCE, 0x3C, 0x7E, 0x83, 0xD8, 0x1F, 0x0F, 0xE6, 0x0F,
  0x07, 0xFF, 0xBF, 0x08, 0x03, 0x02, 0xC3, 0xBF, 0xC3, 0xE0, 0x00, 0x7C,
  0x03, 0xF0, 0x18, 0x00, 0x60, 0x01, 0x80, 0x7F, 0xE1, 0xFF, 0x80, 0x40,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60,
  0x31, 0x80, 0xE6, 0x01, 0xD8, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x67, 0xED,
  0xC3, 0xB0, 0x24, 0x05, 0x81, 0xB0, 0x36, 0x06, 0xE3, 0xCF, 0xD0, 0xF6,
  0x00, 0xCC, 0x39, 0xFE, 0x1F, 0x00, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x30,
  0x0C, 0xE3, 0x7C, 0xE3, 0x30, 0x58, 0x16, 0x0D, 0x83, 0x60, 0xD0, 0x34,
  0x0B, 0x06, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x20,
  0x08, 0x06, 0x01, 0x80, 0x42, 0x13, 0xCD, 0xC3, 0xE0, 0x70, 0x00, 0xE0,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x0C, 0x01, 0x80, 0x30,
  0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC2, 0x18, 0xE2, 0x06, 0xC0, 0x78,
  0x06, 0x00, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x03, 0x38, 0x37,
  0xC3, 0x8C, 0x30, 0x46, 0x0C, 0x67, 0x86, 0xE0, 0x64, 0x24, 0x6F, 0x43,
  0xCC, 0x38, 0x7C, 0x3F, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x01, 0x80, 0x60,
  0x18, 0x04, 0x01, 0x08, 0xC6, 0x33, 0xCD, 0xC3, 0xC0, 0xE0, 0x36, 0x71,
  0xFF, 0x8C, 0xE6, 0x46, 0x26, 0x31, 0x31, 0x19, 0x88, 0xCC, 0x46, 0x46,
  0x22, 0x31, 0x31, 0x98, 0x33, 0x8D, 0xF3, 0x8C, 0xC1, 0x60, 0x58, 0x36,
  0x0D, 0x83, 0x40, 0xD0, 0x2C, 0x18, 0x0F, 0x87, 0xF8, 0xC3, 0x30, 0x36,
  0x07, 0x80, 0xF0, 0x1E, 0x06, 0x61, 0xCF, 0xF0, 0x78, 0x00, 0x1B, 0xC1,
  0xFE, 0x14, 0x33, 0x83, 0x30, 0x33, 0x03, 0x30, 0x32, 0x06, 0x30, 0xE6,
  0xFC, 0x67, 0x86, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x00, 0x1E, 0x67, 0xED,
  0xC3, 0xB0, 0x24, 0x05, 0x81, 0xB0, 0x36, 0x06, 0xE3, 0xCF, 0xD0, 0xF6,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x7D, 0xFF, 0x7C, 0x68, 0x0E, 0x01,
  0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x00, 0x0F, 0x87,
  0xF8, 0xC1, 0x90, 0x03, 0xC0, 0x3F, 0x00, 0xF0, 0x06, 0x40, 0xDF, 0xF0,
  0xFC, 0x00, 0x0C, 0x02, 0x00, 0x80, 0x60, 0xFF, 0xFF, 0xE1, 0x80, 0x40,
  0x10, 0x0C, 0x03, 0x08, 0xCE, 0x27, 0x4F, 0x83, 0x80, 0x60, 0xD8, 0x34,
  0x0F, 0x02, 0xC1, 0xB0, 0x6C, 0x1B, 0x0E, 0xC5, 0x3E, 0x47, 0xB0, 0x78,
  0x4F, 0x0E, 0x41, 0x88, 0x33, 0x06, 0x60, 0xCC, 0x31, 0x8E, 0x23, 0x87,
  0xE0, 0xF0, 0x00, 0x62, 0x6C, 0x45, 0x18, 0xA3, 0x14, 0x63, 0x88, 0x71,
  0x1E, 0x63, 0xCC, 0xDE, 0xF9, 0x9E, 0x00, 0x0E, 0x70, 0xF7, 0xCC, 0xA6,
  0xC6, 0x30, 0x31, 0x81, 0x83, 0x18, 0x18, 0xC6, 0xCF, 0x67, 0xDE, 0x1C,
  0x60, 0x30, 0x66, 0x0C, 0x81, 0x90, 0x26, 0x0C, 0xC1, 0x98, 0x33, 0x0E,
  0x62, 0x8F, 0xF0, 0xF6, 0x00, 0xCC, 0x31, 0xFE, 0x1F, 0x00, 0x1E, 0x67,
  0xFD, 0x87, 0xB0, 0xE0, 0x30, 0x0C, 0x06, 0x11, 0x86, 0xFC, 0x5F, 0xFF,
  0x1F, 0x00, 0x07, 0xE0, 0xFC, 0x10, 0x06, 0x00, 0x40, 0x08, 0x01, 0x80,
  0x10, 0x06, 0x0F, 0x83, 0xF0, 0x02, 0x00, 0x40, 0x18, 0x06, 0x00, 0x80,
  0x30, 0x06, 0x00, 0xFC, 0x1F, 0x00, 0x08, 0xC6, 0x31, 0x08, 0x46, 0x31,
  0x88, 0x42, 0x31, 0x8C, 0x42, 0x11, 0x80, 0x1F, 0x07, 0xE0, 0x10, 0x04,
  0x01, 0x00, 0x80, 0x40, 0x30, 0x0C, 0x01, 0xF0, 0x7C, 0x30, 0x18, 0x02,
  0x00, 0xC0, 0x10, 0x04, 0x03, 0x0F, 0xC3, 0xE0, 0x38, 0x37, 0xC2, 0x66,
  0x6C, 0x7C, 0xC3, 0x80,
};

const GFXglyph IBMPlexMono_Italic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 5, 15, 13, 4, -15 },
  { 11, 6, 6, 13, 5, -16 },
  { 16, 14, 15, 13, 0, -15 },
  { 43, 13, 19, 13, 0, -17 },
  { 74, 15, 15, 13, -1, -15 },
  { 103, 13, 15, 13, 0, -15 },
  { 128, 2, 6, 13, 7, -16 },
  { 130, 8, 20, 13, 5, -17 },
  { 150, 8, 20, 13, 1, -17 },
  { 170, 11, 11, 13, 1, -12 },
  { 186, 11, 12, 13, 1, -13 },
  { 203, 5, 6, 13, 3, -3 },
  { 207, 7, 2, 13, 3, -8 },
  { 209, 4, 3, 13, 4, -3 },
  { 211, 12, 20, 13, 1, -17 },
  { 241, 12, 15, 13, 1, -15 },
  { 264, 10, 15, 13, 1, -15 },
  { 283, 11, 15, 13, 1, -15 },
  { 304, 11, 15, 13, 1, -15 },
  { 325, 12, 15, 13, 0, -15 },
  { 348, 12, 15, 13, 1, -15 },
  { 371, 11, 15, 13, 1, -15 },
  { 392, 11, 15, 13, 2, -15 },
  { 413, 12, 15, 13, 1, -15 },
  { 436, 10, 15, 13, 2, -15 },
  { 455, 5, 12, 13, 4, -12 },
  { 463, 6, 15, 13, 3, -12 },
  { 475, 11, 13, 13, 2, -13 },
  { 493, 11, 6, 13, 1, -10 },
  { 502, 11, 13, 13, 1, -13 },
  { 520, 9, 15, 13, 3, -15 },
  { 537, 11, 17, 13, 1, -15 },
  { 561, 12, 15, 13, 0, -15 },
  { 584, 11, 15, 13, 1, -15 },
  { 605, 11, 15, 13, 2, -15 },
  { 626, 11, 15, 13, 1, -15 },
  { 647, 12, 15, 13, 1, -15 },
  { 670, 12, 15, 13, 1, -15 },
  { 693, 12, 15, 13, 1, -15 },
  { 716, 12, 15, 13, 1, -15 },
  { 739, 12, 15, 13, 1, -15 },
  { 762, 11, 15, 13, 1, -15 },
  { 783, 13, 15, 13, 1, -15 },
  { 808, 9, 15, 13, 2, -15 },
  { 825, 12, 15, 13, 1, -15 },
  { 848, 12, 15, 13, 1, -15 },
  { 871, 12, 15, 13, 1, -15 },
  { 894, 12, 15, 13, 1, -15 },
  { 917, 12, 19, 13, 1, -15 },
  { 946, 12, 15, 13, 1, -15 },
  { 969, 12, 15, 13, 1, -15 },
  { 992, 12, 15, 13, 2, -15 },
  { 1015, 11, 15, 13, 2, -15 },
  { 1036, 12, 15, 13, 2, -15 },
  { 1059, 13, 15, 13, 1, -15 },
  { 1084, 14, 15, 13, 0, -15 },
  { 1111, 12, 15, 13, 2, -15 },
  { 1134, 13, 15, 13, 0, -15 },
  { 1159, 9, 20, 13, 4, -17 },
  { 1182, 6, 20, 13, 4, -17 },
  { 1197, 10, 20, 13, 0, -17 },
  { 1222, 12, 9, 13, 1, -15 },
  { 1236, 11, 2, 13, 0, 2 },
  { 1239, 3, 4, 13, 5, -17 },
  { 1241, 11, 11, 13, 1, -11 },
  { 1257, 11, 16, 13, 1, -16 },
  { 1279, 9, 11, 13, 2, -11 },
  { 1292, 12, 16, 13, 1, -16 },
  { 1316, 10, 11, 13, 2, -11 },
  { 1330, 14, 20, 13, 0, -16 },
  { 1365, 11, 15, 13, 1, -11 },
  { 1386, 10, 16, 13, 1, -16 },
  { 1406, 10, 16, 13, 2, -16 },
  { 1426, 11, 20, 13, 1, -16 },
  { 1454, 12, 16, 13, 1, -16 },
  { 1478, 10, 16, 13, 2, -16 },
  { 1498, 13, 11, 13, 0, -11 },
  { 1516, 10, 11, 13, 1, -11 },
  { 1530, 11, 11, 13, 1, -11 },
  { 1546, 12, 15, 13, 0, -11 },
  { 1569, 11, 15, 13, 1, -11 },
  { 1590, 11, 11, 13, 2, -11 },
  { 1606, 11, 11, 13, 1, -11 },
  { 1622, 10, 15, 13, 2, -15 },
  { 1641, 10, 11, 13, 2, -11 },
  { 1655, 11, 11, 13, 1, -11 },
  { 1671, 11, 11, 13, 1, -11 },
  { 1687, 13, 11, 13, 0, -11 },
  { 1705, 11, 15, 13, 1, -11 },
  { 1726, 11, 11, 13, 1, -11 },
  { 1742, 11, 20, 13, 2, -17 },
  { 1770, 5, 20, 13, 4, -17 },
  { 1783, 10, 20, 13, 1, -17 },
  { 1808, 12, 5, 13, 1, -9 },
};

const GFXfont IBMPlexMono_Italic22pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic22pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic22pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _IBMPLEXMONO_ITALIC22PT7B_H_
