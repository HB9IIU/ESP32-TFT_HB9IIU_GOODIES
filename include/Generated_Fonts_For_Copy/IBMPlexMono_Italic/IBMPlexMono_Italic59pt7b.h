#ifndef _IBMPLEXMONO_ITALIC59PT7B_H_
#define _IBMPLEXMONO_ITALIC59PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic59pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F,
  0x00, 0xF8, 0x00, 0x1F, 0x07, 0xC7, 0x81, 0xF1, 0xE0, 0x78, 0x78, 0x1E,
  0x3E, 0x07, 0x8F, 0x83, 0xE3, 0xC0, 0xF8, 0xF0, 0x3E, 0x3C, 0x0F, 0x0F,
  0x03, 0xC7, 0xC0, 0xF1, 0xF0, 0x7C, 0x78, 0x1F, 0x1E, 0x07, 0xC7, 0x81,
  0xE3, 0xE0, 0x78, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x3E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00,
  0x3E, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x07, 0xC0, 0xF0, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0xFF, 0x80,
  0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0xFF,
  0xF0, 0x1F, 0xFE, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0xFF, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xE0,
  0xFF, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x01, 0xF0, 0x3C,
  0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0x3E,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0xF0, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x07, 0x81, 0xF0,
  0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x3E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x0F, 0xF3, 0xCF, 0xF0, 0x07, 0xE0, 0xF0, 0xFE, 0x03,
  0xF0, 0x3C, 0x0F, 0x80, 0xF8, 0x0E, 0x01, 0xD0, 0x3E, 0x03, 0x80, 0x60,
  0x1F, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x01, 0xF0, 0x1E, 0x00,
  0x00, 0x7C, 0x07, 0x80, 0x00, 0x1F, 0x01, 0xC0, 0x00, 0x07, 0xC0, 0x70,
  0x00, 0x01, 0xF8, 0x1C, 0x00, 0x00, 0x3F, 0x07, 0x00, 0x00, 0x0F, 0xE3,
  0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1E, 0x3F, 0x80, 0x00, 0x07, 0x83, 0xF0,
  0x00, 0x01, 0xC0, 0xFC, 0x00, 0x00, 0x70, 0x1F, 0x00, 0x00, 0x1C, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0xF0,
  0x1F, 0x00, 0x00, 0x38, 0x07, 0xC0, 0x40, 0x0E, 0x01, 0xF0, 0x38, 0x03,
  0x80, 0xFC, 0x1F, 0x01, 0xE0, 0x3E, 0x0F, 0xE0, 0x78, 0x1F, 0x81, 0xFE,
  0x1E, 0x1F, 0xC0, 0x3F, 0xE7, 0x1F, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0x00, 0x7F, 0xF8, 0x00, 0x3E, 0x00, 0xFF, 0xFC, 0x00, 0x3C, 0x01, 0xF0,
  0x7C, 0x00, 0x78, 0x03, 0xE0, 0x3C, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0xC0, 0x1E, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x03, 0xE0, 0x07,
  0x80, 0x1E, 0x03, 0xC0, 0x07, 0x80, 0x3E, 0x07, 0x80, 0x07, 0x80, 0x3C,
  0x0F, 0x00, 0x07, 0x80, 0x3C, 0x1F, 0x00, 0x07, 0x80, 0x3C, 0x1E, 0x00,
  0x07, 0x80, 0x78, 0x3C, 0x00, 0x07, 0x80, 0xF8, 0x7C, 0x00, 0x07, 0xC1,
  0xF0, 0x78, 0x00, 0x03, 0xFF, 0xF0, 0xF0, 0x00, 0x03, 0xFF, 0xE1, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0x07, 0xFF, 0x80, 0x00, 0x1E, 0x0F, 0xFF, 0xC0,
  0x00, 0x3E, 0x1F, 0x07, 0xC0, 0x00, 0x3C, 0x3E, 0x03, 0xC0, 0x00, 0x78,
  0x3C, 0x01, 0xC0, 0x00, 0xF8, 0x7C, 0x01, 0xE0, 0x00, 0xF0, 0x78, 0x01,
  0xE0, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x78, 0x03, 0xC0, 0x07,
  0xC0, 0x78, 0x03, 0xC0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x70,
  0x03, 0xC0, 0x1F, 0x00, 0x78, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x0F, 0x80,
  0x3C, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x00, 0x3F, 0xFF, 0x00, 0x78, 0x00,
  0x3F, 0xFE, 0x00, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00,
  0x7C, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0xF8,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x7C, 0x1F, 0x80,
  0x00, 0x3F, 0x87, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x01, 0xF0, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x08, 0xF8, 0x00, 0x3E,
  0x01, 0xDF, 0x00, 0x0F, 0xC0, 0x7F, 0xE0, 0x01, 0xFC, 0x0F, 0x7C, 0x00,
  0x6F, 0x83, 0xC7, 0xC0, 0x0C, 0xF8, 0xF8, 0xF8, 0x03, 0x9F, 0x1E, 0x0F,
  0xC1, 0xE1, 0xF7, 0xC1, 0xFF, 0xFC, 0x3F, 0xF0, 0x1F, 0xFF, 0x03, 0xFC,
  0x01, 0xFF, 0xC0, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xC0, 0x00, 0x3E, 0x78,
  0xF1, 0xE7, 0xCF, 0x9F, 0x3C, 0x78, 0xF3, 0xE7, 0xCF, 0x9E, 0x3C, 0x78,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0xC0, 0x0F, 0x00, 0x37, 0xE0, 0x3C, 0x07, 0xDF, 0xF1, 0xF1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0xC0,
  0x3C, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07,
  0x40, 0x04, 0x00, 0x08, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xF8, 0x3F, 0xC1, 0xFC,
  0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x0F,
  0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x1E, 0x00, 0x7F, 0xFF, 0xDF,
  0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFE, 0x1F, 0x3F, 0xDF, 0xEF, 0xFF, 0xFF,
  0xFD, 0xFC, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3E,
  0x00, 0x01, 0xE1, 0xF0, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x1E, 0x3E, 0x00,
  0x00, 0x7C, 0xF8, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00,
  0x1F, 0x7C, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x01, 0xE7, 0xC0, 0x78, 0x0F,
  0xBF, 0x03, 0xF0, 0x3E, 0xF8, 0x1F, 0xC0, 0xFB, 0xE0, 0x7F, 0x03, 0xEF,
  0x81, 0xFC, 0x0F, 0xBE, 0x07, 0xF0, 0x3E, 0xF8, 0x0F, 0x80, 0xFB, 0xE0,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x7C, 0xF0, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0xF8,
  0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x03,
  0xF8, 0x1F, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x1F, 0x9F, 0x00, 0x03, 0xF8, 0xF8, 0x00, 0x3F, 0x87, 0xC0,
  0x03, 0xF8, 0x3E, 0x00, 0x3F, 0x81, 0xE0, 0x03, 0xF8, 0x1F, 0x00, 0x1F,
  0x80, 0xF8, 0x00, 0x70, 0x07, 0xC0, 0x01, 0x00, 0x3E, 0x00, 0x10, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0xF8, 0x06, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x07,
  0xF0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0x78,
  0x00, 0x1F, 0x00, 0x60, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF8, 0x20, 0x00, 0x03, 0xE0, 0x60, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7E, 0x0F, 0xE0, 0x01, 0xF8, 0x0F, 0xF0,
  0x0F, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x3E, 0x78, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0xF8,
  0x03, 0xE0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0,
  0x03, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x0F, 0x80, 0x03, 0xC0, 0x1F, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x78, 0x00,
  0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x83, 0xF8, 0x00, 0x1F, 0x1F, 0xFC, 0x00,
  0x3C, 0xFF, 0xFE, 0x00, 0x7B, 0xFF, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x03,
  0xF8, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x70, 0x00,
  0x0F, 0xC1, 0xE0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x01,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x07, 0xF8, 0x01, 0xF1, 0xFF, 0xE0,
  0x3E, 0x7F, 0xFF, 0x03, 0xEF, 0xFF, 0xF8, 0x7D, 0xE0, 0x3F, 0xC7, 0xF8,
  0x00, 0xFE, 0x7F, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x3E, 0xFC, 0x00, 0x03,
  0xEF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xEF, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x03, 0xEF, 0x00, 0x00,
  0x3E, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x87,
  0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFE, 0x7C, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x07, 0xC7, 0x80,
  0x00, 0x3E, 0x1E, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x07, 0xC1, 0xE0, 0x00,
  0x3F, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0xFF, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF0,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0xF8, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x03, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80,
  0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x00, 0x78, 0x7C, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x7C, 0x7C, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0xF8, 0xFC, 0x00,
  0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0xFC, 0x00, 0x7E, 0x1F,
  0x80, 0x03, 0xE3, 0xF0, 0x00, 0x1E, 0x3E, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0xFE,
  0x7E, 0x00, 0x1B, 0xE3, 0xF8, 0x0F, 0x7C, 0x3F, 0xFF, 0xE7, 0xC1, 0xFF,
  0xFC, 0xFC, 0x07, 0xFF, 0x8F, 0x80, 0x1F, 0xE1, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x3F, 0xC1, 0xFE, 0x1F, 0xF0,
  0xFF, 0x87, 0xFC, 0x3F, 0xC0, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE1, 0xFF, 0x0F, 0xF8, 0x3F, 0x80, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0xFF,
  0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xE0,
  0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFC, 0x04, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x83, 0xFC, 0x0F, 0xE1, 0xF8, 0x01, 0xF9, 0xF8, 0x00,
  0x7D, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xC4, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFE, 0x03,
  0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x7C, 0x3C, 0x7C, 0x07, 0xFC, 0xF1, 0xE0,
  0x3F, 0xF3, 0xC7, 0x81, 0xFF, 0xEF, 0x1E, 0x07, 0xC1, 0xBC, 0xF8, 0x3E,
  0x03, 0xE3, 0xC0, 0xF0, 0x07, 0x8F, 0x07, 0xC0, 0x1E, 0x3C, 0x1E, 0x00,
  0x78, 0xF0, 0x78, 0x01, 0xE7, 0xC3, 0xE0, 0x0F, 0x9F, 0x0F, 0x80, 0x3C,
  0x78, 0x3E, 0x00, 0xF1, 0xE0, 0xF0, 0x03, 0xC7, 0x83, 0xC0, 0x0F, 0x1E,
  0x0F, 0x00, 0x3C, 0x78, 0x3C, 0x01, 0xF3, 0xE0, 0xF0, 0x07, 0x8F, 0x83,
  0xC0, 0x3E, 0x3E, 0x0F, 0x00, 0xF8, 0xF8, 0x3E, 0x05, 0xE3, 0xE0, 0xFC,
  0x77, 0x8F, 0x81, 0xFF, 0x9E, 0x3E, 0x07, 0xFE, 0xF8, 0x78, 0x0F, 0xF3,
  0xC1, 0xE0, 0x0E, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x01,
  0xF1, 0xF0, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x03,
  0xE0, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x07,
  0x80, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3E, 0x1F, 0x00,
  0x00, 0x1F, 0x3E, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x1F, 0x7C, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x03,
  0xF8, 0x0F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1,
  0xE0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0x3C, 0x00,
  0x3F, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xF0, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0xF8,
  0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xF1, 0xF0, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0x7E, 0x1E, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x3F,
  0x83, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8,
  0x01, 0xF8, 0x0F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x00,
  0xF8, 0x7C, 0x00, 0x03, 0x87, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x60,
  0xF8, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xF0, 0xF8,
  0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x3F, 0x00, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xE0, 0x0F, 0xF0, 0x0F,
  0x80, 0x0F, 0xC0, 0x3E, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x7C, 0x0F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07,
  0xC1, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x3C,
  0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x3E, 0x1F, 0x00,
  0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00,
  0x7C, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3F, 0x07,
  0xC0, 0x01, 0xF8, 0x1F, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0xFE, 0x01, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x3E,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x78, 0x3E, 0x00,
  0x01, 0xD1, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x3F, 0xFF, 0x3E, 0x00, 0xFF, 0xF8, 0xF8, 0x03, 0xFF, 0xE3, 0xE0, 0x0F,
  0xFF, 0x8F, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x3C, 0x3E, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xFC, 0x1F,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x37, 0x80, 0xF8, 0x01, 0xDE, 0x03, 0xF8,
  0x1E, 0xF8, 0x07, 0xFF, 0xF3, 0xE0, 0x0F, 0xFF, 0x8F, 0x80, 0x1F, 0xFC,
  0x3C, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x78, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xF0, 0x1F, 0x00, 0x0F,
  0x80, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xE0, 0x7C, 0x00, 0x03, 0xF8, 0x0F, 0x80, 0x00,
  0xFE, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0x3E, 0x00, 0x0F, 0xE0, 0x0F, 0x80,
  0x03, 0xF8, 0x01, 0xF0, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x0F, 0xC0, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x3F, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x0F, 0x8F,
  0xC0, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x00, 0x7C, 0x7F, 0x00, 0x00, 0x0F,
  0x9F, 0xE0, 0x00, 0x01, 0xF7, 0xFE, 0x00, 0x00, 0x3F, 0xF7, 0xC0, 0x00,
  0x07, 0xFC, 0x7C, 0x00, 0x01, 0xFF, 0x0F, 0x80, 0x00, 0x3F, 0xC0, 0xF8,
  0x00, 0x07, 0xF0, 0x1F, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x07,
  0xE0, 0x0F, 0x80, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x3E, 0x00,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xE0,
  0x01, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x3F, 0xE0, 0x7F,
  0xC0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x07, 0xBC, 0x03, 0xEF, 0x01,
  0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x7C, 0xF0, 0x3E, 0x78, 0x1E, 0x7C,
  0x0F, 0x9E, 0x0F, 0x9F, 0x03, 0xE3, 0xC3, 0xC7, 0x80, 0xF0, 0xF1, 0xE1,
  0xE0, 0x3C, 0x3C, 0xF8, 0x78, 0x0F, 0x0F, 0x3C, 0x3E, 0x07, 0xC1, 0xFF,
  0x0F, 0x81, 0xF0, 0x7F, 0x83, 0xE0, 0x7C, 0x1F, 0xC0, 0xF0, 0x1E, 0x07,
  0xF0, 0x3C, 0x07, 0x80, 0xF8, 0x0F, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0xF8,
  0x0F, 0x01, 0xF0, 0x3E, 0x03, 0x80, 0x7C, 0x0F, 0x80, 0x60, 0x1E, 0x03,
  0xC0, 0x10, 0x07, 0x80, 0xF0, 0x04, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF8,
  0x1F, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0xFF, 0x00, 0x07,
  0xC0, 0x7F, 0x80, 0x03, 0xE0, 0x3F, 0xC0, 0x01, 0xE0, 0x3F, 0xE0, 0x00,
  0xF0, 0x1F, 0xF0, 0x00, 0xF8, 0x0F, 0xFC, 0x00, 0x7C, 0x07, 0x9E, 0x00,
  0x3E, 0x03, 0xCF, 0x00, 0x1F, 0x01, 0xE7, 0x80, 0x0F, 0x01, 0xF3, 0xE0,
  0x07, 0x80, 0xF9, 0xF0, 0x07, 0xC0, 0x7C, 0x78, 0x03, 0xE0, 0x3C, 0x3C,
  0x01, 0xF0, 0x1E, 0x1E, 0x00, 0xF8, 0x0F, 0x0F, 0x80, 0x78, 0x0F, 0x83,
  0xC0, 0x3C, 0x07, 0xC1, 0xE0, 0x3E, 0x03, 0xE0, 0xF0, 0x1F, 0x01, 0xE0,
  0x7C, 0x0F, 0x80, 0xF0, 0x3E, 0x07, 0x80, 0x78, 0x0F, 0x03, 0xC0, 0x7C,
  0x07, 0x81, 0xE0, 0x3E, 0x03, 0xC1, 0xF0, 0x1F, 0x01, 0xF0, 0xF8, 0x0F,
  0x00, 0x78, 0x7C, 0x07, 0x80, 0x3C, 0x3C, 0x03, 0xC0, 0x1E, 0x1E, 0x03,
  0xE0, 0x0F, 0x8F, 0x01, 0xF0, 0x07, 0xCF, 0x80, 0xF8, 0x01, 0xE7, 0xC0,
  0x78, 0x00, 0xF3, 0xE0, 0x3C, 0x00, 0x79, 0xE0, 0x1E, 0x00, 0x3E, 0xF0,
  0x1F, 0x00, 0x0F, 0x78, 0x0F, 0x80, 0x07, 0xFC, 0x07, 0xC0, 0x03, 0xFE,
  0x03, 0xC0, 0x01, 0xFF, 0x01, 0xE0, 0x00, 0xFF, 0x00, 0xF0, 0x00, 0x3F,
  0x80, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFC, 0x07,
  0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07, 0x87,
  0xC0, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7D, 0xF0, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3E,
  0xF8, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x1F, 0x3E,
  0x00, 0x00, 0x7C, 0xF0, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x0F, 0x8F, 0x00,
  0x00, 0x3E, 0x3C, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x3F, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x3F,
  0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x3E, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x0F, 0xC0,
  0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x78,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x3C, 0x00,
  0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFC, 0x07, 0xE0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0xF8, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x1E,
  0x3E, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x07, 0xDF,
  0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xF7, 0xC0,
  0x00, 0x0F, 0xBF, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x01,
  0xFB, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x7C,
  0xF0, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x3E, 0x3C,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3F, 0x0F, 0x80,
  0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x3F, 0x01, 0xF8, 0x01,
  0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x60, 0x00, 0x7E, 0x03, 0xC0, 0x00, 0xF8, 0x3F, 0x00,
  0x01, 0xF1, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x3E, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x0F, 0xC0, 0xF0, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x0F, 0xE0,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x7C,
  0x03, 0xE0, 0x00, 0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xE0,
  0x0F, 0x80, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0x1F, 0xF0, 0x0F, 0xE0,
  0x01, 0xFC, 0x07, 0xC0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x1E, 0x03, 0xE0,
  0x00, 0x06, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x08, 0x00, 0x00, 0x3E, 0x0E, 0x00, 0x00,
  0x3F, 0x0F, 0x80, 0x00, 0x1F, 0x0F, 0xE0, 0x00, 0x1F, 0x81, 0xFC, 0x00,
  0x3F, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00,
  0xF8, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C,
  0x3E, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x1F,
  0x00, 0x00, 0x78, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x3C, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F,
  0x01, 0xE0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x3F, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0xF0, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7C, 0x3E,
  0x00, 0x00, 0xF8, 0x3C, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x07, 0xC0, 0xF0,
  0x00, 0x0F, 0x81, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0,
  0x01, 0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x1E, 0x00,
  0x1F, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01,
  0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x3E,
  0x00, 0x07, 0x80, 0x7C, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x1E, 0x03, 0xE0,
  0x00, 0x3C, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x03, 0xC7, 0xC0, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x7C, 0x1E, 0x00,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x00, 0x3C, 0x1F,
  0x01, 0xF8, 0x0F, 0x83, 0xC0, 0x3F, 0x01, 0xF0, 0x78, 0x0F, 0xE0, 0x3C,
  0x0F, 0x01, 0xFC, 0x07, 0x81, 0xE0, 0x3F, 0x81, 0xF0, 0x3C, 0x0F, 0xF0,
  0x3E, 0x07, 0x81, 0xEE, 0x07, 0x80, 0xF0, 0x79, 0xC0, 0xF0, 0x1E, 0x0F,
  0x38, 0x3E, 0x03, 0xC1, 0xE7, 0x07, 0xC0, 0xF8, 0x78, 0xE0, 0xF0, 0x1F,
  0x0F, 0x1C, 0x1E, 0x03, 0xC3, 0xC3, 0x83, 0xC0, 0x78, 0x78, 0x78, 0xF8,
  0x0F, 0x0F, 0x0F, 0x1E, 0x01, 0xE3, 0xC1, 0xE3, 0xC0, 0x3C, 0x78, 0x3C,
  0x78, 0x07, 0x8F, 0x07, 0x9F, 0x00, 0xF3, 0xC0, 0xF3, 0xC0, 0x1E, 0x78,
  0x1E, 0x78, 0x03, 0xDE, 0x03, 0xCF, 0x00, 0xFB, 0xC0, 0x7B, 0xE0, 0x1E,
  0x78, 0x0F, 0x78, 0x03, 0xDE, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x3D, 0xE0,
  0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F,
  0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x00, 0x3E,
  0x1F, 0x80, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0xF8, 0x00,
  0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xEF, 0x80,
  0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x00,
  0x0F, 0x80, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xDF,
  0x00, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x01, 0xF8,
  0x3E, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x1F,
  0x80, 0x7C, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x03, 0xE0, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x1F, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00,
  0x0F, 0xBF, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3E, 0xF8,
  0x00, 0x01, 0xF1, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3C, 0x0F, 0x00,
  0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x7C, 0x01, 0xE0, 0x01,
  0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x7C, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x78, 0x0F, 0x80, 0x01, 0xE0, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x01,
  0xE7, 0x00, 0x00, 0x07, 0xC4, 0x00, 0x00, 0x08, 0x7F, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xE0, 0x71,
  0xE3, 0xE3, 0xC7, 0x8F, 0x8F, 0x1E, 0x1E, 0x3C, 0x20, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xFF, 0x87, 0xC0, 0x7F, 0xFE, 0x3E, 0x07, 0xFF, 0xF9, 0xE0,
  0x7F, 0x81, 0xEF, 0x07, 0xE0, 0x03, 0xF8, 0x3E, 0x00, 0x0F, 0xC3, 0xE0,
  0x00, 0x7E, 0x1F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x0F, 0x80, 0x00,
  0x78, 0x78, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF1,
  0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x78, 0x78, 0x00, 0x03, 0xC7, 0xC0,
  0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00,
  0x7C, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x0F, 0x00, 0x03, 0xF0,
  0x7C, 0x00, 0x3F, 0x83, 0xE0, 0x03, 0x7C, 0x1F, 0x80, 0x3B, 0xE0, 0x7E,
  0x07, 0x9F, 0xF3, 0xFF, 0xF8, 0xFF, 0x0F, 0xFF, 0x83, 0xF8, 0x3F, 0xF8,
  0x0F, 0xC0, 0x7F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x7F, 0x00, 0x1F, 0x0F, 0xFE, 0x00,
  0xF8, 0xFF, 0xF8, 0x07, 0x8F, 0xFF, 0xE0, 0x3C, 0xF0, 0x3F, 0x83, 0xEE,
  0x00, 0xFC, 0x1F, 0x60, 0x03, 0xE0, 0xFE, 0x00, 0x0F, 0x87, 0xE0, 0x00,
  0x7C, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xF8,
  0xF8, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF1, 0xE0,
  0x00, 0x0F, 0x8F, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x3E, 0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x7C,
  0x78, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3E, 0x3F, 0x00, 0x03, 0xE1, 0xF8,
  0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF0, 0x7B, 0xC0, 0x7F, 0x03, 0xCF, 0xFF,
  0xF0, 0x3E, 0x3F, 0xFF, 0x01, 0xF0, 0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x0F, 0x83, 0xE0, 0x00,
  0xF0, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x06, 0x1E, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0x7C, 0x00,
  0x1F, 0x87, 0xC0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x1F, 0xC0, 0x78, 0x00, 0x7F, 0xF0,
  0x78, 0x01, 0xFF, 0xFC, 0xF8, 0x03, 0xFF, 0xFC, 0xF8, 0x07, 0xF8, 0x1E,
  0xF8, 0x0F, 0xC0, 0x06, 0xF0, 0x0F, 0x80, 0x03, 0xF0, 0x1F, 0x00, 0x01,
  0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01,
  0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x01,
  0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F,
  0xC0, 0x78, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x17, 0x80, 0x7C, 0x00, 0x37,
  0x80, 0x7E, 0x00, 0xEF, 0x80, 0x3F, 0x83, 0xCF, 0x80, 0x3F, 0xFF, 0xCF,
  0x80, 0x1F, 0xFF, 0x8F, 0x00, 0x0F, 0xFE, 0x0F, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0xFE, 0x0F, 0xC0, 0x07, 0xC3, 0xE0, 0x00,
  0xF8, 0xF8, 0x00, 0x0F, 0x1E, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x7C, 0xF0,
  0x00, 0x0F, 0xBE, 0x00, 0x07, 0xF7, 0xC0, 0x03, 0xFC, 0xF8, 0x1F, 0xFF,
  0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x02, 0x1E, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x3E, 0x7C, 0x00,
  0x0F, 0x8F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x1F, 0xC0, 0x7F, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0x00, 0xF8,
  0x00, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x00,
  0x3F, 0x07, 0x80, 0x00, 0x00, 0x3F, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0x1E,
  0x00, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0xF0, 0x0F,
  0xFF, 0xE7, 0xC0, 0x7F, 0xFF, 0x9F, 0x03, 0xFC, 0x0F, 0x7C, 0x1F, 0xC0,
  0x0D, 0xF0, 0x7C, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0xF8, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x3E,
  0x3E, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x7C, 0x3C, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0x1E, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x1F, 0x83, 0xC0, 0x00, 0x7E, 0x0F, 0x80, 0x03, 0xF8, 0x3E, 0x00, 0x1B,
  0xC0, 0xFC, 0x00, 0xCF, 0x01, 0xFC, 0x0F, 0x7C, 0x07, 0xFF, 0xF9, 0xF0,
  0x0F, 0xFF, 0xC7, 0xC0, 0x1F, 0xFE, 0x1F, 0x00, 0x1F, 0xE0, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0xC0, 0x00,
  0xF8, 0x07, 0x80, 0x07, 0xE0, 0x3F, 0x80, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x0F,
  0xE0, 0x07, 0xC3, 0xFF, 0x00, 0x7C, 0x7F, 0xFC, 0x07, 0xCF, 0xFF, 0xC0,
  0x7D, 0xE0, 0xFE, 0x07, 0x98, 0x03, 0xE0, 0x7B, 0x00, 0x3E, 0x0F, 0xE0,
  0x01, 0xF0, 0xFC, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x1F,
  0x0F, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x1F, 0x00, 0x01, 0xE1, 0xF0,
  0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x3C, 0x3E, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x7C, 0x3E,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x78, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0xF8, 0x78, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x0C, 0x00, 0xF8,
  0x03, 0xC0, 0x1E, 0x00, 0xFC, 0x03, 0xC0, 0x3F, 0x00, 0xF8, 0x0F, 0xC0,
  0x1F, 0x03, 0xF0, 0x03, 0xE1, 0xFC, 0x00, 0x78, 0x7E, 0x00, 0x0F, 0x1F,
  0x80, 0x03, 0xE7, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x01, 0x00, 0x1F, 0x00, 0x38, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFE,
  0x01, 0xF0, 0x03, 0xF0, 0x1E, 0x00, 0x1F, 0x81, 0xE0, 0x00, 0xFC, 0x3E,
  0x00, 0x07, 0xE3, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF3, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x1F, 0xC0, 0x01, 0xF0, 0xFF, 0xE0,
  0x03, 0xE3, 0xFF, 0xE0, 0x07, 0xCF, 0xFF, 0xE0, 0x0F, 0xBC, 0x0F, 0xC0,
  0x1E, 0x60, 0x0F, 0x80, 0x3D, 0x80, 0x0F, 0x80, 0xFE, 0x00, 0x1F, 0x01,
  0xFC, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x78, 0x07, 0xC0, 0x01, 0xF0, 0x0F,
  0x80, 0x03, 0xE0, 0x1E, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x3F, 0x00, 0x07, 0x87,
  0xF8, 0x00, 0x0F, 0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7C, 0x3E,
  0x00, 0x00, 0xF8, 0x3E, 0x00, 0x61, 0xF0, 0x7C, 0x01, 0xE3, 0xC0, 0x78,
  0x07, 0xE7, 0x80, 0xF8, 0x1F, 0x9F, 0x00, 0xF0, 0x7E, 0x3E, 0x01, 0xF1,
  0xF8, 0x7C, 0x03, 0xE7, 0xE0, 0xF8, 0x03, 0xFF, 0x81, 0xE0, 0x07, 0xFC,
  0x03, 0xC0, 0x07, 0xF0, 0x08, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x0C, 0x03, 0xC0, 0x0F, 0x03, 0xE0, 0x0F, 0xC1, 0xF0, 0x0F, 0xC0, 0xF8,
  0x0F, 0x80, 0x7C, 0x1F, 0x80, 0x3C, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x1F,
  0x1F, 0x80, 0x0F, 0x9F, 0x80, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x7C, 0x03, 0xCF,
  0xF0, 0xFF, 0x01, 0xEF, 0xF8, 0xFF, 0xC1, 0xF7, 0xFE, 0xFF, 0xE0, 0xFE,
  0x1F, 0x71, 0xF0, 0x7A, 0x07, 0xE0, 0x7C, 0x3E, 0x03, 0xF0, 0x3E, 0x1F,
  0x01, 0xF0, 0x1E, 0x1F, 0x00, 0xF8, 0x0F, 0x0F, 0x80, 0x78, 0x07, 0x87,
  0x80, 0x7C, 0x03, 0xC3, 0xC0, 0x3E, 0x01, 0xE1, 0xE0, 0x1E, 0x01, 0xF0,
  0xF0, 0x0F, 0x00, 0xF8, 0xF8, 0x07, 0x80, 0x78, 0x7C, 0x03, 0xC0, 0x3C,
  0x3C, 0x03, 0xE0, 0x1E, 0x1E, 0x01, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0x0F,
  0x87, 0x80, 0x78, 0x07, 0xC7, 0xC0, 0x3C, 0x03, 0xC3, 0xE0, 0x1E, 0x01,
  0xE1, 0xE0, 0x1F, 0x00, 0xF0, 0xF0, 0x0F, 0x80, 0x78, 0x78, 0x07, 0x80,
  0x7C, 0x3C, 0x03, 0xC0, 0x3E, 0x3E, 0x01, 0xE0, 0x1E, 0x1F, 0x00, 0xF0,
  0x0F, 0x0F, 0x00, 0xF8, 0x07, 0x87, 0x80, 0x7C, 0x03, 0xC3, 0xC0, 0x3C,
  0x03, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x7C, 0x3F, 0xF0, 0x07, 0xC7, 0xFF,
  0xC0, 0x7C, 0xFF, 0xFC, 0x07, 0xDE, 0x0F, 0xE0, 0x79, 0x80, 0x3E, 0x07,
  0xB0, 0x03, 0xE0, 0xFE, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF0, 0xFC, 0x00,
  0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE1,
  0xF0, 0x00, 0x1E, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x1F, 0x00,
  0x03, 0xE1, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x3C,
  0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3, 0xC0,
  0x00, 0x78, 0x3C, 0x00, 0x07, 0x87, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x87, 0x80, 0x00, 0xF0, 0xF8,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x00, 0x7C,
  0x1F, 0x80, 0x03, 0xC1, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xE3, 0xE0,
  0x00, 0x1E, 0x7C, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x00, 0x00,
  0x3E, 0xF0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0xF8, 0x78, 0x00, 0x1F, 0x87, 0xC0, 0x01, 0xF0, 0x7E, 0x00,
  0x7E, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03,
  0xE1, 0xFF, 0xC0, 0x07, 0xC7, 0xFF, 0xC0, 0x0F, 0x1F, 0xFF, 0xC0, 0x1E,
  0x78, 0x1F, 0xC0, 0x7D, 0xC0, 0x1F, 0x80, 0xFB, 0x00, 0x1F, 0x01, 0xFC,
  0x00, 0x1F, 0x03, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80,
  0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x1F, 0x07, 0x80, 0x00,
  0x3E, 0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x80, 0x01, 0xF0, 0x3F, 0x00, 0x07, 0xE0,
  0x7F, 0x00, 0x1F, 0x80, 0xF7, 0x80, 0xFE, 0x01, 0xE7, 0xFF, 0xF8, 0x07,
  0xC7, 0xFF, 0xE0, 0x0F, 0x87, 0xFF, 0x80, 0x1F, 0x03, 0xF8, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFF,
  0x83, 0xC0, 0x7F, 0xFF, 0x3E, 0x07, 0xFF, 0xF9, 0xF0, 0x7F, 0x81, 0xEF,
  0x87, 0xE0, 0x03, 0x7C, 0x3E, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x3E, 0x1F,
  0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C, 0x78, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x0F,
  0x8F, 0x80, 0x00, 0x7C, 0x78, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F, 0x3E,
  0x00, 0x00, 0xF1, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C, 0x7C, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x3F, 0x0F, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x17,
  0x83, 0xE0, 0x01, 0xBC, 0x1F, 0x80, 0x3B, 0xE0, 0x7F, 0x07, 0xDF, 0x03,
  0xFF, 0xFC, 0xF8, 0x0F, 0xFF, 0xC7, 0x80, 0x3F, 0xF8, 0x3C, 0x00, 0x7F,
  0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x7F, 0xFC, 0x07, 0xFB, 0xFF, 0xE1,
  0xFF, 0x9F, 0xFF, 0x1F, 0xFD, 0xFF, 0xF9, 0xFF, 0xE0, 0x07, 0x9E, 0x00,
  0x00, 0x3D, 0xC0, 0x00, 0x03, 0xEC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x03, 0xF8, 0x07,
  0xF0, 0x7E, 0x00, 0x1F, 0x07, 0x80, 0x00, 0xC0, 0xF8, 0x00, 0x08, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC2, 0x00, 0x00, 0x3C, 0x30, 0x00, 0x07, 0xC7, 0x80,
  0x00, 0x7C, 0xFE, 0x00, 0x0F, 0x87, 0xF8, 0x07, 0xF8, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x40, 0x3C, 0x00, 0x38, 0x0F, 0x00, 0x3E, 0x07, 0xC0, 0x1F, 0xC1, 0xF0,
  0x1F, 0xC0, 0x7C, 0x0F, 0xE0, 0x1F, 0x0F, 0xE0, 0x07, 0x87, 0xF0, 0x01,
  0xF7, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x7C,
  0x00, 0x0F, 0x8F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x7C, 0x00, 0x0F,
  0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7, 0x80,
  0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8,
  0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x78, 0x78, 0x00,
  0x0F, 0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F,
  0x80, 0x03, 0xF1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x87, 0xC0, 0x07,
  0xF0, 0xF8, 0x01, 0xFE, 0x1F, 0x80, 0x77, 0xC1, 0xF8, 0x3C, 0xF8, 0x3F,
  0xFF, 0x9E, 0x03, 0xFF, 0xE3, 0xC0, 0x3F, 0xF0, 0xF8, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xCF, 0xFF, 0x00, 0x3E, 0xFF, 0xE0, 0x03, 0xEF,
  0xFE, 0x00, 0x3E, 0xFF, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0,
  0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xC0, 0x01, 0xF0, 0x3C, 0x00, 0x1F,
  0x03, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C,
  0x00, 0x1E, 0x07, 0x80, 0x03, 0xE0, 0x78, 0x00, 0x3E, 0x07, 0x80, 0x03,
  0xE0, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x0F,
  0x00, 0x1F, 0x80, 0xF0, 0x01, 0xF0, 0x0F, 0x00, 0x3E, 0x01, 0xF0, 0x07,
  0xE0, 0x1F, 0x01, 0xFC, 0x01, 0xF0, 0x7F, 0x80, 0x1F, 0x1F, 0xF0, 0x01,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x7C, 0x07, 0xC1, 0xE1, 0xE0, 0x1E,
  0x07, 0xC7, 0x80, 0x78, 0x0F, 0x1E, 0x01, 0xE0, 0x3C, 0x78, 0x07, 0x80,
  0xF3, 0xE0, 0x1E, 0x03, 0xCF, 0x00, 0xF8, 0x0F, 0x3C, 0x03, 0xC0, 0x3C,
  0xF0, 0x0F, 0x00, 0xF3, 0xC0, 0x3C, 0x03, 0xCF, 0x00, 0xF0, 0x0F, 0x7C,
  0x03, 0xC0, 0x3D, 0xE0, 0x1F, 0x00, 0xF7, 0x80, 0x78, 0x03, 0xDE, 0x01,
  0xE0, 0x0F, 0x78, 0x07, 0x80, 0x3D, 0xE0, 0x1E, 0x01, 0xFF, 0x80, 0x78,
  0x07, 0xBC, 0x03, 0xE0, 0x1E, 0xF0, 0x0F, 0x00, 0x7B, 0xC0, 0x3C, 0x03,
  0xEF, 0x00, 0xF0, 0x0F, 0x3C, 0x07, 0xC0, 0x7C, 0xF0, 0x1F, 0x01, 0xE3,
  0xC0, 0xDC, 0x0F, 0x8F, 0x03, 0x70, 0x7C, 0x3E, 0x39, 0xE3, 0xF0, 0xFF,
  0xE7, 0xFF, 0x83, 0xFF, 0x1F, 0xFC, 0x07, 0xF8, 0x3F, 0xE0, 0x0F, 0xC0,
  0x7E, 0x00, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x01,
  0xFF, 0x07, 0xFF, 0x00, 0xFF, 0xF1, 0xFF, 0xE0, 0x3F, 0x9E, 0x3C, 0x3E,
  0x1F, 0xC3, 0xCF, 0x07, 0xC7, 0xF0, 0x79, 0xC0, 0xF8, 0xF8, 0x0F, 0x70,
  0x0F, 0x0C, 0x01, 0xEE, 0x01, 0xE1, 0x00, 0x3D, 0x80, 0x3C, 0x00, 0x07,
  0xB0, 0x0F, 0x80, 0x00, 0xFC, 0x01, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x01, 0x80, 0x3F, 0x00, 0x00, 0xF0, 0x07,
  0xE0, 0x00, 0x3E, 0x01, 0xFC, 0x00, 0x87, 0xC0, 0x37, 0x80, 0x78, 0xF8,
  0x0E, 0xF0, 0x1F, 0x1F, 0x01, 0xDE, 0x0F, 0xD3, 0xE0, 0x73, 0xE3, 0xF0,
  0x3E, 0x3E, 0x3C, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0x00, 0xFF, 0xE0, 0xFF,
  0xC0, 0x0F, 0xF8, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF0, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x78, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x1E, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x3E,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0x00,
  0x01, 0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x01,
  0xF8, 0x1F, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x3F, 0x01, 0xF0, 0x01, 0xBC,
  0x07, 0xC0, 0x07, 0xF0, 0x1F, 0x80, 0x77, 0xC0, 0x3F, 0x03, 0xDF, 0x00,
  0xFF, 0xFE, 0x7C, 0x01, 0xFF, 0xF1, 0xE0, 0x03, 0xFF, 0x87, 0x80, 0x03,
  0xF8, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x20, 0x00, 0x3E, 0x01, 0xE0, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0,
  0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0x01, 0xF0,
  0x3F, 0xFF, 0x07, 0xC1, 0xFF, 0xFF, 0x1F, 0x0F, 0xC1, 0xFF, 0x78, 0x3C,
  0x00, 0xFF, 0xE1, 0xF0, 0x00, 0xFF, 0x07, 0x80, 0x01, 0xF8, 0x1E, 0x00,
  0x0F, 0xC0, 0x78, 0x00, 0x7E, 0x01, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xE0, 0x04, 0x00, 0x3F, 0x00, 0xF0, 0x01, 0xF8, 0x03, 0xC0, 0x0F,
  0xC0, 0x07, 0x80, 0x7C, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x78, 0x1F, 0x00,
  0x01, 0xF0, 0xFF, 0xC0, 0x07, 0xC7, 0xFF, 0xF8, 0x0F, 0x1E, 0x7F, 0xFE,
  0x3C, 0xF8, 0x3F, 0xFF, 0xF3, 0xE0, 0x1F, 0xFF, 0x8F, 0x80, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x18, 0x07, 0xF8, 0x00,
  0x7C, 0x3F, 0xF8, 0x00, 0xF0, 0x7F, 0xF8, 0x01, 0xE1, 0xF1, 0xF0, 0x07,
  0x87, 0xC1, 0xF0, 0x0F, 0x0F, 0x01, 0xE0, 0x3C, 0x3E, 0x03, 0xE0, 0xF8,
  0x78, 0x03, 0xE3, 0xE0, 0xF0, 0x03, 0xFF, 0xC3, 0xC0, 0x07, 0xFF, 0x07,
  0x80, 0x07, 0xFC, 0x02, 0x00, 0x03, 0xE0, 0x00,
};

const GFXglyph IBMPlexMono_Italic59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 14, 42, 35, 11, -41 },
  { 75, 18, 16, 35, 12, -44 },
  { 111, 36, 41, 35, 1, -41 },
  { 296, 34, 55, 35, 1, -48 },
  { 530, 40, 43, 35, -1, -42 },
  { 745, 35, 43, 35, 0, -42 },
  { 934, 7, 16, 35, 18, -44 },
  { 948, 22, 53, 35, 12, -45 },
  { 1094, 22, 53, 35, 2, -45 },
  { 1240, 30, 29, 35, 3, -32 },
  { 1349, 28, 28, 35, 4, -32 },
  { 1447, 13, 16, 35, 8, -8 },
  { 1473, 18, 4, 35, 9, -20 },
  { 1482, 9, 8, 35, 11, -7 },
  { 1491, 34, 53, 35, 1, -45 },
  { 1717, 30, 43, 35, 4, -42 },
  { 1879, 29, 41, 35, 2, -41 },
  { 2028, 31, 42, 35, 2, -42 },
  { 2191, 31, 43, 35, 1, -42 },
  { 2358, 32, 41, 35, 1, -41 },
  { 2522, 31, 42, 35, 3, -41 },
  { 2685, 28, 42, 35, 4, -41 },
  { 2832, 30, 41, 35, 6, -41 },
  { 2986, 32, 43, 35, 2, -42 },
  { 3158, 28, 42, 35, 5, -42 },
  { 3305, 13, 31, 35, 11, -30 },
  { 3356, 16, 38, 35, 8, -30 },
  { 3432, 29, 34, 35, 5, -35 },
  { 3556, 30, 16, 35, 3, -26 },
  { 3616, 28, 34, 35, 3, -35 },
  { 3735, 25, 43, 35, 8, -42 },
  { 3870, 30, 49, 35, 3, -42 },
  { 4054, 32, 41, 35, -1, -41 },
  { 4218, 30, 41, 35, 3, -41 },
  { 4372, 29, 43, 35, 5, -42 },
  { 4528, 30, 41, 35, 3, -41 },
  { 4682, 32, 41, 35, 3, -41 },
  { 4846, 33, 41, 35, 3, -41 },
  { 5016, 30, 43, 35, 4, -42 },
  { 5178, 33, 41, 35, 2, -41 },
  { 5348, 33, 41, 35, 2, -41 },
  { 5518, 30, 42, 35, 3, -41 },
  { 5676, 35, 41, 35, 3, -41 },
  { 5856, 25, 41, 35, 5, -41 },
  { 5985, 34, 41, 35, 2, -41 },
  { 6160, 33, 41, 35, 2, -41 },
  { 6330, 30, 43, 35, 4, -42 },
  { 6492, 31, 41, 35, 3, -41 },
  { 6651, 30, 53, 35, 4, -42 },
  { 6850, 31, 41, 35, 3, -41 },
  { 7009, 33, 43, 35, 1, -42 },
  { 7187, 33, 41, 35, 5, -41 },
  { 7357, 31, 42, 35, 4, -41 },
  { 7520, 31, 41, 35, 6, -41 },
  { 7679, 35, 41, 35, 3, -41 },
  { 7859, 39, 41, 35, -1, -41 },
  { 8059, 34, 41, 35, 5, -41 },
  { 8234, 36, 41, 35, 0, -41 },
  { 8419, 26, 53, 35, 9, -45 },
  { 8592, 15, 53, 35, 11, -45 },
  { 8692, 25, 53, 35, 1, -45 },
  { 8858, 30, 24, 35, 4, -41 },
  { 8948, 29, 4, 35, 0, 6 },
  { 8963, 7, 11, 35, 14, -46 },
  { 8973, 29, 32, 35, 3, -31 },
  { 9089, 29, 45, 35, 3, -44 },
  { 9253, 27, 32, 35, 4, -31 },
  { 9361, 32, 45, 35, 3, -44 },
  { 9541, 27, 32, 35, 4, -31 },
  { 9649, 39, 57, 35, -1, -44 },
  { 9927, 30, 44, 35, 2, -31 },
  { 10092, 28, 44, 35, 3, -44 },
  { 10246, 27, 45, 35, 5, -44 },
  { 10398, 28, 57, 35, 3, -44 },
  { 10598, 31, 45, 35, 3, -44 },
  { 10773, 25, 45, 35, 6, -44 },
  { 10914, 33, 31, 35, 1, -31 },
  { 11042, 28, 31, 35, 3, -31 },
  { 11151, 28, 32, 35, 4, -31 },
  { 11263, 31, 43, 35, 1, -31 },
  { 11430, 29, 43, 35, 3, -31 },
  { 11586, 29, 30, 35, 6, -30 },
  { 11695, 28, 32, 35, 3, -31 },
  { 11807, 26, 42, 35, 5, -41 },
  { 11944, 27, 31, 35, 5, -30 },
  { 12049, 28, 31, 35, 4, -31 },
  { 12158, 30, 32, 35, 3, -31 },
  { 12278, 35, 32, 35, 0, -31 },
  { 12418, 30, 43, 35, 2, -30 },
  { 12580, 30, 32, 35, 3, -31 },
  { 12700, 27, 53, 35, 7, -45 },
  { 12879, 13, 53, 35, 12, -45 },
  { 12966, 27, 53, 35, 3, -45 },
  { 13145, 31, 13, 35, 3, -24 },
};

const GFXfont IBMPlexMono_Italic59pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic59pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic59pt7bGlyphs,
  0x20, 0x7E, 77
};

#endif // _IBMPLEXMONO_ITALIC59PT7B_H_
