#ifndef _IBMPLEXMONO_ITALIC32PT7B_H_
#define _IBMPLEXMONO_ITALIC32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x1C, 0x38, 0x70, 0xE1, 0x83, 0x0E, 0x1C, 0x30, 0x60, 0xC1,
  0x82, 0x04, 0x00, 0x00, 0x01, 0xE7, 0xCF, 0x8E, 0x00, 0x71, 0xB0, 0xD8,
  0xEC, 0x7E, 0x37, 0x1B, 0x8D, 0x86, 0xC7, 0x00, 0x00, 0x31, 0xC0, 0x07,
  0x1C, 0x00, 0x61, 0x80, 0x06, 0x38, 0x00, 0xE3, 0x80, 0x0C, 0x30, 0x00,
  0xC7, 0x01, 0xFC, 0x7F, 0x1F, 0x87, 0xF0, 0x18, 0xE0, 0x03, 0x8C, 0x00,
  0x30, 0xC0, 0x07, 0x1C, 0x07, 0xE1, 0xFC, 0xFE, 0x1F, 0x80, 0xE3, 0x80,
  0x0C, 0x30, 0x00, 0xC3, 0x00, 0x1C, 0x70, 0x01, 0x86, 0x00, 0x18, 0x60,
  0x03, 0x8E, 0x00, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x07, 0xF0,
  0x07, 0xFF, 0x03, 0x99, 0xE1, 0xC6, 0x1C, 0xE1, 0x84, 0x38, 0x60, 0x0E,
  0x18, 0x03, 0x86, 0x00, 0x73, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x03, 0x78, 0x00, 0xC7, 0x00, 0x61, 0xC0, 0x18, 0x70, 0x06, 0x1C,
  0x41, 0x87, 0x38, 0x63, 0x87, 0x91, 0xC0, 0xFF, 0xE0, 0x0F, 0xE0, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0xE0, 0x1C, 0x1F, 0xC0, 0x60,
  0xE3, 0x03, 0x03, 0x06, 0x1C, 0x1C, 0x18, 0x60, 0x60, 0xE3, 0x01, 0x83,
  0x98, 0x06, 0x0C, 0xE0, 0x1C, 0x73, 0x00, 0x3F, 0x98, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x01, 0x9F, 0xC0, 0x0C, 0x61, 0x80, 0x73, 0x06, 0x01,
  0x8C, 0x18, 0x0C, 0x30, 0x60, 0x71, 0xC1, 0x81, 0x83, 0x0E, 0x0C, 0x0C,
  0x70, 0x70, 0x3F, 0x83, 0x80, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xC0,
  0x0E, 0x38, 0x03, 0x83, 0x80, 0x60, 0x70, 0x0C, 0x0E, 0x01, 0x81, 0xC0,
  0x38, 0x38, 0x07, 0x0E, 0x00, 0x61, 0x80, 0x7F, 0xE0, 0x1C, 0xE0, 0x07,
  0x1C, 0x00, 0xC1, 0xC0, 0x38, 0x38, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x5C,
  0x0F, 0x1F, 0x81, 0x67, 0x38, 0x6E, 0xC7, 0xF8, 0xF8, 0x3E, 0x0E, 0x00,
  0x33, 0x37, 0x76, 0x66, 0xE0, 0x00, 0xF0, 0x1C, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0x60, 0x06, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x07,
  0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x70, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00,
  0x60, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0xE1, 0x83, 0xFD, 0xBF, 0x3F, 0xFC, 0x0F, 0xE0, 0x07,
  0xC0, 0x0E, 0xC0, 0x1C, 0xE0, 0x1C, 0x60, 0x38, 0x70, 0x70, 0x30, 0x20,
  0x20, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x1F, 0x1E, 0x1C,
  0x3C, 0x38, 0x38, 0x70, 0x60, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFE, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xFC, 0x0E, 0x0E, 0x1C, 0x07, 0x38,
  0x07, 0x38, 0x03, 0x70, 0x03, 0x70, 0x03, 0x60, 0x03, 0x61, 0xC7, 0xE3,
  0xC7, 0xE3, 0xC7, 0xE3, 0x87, 0xE0, 0x06, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0,
  0x0C, 0xE0, 0x1C, 0x60, 0x38, 0x70, 0x70, 0x3F, 0xE0, 0x1F, 0x80, 0x00,
  0xF8, 0x01, 0xF8, 0x03, 0xB8, 0x07, 0x38, 0x1E, 0x30, 0x3C, 0x30, 0x18,
  0x70, 0x20, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xF8, 0x03, 0xFF, 0x03,
  0xC3, 0xC3, 0x80, 0xE1, 0xC0, 0x39, 0x40, 0x1C, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07,
  0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x0F, 0xFF, 0xE7, 0xFF, 0xF0, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xC3,
  0xC3, 0x80, 0xE0, 0x80, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x20, 0x07, 0x38, 0x07, 0x1E, 0x07,
  0x87, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0x6C, 0x00, 0x3B, 0x00, 0x1C, 0xC0, 0x0E, 0x70, 0x07, 0x1C, 0x01,
  0x87, 0x00, 0xE1, 0x80, 0x70, 0x60, 0x38, 0x18, 0x1C, 0x0E, 0x06, 0x03,
  0x83, 0x80, 0xE1, 0xC0, 0x30, 0x7F, 0xFF, 0xDF, 0xFF, 0xE8, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x0C,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x31,
  0xF0, 0x37, 0xF8, 0x3C, 0x3C, 0x70, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x40, 0x1C, 0xE0, 0x3C, 0xF0, 0x78, 0x7F,
  0xF0, 0x1F, 0xC0, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x39, 0xF0, 0xEF, 0xF9, 0xB0, 0x73,
  0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x3B, 0x80, 0x73, 0x83, 0xC3, 0xFF, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0x7F,
  0xFF, 0x60, 0x07, 0x60, 0x0E, 0x60, 0x0E, 0xE0, 0x1C, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03,
  0x80, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0x83, 0xC1, 0xE3,
  0x80, 0x71, 0xC0, 0x38, 0xE0, 0x1C, 0x60, 0x0E, 0x38, 0x06, 0x0E, 0x0E,
  0x03, 0xFE, 0x01, 0xFE, 0x03, 0x81, 0xC3, 0x80, 0x73, 0x80, 0x39, 0x80,
  0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x03, 0x9C, 0x03, 0x8F, 0x07, 0x83,
  0xFF, 0x80, 0x7F, 0x00, 0x07, 0xE0, 0x3F, 0xF0, 0xF0, 0x73, 0x80, 0x66,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0xC0, 0x3F, 0x80,
  0x73, 0x83, 0xE7, 0xFD, 0x83, 0xE7, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x1E, 0x7C,
  0xF8, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x3E, 0x7C,
  0x70, 0x07, 0x87, 0xC3, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x78, 0x38, 0x3C, 0x1C, 0x0E, 0x0E, 0x06,
  0x07, 0x00, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x20,
  0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFE, 0xFF, 0xFE, 0x20, 0x00, 0x70, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x3C, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x00, 0xC0, 0x01,
  0x00, 0x00, 0x0F, 0xE0, 0x7F, 0xC7, 0x83, 0x9C, 0x06, 0xE0, 0x1C, 0x80,
  0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x01, 0xE0, 0x3F, 0x03, 0xF0, 0x0F,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x10, 0x00, 0x00, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x0E, 0x0E, 0x1C,
  0x07, 0x38, 0x03, 0x30, 0x03, 0x30, 0xF3, 0x71, 0xFB, 0x63, 0x8F, 0x63,
  0x07, 0x67, 0x06, 0xE7, 0x06, 0xE7, 0x06, 0xE6, 0x06, 0xC6, 0x0E, 0xC6,
  0x0C, 0xC7, 0x1C, 0xC7, 0xEC, 0xC3, 0xEC, 0xC0, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x78, 0x00, 0x3F, 0xE0, 0x0F, 0xE0, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x0D, 0x80, 0x0E, 0xC0, 0x06, 0x70, 0x07, 0x38,
  0x03, 0x1C, 0x03, 0x8E, 0x01, 0x83, 0x01, 0xC1, 0x80, 0xC0, 0xC0, 0xE0,
  0x70, 0x7F, 0xF8, 0x7F, 0xFC, 0x30, 0x0E, 0x38, 0x03, 0x18, 0x01, 0x9C,
  0x00, 0xCE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1C, 0x0F, 0xFC, 0x07, 0xFF,
  0x03, 0x01, 0xC1, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x38,
  0x06, 0x18, 0x07, 0x0C, 0x07, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0x80, 0xE1,
  0xC0, 0x38, 0xC0, 0x1C, 0x60, 0x0E, 0x70, 0x07, 0x38, 0x03, 0x9C, 0x03,
  0x8E, 0x03, 0x87, 0xFF, 0x87, 0xFF, 0x80, 0x01, 0xF8, 0x01, 0xFF, 0x03,
  0xC3, 0xC1, 0xC0, 0xE1, 0xC0, 0x39, 0xC0, 0x20, 0xE0, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x0E, 0x38, 0x07, 0x1C, 0x07, 0x07,
  0x07, 0x01, 0xFF, 0x00, 0x7E, 0x00, 0x1F, 0xF0, 0x1F, 0xFC, 0x1C, 0x1E,
  0x1C, 0x0E, 0x18, 0x07, 0x18, 0x07, 0x38, 0x07, 0x38, 0x07, 0x38, 0x07,
  0x38, 0x07, 0x30, 0x07, 0x30, 0x07, 0x70, 0x07, 0x70, 0x06, 0x70, 0x0E,
  0x70, 0x0E, 0x60, 0x0C, 0x60, 0x1C, 0xE0, 0x38, 0xE0, 0x70, 0xFF, 0xE0,
  0xFF, 0x80, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xC0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0xFF, 0xF0, 0xFF, 0xFC, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x7F,
  0xFE, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xC0, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0xFF, 0xF0, 0xFF, 0xF8, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xFE, 0x0F, 0x0E,
  0x1C, 0x07, 0x18, 0x03, 0x38, 0x04, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0xE0, 0xFE, 0xE0, 0xFE, 0xE0, 0x0E, 0xE0, 0x0E,
  0xE0, 0x0C, 0xE0, 0x0C, 0xE0, 0x1C, 0x70, 0x3C, 0x78, 0x7C, 0x3F, 0xDC,
  0x1F, 0x18, 0x0E, 0x01, 0xC3, 0x00, 0x70, 0xC0, 0x1C, 0x70, 0x06, 0x1C,
  0x01, 0x87, 0x00, 0xE1, 0xC0, 0x38, 0x60, 0x0E, 0x18, 0x03, 0x8E, 0x00,
  0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x30, 0x07, 0x0C, 0x01, 0xC3, 0x00, 0x61,
  0xC0, 0x18, 0x70, 0x0E, 0x1C, 0x03, 0x86, 0x00, 0xE1, 0x80, 0x38, 0xE0,
  0x0C, 0x38, 0x03, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x7F, 0xFC, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x38, 0xE0, 0x38, 0xE0, 0x70, 0x70, 0xF0, 0x7F, 0xE0,
  0x1F, 0x80, 0x0E, 0x00, 0xF0, 0xE0, 0x1C, 0x0C, 0x03, 0x80, 0xC0, 0x70,
  0x1C, 0x0E, 0x01, 0xC1, 0xC0, 0x1C, 0x38, 0x01, 0x87, 0x00, 0x18, 0xE0,
  0x03, 0x9C, 0x00, 0x3B, 0xE0, 0x03, 0xFE, 0x00, 0x3E, 0x70, 0x03, 0xC7,
  0x00, 0x38, 0x38, 0x07, 0x03, 0x80, 0x70, 0x18, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x06, 0x00, 0xE0, 0x60, 0x0E, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x38,
  0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x1E, 0x01, 0xC7, 0x80, 0xF1, 0xE0, 0x7C, 0x7C, 0x1F, 0x1B, 0x0F, 0xC6,
  0xC3, 0x63, 0xB1, 0xD8, 0xEE, 0xE6, 0x39, 0xB1, 0x8C, 0x7C, 0xE3, 0x1E,
  0x38, 0xC7, 0x0C, 0x70, 0xC3, 0x1C, 0x20, 0xC7, 0x08, 0x31, 0x80, 0x1C,
  0x60, 0x07, 0x18, 0x01, 0x8E, 0x00, 0x63, 0x80, 0x18, 0xE0, 0x0E, 0x30,
  0x03, 0x80, 0x0F, 0x01, 0xC3, 0xC0, 0x70, 0xF0, 0x1C, 0x7E, 0x06, 0x1F,
  0x81, 0x87, 0x60, 0x61, 0x98, 0x38, 0x66, 0x0E, 0x19, 0xC3, 0x8E, 0x30,
  0xC3, 0x8C, 0x30, 0xC3, 0x0C, 0x30, 0xE7, 0x0C, 0x39, 0xC3, 0x06, 0x61,
  0xC1, 0x98, 0x70, 0x76, 0x18, 0x1D, 0x86, 0x03, 0xE1, 0x80, 0xF8, 0xE0,
  0x3C, 0x38, 0x0F, 0x00, 0x01, 0xF8, 0x07, 0xFC, 0x0E, 0x0E, 0x1C, 0x07,
  0x38, 0x07, 0x38, 0x03, 0x70, 0x03, 0x70, 0x03, 0x70, 0x03, 0x60, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x06, 0xE0, 0x0E, 0xE0, 0x0E,
  0xE0, 0x0C, 0xE0, 0x1C, 0x60, 0x38, 0x70, 0x70, 0x3F, 0xE0, 0x1F, 0x80,
  0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xC0, 0x38, 0x30, 0x07, 0x1C, 0x01, 0xC7,
  0x00, 0x71, 0xC0, 0x1C, 0x70, 0x06, 0x18, 0x03, 0x86, 0x01, 0xC3, 0xFF,
  0xE0, 0xFF, 0xF0, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xF8, 0x07, 0xFC, 0x0E, 0x0E, 0x1C, 0x07, 0x38, 0x07,
  0x38, 0x03, 0x70, 0x03, 0x70, 0x03, 0x70, 0x03, 0x60, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x06, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0C,
  0xE0, 0x1C, 0x60, 0x38, 0x70, 0x70, 0x3F, 0xE0, 0x1F, 0x80, 0x03, 0x00,
  0x03, 0x84, 0x01, 0xC6, 0x00, 0xDC, 0x00, 0xF8, 0x00, 0x70, 0x0F, 0xFE,
  0x03, 0xFF, 0xC0, 0xC0, 0x38, 0x30, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x71,
  0xC0, 0x1C, 0x70, 0x06, 0x18, 0x03, 0x86, 0x01, 0xC3, 0xFF, 0xE0, 0xFF,
  0xE0, 0x38, 0x60, 0x0E, 0x1C, 0x03, 0x07, 0x00, 0xC0, 0xC0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x01, 0xC1, 0xC0, 0x70, 0x60, 0x0C, 0x38, 0x03, 0x80,
  0x01, 0xFC, 0x01, 0xFF, 0xC0, 0xF0, 0x78, 0x70, 0x07, 0x18, 0x01, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0xC0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x10, 0x01, 0xCE, 0x00, 0xE1, 0xE0, 0xF0, 0x3F, 0xF8, 0x03,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x03, 0x8C, 0x01, 0xCE, 0x00, 0xE7, 0x00,
  0x63, 0x80, 0x31, 0xC0, 0x38, 0xC0, 0x1C, 0x60, 0x0E, 0x70, 0x06, 0x38,
  0x03, 0x1C, 0x01, 0x8E, 0x01, 0xC6, 0x00, 0xE3, 0x00, 0x73, 0x80, 0x31,
  0xC0, 0x18, 0xE0, 0x1C, 0x70, 0x0E, 0x18, 0x0E, 0x0E, 0x0F, 0x03, 0xFF,
  0x00, 0xFE, 0x00, 0xE0, 0x03, 0xB0, 0x01, 0xD8, 0x01, 0xCC, 0x00, 0xE7,
  0x00, 0xE3, 0x80, 0x71, 0xC0, 0x30, 0xE0, 0x38, 0x30, 0x18, 0x18, 0x1C,
  0x0C, 0x0C, 0x06, 0x0E, 0x03, 0x86, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x33,
  0x80, 0x19, 0xC0, 0x0C, 0xC0, 0x06, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x67, 0x00, 0x0C, 0xE0, 0x03, 0x98, 0x00, 0x73,
  0x00, 0x0C, 0x60, 0x01, 0x8C, 0x38, 0x71, 0x87, 0x0E, 0x31, 0xF1, 0x86,
  0x36, 0x31, 0xC6, 0xCE, 0x39, 0x99, 0xC7, 0x33, 0x30, 0xCE, 0x66, 0x19,
  0x8D, 0xC3, 0x31, 0xB8, 0x6C, 0x36, 0x0D, 0x86, 0xC1, 0xF0, 0xD8, 0x3C,
  0x1F, 0x07, 0x83, 0xC1, 0xF0, 0x78, 0x00, 0x07, 0x00, 0x3C, 0x1C, 0x01,
  0xC0, 0x38, 0x0F, 0x00, 0xE0, 0x38, 0x01, 0xC1, 0xC0, 0x07, 0x0E, 0x00,
  0x0E, 0x70, 0x00, 0x39, 0xC0, 0x00, 0x6E, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xFC, 0x00, 0x07, 0x70, 0x00, 0x1C, 0xC0,
  0x00, 0xE3, 0x80, 0x07, 0x06, 0x00, 0x38, 0x1C, 0x01, 0xC0, 0x30, 0x07,
  0x00, 0xE0, 0x38, 0x01, 0x83, 0xC0, 0x07, 0x00, 0xE0, 0x03, 0xF8, 0x00,
  0xE7, 0x00, 0x71, 0xC0, 0x38, 0x30, 0x0E, 0x0E, 0x07, 0x01, 0x83, 0x80,
  0x71, 0xC0, 0x1C, 0x70, 0x03, 0x38, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xFF,
  0xE1, 0xFF, 0xFC, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0xFF, 0xF9,
  0xFF, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0xE0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x0F, 0xF8, 0x3F, 0xE0, 0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x60, 0x60, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x18, 0x18, 0x18, 0x18, 0x0C, 0x0C, 0x0C, 0x0C,
  0x0C, 0x06, 0x06, 0x06, 0x06, 0x03, 0x03, 0x03, 0x07, 0xFC, 0x1F, 0xF0,
  0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x07, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0xF0, 0x00,
  0xF0, 0x01, 0xF0, 0x03, 0xB8, 0x07, 0x18, 0x06, 0x1C, 0x0E, 0x0C, 0x1C,
  0x0C, 0x38, 0x0E, 0x30, 0x06, 0x70, 0x07, 0xE0, 0x03, 0x40, 0x02, 0xFF,
  0xFF, 0xFF, 0xFE, 0x6E, 0x73, 0x31, 0x07, 0xC6, 0x3F, 0xCC, 0xF0, 0xF9,
  0xC0, 0x77, 0x00, 0xEC, 0x01, 0xB8, 0x03, 0x70, 0x06, 0xE0, 0x1D, 0x80,
  0x3B, 0x00, 0x76, 0x00, 0xCC, 0x03, 0x9C, 0x0B, 0x3C, 0x3E, 0x3F, 0xCF,
  0x3E, 0x1E, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x1C, 0x7C, 0x3B, 0xFC, 0x7C, 0x3C, 0xD0, 0x39, 0xC0,
  0x33, 0x00, 0x6E, 0x00, 0xDC, 0x01, 0xB8, 0x03, 0x60, 0x0E, 0xC0, 0x1D,
  0x80, 0x3F, 0x00, 0xEE, 0x01, 0xDF, 0x0F, 0x33, 0xFC, 0x63, 0xE0, 0x03,
  0xF0, 0x1F, 0xF0, 0x70, 0x71, 0xC0, 0x73, 0x00, 0x8E, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x46, 0x01, 0xCE,
  0x07, 0x0E, 0x1C, 0x1F, 0xF0, 0x0F, 0x80, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x0F, 0x8C,
  0x1F, 0xF6, 0x1E, 0x0B, 0x0E, 0x03, 0x8E, 0x01, 0xC6, 0x00, 0xE7, 0x00,
  0x73, 0x80, 0x31, 0xC0, 0x18, 0xC0, 0x1C, 0x60, 0x0E, 0x30, 0x07, 0x18,
  0x07, 0x8E, 0x07, 0x87, 0x86, 0xC1, 0xFE, 0xE0, 0x7C, 0x70, 0x03, 0xF0,
  0x1F, 0xF8, 0x78, 0x79, 0xC0, 0x73, 0x00, 0xEE, 0x01, 0xD8, 0x07, 0xB0,
  0x7E, 0xFF, 0xF1, 0xFE, 0x03, 0x80, 0x07, 0x00, 0x46, 0x00, 0xCE, 0x03,
  0x9E, 0x1E, 0x1F, 0xF8, 0x0F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x18, 0x38, 0x00,
  0xF0, 0xE0, 0x00, 0xE3, 0x80, 0x01, 0xCC, 0x00, 0x03, 0xB0, 0x00, 0x07,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xE3, 0x87, 0xF9, 0x87, 0x82, 0xC3,
  0x80, 0xE3, 0x80, 0x71, 0x80, 0x39, 0xC0, 0x18, 0xE0, 0x0C, 0x70, 0x06,
  0x38, 0x07, 0x18, 0x03, 0x8C, 0x01, 0xC7, 0x01, 0xC3, 0x81, 0xE0, 0xE1,
  0xB0, 0x7F, 0x98, 0x0F, 0x9C, 0x00, 0x0C, 0x00, 0x06, 0x08, 0x07, 0x0E,
  0x07, 0x03, 0xFF, 0x00, 0xFE, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x78, 0x39, 0xFC, 0x74,
  0x38, 0xF0, 0x31, 0xC0, 0x73, 0x80, 0xE6, 0x01, 0x9C, 0x03, 0x38, 0x06,
  0x70, 0x1C, 0xC0, 0x39, 0x80, 0x73, 0x00, 0xEE, 0x01, 0x9C, 0x03, 0x38,
  0x0E, 0x60, 0x1C, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x08, 0x38, 0x30, 0xC3,
  0x83, 0x1C, 0x1C, 0xE0, 0x77, 0x01, 0xF8, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x0F, 0xF8, 0x20, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x60, 0x60, 0xE0, 0xC0, 0xE1, 0x80, 0xE7, 0x00,
  0xEE, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0xF8, 0x3B, 0xFC,
  0x3A, 0x1C, 0x3C, 0x0E, 0x38, 0x0E, 0x38, 0x0C, 0x30, 0x1C, 0x70, 0x38,
  0x70, 0xF0, 0x77, 0x80, 0x63, 0x00, 0x63, 0x82, 0x63, 0x87, 0xE1, 0xCE,
  0xE1, 0xDC, 0xE0, 0xF8, 0xC0, 0x70, 0x7F, 0x81, 0xFE, 0x08, 0x38, 0x00,
  0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x08,
  0x70, 0x71, 0xC3, 0x86, 0x1C, 0x18, 0xE0, 0x6F, 0x01, 0xF0, 0x07, 0x80,
  0x19, 0xC3, 0x86, 0xF9, 0xF1, 0xC6, 0x9C, 0x71, 0xC3, 0x38, 0x70, 0xCE,
  0x18, 0x33, 0x06, 0x1C, 0xC1, 0x87, 0x30, 0xE1, 0x8C, 0x38, 0x67, 0x0C,
  0x19, 0xC3, 0x06, 0x60, 0xC3, 0x98, 0x30, 0xE6, 0x1C, 0x31, 0x87, 0x0C,
  0xE1, 0x83, 0x00, 0x18, 0xF0, 0x73, 0xF8, 0xE8, 0x71, 0xE0, 0x63, 0x80,
  0xE7, 0x01, 0xCC, 0x03, 0x38, 0x06, 0x70, 0x0C, 0xE0, 0x39, 0x80, 0x73,
  0x00, 0xE6, 0x01, 0xDC, 0x03, 0x38, 0x06, 0x70, 0x1C, 0xC0, 0x38, 0x03,
  0xF0, 0x1F, 0xF0, 0x70, 0x71, 0xC0, 0x77, 0x00, 0xEE, 0x00, 0xD8, 0x01,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x6E, 0x01, 0xCC,
  0x07, 0x1C, 0x1C, 0x1F, 0xF0, 0x0F, 0x80, 0x1C, 0x7C, 0x1D, 0xFE, 0x1F,
  0x0F, 0x1A, 0x07, 0x1C, 0x03, 0x18, 0x03, 0x38, 0x03, 0x38, 0x03, 0x38,
  0x03, 0x30, 0x07, 0x30, 0x07, 0x30, 0x07, 0x70, 0x0E, 0x70, 0x0E, 0x7C,
  0x3C, 0x67, 0xF8, 0x63, 0xE0, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x07, 0xC7, 0x1F, 0xF6, 0x3C, 0x16, 0x38,
  0x0E, 0x70, 0x0E, 0x60, 0x0E, 0xE0, 0x0C, 0xE0, 0x0C, 0xE0, 0x0C, 0xC0,
  0x1C, 0xC0, 0x1C, 0xC0, 0x1C, 0xC0, 0x38, 0xE0, 0x58, 0xF0, 0xD8, 0x7F,
  0xB8, 0x3F, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x70, 0x7F, 0x1F, 0x7F, 0x7F, 0x87, 0x40, 0x06, 0x80, 0x07,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x03, 0xF0, 0x1F, 0xF8, 0x70, 0x79, 0xC0, 0x23, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x01, 0xF0, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xD8, 0x03, 0xBC, 0x0E, 0x3F, 0xF8, 0x1F, 0xC0, 0x03, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0x80, 0x06, 0x03, 0xFF, 0xFF, 0xFF, 0xC3, 0x80, 0x0E,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06,
  0x02, 0x18, 0x1C, 0x61, 0xE3, 0x8E, 0x0E, 0xF0, 0x3F, 0x00, 0x78, 0x00,
  0x70, 0x0D, 0xC0, 0x37, 0x01, 0xD8, 0x07, 0x60, 0x1D, 0x80, 0x7E, 0x01,
  0xB8, 0x06, 0xE0, 0x3B, 0x00, 0xEC, 0x03, 0xB0, 0x0E, 0xC0, 0xF3, 0x82,
  0xCE, 0x17, 0x1F, 0xDC, 0x3C, 0x70, 0xFC, 0x05, 0xF8, 0x1C, 0x30, 0x38,
  0xE0, 0x31, 0xC0, 0x63, 0x80, 0xC6, 0x01, 0x8C, 0x07, 0x18, 0x0E, 0x30,
  0x18, 0xE0, 0x71, 0xC0, 0xC3, 0x83, 0x86, 0x0E, 0x0C, 0x78, 0x1F, 0xE0,
  0x1E, 0x00, 0x38, 0x61, 0x18, 0x31, 0xCC, 0x18, 0x66, 0x1C, 0x33, 0x0E,
  0x19, 0x86, 0x0D, 0xC3, 0x06, 0xE1, 0x83, 0x60, 0xC1, 0xB0, 0xE1, 0xD8,
  0x70, 0xCC, 0x30, 0x6E, 0x18, 0x77, 0x1C, 0x33, 0x9B, 0x38, 0xF9, 0xF8,
  0x78, 0x70, 0x00, 0x03, 0x83, 0xC1, 0xF9, 0xFC, 0x7B, 0x33, 0xBC, 0x6C,
  0x32, 0x0D, 0x06, 0x01, 0xA0, 0xC0, 0x38, 0x20, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x70, 0xF0, 0x0E, 0x16, 0x19, 0xC6, 0xC7,
  0xB9, 0x99, 0xC3, 0xF3, 0xF0, 0x78, 0x38, 0x00, 0x1C, 0x03, 0x1C, 0x03,
  0x1C, 0x07, 0x18, 0x07, 0x18, 0x07, 0x18, 0x06, 0x38, 0x06, 0x38, 0x06,
  0x38, 0x06, 0x38, 0x0E, 0x30, 0x0E, 0x30, 0x0C, 0x30, 0x1C, 0x38, 0x2C,
  0x38, 0x7C, 0x1F, 0xDC, 0x0F, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x40, 0x38,
  0xE0, 0xF0, 0xFF, 0xE0, 0x3F, 0x80, 0x0F, 0xC7, 0x1F, 0xF7, 0x30, 0x7F,
  0x70, 0x1E, 0x60, 0x1C, 0x60, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x0C, 0x1C, 0x0C, 0x38, 0x0C, 0x7C, 0x0E, 0xFF, 0xC6,
  0xC7, 0xFC, 0xC0, 0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x30, 0x00, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x83, 0xF8, 0x0F, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x70, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x06, 0x0C, 0x18, 0x30, 0xE1, 0x83, 0x06,
  0x0C, 0x18, 0x70, 0xC1, 0x83, 0x06, 0x0C, 0x38, 0x60, 0xC1, 0x83, 0x0E,
  0x1C, 0x30, 0x60, 0xC1, 0x87, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1F, 0xC0, 0x3F, 0x81, 0xC0,
  0x03, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x0F,
  0x01, 0x8F, 0xC0, 0xCE, 0x60, 0xC6, 0x18, 0x66, 0x0E, 0x63, 0x03, 0xF3,
  0x80, 0xF0,
};

const GFXglyph IBMPlexMono_Italic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 7, 22, 19, 6, -22 },
  { 21, 9, 9, 19, 7, -24 },
  { 32, 20, 22, 19, 0, -22 },
  { 87, 18, 28, 19, 1, -25 },
  { 150, 22, 22, 19, -1, -22 },
  { 211, 19, 22, 19, 0, -22 },
  { 264, 4, 9, 19, 9, -24 },
  { 269, 12, 28, 19, 7, -24 },
  { 311, 12, 28, 19, 1, -24 },
  { 353, 16, 16, 19, 2, -18 },
  { 385, 16, 16, 19, 2, -18 },
  { 417, 8, 9, 19, 4, -4 },
  { 426, 10, 2, 19, 5, -11 },
  { 429, 5, 4, 19, 6, -4 },
  { 432, 18, 28, 19, 1, -24 },
  { 495, 16, 22, 19, 2, -22 },
  { 539, 16, 22, 19, 1, -22 },
  { 583, 17, 22, 19, 1, -22 },
  { 630, 17, 22, 19, 1, -22 },
  { 677, 18, 22, 19, 0, -22 },
  { 727, 16, 22, 19, 2, -22 },
  { 771, 15, 22, 19, 2, -22 },
  { 813, 16, 22, 19, 3, -22 },
  { 857, 17, 22, 19, 1, -22 },
  { 904, 15, 22, 19, 3, -22 },
  { 946, 7, 17, 19, 6, -17 },
  { 961, 9, 22, 19, 4, -17 },
  { 986, 15, 18, 19, 3, -19 },
  { 1020, 16, 8, 19, 2, -14 },
  { 1036, 15, 18, 19, 2, -19 },
  { 1070, 14, 22, 19, 4, -22 },
  { 1109, 16, 26, 19, 2, -22 },
  { 1161, 17, 22, 19, 0, -22 },
  { 1208, 17, 22, 19, 1, -22 },
  { 1255, 17, 22, 19, 2, -22 },
  { 1302, 16, 22, 19, 2, -22 },
  { 1346, 18, 22, 19, 1, -22 },
  { 1396, 18, 22, 19, 1, -22 },
  { 1446, 16, 22, 19, 2, -22 },
  { 1490, 18, 22, 19, 1, -22 },
  { 1540, 18, 22, 19, 1, -22 },
  { 1590, 16, 22, 19, 2, -22 },
  { 1634, 20, 22, 19, 1, -22 },
  { 1689, 14, 22, 19, 2, -22 },
  { 1728, 18, 22, 19, 1, -22 },
  { 1778, 18, 22, 19, 1, -22 },
  { 1828, 16, 22, 19, 2, -22 },
  { 1872, 18, 22, 19, 1, -22 },
  { 1922, 16, 28, 19, 2, -22 },
  { 1978, 18, 22, 19, 1, -22 },
  { 2028, 18, 22, 19, 1, -22 },
  { 2078, 18, 22, 19, 3, -22 },
  { 2128, 17, 22, 19, 2, -22 },
  { 2175, 17, 22, 19, 3, -22 },
  { 2222, 19, 22, 19, 1, -22 },
  { 2275, 22, 22, 19, -1, -22 },
  { 2336, 18, 22, 19, 3, -22 },
  { 2386, 19, 22, 19, 0, -22 },
  { 2439, 14, 28, 19, 5, -24 },
  { 2488, 8, 28, 19, 6, -24 },
  { 2516, 14, 28, 19, 0, -24 },
  { 2565, 16, 13, 19, 2, -22 },
  { 2591, 16, 2, 19, 0, 3 },
  { 2595, 4, 6, 19, 7, -25 },
  { 2598, 15, 17, 19, 2, -17 },
  { 2630, 15, 24, 19, 2, -24 },
  { 2675, 15, 17, 19, 2, -17 },
  { 2707, 17, 24, 19, 2, -24 },
  { 2758, 15, 17, 19, 2, -17 },
  { 2790, 22, 30, 19, -1, -24 },
  { 2873, 17, 23, 19, 1, -17 },
  { 2922, 15, 24, 19, 2, -24 },
  { 2967, 14, 24, 19, 3, -24 },
  { 3009, 15, 30, 19, 2, -24 },
  { 3066, 16, 24, 19, 2, -24 },
  { 3114, 14, 24, 19, 3, -24 },
  { 3156, 18, 17, 19, 0, -17 },
  { 3195, 15, 17, 19, 2, -17 },
  { 3227, 15, 17, 19, 2, -17 },
  { 3259, 16, 23, 19, 1, -17 },
  { 3305, 16, 23, 19, 2, -17 },
  { 3351, 16, 17, 19, 3, -17 },
  { 3385, 15, 17, 19, 2, -17 },
  { 3417, 14, 22, 19, 3, -22 },
  { 3456, 14, 17, 19, 3, -17 },
  { 3486, 15, 17, 19, 2, -17 },
  { 3518, 17, 17, 19, 1, -17 },
  { 3555, 19, 17, 19, 0, -17 },
  { 3596, 16, 23, 19, 1, -17 },
  { 3642, 16, 17, 19, 2, -17 },
  { 3676, 14, 28, 19, 4, -24 },
  { 3725, 7, 28, 19, 6, -24 },
  { 3750, 15, 28, 19, 1, -24 },
  { 3803, 17, 7, 19, 1, -13 },
};

const GFXfont IBMPlexMono_Italic32pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic32pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic32pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _IBMPLEXMONO_ITALIC32PT7B_H_
