#ifndef _IBMPLEXMONO_ITALIC11PT7B_H_
#define _IBMPLEXMONO_ITALIC11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x29, 0x24, 0x36, 0x7A, 0xA0, 0x14, 0x29, 0x99, 0x42, 0x99, 0x94,
  0x28, 0x08, 0xF5, 0x54, 0x70, 0x71, 0x69, 0x78, 0x80, 0x72, 0xAA, 0x63,
  0x00, 0xCE, 0x95, 0x4E, 0x38, 0xA2, 0x8A, 0xF2, 0x4A, 0xDB, 0x68, 0x12,
  0x44, 0x88, 0x88, 0x46, 0x20, 0x84, 0x10, 0x88, 0x42, 0x26, 0x00, 0x21,
  0x3E, 0xC9, 0x00, 0x21, 0x3E, 0x44, 0x00, 0xE8, 0xE0, 0xF0, 0x06, 0x08,
  0x20, 0x41, 0x02, 0x08, 0x20, 0x41, 0x00, 0x7A, 0x63, 0x1A, 0xC6, 0x5C,
  0x18, 0xA5, 0x04, 0x10, 0x41, 0x3F, 0x39, 0x90, 0x41, 0x18, 0xC4, 0x3F,
  0x3D, 0x90, 0x4E, 0x08, 0x18, 0x9C, 0x0C, 0x52, 0x92, 0x4B, 0xF0, 0x82,
  0x7A, 0x21, 0xE8, 0x86, 0x5E, 0x1B, 0x11, 0x6C, 0xC6, 0x7E, 0xFE, 0x20,
  0x84, 0x20, 0x84, 0x30, 0x3D, 0x14, 0x4E, 0x46, 0x14, 0xDE, 0x74, 0x63,
  0x17, 0x88, 0x98, 0x50, 0xF0, 0x50, 0x3A, 0x09, 0xB1, 0x82, 0x08, 0xF8,
  0x3E, 0x83, 0x06, 0x26, 0x40, 0x3A, 0x62, 0x64, 0x01, 0x88, 0x72, 0x6F,
  0x5C, 0xE6, 0xF0, 0xF0, 0x18, 0x62, 0x8A, 0x49, 0xE4, 0x61, 0x3D, 0x14,
  0x5E, 0x45, 0x14, 0x7E, 0x3A, 0x61, 0x08, 0x4A, 0x6E, 0x72, 0x63, 0x18,
  0xC6, 0x5C, 0x7E, 0x08, 0x3E, 0x82, 0x08, 0x3C, 0x7E, 0x08, 0x3E, 0x82,
  0x08, 0x20, 0x32, 0x61, 0x0B, 0xC6, 0x7E, 0x26, 0x89, 0x13, 0xE4, 0x48,
  0x92, 0x44, 0x3C, 0x41, 0x04, 0x10, 0x42, 0x3E, 0x78, 0x42, 0x11, 0x0A,
  0x5C, 0x26, 0x89, 0x22, 0x87, 0x09, 0x12, 0x42, 0x42, 0x11, 0x08, 0x42,
  0x1F, 0x66, 0xD9, 0xB3, 0xA5, 0x4C, 0xA1, 0x44, 0x26, 0xC9, 0x52, 0xA5,
  0x4A, 0x96, 0x44, 0x7A, 0x63, 0x18, 0xC6, 0x5C, 0x7C, 0x63, 0x1F, 0x42,
  0x10, 0x7A, 0x63, 0x18, 0xC6, 0x5C, 0x29, 0x80, 0x7C, 0x63, 0x1F, 0x52,
  0x53, 0x3D, 0x14, 0x0C, 0x0C, 0x18, 0x5E, 0xFC, 0x82, 0x08, 0x20, 0x82,
  0x10, 0x4E, 0x28, 0xA2, 0x8A, 0x29, 0x3C, 0x86, 0x28, 0xA4, 0x51, 0x46,
  0x18, 0x42, 0x85, 0x53, 0xA7, 0x56, 0xB6, 0x64, 0x42, 0x48, 0xA0, 0x81,
  0x05, 0x12, 0x42, 0x85, 0x25, 0x14, 0x20, 0x82, 0x10, 0x7E, 0x08, 0x20,
  0x82, 0x04, 0x10, 0x7E, 0x74, 0x44, 0x88, 0x88, 0x8E, 0x92, 0x44, 0x92,
  0x24, 0x38, 0x44, 0x21, 0x08, 0x42, 0x27, 0x00, 0x32, 0x93, 0x10, 0xF8,
  0xC0, 0x6C, 0xE3, 0x29, 0x7C, 0x42, 0x2D, 0x98, 0xC6, 0x5E, 0x74, 0x61,
  0x09, 0xB0, 0x08, 0x5F, 0x18, 0xC6, 0x5E, 0x74, 0x7D, 0x09, 0xF8, 0x0E,
  0x11, 0xF8, 0x81, 0x02, 0x04, 0x50, 0xE0, 0xC0, 0x3D, 0x14, 0x52, 0x49,
  0xE8, 0x9C, 0x42, 0x2D, 0x98, 0xCA, 0x52, 0x30, 0x38, 0x44, 0x25, 0x4C,
  0x18, 0x1C, 0x21, 0x08, 0x94, 0xA3, 0x00, 0x42, 0x2D, 0x99, 0x72, 0xB6,
  0xE1, 0x08, 0x84, 0x29, 0x6C, 0x7D, 0x55, 0x65, 0xA6, 0x90, 0xB6, 0x63,
  0x29, 0x48, 0x74, 0x63, 0x19, 0x78, 0x59, 0x94, 0x51, 0x4A, 0xE8, 0x20,
  0x7C, 0x63, 0x29, 0x78, 0x42, 0xF9, 0x10, 0x84, 0x20, 0x74, 0xF8, 0x29,
  0x78, 0x21, 0x3E, 0x84, 0x29, 0x6C, 0x8C, 0x63, 0x29, 0x78, 0xCA, 0x53,
  0x19, 0x70, 0x55, 0x55, 0x65, 0x95, 0xE0, 0x2C, 0xA6, 0x40, 0x8B, 0x5B,
  0x00, 0x45, 0x14, 0x52, 0x49, 0xE8, 0x9C, 0x7C, 0x4C, 0xA8, 0xFC, 0x39,
  0x08, 0x2E, 0x10, 0x88, 0x43, 0x80, 0x29, 0x24, 0x94, 0x90, 0x38, 0x21,
  0x08, 0x1C, 0xC2, 0x04, 0x13, 0x80, 0x65, 0x59, 0x80,
};

const GFXglyph IBMPlexMono_Italic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 8, 7, 2, -8 },
  { 4, 4, 3, 7, 2, -8 },
  { 6, 7, 8, 7, 0, -8 },
  { 13, 6, 10, 7, 0, -9 },
  { 21, 7, 8, 7, 0, -8 },
  { 28, 6, 8, 7, 0, -8 },
  { 34, 2, 3, 7, 3, -8 },
  { 35, 4, 10, 7, 2, -8 },
  { 40, 5, 10, 7, 0, -8 },
  { 47, 5, 5, 7, 1, -6 },
  { 51, 5, 5, 7, 1, -6 },
  { 55, 2, 3, 7, 2, -1 },
  { 56, 3, 1, 7, 2, -4 },
  { 57, 2, 2, 7, 2, -2 },
  { 58, 7, 10, 7, 0, -8 },
  { 67, 5, 8, 7, 1, -8 },
  { 72, 6, 8, 7, 0, -8 },
  { 78, 6, 8, 7, 0, -8 },
  { 84, 6, 8, 7, 0, -8 },
  { 90, 6, 8, 7, 0, -8 },
  { 96, 5, 8, 7, 1, -8 },
  { 101, 5, 8, 7, 1, -8 },
  { 106, 6, 8, 7, 1, -8 },
  { 112, 6, 8, 7, 0, -8 },
  { 118, 5, 8, 7, 1, -8 },
  { 123, 2, 6, 7, 2, -6 },
  { 125, 2, 8, 7, 2, -6 },
  { 127, 5, 6, 7, 1, -6 },
  { 131, 5, 3, 7, 1, -5 },
  { 133, 5, 6, 7, 1, -6 },
  { 137, 5, 8, 7, 1, -8 },
  { 142, 5, 9, 7, 1, -8 },
  { 148, 6, 8, 7, 0, -8 },
  { 154, 6, 8, 7, 0, -8 },
  { 160, 5, 8, 7, 1, -8 },
  { 165, 5, 8, 7, 1, -8 },
  { 170, 6, 8, 7, 1, -8 },
  { 176, 6, 8, 7, 1, -8 },
  { 182, 5, 8, 7, 1, -8 },
  { 187, 7, 8, 7, 0, -8 },
  { 194, 6, 8, 7, 0, -8 },
  { 200, 5, 8, 7, 1, -8 },
  { 205, 7, 8, 7, 0, -8 },
  { 212, 5, 8, 7, 1, -8 },
  { 217, 7, 8, 7, 0, -8 },
  { 224, 7, 8, 7, 0, -8 },
  { 231, 5, 8, 7, 1, -8 },
  { 236, 5, 8, 7, 1, -8 },
  { 241, 5, 10, 7, 1, -8 },
  { 248, 5, 8, 7, 1, -8 },
  { 253, 6, 8, 7, 0, -8 },
  { 259, 6, 8, 7, 1, -8 },
  { 265, 6, 8, 7, 1, -8 },
  { 271, 6, 8, 7, 1, -8 },
  { 277, 7, 8, 7, 0, -8 },
  { 284, 7, 8, 7, 0, -8 },
  { 291, 6, 8, 7, 1, -8 },
  { 297, 7, 8, 7, 0, -8 },
  { 304, 4, 10, 7, 2, -8 },
  { 309, 3, 10, 7, 2, -8 },
  { 313, 5, 10, 7, 0, -8 },
  { 320, 5, 4, 7, 1, -8 },
  { 323, 5, 1, 7, 0, 1 },
  { 324, 1, 2, 7, 3, -9 },
  { 325, 5, 6, 7, 1, -6 },
  { 329, 5, 8, 7, 1, -8 },
  { 334, 5, 6, 7, 1, -6 },
  { 338, 5, 8, 7, 1, -8 },
  { 343, 5, 6, 7, 1, -6 },
  { 347, 7, 10, 7, 0, -8 },
  { 356, 6, 8, 7, 0, -6 },
  { 362, 5, 8, 7, 1, -8 },
  { 367, 5, 8, 7, 1, -8 },
  { 372, 5, 10, 7, 1, -8 },
  { 379, 5, 8, 7, 1, -8 },
  { 384, 5, 8, 7, 1, -8 },
  { 389, 6, 6, 7, 0, -6 },
  { 394, 5, 6, 7, 1, -6 },
  { 398, 5, 6, 7, 1, -6 },
  { 402, 6, 8, 7, 0, -6 },
  { 408, 5, 8, 7, 1, -6 },
  { 413, 5, 6, 7, 1, -6 },
  { 417, 5, 6, 7, 1, -6 },
  { 421, 5, 8, 7, 1, -8 },
  { 426, 5, 6, 7, 1, -6 },
  { 430, 5, 6, 7, 1, -6 },
  { 434, 6, 6, 7, 0, -6 },
  { 439, 7, 6, 7, 0, -6 },
  { 445, 6, 8, 7, 0, -6 },
  { 451, 5, 6, 7, 1, -6 },
  { 455, 5, 10, 7, 1, -8 },
  { 462, 3, 10, 7, 2, -8 },
  { 466, 6, 10, 7, 0, -8 },
  { 474, 6, 3, 7, 0, -5 },
};

const GFXfont IBMPlexMono_Italic11pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic11pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic11pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _IBMPLEXMONO_ITALIC11PT7B_H_
