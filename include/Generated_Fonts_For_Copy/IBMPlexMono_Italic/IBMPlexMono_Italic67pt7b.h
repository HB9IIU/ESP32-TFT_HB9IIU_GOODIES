#ifndef _IBMPLEXMONO_ITALIC67PT7B_H_
#define _IBMPLEXMONO_ITALIC67PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic67pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x7F, 0xC0, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0x00, 0x1F, 0x01, 0xF1, 0xF0, 0x1F,
  0x1F, 0x03, 0xE1, 0xF0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03,
  0xE3, 0xE0, 0x3E, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0,
  0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0xF8,
  0x0F, 0x8F, 0x80, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00,
  0x01, 0xF8, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x01, 0xF0,
  0x1F, 0x00, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00,
  0x0F, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x00,
  0xF0, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x1F,
  0x00, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0xF3, 0xFE, 0x00,
  0xFF, 0x07, 0x87, 0xF8, 0x0F, 0xE0, 0x3C, 0x0F, 0xE0, 0x7E, 0x01, 0xE0,
  0x3F, 0x03, 0xF0, 0x1E, 0x00, 0xE0, 0x3F, 0x00, 0xF0, 0x02, 0x01, 0xF8,
  0x07, 0x80, 0x00, 0x0F, 0xC0, 0x3C, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00,
  0x03, 0xE0, 0x0F, 0x00, 0x00, 0x1F, 0x80, 0xF0, 0x00, 0x00, 0xFC, 0x07,
  0x80, 0x00, 0x07, 0xE0, 0x3C, 0x00, 0x00, 0x1F, 0x81, 0xE0, 0x00, 0x00,
  0xFF, 0x0F, 0x00, 0x00, 0x03, 0xFE, 0x78, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x3C, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0xFF, 0x00, 0x00, 0x0F,
  0x03, 0xF8, 0x00, 0x00, 0x78, 0x0F, 0xC0, 0x00, 0x03, 0xC0, 0x3F, 0x00,
  0x00, 0x1E, 0x01, 0xF8, 0x00, 0x01, 0xE0, 0x0F, 0xC0, 0x00, 0x0F, 0x00,
  0x7E, 0x00, 0x00, 0x78, 0x03, 0xF0, 0x00, 0x03, 0xC0, 0x1F, 0x81, 0x00,
  0x1E, 0x00, 0xF8, 0x1C, 0x00, 0xF0, 0x0F, 0xC1, 0xE0, 0x0F, 0x00, 0x7E,
  0x1F, 0x80, 0x78, 0x07, 0xE0, 0xFF, 0x03, 0xC0, 0x7F, 0x03, 0xFC, 0x1E,
  0x0F, 0xF0, 0x0F, 0xFC, 0xF1, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x0F, 0xFF, 0xE0,
  0x00, 0x7C, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF0, 0x03, 0xF0, 0x1F, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF0, 0x01,
  0xE0, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x7C,
  0x00, 0x1E, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0xF8, 0x0F, 0x80,
  0x03, 0xE0, 0x03, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0x0F, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0x03,
  0xE0, 0x07, 0x83, 0xE0, 0x00, 0x0F, 0x80, 0x3E, 0x0F, 0x00, 0x00, 0x1E,
  0x01, 0xF0, 0x7C, 0x00, 0x00, 0x7E, 0x0F, 0xC3, 0xE0, 0x00, 0x00, 0xFF,
  0xFE, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x40, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0x07, 0xE0, 0xF8, 0x00, 0x00, 0x78, 0x3E, 0x01,
  0xF0, 0x00, 0x03, 0xE1, 0xF0, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x0F,
  0x00, 0x00, 0xF8, 0x1E, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0xF0,
  0x00, 0x1F, 0x03, 0xE0, 0x03, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x00,
  0x03, 0xE0, 0x3C, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0xF0, 0x01, 0xF0, 0x00,
  0xF8, 0x03, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x3C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xE0, 0x1F, 0x00, 0x1F, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0xF8, 0x00,
  0x1F, 0xFF, 0xC0, 0x07, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFC,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0x0F, 0x80, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x3F, 0x80, 0x00, 0x1F, 0xF9, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xC7, 0xFC, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x8F, 0xC0, 0x00, 0xF8, 0x01, 0xDF, 0x80, 0x01,
  0xF8, 0x07, 0xFF, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x00, 0x0D, 0xF0, 0x3E,
  0xFC, 0x00, 0x3B, 0xF0, 0x7C, 0xFC, 0x00, 0x77, 0xE1, 0xF1, 0xF8, 0x01,
  0xC7, 0xE7, 0xE1, 0xFC, 0x0F, 0x8F, 0xCF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF,
  0x03, 0xFF, 0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xF0, 0x03, 0xFF,
  0xC0, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x00, 0x1F, 0x1F, 0x1F, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0xF8,
  0xF8, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x02, 0x00, 0x1F, 0x00, 0x09, 0xF0, 0x07, 0xC0, 0x1E, 0x7F, 0x81, 0xF0,
  0x3F, 0xBF, 0xFC, 0x78, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x03, 0xF1, 0xF0, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x7E, 0x01, 0xF0,
  0x00, 0x3F, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x07, 0xE0, 0x03,
  0xF0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xD0, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x07, 0xFC,
  0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F,
  0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80,
  0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x1F, 0x1F, 0xE7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFE, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x07, 0xE0,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x7E,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x1F,
  0x1F, 0x00, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x00,
  0x7C, 0xF8, 0x00, 0x00, 0x1F, 0x7E, 0x01, 0xF0, 0x0F, 0xDF, 0x80, 0xFE,
  0x03, 0xF7, 0xE0, 0x7F, 0xC0, 0xFD, 0xF8, 0x1F, 0xE0, 0x3F, 0x7E, 0x07,
  0xF8, 0x0F, 0xDF, 0x01, 0xFE, 0x03, 0xEF, 0xC0, 0x7F, 0x01, 0xFB, 0xF0,
  0x0F, 0x80, 0x7E, 0xFC, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0x3F,
  0x3E, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0xC0,
  0x01, 0xF8, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xEF, 0xC0, 0x00, 0x3F, 0xCF,
  0x80, 0x00, 0x7F, 0x8F, 0x80, 0x00, 0xFF, 0x0F, 0x80, 0x01, 0xFC, 0x0F,
  0x80, 0x03, 0xF8, 0x1F, 0x80, 0x0F, 0xF0, 0x1F, 0x80, 0x1F, 0xE0, 0x1F,
  0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x02, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xF0,
  0x0F, 0xE0, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x03, 0xF0, 0x04, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x80,
  0xFF, 0x80, 0x3F, 0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0xF8,
  0x00, 0x0F, 0xE0, 0x0E, 0x00, 0x00, 0xFC, 0x00, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x06, 0x00, 0x00,
  0x1F, 0x83, 0xC0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0xC0,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00,
  0x0F, 0xCF, 0x80, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x03, 0xE1, 0xF8, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x0F, 0xC1,
  0xF0, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x1F, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x00, 0xF8, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x1F, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x7C, 0x00,
  0x00, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x0F, 0x03, 0xFC, 0x00, 0x01, 0xE1, 0xFF, 0xF0, 0x00, 0x7C, 0xFF,
  0xFF, 0x00, 0x0F, 0xBF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x0F, 0xE0,
  0x1E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x10, 0x00, 0x00, 0xFC, 0x0F, 0x00, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x07,
  0xE0, 0xFF, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0xFF, 0x00,
  0x0F, 0xC7, 0xFF, 0xC0, 0x0F, 0x8F, 0xFF, 0xF0, 0x1F, 0x9F, 0xFF, 0xF8,
  0x1F, 0x3F, 0xFF, 0xFC, 0x3F, 0x7C, 0x07, 0xFC, 0x3E, 0xE0, 0x01, 0xFE,
  0x3F, 0xC0, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0xFC,
  0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xF0,
  0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xE0, 0x00, 0x01,
  0xF9, 0xF0, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00,
  0x7C, 0x3E, 0x00, 0x00, 0x7E, 0x1E, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00,
  0x3F, 0x0F, 0x80, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x07, 0xF0, 0x0F, 0xC0, 0x00,
  0x7F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0x80,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3E,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00,
  0x7E, 0x0F, 0x80, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x00, 0xFC, 0x7C, 0x00,
  0x00, 0x1F, 0x9F, 0x80, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x7E,
  0x3F, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00,
  0x7E, 0x1F, 0xC0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFC, 0x07,
  0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x7E, 0x3F, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00,
  0x3E, 0x7C, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x7E, 0xF8, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0xFE, 0xFC, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x03,
  0xFC, 0x7F, 0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x3E, 0xF8, 0x3F, 0xFF, 0xFC,
  0xF8, 0x1F, 0xFF, 0xF9, 0xF0, 0x0F, 0xFF, 0xF3, 0xF0, 0x07, 0xFF, 0xC3,
  0xE0, 0x00, 0xFF, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x0F, 0xF0, 0x7F, 0xC1, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0,
  0xFF, 0xC1, 0xFE, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x7F, 0x81, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFE,
  0x0F, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x40, 0x1F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC1, 0xFE, 0x03,
  0xFE, 0x3F, 0x80, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF7, 0x80, 0x00, 0x3F, 0x18, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0,
  0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x0F, 0x81, 0xF8,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x01, 0xF1, 0xF0, 0x01, 0xF0, 0x7C,
  0x7C, 0x01, 0xFF, 0x1E, 0x1F, 0x00, 0xFF, 0xE7, 0x87, 0x80, 0x7F, 0xF9,
  0xE3, 0xE0, 0x3F, 0xFF, 0x78, 0xF8, 0x1F, 0xC1, 0xFE, 0x3E, 0x07, 0xE0,
  0x1F, 0x8F, 0x83, 0xF0, 0x07, 0xE7, 0xE0, 0xFC, 0x00, 0xF1, 0xF0, 0x3E,
  0x00, 0x3C, 0x7C, 0x1F, 0x80, 0x1F, 0x1F, 0x07, 0xC0, 0x07, 0xC7, 0xC1,
  0xF0, 0x01, 0xF1, 0xF0, 0x7C, 0x00, 0x7C, 0x7C, 0x1F, 0x00, 0x1E, 0x3E,
  0x0F, 0xC0, 0x07, 0x8F, 0x83, 0xF0, 0x03, 0xE3, 0xE0, 0xF8, 0x00, 0xF8,
  0xF8, 0x3E, 0x00, 0x3E, 0x3E, 0x0F, 0x80, 0x1F, 0x8F, 0x83, 0xE0, 0x07,
  0xC3, 0xE0, 0x7C, 0x03, 0xF0, 0xF8, 0x1F, 0x01, 0xFC, 0x3E, 0x07, 0xF1,
  0xDF, 0x0F, 0x81, 0xFF, 0xF7, 0xC3, 0xE0, 0x3F, 0xF9, 0xF0, 0xF8, 0x0F,
  0xFE, 0x78, 0x3E, 0x00, 0xFE, 0x1E, 0x0F, 0x80, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xBE, 0x00, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x00, 0xF8,
  0x1F, 0x00, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00,
  0x3F, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x1F, 0x80, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0xFC, 0x00, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x03, 0xE1, 0xF8,
  0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x3F,
  0x3E, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x7C, 0x00, 0x1F, 0xE0, 0x1F, 0x00, 0x01, 0xFC, 0x07, 0xC0, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0xF8, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3E, 0x07, 0xE0,
  0x00, 0x1F, 0x81, 0xF0, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x07, 0xE0, 0x1F,
  0x00, 0x07, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x03, 0xE0, 0x00, 0x7F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0x07, 0xC3, 0xF0, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x00, 0xFC, 0x3E,
  0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x01, 0xFC, 0x1F, 0x00, 0x01, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0x0F, 0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00,
  0x1C, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xC0, 0x7C, 0x00, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x7F, 0x80, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x7C, 0x00, 0xFF, 0x80, 0x3F, 0x00, 0x0F, 0xF0, 0x0F, 0xC0, 0x00,
  0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0xF8, 0x00, 0x07, 0xE0, 0x3E, 0x00,
  0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x3F, 0x07,
  0xC0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x03,
  0xF0, 0xF8, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x01, 0xF8, 0x7C, 0x00,
  0x00, 0x7E, 0x1F, 0x00, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F,
  0x81, 0xF0, 0x00, 0x1F, 0xC0, 0x7C, 0x00, 0x1F, 0xE0, 0x1F, 0x00, 0x1F,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x00,
  0x7E, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x00, 0x7C, 0x1F, 0x80, 0x00, 0x1C, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7F,
  0xFF, 0x1F, 0x80, 0x1F, 0xFF, 0xC7, 0xE0, 0x07, 0xFF, 0xF1, 0xF0, 0x01,
  0xFF, 0xF8, 0x7C, 0x00, 0xFF, 0xFE, 0x3F, 0x00, 0x00, 0x0F, 0x8F, 0xC0,
  0x00, 0x03, 0xE3, 0xF0, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0x3E, 0x3F,
  0x00, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x01, 0xF0,
  0x7C, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F,
  0xC1, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x01,
  0xFE, 0x03, 0xF8, 0x00, 0xEF, 0x80, 0x7F, 0x80, 0xF3, 0xE0, 0x1F, 0xFF,
  0xFC, 0xF8, 0x03, 0xFF, 0xFE, 0x7E, 0x00, 0x7F, 0xFF, 0x1F, 0x00, 0x0F,
  0xFF, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00,
  0x03, 0xE0, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x3F, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00,
  0x1F, 0x80, 0x7C, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x03, 0x80, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x1F,
  0xC0, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0x01,
  0xF8, 0x00, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x01, 0xF8, 0x00,
  0x03, 0xF8, 0x01, 0xF0, 0x00, 0x07, 0xF0, 0x01, 0xF0, 0x00, 0x0F, 0xE0,
  0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x01, 0xFC,
  0x00, 0x03, 0xE0, 0x03, 0xF8, 0x00, 0x03, 0xE0, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x3F,
  0x80, 0x00, 0x07, 0xC0, 0x7F, 0x00, 0x00, 0x07, 0xC0, 0xFE, 0x00, 0x00,
  0x07, 0xC1, 0xFC, 0x00, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x00, 0x0F, 0xC7,
  0xF8, 0x00, 0x00, 0x0F, 0xCF, 0xF8, 0x00, 0x00, 0x0F, 0x9F, 0xF8, 0x00,
  0x00, 0x0F, 0xBF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x7C, 0x00, 0x00, 0x1F,
  0xFE, 0x7E, 0x00, 0x00, 0x1F, 0xFC, 0x7E, 0x00, 0x00, 0x1F, 0xF8, 0x3F,
  0x00, 0x00, 0x1F, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0x03, 0xF8, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x03, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x03, 0xEF, 0x00, 0x1F, 0xF8,
  0x07, 0xDE, 0x00, 0x7D, 0xF0, 0x0F, 0xBE, 0x00, 0xF3, 0xE0, 0x1F, 0x7C,
  0x03, 0xE7, 0xC0, 0x7C, 0x78, 0x07, 0x9F, 0x00, 0xF8, 0xF0, 0x1F, 0x3E,
  0x01, 0xF1, 0xF0, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0xF8, 0xF8, 0x07, 0xC3,
  0xC3, 0xE1, 0xF0, 0x0F, 0x87, 0x87, 0x83, 0xE0, 0x3E, 0x0F, 0x9F, 0x0F,
  0x80, 0x7C, 0x1F, 0x3C, 0x1F, 0x00, 0xF8, 0x1E, 0xF8, 0x3E, 0x01, 0xF0,
  0x3F, 0xE0, 0x7C, 0x03, 0xE0, 0x7F, 0xC0, 0xF8, 0x07, 0xC0, 0xFF, 0x01,
  0xF0, 0x1F, 0x00, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00,
  0x7C, 0x03, 0xE0, 0x0E, 0x00, 0xF8, 0x0F, 0xC0, 0x18, 0x03, 0xE0, 0x1F,
  0x00, 0x20, 0x07, 0xC0, 0x3E, 0x00, 0x40, 0x0F, 0x80, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xF8, 0x0F,
  0xF8, 0x00, 0x0F, 0x80, 0x7F, 0xC0, 0x00, 0x7C, 0x03, 0xFE, 0x00, 0x03,
  0xE0, 0x1F, 0xF0, 0x00, 0x1F, 0x00, 0xFF, 0xC0, 0x00, 0xF8, 0x0F, 0xBE,
  0x00, 0x0F, 0xC0, 0x7D, 0xF0, 0x00, 0x7C, 0x03, 0xEF, 0x80, 0x03, 0xE0,
  0x1F, 0x3E, 0x00, 0x1F, 0x00, 0xF9, 0xF0, 0x00, 0xF8, 0x07, 0xCF, 0x80,
  0x07, 0xC0, 0x7C, 0x7C, 0x00, 0x7E, 0x03, 0xE3, 0xE0, 0x03, 0xE0, 0x1F,
  0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x07, 0xC3, 0xE0, 0x07,
  0xC0, 0x3E, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x78, 0x03, 0xF0, 0x1F, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xC0,
  0x3E, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xF8,
  0x1F, 0x80, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3E,
  0x00, 0xF0, 0x3E, 0x01, 0xF0, 0x07, 0xC1, 0xF0, 0x0F, 0x80, 0x3E, 0x0F,
  0x80, 0xF8, 0x01, 0xF0, 0xFC, 0x07, 0xC0, 0x0F, 0x87, 0xC0, 0x3E, 0x00,
  0x3E, 0x3E, 0x01, 0xF0, 0x01, 0xF1, 0xF0, 0x0F, 0x80, 0x0F, 0x8F, 0x80,
  0x7C, 0x00, 0x7C, 0x7C, 0x07, 0xC0, 0x01, 0xE7, 0xE0, 0x3E, 0x00, 0x0F,
  0xBE, 0x01, 0xF0, 0x00, 0x7D, 0xF0, 0x0F, 0x80, 0x03, 0xEF, 0x80, 0x7C,
  0x00, 0x1F, 0x7C, 0x03, 0xE0, 0x00, 0x7F, 0xE0, 0x3E, 0x00, 0x03, 0xFF,
  0x01, 0xF0, 0x00, 0x1F, 0xF0, 0x0F, 0x80, 0x00, 0xFF, 0x80, 0x7C, 0x00,
  0x03, 0xFC, 0x03, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x0F, 0xE0,
  0x03, 0xF0, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x1F, 0x81, 0xFC,
  0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x00, 0x7C,
  0x7E, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x01,
  0xF3, 0xF0, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x00, 0xFC,
  0xFC, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00,
  0x3F, 0x07, 0xC0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x03, 0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0xFF,
  0x81, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0x80, 0x01, 0xFE, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00,
  0x3F, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x03, 0xF0,
  0x3E, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x1F, 0xC0,
  0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x0F,
  0xE0, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x1F, 0x81,
  0xFC, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x00,
  0x7C, 0x7E, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x07, 0xCF, 0xC0, 0x00,
  0x01, 0xF3, 0xF0, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x1F,
  0xBF, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x7C, 0x3F, 0x00,
  0x00, 0x3F, 0x07, 0xC0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x40, 0x00, 0x1F,
  0x80, 0x38, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00,
  0x1F, 0x8F, 0xE0, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x01, 0xFE, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x1F, 0x00, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x7E, 0x00,
  0x00, 0x7E, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0xFC, 0x07,
  0xC0, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x7C,
  0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0x00,
  0x00, 0x7F, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x07, 0x01,
  0xF8, 0x00, 0x00, 0x10, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0xF8, 0x08, 0x00, 0x00, 0x0F, 0xC0, 0xE0, 0x00, 0x00,
  0x7E, 0x0F, 0x00, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x00, 0x3F, 0x07, 0xF8,
  0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0xF8,
  0x1F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x00, 0x7C, 0x0F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x01, 0xF0,
  0x3E, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0xFC, 0x00,
  0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x7C,
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x0F,
  0xE0, 0x0F, 0xC0, 0x03, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0x00, 0xFC, 0x7C, 0x00, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x01, 0xF8, 0x7C,
  0x00, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x3E,
  0x00, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x1F, 0x00,
  0x00, 0xF8, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0xF8, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x07, 0xC1, 0xF8, 0x00,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x00, 0x7C, 0x3E,
  0x00, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x0F, 0x00,
  0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0xFE, 0x00, 0xF8, 0x1F, 0x00, 0xFE,
  0x01, 0xF0, 0x1F, 0x00, 0xFE, 0x01, 0xF0, 0x1F, 0x01, 0xFE, 0x01, 0xF0,
  0x1F, 0x01, 0xFE, 0x01, 0xF0, 0x1E, 0x01, 0xFE, 0x01, 0xE0, 0x1E, 0x03,
  0xFE, 0x03, 0xE0, 0x3E, 0x03, 0xDE, 0x03, 0xE0, 0x3E, 0x07, 0xDE, 0x03,
  0xE0, 0x3E, 0x07, 0x9E, 0x03, 0xC0, 0x3E, 0x07, 0x9E, 0x07, 0xC0, 0x3E,
  0x0F, 0x9E, 0x07, 0xC0, 0x3E, 0x0F, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x1F,
  0x07, 0x80, 0x3E, 0x1F, 0x1F, 0x0F, 0x80, 0x3E, 0x1E, 0x1F, 0x0F, 0x80,
  0x3C, 0x1E, 0x1F, 0x0F, 0x80, 0x3C, 0x3E, 0x0F, 0x0F, 0x00, 0x3C, 0x3C,
  0x0F, 0x1F, 0x00, 0x7C, 0x7C, 0x0F, 0x1F, 0x00, 0x7C, 0x78, 0x0F, 0x1F,
  0x00, 0x7C, 0x78, 0x0F, 0x1F, 0x00, 0x7C, 0xF8, 0x0F, 0x3E, 0x00, 0x7C,
  0xF0, 0x0F, 0x3E, 0x00, 0x7C, 0xF0, 0x0F, 0x3E, 0x00, 0x7D, 0xF0, 0x0F,
  0x3E, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x00, 0x7B, 0xE0, 0x0F, 0x7C, 0x00,
  0x7B, 0xE0, 0x0F, 0x7C, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xE0, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xC7, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFD, 0xF0,
  0x00, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x00, 0x7F, 0x01, 0xF0,
  0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x00, 0x3E, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x01, 0xF3,
  0xF0, 0x00, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x00, 0x3E, 0x3E, 0x00,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE0, 0x7C,
  0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0,
  0x01, 0xF0, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x7E,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x00, 0x3F,
  0x7C, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xF1, 0x80, 0x00, 0x00,
  0x30, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF0, 0x08, 0x3E,
  0x3F, 0x0F, 0x83, 0xE1, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0x83, 0xC0, 0xF0,
  0x60, 0x00, 0x0F, 0xE0, 0x1F, 0x00, 0x7F, 0xFC, 0x1F, 0x00, 0xFF, 0xFE,
  0x1F, 0x01, 0xFF, 0xFF, 0x3F, 0x03, 0xFF, 0xFF, 0xBE, 0x07, 0xFC, 0x07,
  0xBE, 0x0F, 0xE0, 0x01, 0xBE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0x80, 0x00,
  0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00,
  0x7C, 0x7E, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00,
  0x7C, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00,
  0xF8, 0xFC, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00,
  0xF8, 0xF8, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x07,
  0xF0, 0xFC, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x1B, 0xE0, 0x7E, 0x00, 0x7B,
  0xE0, 0x7F, 0x81, 0xF3, 0xFF, 0x3F, 0xFF, 0xE3, 0xFF, 0x3F, 0xFF, 0xC3,
  0xFF, 0x1F, 0xFF, 0xC1, 0xFE, 0x0F, 0xFF, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x3F, 0x80, 0x07, 0xC0, 0xFF, 0xF0, 0x07, 0xC3, 0xFF,
  0xF8, 0x07, 0xC7, 0xFF, 0xFC, 0x07, 0xCF, 0xFF, 0xFC, 0x0F, 0xCF, 0x81,
  0xFE, 0x0F, 0xDC, 0x00, 0x7E, 0x0F, 0xB8, 0x00, 0x3F, 0x0F, 0xB0, 0x00,
  0x3F, 0x0F, 0xE0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x1F, 0x1F, 0xC0, 0x00,
  0x1F, 0x1F, 0x80, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x1F, 0x1F, 0x00, 0x00,
  0x1F, 0x1F, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00,
  0x1F, 0x3F, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00,
  0x3F, 0x3E, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0xFF, 0x80, 0x07,
  0xF0, 0xFD, 0xE0, 0x3F, 0xE0, 0xF9, 0xFF, 0xFF, 0xC0, 0xF8, 0xFF, 0xFF,
  0x80, 0xF8, 0x7F, 0xFF, 0x00, 0xF8, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0,
  0x7F, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x7C, 0x7E,
  0x00, 0x01, 0xC3, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x18, 0xF8, 0x00, 0x00, 0xFB, 0xF0,
  0x00, 0x07, 0xE7, 0xC0, 0x00, 0x3F, 0x1F, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x0F, 0xE0, 0xFC, 0x00, 0x7F, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7F,
  0x80, 0xFC, 0x00, 0x3F, 0xFC, 0x1F, 0x00, 0x1F, 0xFF, 0xC3, 0xE0, 0x07,
  0xFF, 0xFC, 0x7C, 0x01, 0xFF, 0xFF, 0xCF, 0x80, 0x7F, 0xC0, 0x7D, 0xF0,
  0x1F, 0xE0, 0x03, 0xBE, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x00, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0xFC, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x03, 0xF0, 0x3E, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x1F, 0xC0, 0xF8,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x3F, 0xC0,
  0x7F, 0x00, 0x0E, 0xF8, 0x07, 0xF0, 0x03, 0x9F, 0x00, 0xFF, 0x01, 0xF7,
  0xE0, 0x0F, 0xFF, 0xFC, 0xF8, 0x01, 0xFF, 0xFF, 0x1F, 0x00, 0x1F, 0xFF,
  0xC3, 0xE0, 0x00, 0xFF, 0xF0, 0x7C, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0x81,
  0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x7E, 0x3F,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x03, 0xE7, 0xE0,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x9F, 0x00, 0x00, 0xFE, 0x7E, 0x00,
  0x0F, 0xF8, 0xFC, 0x07, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x61, 0xF8, 0x00, 0x01, 0xE3, 0xF0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x3F, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0x80, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xF9, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x07, 0xE0, 0x01, 0xFF, 0xE0, 0xF8, 0x00, 0xFF, 0xFE,
  0x1F, 0x00, 0x3F, 0xFF, 0xE3, 0xE0, 0x0F, 0xFF, 0xFE, 0x7C, 0x03, 0xFE,
  0x03, 0xEF, 0x80, 0xFF, 0x00, 0x1D, 0xF0, 0x1F, 0x80, 0x01, 0xFC, 0x07,
  0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x00, 0xF8, 0x3F, 0x00,
  0x00, 0x1F, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x1F,
  0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00,
  0xFE, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xC0,
  0x03, 0xBE, 0x01, 0xFC, 0x00, 0xF7, 0xC0, 0x3F, 0xC0, 0x7C, 0xF8, 0x03,
  0xFF, 0xFF, 0x3F, 0x00, 0x7F, 0xFF, 0xC7, 0xC0, 0x07, 0xFF, 0xF0, 0xF8,
  0x00, 0x3F, 0xFC, 0x1F, 0x00, 0x01, 0xFE, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x10, 0x00, 0x07, 0xE0, 0x03,
  0x00, 0x01, 0xFC, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0xC0,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x1F,
  0xC0, 0x03, 0xE0, 0xFF, 0xE0, 0x0F, 0xC3, 0xFF, 0xE0, 0x1F, 0x8F, 0xFF,
  0xE0, 0x3E, 0x3F, 0xFF, 0xE0, 0x7C, 0xF8, 0x3F, 0xC0, 0xF9, 0xC0, 0x1F,
  0x81, 0xF7, 0x00, 0x3F, 0x87, 0xE8, 0x00, 0x3F, 0x0F, 0xF0, 0x00, 0x7E,
  0x1F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0,
  0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF8, 0x7C,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xFC, 0x3E, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7E, 0x1F, 0x00, 0x00,
  0xF8, 0x7E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x10, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x01,
  0x80, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0xFE,
  0x00, 0x7C, 0x03, 0xF8, 0x00, 0xF8, 0x0F, 0xE0, 0x01, 0xF0, 0x3F, 0x80,
  0x03, 0xE0, 0xFE, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x1F, 0x1F, 0xE0, 0x00,
  0x3F, 0x7F, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x20, 0x00, 0xF8,
  0x00, 0xE0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0,
  0x0F, 0xE0, 0x1F, 0x80, 0x0F, 0xE0, 0x3E, 0x00, 0x0F, 0xE0, 0x7C, 0x00,
  0x0F, 0xE0, 0xF8, 0x00, 0x0F, 0xE1, 0xF0, 0x00, 0x0F, 0xE7, 0xE0, 0x00,
  0x1F, 0xEF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0xFE, 0x00, 0x03, 0xE0, 0xFF, 0xE0, 0x01,
  0xF8, 0x7F, 0xFC, 0x00, 0x7E, 0x3F, 0xFF, 0x80, 0x1F, 0x1F, 0xFF, 0xF0,
  0x07, 0xCF, 0x81, 0xFC, 0x01, 0xF7, 0x80, 0x3F, 0x80, 0x7D, 0x80, 0x07,
  0xE0, 0x3F, 0xE0, 0x01, 0xF8, 0x0F, 0xF0, 0x00, 0x7E, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x01, 0xF0, 0x0F, 0x80,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x7C,
  0x00, 0x3F, 0x80, 0x1F, 0x00, 0x3F, 0xC0, 0x07, 0xC0, 0x3F, 0xC0, 0x01,
  0xF0, 0xFF, 0xC0, 0x00, 0xFC, 0x7F, 0xC0, 0x00, 0x3F, 0x0F, 0x80, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x10, 0xF8, 0x1F, 0x00,
  0x0E, 0x3E, 0x07, 0xE0, 0x07, 0x9F, 0x80, 0xF8, 0x07, 0xF7, 0xC0, 0x3F,
  0x03, 0xF9, 0xF0, 0x07, 0xC1, 0xFC, 0x7C, 0x01, 0xF8, 0xFE, 0x1F, 0x00,
  0x3E, 0x7F, 0x07, 0xC0, 0x0F, 0xFF, 0x83, 0xF0, 0x01, 0xFF, 0xC0, 0xF8,
  0x00, 0x7F, 0xE0, 0x3E, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x80, 0x3F, 0x00, 0x0C, 0x03, 0xF0, 0x01, 0xE0, 0x3E, 0x00,
  0x7F, 0x03, 0xE0, 0x0F, 0xE0, 0x3E, 0x01, 0xFC, 0x03, 0xE0, 0x3F, 0x80,
  0x7E, 0x07, 0xF0, 0x07, 0xC0, 0xFE, 0x00, 0x7C, 0x3F, 0xC0, 0x07, 0xC7,
  0xF8, 0x00, 0x7C, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xC1, 0xF0, 0x0F, 0xC0, 0x3E, 0x3F, 0xC0, 0xFF, 0x01, 0xF3, 0xFF, 0x0F,
  0xFC, 0x0F, 0x9F, 0xF8, 0xFF, 0xF0, 0x7D, 0xFF, 0xCF, 0xFF, 0x83, 0xFC,
  0x3F, 0xF0, 0xFC, 0x3F, 0xC0, 0xFF, 0x03, 0xE1, 0xFC, 0x07, 0xF0, 0x1F,
  0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x7E, 0x01, 0xF8, 0x07, 0xC3, 0xE0, 0x0F,
  0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x01, 0xF1, 0xF8, 0x03, 0xE0, 0x0F, 0x0F,
  0x80, 0x1E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x80,
  0x3E, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE0, 0x0F, 0x8F, 0xC0,
  0x1F, 0x00, 0x78, 0x7C, 0x01, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x80, 0x3E,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE0, 0x0F, 0x87, 0xC0, 0x1F,
  0x00, 0x7C, 0x3C, 0x00, 0xF0, 0x03, 0xC3, 0xE0, 0x0F, 0x80, 0x3E, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x00,
  0x7C, 0x3E, 0x00, 0xF8, 0x03, 0xE1, 0xE0, 0x07, 0x80, 0x1E, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x00, 0x7C,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x03, 0xE0, 0x3F, 0x80, 0x0F, 0xC1, 0xFF,
  0xC0, 0x1F, 0x87, 0xFF, 0xC0, 0x3E, 0x1F, 0xFF, 0xC0, 0x7C, 0x7F, 0xFF,
  0xC0, 0xF9, 0xF0, 0x7F, 0x81, 0xF3, 0x80, 0x3F, 0x07, 0xEE, 0x00, 0x7F,
  0x0F, 0xD0, 0x00, 0x7E, 0x1F, 0xE0, 0x00, 0xFC, 0x3F, 0x80, 0x01, 0xF8,
  0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7C, 0x3E,
  0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x0F, 0x87, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x00,
  0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00,
  0x3E, 0x1F, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF0, 0x00,
  0xFC, 0x0F, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3E, 0x1F, 0x80, 0x00,
  0x3E, 0x1F, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00,
  0x1F, 0x7E, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00,
  0x3F, 0x7C, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00,
  0xFC, 0x7C, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03,
  0xF8, 0x3E, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFC, 0x07,
  0xF0, 0x00, 0x1F, 0x03, 0xFF, 0xC0, 0x03, 0xE1, 0xFF, 0xFC, 0x00, 0x7C,
  0x7F, 0xFF, 0xC0, 0x0F, 0x9F, 0xFF, 0xF8, 0x03, 0xF3, 0xE0, 0x7F, 0x80,
  0x7E, 0xE0, 0x03, 0xF0, 0x0F, 0xB8, 0x00, 0x3F, 0x01, 0xF6, 0x00, 0x07,
  0xE0, 0x3F, 0x80, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x0F, 0x81, 0xFC, 0x00,
  0x01, 0xF0, 0x3F, 0x00, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0xFC, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x03,
  0xF0, 0x7C, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x01, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0xFE, 0x00, 0x07, 0xF0, 0x3F, 0xE0, 0x01, 0xFC, 0x07, 0xEF, 0x01, 0xFF,
  0x00, 0xF9, 0xFF, 0xFF, 0xC0, 0x1F, 0x1F, 0xFF, 0xF0, 0x03, 0xE1, 0xFF,
  0xFC, 0x00, 0x7C, 0x1F, 0xFF, 0x00, 0x1F, 0x80, 0xFF, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0x80, 0x1F, 0xFE, 0x0F, 0x80,
  0x3F, 0xFF, 0x87, 0xC0, 0x3F, 0xFF, 0xE3, 0xE0, 0x3F, 0xFF, 0xF9, 0xF0,
  0x3F, 0xE0, 0x3E, 0xF8, 0x3F, 0xC0, 0x07, 0x7C, 0x1F, 0x80, 0x01, 0xFC,
  0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00,
  0x7C, 0x7E, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x3F, 0x1F, 0x00, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x07, 0xE1, 0xF0, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x03, 0xF8, 0x7C, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xBE, 0x0F, 0xE0,
  0x01, 0xDF, 0x03, 0xF8, 0x01, 0xCF, 0x81, 0xFE, 0x03, 0xEF, 0xC0, 0x7F,
  0xFF, 0xE7, 0xC0, 0x3F, 0xFF, 0xE3, 0xE0, 0x0F, 0xFF, 0xE1, 0xF0, 0x01,
  0xFF, 0xE0, 0xF8, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0xFF, 0x00,
  0xFF, 0x7F, 0xFF, 0x07, 0xFF, 0x7F, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0xE0,
  0x00, 0x00, 0x3E, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7D, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xF0, 0x07, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xC0,
  0x00, 0x18, 0x07, 0xE0, 0x00, 0x08, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x04, 0x00, 0x00, 0x1F, 0x03, 0x00, 0x00, 0x0F,
  0x87, 0xE0, 0x00, 0x0F, 0xC7, 0xF8, 0x00, 0x1F, 0xC1, 0xFF, 0x80, 0x3F,
  0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x20, 0x07, 0xE0,
  0x01, 0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x1F, 0x00, 0x3F, 0xC0, 0x3E, 0x00,
  0xFF, 0x00, 0x7C, 0x07, 0xFC, 0x01, 0xF8, 0x1F, 0xE0, 0x03, 0xF0, 0xFF,
  0x80, 0x07, 0xC3, 0xFE, 0x00, 0x0F, 0xDF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x01, 0xF1,
  0xF0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xFC, 0x7C,
  0x00, 0x03, 0xE3, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3E, 0x3E, 0x00,
  0x00, 0xF8, 0xF8, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x8F, 0x80, 0x00,
  0x7E, 0x7E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x1F,
  0x1F, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x1F, 0x8F, 0x80, 0x00, 0x7E, 0x3E, 0x00, 0x03, 0xF8, 0xF8, 0x00,
  0x0F, 0xC3, 0xE0, 0x00, 0x7F, 0x0F, 0x80, 0x01, 0x7C, 0x3E, 0x00, 0x0F,
  0xF0, 0xFC, 0x00, 0x6F, 0xC3, 0xF8, 0x07, 0xBF, 0x0F, 0xF0, 0x3C, 0xF8,
  0x1F, 0xFF, 0xE3, 0xE0, 0x7F, 0xFF, 0x8F, 0x80, 0xFF, 0xFC, 0x3E, 0x01,
  0xFF, 0xC1, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x0C, 0x7F,
  0xF8, 0x00, 0x7E, 0x7F, 0xF8, 0x00, 0x7E, 0x7F, 0xF8, 0x00, 0x3E, 0xFF,
  0xF8, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x1F, 0x01,
  0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3F, 0x03,
  0xE0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7E, 0x03,
  0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0xFC, 0x07,
  0xC0, 0x01, 0xF8, 0x07, 0xC0, 0x01, 0xF8, 0x07, 0xC0, 0x03, 0xF0, 0x07,
  0xC0, 0x07, 0xF0, 0x07, 0xC0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x0F,
  0x80, 0x7F, 0x80, 0x0F, 0x81, 0xFF, 0x00, 0x0F, 0x87, 0xFE, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x81,
  0xF0, 0x07, 0x80, 0xF8, 0x3E, 0x00, 0xF0, 0x1F, 0x07, 0x80, 0x3E, 0x03,
  0xE1, 0xF0, 0x07, 0xC0, 0x3C, 0x3E, 0x00, 0xF8, 0x07, 0xC7, 0xC0, 0x1F,
  0x00, 0xF8, 0xF8, 0x03, 0xC0, 0x1F, 0x1F, 0x00, 0x78, 0x03, 0xE3, 0xC0,
  0x1F, 0x00, 0x7C, 0x78, 0x03, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0x01, 0xF3,
  0xE0, 0x0F, 0x80, 0x3E, 0x7C, 0x01, 0xE0, 0x07, 0xCF, 0x80, 0x3C, 0x00,
  0xF9, 0xE0, 0x0F, 0x80, 0x1F, 0x3C, 0x01, 0xF0, 0x03, 0xEF, 0x80, 0x3E,
  0x00, 0x79, 0xF0, 0x07, 0xC0, 0x1F, 0x3E, 0x00, 0xF0, 0x03, 0xE7, 0xC0,
  0x1E, 0x00, 0x7C, 0xF0, 0x07, 0xC0, 0x0F, 0x9E, 0x00, 0xF8, 0x03, 0xE7,
  0xC0, 0x1F, 0x00, 0x7C, 0xF8, 0x03, 0xE0, 0x0F, 0x9F, 0x00, 0xFC, 0x03,
  0xF3, 0xE0, 0x1F, 0x80, 0x7C, 0x7C, 0x03, 0xF0, 0x1F, 0x8F, 0x80, 0xDE,
  0x07, 0xE1, 0xF0, 0x3B, 0xC0, 0xFC, 0x3F, 0x0E, 0x7C, 0x7F, 0x07, 0xFF,
  0xCF, 0xFF, 0xC0, 0xFF, 0xF1, 0xFF, 0xF0, 0x0F, 0xFC, 0x1F, 0xFC, 0x00,
  0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x1F, 0xFC,
  0x00, 0x7F, 0xF8, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x7F, 0xFE, 0x01, 0xFE,
  0x78, 0xFC, 0x7E, 0x07, 0xF8, 0x7C, 0xF0, 0x3F, 0x0F, 0xE0, 0x7D, 0xE0,
  0x1F, 0x1F, 0xC0, 0x7D, 0xC0, 0x1F, 0x0F, 0x00, 0x7D, 0xC0, 0x1F, 0x0E,
  0x00, 0x3D, 0x80, 0x1F, 0x08, 0x00, 0x3F, 0x80, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x38, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1C,
  0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0x00, 0x78, 0x01, 0xFE,
  0x00, 0x20, 0xF8, 0x01, 0xFE, 0x00, 0x70, 0xF8, 0x03, 0xBE, 0x01, 0xF0,
  0xF8, 0x03, 0xBE, 0x03, 0xF8, 0xFC, 0x07, 0x9E, 0x0F, 0xE0, 0x7C, 0x0F,
  0x1E, 0x1F, 0xC0, 0x7E, 0x1F, 0x1F, 0x7F, 0x80, 0x7F, 0xFE, 0x1F, 0xFF,
  0x00, 0x7F, 0xFE, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x0F, 0xFC, 0x00, 0x1F,
  0xF0, 0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x3F,
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x7C,
  0x07, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x01,
  0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3F, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0xFC, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x0F, 0x80,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x07, 0xE0, 0x3E,
  0x00, 0x03, 0xF8, 0x0F, 0x80, 0x01, 0xFC, 0x03, 0xE0, 0x00, 0x7F, 0x00,
  0xFC, 0x00, 0x37, 0xC0, 0x3F, 0x00, 0x1D, 0xF0, 0x0F, 0xE0, 0x0E, 0xFC,
  0x03, 0xFC, 0x0F, 0x3F, 0x00, 0x7F, 0xFF, 0xCF, 0x80, 0x0F, 0xFF, 0xE3,
  0xE0, 0x03, 0xFF, 0xF0, 0xF8, 0x00, 0x3F, 0xF8, 0x3E, 0x00, 0x03, 0xF0,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x10,
  0x00, 0x07, 0xE0, 0x0C, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x01, 0xFC, 0x03,
  0xFC, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xC0, 0x3F, 0xFF, 0x81, 0xF0, 0x1F,
  0xFF, 0xF8, 0x7C, 0x0F, 0xFF, 0xFF, 0x1F, 0x03, 0xFF, 0xFF, 0xFF, 0xC1,
  0xF8, 0x1F, 0xFF, 0xF0, 0x7C, 0x00, 0x7F, 0xFC, 0x3E, 0x00, 0x07, 0xFE,
  0x0F, 0x80, 0x00, 0x7E, 0x03, 0xC0, 0x00, 0x3F, 0x00, 0xF0, 0x00, 0x1F,
  0x80, 0x3C, 0x00, 0x0F, 0xC0, 0x0F, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0x00,
  0x07, 0xE0, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0xFE, 0x00, 0x01, 0xF0, 0x7F, 0x80, 0x00,
  0x7C, 0x3F, 0xFE, 0x00, 0x1F, 0x1F, 0xFF, 0xFC, 0x07, 0xC7, 0xDF, 0xFF,
  0xF9, 0xF1, 0xF0, 0xFF, 0xFF, 0xFC, 0x7C, 0x07, 0xFF, 0xFF, 0x1F, 0x00,
  0x3F, 0xFF, 0x8F, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01,
  0xE0, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0x80, 0x3F, 0xE0, 0x00, 0x7C, 0x0F, 0xFE, 0x00, 0x0F, 0x83, 0xFF,
  0xE0, 0x01, 0xE0, 0xFF, 0xFE, 0x00, 0x7C, 0x1F, 0x8F, 0xC0, 0x0F, 0x87,
  0xC0, 0xFC, 0x03, 0xE1, 0xF8, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF8, 0x1F,
  0x07, 0x80, 0x1F, 0x87, 0xE1, 0xF0, 0x01, 0xFF, 0xF8, 0x3C, 0x00, 0x3F,
  0xFE, 0x0F, 0x80, 0x03, 0xFF, 0x81, 0xF0, 0x00, 0x3F, 0xE0, 0x04, 0x00,
  0x01, 0xF0, 0x00,
};

const GFXglyph IBMPlexMono_Italic67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 40, 0, -1 },
  { 1, 15, 48, 40, 13, -47 },
  { 91, 20, 18, 40, 14, -50 },
  { 136, 40, 47, 40, 1, -47 },
  { 371, 37, 63, 40, 2, -55 },
  { 663, 46, 49, 40, -2, -48 },
  { 945, 39, 49, 40, 0, -48 },
  { 1184, 8, 18, 40, 20, -50 },
  { 1202, 25, 60, 40, 14, -51 },
  { 1390, 25, 60, 40, 3, -51 },
  { 1578, 34, 33, 40, 4, -37 },
  { 1719, 33, 33, 40, 4, -37 },
  { 1856, 15, 18, 40, 9, -9 },
  { 1890, 20, 5, 40, 11, -23 },
  { 1903, 10, 9, 40, 13, -8 },
  { 1915, 38, 60, 40, 2, -51 },
  { 2200, 34, 49, 40, 4, -48 },
  { 2409, 32, 47, 40, 3, -47 },
  { 2597, 35, 48, 40, 2, -48 },
  { 2807, 35, 49, 40, 2, -48 },
  { 3022, 36, 47, 40, 1, -47 },
  { 3234, 35, 48, 40, 3, -47 },
  { 3444, 32, 48, 40, 4, -47 },
  { 3636, 33, 47, 40, 7, -47 },
  { 3830, 35, 49, 40, 3, -48 },
  { 4045, 32, 48, 40, 6, -48 },
  { 4237, 14, 36, 40, 13, -35 },
  { 4300, 18, 44, 40, 9, -35 },
  { 4399, 32, 38, 40, 6, -40 },
  { 4551, 35, 19, 40, 3, -30 },
  { 4635, 33, 38, 40, 3, -40 },
  { 4792, 28, 49, 40, 9, -48 },
  { 4964, 34, 56, 40, 4, -48 },
  { 5202, 36, 47, 40, -1, -47 },
  { 5414, 34, 47, 40, 3, -47 },
  { 5614, 34, 49, 40, 5, -48 },
  { 5823, 34, 47, 40, 4, -47 },
  { 6023, 37, 47, 40, 3, -47 },
  { 6241, 37, 47, 40, 3, -47 },
  { 6459, 34, 49, 40, 4, -48 },
  { 6668, 37, 47, 40, 3, -47 },
  { 6886, 37, 47, 40, 3, -47 },
  { 7104, 33, 48, 40, 4, -47 },
  { 7302, 40, 47, 40, 3, -47 },
  { 7537, 29, 47, 40, 5, -47 },
  { 7708, 39, 47, 40, 2, -47 },
  { 7938, 37, 47, 40, 3, -47 },
  { 8156, 34, 49, 40, 4, -48 },
  { 8365, 36, 47, 40, 3, -47 },
  { 8577, 34, 61, 40, 4, -48 },
  { 8837, 36, 47, 40, 3, -47 },
  { 9049, 37, 49, 40, 2, -48 },
  { 9276, 37, 47, 40, 6, -47 },
  { 9494, 35, 48, 40, 5, -47 },
  { 9704, 36, 47, 40, 7, -47 },
  { 9916, 40, 47, 40, 3, -47 },
  { 10151, 44, 47, 40, -1, -47 },
  { 10410, 38, 47, 40, 6, -47 },
  { 10634, 41, 47, 40, 0, -47 },
  { 10875, 28, 60, 40, 11, -51 },
  { 11085, 18, 60, 40, 12, -51 },
  { 11220, 28, 60, 40, 1, -51 },
  { 11430, 34, 27, 40, 4, -47 },
  { 11545, 33, 5, 40, 0, 6 },
  { 11566, 9, 13, 40, 15, -52 },
  { 11581, 32, 36, 40, 4, -35 },
  { 11725, 32, 51, 40, 4, -50 },
  { 11929, 30, 36, 40, 5, -35 },
  { 12064, 35, 51, 40, 4, -50 },
  { 12288, 31, 36, 40, 5, -35 },
  { 12428, 44, 64, 40, -1, -50 },
  { 12780, 35, 49, 40, 2, -35 },
  { 12995, 31, 50, 40, 4, -50 },
  { 13189, 31, 52, 40, 5, -51 },
  { 13391, 31, 65, 40, 4, -51 },
  { 13643, 34, 51, 40, 4, -50 },
  { 13860, 28, 51, 40, 7, -50 },
  { 14039, 37, 35, 40, 1, -35 },
  { 14201, 31, 35, 40, 4, -35 },
  { 14337, 32, 36, 40, 4, -35 },
  { 14481, 35, 48, 40, 1, -35 },
  { 14691, 33, 48, 40, 4, -35 },
  { 14889, 32, 35, 40, 7, -35 },
  { 15029, 33, 36, 40, 3, -35 },
  { 15178, 31, 48, 40, 5, -47 },
  { 15364, 30, 36, 40, 6, -35 },
  { 15499, 32, 36, 40, 4, -35 },
  { 15643, 35, 36, 40, 3, -35 },
  { 15801, 40, 36, 40, 0, -35 },
  { 15981, 34, 49, 40, 2, -35 },
  { 16190, 34, 36, 40, 3, -35 },
  { 16343, 32, 60, 40, 7, -51 },
  { 16583, 15, 60, 40, 13, -51 },
  { 16696, 31, 60, 40, 3, -51 },
  { 16929, 35, 15, 40, 3, -28 },
};

const GFXfont IBMPlexMono_Italic67pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic67pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic67pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _IBMPLEXMONO_ITALIC67PT7B_H_
