#ifndef _IBMPLEXMONO_ITALIC36PT7B_H_
#define _IBMPLEXMONO_ITALIC36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x07, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C,
  0x1C, 0x18, 0x18, 0x18, 0x10, 0x00, 0x00, 0x00, 0x00, 0x78, 0xF8, 0xF8,
  0xF8, 0xF0, 0x71, 0xDC, 0x77, 0x1D, 0x87, 0xE1, 0xB8, 0x6E, 0x3B, 0x8E,
  0xE3, 0xB0, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0xE1, 0xC0, 0x03, 0x86, 0x00,
  0x0C, 0x38, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x00, 0x06, 0x1C, 0x07, 0xF8,
  0x7F, 0x1F, 0xE1, 0xFC, 0x7F, 0x0F, 0xF0, 0x1C, 0x38, 0x00, 0x70, 0xC0,
  0x01, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x60, 0x1F, 0xC3, 0xFC, 0x7F,
  0x0F, 0xF3, 0xFC, 0x3F, 0x80, 0x61, 0xC0, 0x01, 0x87, 0x00, 0x0E, 0x18,
  0x00, 0x30, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x0C, 0x00, 0x38, 0x70, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0xFE,
  0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xF1, 0x9E, 0x1E, 0x18, 0xF1, 0xC3,
  0x86, 0x1C, 0x30, 0x01, 0xC3, 0x00, 0x1C, 0x30, 0x01, 0xE3, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x67, 0xC0,
  0x06, 0x3C, 0x00, 0xE1, 0xC0, 0x0C, 0x1C, 0x40, 0xC1, 0xC6, 0x0C, 0x1C,
  0xF0, 0xC3, 0x87, 0xCC, 0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x07, 0xF0,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xF0, 0x03, 0x81, 0xFC, 0x03, 0x81, 0xC7, 0x03, 0x81, 0xC1, 0x81, 0x80,
  0xC0, 0xC1, 0x80, 0xE0, 0x61, 0xC0, 0x70, 0x31, 0xC0, 0x38, 0x38, 0xC0,
  0x1C, 0x18, 0xE0, 0x06, 0x1C, 0xE0, 0x03, 0xFC, 0x60, 0x00, 0xF8, 0x40,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x07, 0x1F, 0xC0, 0x03, 0x1C,
  0x70, 0x03, 0x9C, 0x18, 0x03, 0x8C, 0x0C, 0x01, 0x86, 0x06, 0x01, 0xC3,
  0x03, 0x01, 0xC1, 0x81, 0x80, 0xC0, 0xC1, 0xC0, 0xC0, 0x71, 0xC0, 0xE0,
  0x1F, 0xC0, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xF8, 0x00,
  0xFF, 0xE0, 0x07, 0x87, 0x80, 0x78, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x07,
  0x00, 0xE0, 0x38, 0x03, 0x01, 0xC0, 0x1C, 0x1C, 0x00, 0x71, 0xE0, 0x1F,
  0xBE, 0x03, 0xFF, 0xC0, 0x3C, 0x70, 0x01, 0xC3, 0x80, 0x1E, 0x0E, 0x00,
  0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x05, 0xC0, 0x78, 0x7E, 0x02,
  0xE7, 0x38, 0x37, 0x39, 0xFF, 0x9F, 0x87, 0xF8, 0xFC, 0x1F, 0x03, 0xC0,
  0x77, 0x76, 0x6E, 0xEE, 0xEC, 0x00, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80,
  0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70,
  0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0,
  0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E,
  0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x38,
  0x00, 0xC0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x20, 0x38, 0x17, 0x0E,
  0x1F, 0xFB, 0xFF, 0x3F, 0xFF, 0x01, 0xFE, 0x00, 0x3E, 0x00, 0x1F, 0xC0,
  0x07, 0x70, 0x03, 0x8E, 0x01, 0xC3, 0x80, 0xE0, 0x70, 0x70, 0x1C, 0x08,
  0x04, 0x00, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x7F, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1F, 0x1E, 0x1E,
  0x3C, 0x3C, 0x38, 0x70, 0x70, 0x60, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xC1, 0xE1, 0xE0, 0x1C, 0x38,
  0x03, 0x8E, 0x00, 0x31, 0xC0, 0x06, 0x78, 0x00, 0xEE, 0x00, 0x19, 0xC0,
  0x07, 0x38, 0x70, 0xE7, 0x1F, 0x1D, 0xE3, 0xE3, 0xB8, 0x78, 0x77, 0x00,
  0x1E, 0xE0, 0x03, 0x9C, 0x00, 0x73, 0x80, 0x1C, 0x70, 0x03, 0x87, 0x00,
  0xE0, 0xF0, 0x7C, 0x0F, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xF3, 0x80, 0xF1, 0xC0,
  0xF0, 0xE0, 0xF0, 0x70, 0x20, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x1F, 0xFF,
  0x03, 0xC1, 0xE0, 0xE0, 0x1E, 0x3C, 0x01, 0xC7, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3F, 0xFF, 0xE7,
  0xFF, 0xFC, 0xFF, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x0F, 0xFF,
  0x03, 0xC1, 0xF0, 0xE0, 0x1E, 0x08, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x30, 0x03, 0xCF, 0x00, 0x70, 0xF0, 0x3E, 0x1F, 0xFF, 0x80,
  0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x0E, 0xE0, 0x03, 0x98, 0x00, 0x77, 0x00, 0x1C, 0xE0, 0x07, 0x1C,
  0x01, 0xC3, 0x80, 0x70, 0x60, 0x0C, 0x0C, 0x03, 0x03, 0x80, 0xE0, 0x70,
  0x38, 0x0E, 0x0E, 0x01, 0xC3, 0x80, 0x30, 0x60, 0x0E, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFF,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x1F, 0x00, 0x6F, 0xF8, 0x1F, 0xFF, 0x83, 0xE0, 0xF0,
  0x70, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x1E, 0x30, 0x03, 0x8F, 0x00, 0xF1, 0xF0, 0x7C, 0x1F, 0xFF, 0x01,
  0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1E, 0x7E, 0x0E, 0xFF, 0x87, 0xFF, 0xE7, 0xE0, 0xFB, 0xC0, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xE7,
  0x00, 0xF3, 0xC0, 0xF0, 0xFF, 0xF0, 0x3F, 0xF0, 0x0F, 0xE0, 0x00, 0x7F,
  0xFF, 0xDF, 0xFF, 0xE7, 0xFF, 0xFB, 0x80, 0x0E, 0xE0, 0x07, 0x38, 0x01,
  0xCE, 0x00, 0xE3, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F,
  0xFC, 0x07, 0xFF, 0xE0, 0xF8, 0x1E, 0x0E, 0x00, 0xE1, 0xE0, 0x0F, 0x1C,
  0x00, 0xE1, 0xC0, 0x0E, 0x0E, 0x01, 0xC0, 0xF0, 0x3C, 0x07, 0xFF, 0x00,
  0x1F, 0xC0, 0x07, 0xFF, 0x01, 0xE0, 0x78, 0x38, 0x01, 0xC7, 0x00, 0x1C,
  0x70, 0x01, 0xC7, 0x00, 0x1C, 0xF0, 0x01, 0xCF, 0x00, 0x3C, 0x70, 0x03,
  0x87, 0xC0, 0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x01,
  0xF8, 0x03, 0xFF, 0x07, 0xFF, 0xC7, 0xC1, 0xE3, 0x80, 0x3B, 0x80, 0x1D,
  0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFE, 0x01,
  0xF7, 0x81, 0xF3, 0xFF, 0xB8, 0xFF, 0xB8, 0x1F, 0x1C, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x1F, 0x3F, 0x3E, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0xF8, 0xF8, 0xF8, 0xF0,
  0x07, 0x81, 0xF0, 0xFC, 0x3E, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x78, 0x1E, 0x0F, 0x03, 0xC0,
  0xE0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x01,
  0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01,
  0x80, 0x00, 0x40, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF,
  0xFF, 0xE0, 0x10, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x08, 0x00, 0x00, 0x07,
  0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xC1, 0xFF, 0x01, 0xFC, 0x01, 0xF0, 0x03,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x01, 0xE0, 0x1F, 0x80, 0xFC, 0x01,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x3C, 0x00, 0x00, 0xFC,
  0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3C, 0x0F, 0x1E, 0x01, 0xC7, 0x00, 0x73,
  0x80, 0x0C, 0xE0, 0xF3, 0x30, 0xFC, 0xDC, 0x3F, 0xB7, 0x1E, 0x3D, 0xC7,
  0x07, 0x73, 0x81, 0x98, 0xE0, 0x6E, 0x38, 0x1B, 0x8E, 0x0E, 0xE3, 0x03,
  0xB8, 0xC0, 0xEE, 0x38, 0x73, 0x8F, 0xEC, 0xE3, 0xFB, 0x38, 0x7D, 0xCE,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0x80, 0x7F,
  0xE0, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x07, 0x70, 0x00, 0xEE, 0x00, 0x38, 0xC0, 0x07, 0x1C, 0x00,
  0xC3, 0x80, 0x38, 0x70, 0x06, 0x0E, 0x01, 0xC1, 0xC0, 0x30, 0x38, 0x0E,
  0x03, 0x01, 0xC0, 0x70, 0x7F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0x70,
  0x07, 0x1C, 0x00, 0xE3, 0x80, 0x1C, 0xF0, 0x03, 0xDC, 0x00, 0x3F, 0x80,
  0x07, 0xE0, 0x00, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xF8, 0x70,
  0x0F, 0x1C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x07, 0x38, 0x03,
  0xCE, 0x00, 0xE3, 0x80, 0x70, 0xFF, 0xF8, 0x3F, 0xF8, 0x0F, 0xFF, 0x87,
  0x00, 0x71, 0xC0, 0x0E, 0x70, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0x39, 0xC0,
  0x0E, 0xE0, 0x07, 0x38, 0x07, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3C, 0x1E, 0x1E, 0x03,
  0x8F, 0x00, 0x73, 0x80, 0x19, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x8E, 0x00, 0x73, 0x80, 0x38, 0xF0, 0x1E,
  0x1E, 0x0F, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x0F, 0xFC,
  0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x38, 0x1E, 0x1C, 0x03, 0xC7, 0x00, 0x71,
  0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x73, 0x80, 0x1C, 0xE0,
  0x07, 0x38, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x0F, 0x70, 0x03,
  0x9C, 0x00, 0xE7, 0x00, 0x79, 0xC0, 0x1C, 0x70, 0x0F, 0x18, 0x0F, 0x8F,
  0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC,
  0x7F, 0xFF, 0x8E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0xFF, 0xC3,
  0xFF, 0xF8, 0x7F, 0xFF, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3F,
  0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE,
  0x1F, 0xFF, 0xE1, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xFF,
  0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xC1, 0xE1, 0xE0, 0x1C, 0x38, 0x03,
  0x8F, 0x00, 0x29, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x07, 0xF8, 0xE0, 0xFF, 0x3C, 0x1F, 0xE7, 0x00, 0x1C,
  0xE0, 0x03, 0x9C, 0x00, 0x63, 0xC0, 0x1C, 0x38, 0x03, 0x87, 0x00, 0xF0,
  0xF8, 0x6E, 0x0F, 0xFD, 0xC0, 0xFF, 0x38, 0x0F, 0x86, 0x00, 0x07, 0x00,
  0x70, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0,
  0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x1F,
  0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC3,
  0x80, 0x1C, 0x38, 0x03, 0xC3, 0x80, 0x38, 0x70, 0x03, 0x87, 0x00, 0x38,
  0x70, 0x03, 0x87, 0x00, 0x38, 0x70, 0x03, 0x87, 0x00, 0x70, 0xE0, 0x07,
  0x00, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x7F, 0xFF, 0x07, 0xFF,
  0xF0, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFC, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x86, 0x00, 0xE3, 0x80,
  0x78, 0xF0, 0x1C, 0x1E, 0x1F, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xC0,
  0x00, 0x0E, 0x00, 0x78, 0xE0, 0x07, 0x87, 0x00, 0x78, 0x38, 0x07, 0x81,
  0xC0, 0x78, 0x0E, 0x07, 0x80, 0x70, 0x78, 0x07, 0x07, 0x80, 0x38, 0x78,
  0x01, 0xC7, 0x80, 0x0E, 0x78, 0x00, 0x77, 0xC0, 0x03, 0xFE, 0x00, 0x3F,
  0x38, 0x01, 0xF1, 0xC0, 0x0F, 0x07, 0x00, 0x70, 0x38, 0x03, 0x80, 0xE0,
  0x1C, 0x07, 0x01, 0xC0, 0x3C, 0x0E, 0x00, 0xE0, 0x70, 0x07, 0x03, 0x80,
  0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x00, 0x78, 0x78, 0x07, 0xC3,
  0xC0, 0x7C, 0x1F, 0x03, 0xE1, 0xF8, 0x3F, 0x0E, 0xC1, 0xF8, 0x76, 0x1D,
  0xC3, 0xB8, 0xCE, 0x19, 0xCE, 0x60, 0xC6, 0xE7, 0x0E, 0x36, 0x38, 0x71,
  0xF1, 0xC3, 0x8F, 0x0E, 0x1C, 0x38, 0x70, 0xC1, 0x83, 0x06, 0x08, 0x38,
  0x70, 0x41, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x86, 0x00,
  0x18, 0x30, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x80,
  0x07, 0x80, 0x70, 0xF8, 0x07, 0x0F, 0x80, 0x70, 0xFC, 0x07, 0x0F, 0xC0,
  0x70, 0xDC, 0x06, 0x1C, 0xC0, 0xE1, 0xCE, 0x0E, 0x1C, 0xE0, 0xE1, 0xCE,
  0x0E, 0x1C, 0x60, 0xE1, 0x86, 0x0C, 0x38, 0x71, 0xC3, 0x87, 0x1C, 0x38,
  0x71, 0xC3, 0x83, 0x1C, 0x38, 0x39, 0xC3, 0x03, 0x98, 0x70, 0x3B, 0x87,
  0x01, 0xB8, 0x70, 0x1B, 0x87, 0x01, 0xF8, 0x70, 0x1F, 0x86, 0x01, 0xF0,
  0xE0, 0x0F, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xC1,
  0xE1, 0xE0, 0x1C, 0x38, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x06, 0x78, 0x00,
  0xEE, 0x00, 0x39, 0xC0, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x1D, 0xE0, 0x03,
  0xB8, 0x00, 0x77, 0x00, 0x1E, 0xE0, 0x03, 0x9C, 0x00, 0x73, 0x80, 0x1E,
  0x78, 0x03, 0x87, 0x00, 0xE0, 0xF0, 0x7C, 0x0F, 0xFF, 0x00, 0xFF, 0x80,
  0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0x0E, 0x00,
  0xF1, 0xC0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x07, 0x38, 0x00,
  0xE7, 0x00, 0x3C, 0xE0, 0x07, 0x1C, 0x01, 0xE3, 0xFF, 0xF8, 0x7F, 0xFE,
  0x1F, 0xFF, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xC1,
  0xE1, 0xE0, 0x1C, 0x38, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x06, 0x78, 0x00,
  0xEE, 0x00, 0x39, 0xC0, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x1D, 0xE0, 0x03,
  0xB8, 0x00, 0x77, 0x00, 0x1E, 0xE0, 0x03, 0x9C, 0x00, 0x73, 0x80, 0x1E,
  0x78, 0x03, 0x87, 0x00, 0xE0, 0xF0, 0x7C, 0x0F, 0xFF, 0x01, 0xFF, 0xC0,
  0x0F, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x06, 0x00, 0x71, 0xC0, 0x0F, 0x7C,
  0x00, 0xFE, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0,
  0x7F, 0xFF, 0x0E, 0x00, 0xF1, 0xC0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x38,
  0xE0, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x3C, 0xE0, 0x07, 0x1C, 0x01, 0xE3,
  0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x03, 0x83, 0x80, 0x70, 0x70, 0x0E,
  0x07, 0x01, 0xC0, 0xE0, 0x38, 0x1E, 0x0E, 0x01, 0xC1, 0xC0, 0x38, 0x38,
  0x03, 0x87, 0x00, 0x70, 0xE0, 0x07, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF8,
  0x07, 0xFF, 0xC0, 0xF8, 0x1E, 0x1E, 0x00, 0xF1, 0xC0, 0x06, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0xC0, 0x03, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x40, 0x01, 0xC6, 0x00, 0x1C, 0xF0, 0x03, 0x87,
  0xC0, 0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x3C, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x01,
  0xCE, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x0E, 0x70, 0x03, 0x9C, 0x00, 0xE7,
  0x00, 0x79, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x01, 0xCE, 0x00, 0x73, 0x80,
  0x1C, 0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x78, 0xE0, 0x1C,
  0x3C, 0x1F, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0xE0, 0x00,
  0xFC, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x01, 0xC6, 0x00, 0x38, 0xC0, 0x0E,
  0x1C, 0x01, 0xC3, 0x80, 0x70, 0x70, 0x0E, 0x0E, 0x03, 0x81, 0xC0, 0x70,
  0x38, 0x0E, 0x03, 0x03, 0x80, 0x60, 0x70, 0x0E, 0x1C, 0x01, 0xC3, 0x80,
  0x38, 0xE0, 0x07, 0x1C, 0x00, 0xE7, 0x00, 0x0C, 0xE0, 0x01, 0xB8, 0x00,
  0x37, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x30, 0x00,
  0x39, 0x80, 0x01, 0xCC, 0x00, 0x0C, 0x60, 0x00, 0xE7, 0x00, 0x07, 0x38,
  0x00, 0x39, 0xC0, 0x01, 0x8E, 0x1E, 0x1C, 0x70, 0xF0, 0xE3, 0x87, 0x87,
  0x18, 0x7C, 0x30, 0xC3, 0x63, 0x86, 0x3B, 0x1C, 0x31, 0x98, 0xE1, 0x8C,
  0xC6, 0x1C, 0xE6, 0x30, 0xE6, 0x33, 0x87, 0x71, 0x9C, 0x3B, 0x8E, 0xC1,
  0xD8, 0x76, 0x0F, 0xC3, 0xF0, 0x6C, 0x1F, 0x83, 0xE0, 0xF8, 0x1F, 0x07,
  0xC0, 0xF0, 0x3E, 0x00, 0x07, 0x80, 0x0F, 0x03, 0x80, 0x1E, 0x03, 0x80,
  0x1C, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0x78, 0x00, 0xE0, 0xF0, 0x00, 0xE0,
  0xE0, 0x00, 0x71, 0xC0, 0x00, 0x73, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xE7, 0x00, 0x01, 0xE7, 0x00, 0x01, 0xC3, 0x80, 0x03, 0x83,
  0x80, 0x07, 0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x3C, 0x00,
  0xE0, 0x38, 0x00, 0xE0, 0xF0, 0x00, 0x70, 0xF0, 0x00, 0x7B, 0x80, 0x07,
  0x1C, 0x00, 0x78, 0x70, 0x07, 0x83, 0x80, 0x38, 0x0E, 0x03, 0x80, 0x70,
  0x3C, 0x03, 0x81, 0xC0, 0x0E, 0x1C, 0x00, 0x71, 0xC0, 0x01, 0xDE, 0x00,
  0x0E, 0xE0, 0x00, 0x7E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC0, 0x07, 0xFE,
  0x0F, 0xFC, 0x1F, 0xF8, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x0E, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xC0, 0x60,
  0x30, 0x1C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x70, 0x18, 0x0C, 0x06, 0x03,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0E, 0x03, 0x01, 0x80, 0xC0, 0x70, 0x18,
  0x0C, 0x06, 0x03, 0x81, 0xC0, 0x60, 0x30, 0x18, 0x0E, 0x03, 0x03, 0xFF,
  0x03, 0xFE, 0x07, 0xFE, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0,
  0xFF, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xE7, 0x00,
  0x1C, 0xE0, 0x07, 0x0C, 0x01, 0xC1, 0xC0, 0x38, 0x38, 0x0E, 0x03, 0x83,
  0x80, 0x70, 0xE0, 0x06, 0x1C, 0x00, 0xE7, 0x00, 0x1D, 0xC0, 0x01, 0xD0,
  0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF8, 0x27, 0x1C, 0xE3,
  0x1C, 0x40, 0x03, 0xE1, 0x87, 0xFD, 0xC7, 0xFE, 0xE7, 0xC1, 0xF3, 0x80,
  0x7B, 0x80, 0x1D, 0xC0, 0x0C, 0xE0, 0x0E, 0xE0, 0x07, 0x70, 0x03, 0xB8,
  0x01, 0xDC, 0x00, 0xEE, 0x00, 0xE7, 0x00, 0xF3, 0x80, 0x79, 0xF0, 0xDC,
  0x7F, 0xEF, 0x9F, 0xE7, 0xC7, 0xC1, 0xE0, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x7C, 0x07, 0x3F, 0xC1, 0xDF, 0xF8, 0xEC, 0x1E, 0x3E, 0x03,
  0x8F, 0x00, 0x63, 0x80, 0x1C, 0xE0, 0x07, 0x30, 0x01, 0xDC, 0x00, 0xE7,
  0x00, 0x39, 0xC0, 0x0E, 0x70, 0x03, 0x9C, 0x01, 0xC7, 0x00, 0xF3, 0xA0,
  0x78, 0xEF, 0xFC, 0x39, 0xFE, 0x0E, 0x3F, 0x00, 0x03, 0xF0, 0x0F, 0xFC,
  0x1F, 0xFE, 0x3C, 0x1E, 0x78, 0x07, 0x70, 0x06, 0x70, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x08, 0xE0, 0x0E, 0xE0, 0x0E,
  0xE0, 0x1C, 0x78, 0x78, 0x7F, 0xF0, 0x3F, 0xE0, 0x0F, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x03, 0xE1, 0xC1, 0xFF, 0x38, 0x7F, 0xF6,
  0x1F, 0x07, 0xC3, 0x80, 0x78, 0xF0, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x1C,
  0xE0, 0x03, 0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0xF1,
  0xC0, 0x1E, 0x38, 0x07, 0x83, 0xC3, 0xF0, 0x7F, 0xEE, 0x07, 0xF9, 0xC0,
  0x7C, 0x38, 0x00, 0x01, 0xF8, 0x0F, 0xFE, 0x1F, 0xFF, 0x3E, 0x0F, 0x78,
  0x07, 0x70, 0x07, 0xE0, 0x0F, 0xE0, 0x7E, 0xFF, 0xFC, 0xFF, 0xF0, 0xFF,
  0x00, 0xE0, 0x00, 0xE0, 0x04, 0xE0, 0x06, 0xE0, 0x0F, 0xF8, 0x3C, 0x7F,
  0xF8, 0x3F, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x06, 0x00, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x20, 0x70, 0x00, 0x70,
  0x70, 0x00, 0xF8, 0x70, 0x00, 0x78, 0x70, 0x00, 0x3C, 0x70, 0x00, 0x1E,
  0x60, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xF0, 0xE0, 0xFF, 0x98, 0x3F, 0xFB, 0x0F, 0x83, 0xE1, 0xC0, 0x3C, 0x78,
  0x03, 0x8E, 0x00, 0x71, 0xC0, 0x0C, 0x70, 0x01, 0x8E, 0x00, 0x71, 0xC0,
  0x0E, 0x38, 0x01, 0xC7, 0x00, 0x78, 0xE0, 0x0E, 0x1E, 0x02, 0xC1, 0xE1,
  0xF8, 0x3F, 0xF7, 0x03, 0xFC, 0xE0, 0x3E, 0x1C, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x80, 0x3C, 0x1C, 0x0F, 0x07, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xF8,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x7C, 0x0E, 0x7F, 0x07, 0x7F,
  0xC3, 0xB0, 0xE1, 0xE0, 0x79, 0xE0, 0x1C, 0xF0, 0x0E, 0x70, 0x07, 0x38,
  0x03, 0x1C, 0x03, 0x8C, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x39,
  0xC0, 0x18, 0xE0, 0x1C, 0x60, 0x0E, 0x70, 0x07, 0x38, 0x03, 0x80, 0x00,
  0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0x01, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07,
  0x02, 0x07, 0x07, 0x06, 0x0F, 0x06, 0x1E, 0x0E, 0x7C, 0x0E, 0xF8, 0x0F,
  0xF0, 0x0F, 0xC0, 0x07, 0x80, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x07, 0xFF, 0x03, 0xFF, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x20, 0x38,
  0x18, 0x1C, 0x1E, 0x0E, 0x07, 0x87, 0x01, 0xE3, 0x00, 0x7B, 0x80, 0x1F,
  0xC0, 0x07, 0xE0, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x7C, 0x03, 0x9F, 0xE0, 0x77, 0xFC, 0x0F, 0xC3, 0xC1, 0xA0,
  0x38, 0x78, 0x07, 0x0F, 0x01, 0xC1, 0xC0, 0x38, 0x38, 0x1E, 0x07, 0x0F,
  0x80, 0xCF, 0xC0, 0x38, 0xC0, 0x07, 0x1C, 0x08, 0xE3, 0x83, 0x9C, 0x38,
  0xFB, 0x87, 0x3C, 0x60, 0x7F, 0x1C, 0x0F, 0xC3, 0x80, 0xE0, 0x00, 0xFF,
  0xC1, 0xFF, 0x03, 0xFE, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x10, 0xE0,
  0xF1, 0xC3, 0xC3, 0x0F, 0x06, 0x3C, 0x1C, 0xF0, 0x3F, 0xC0, 0x7F, 0x00,
  0x78, 0x00, 0x1C, 0xF1, 0xE1, 0xDF, 0x3F, 0x1F, 0xFF, 0xF1, 0xE3, 0xE7,
  0x1C, 0x3C, 0x31, 0xC3, 0x83, 0x38, 0x38, 0x33, 0x83, 0x87, 0x38, 0x30,
  0x73, 0x83, 0x07, 0x38, 0x70, 0x63, 0x07, 0x06, 0x70, 0x70, 0x67, 0x07,
  0x0E, 0x70, 0x60, 0xE7, 0x06, 0x0E, 0x60, 0xE0, 0xC6, 0x0E, 0x0C, 0xE0,
  0xE1, 0xC0, 0x1C, 0x7C, 0x0E, 0x7F, 0x07, 0x7F, 0xC3, 0xB0, 0xE3, 0xE0,
  0x79, 0xE0, 0x1C, 0xF0, 0x0E, 0x70, 0x07, 0x38, 0x03, 0x1C, 0x03, 0x9C,
  0x01, 0xCE, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x18, 0xE0, 0x1C,
  0x60, 0x0E, 0x70, 0x07, 0x38, 0x03, 0x80, 0x01, 0xF8, 0x03, 0xFF, 0x03,
  0xFF, 0xC3, 0xC1, 0xE3, 0xC0, 0x3B, 0xC0, 0x1D, 0xC0, 0x0E, 0xE0, 0x07,
  0x70, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x73, 0x00,
  0x39, 0xC0, 0x3C, 0xF0, 0x7C, 0x3F, 0xFC, 0x0F, 0xFC, 0x01, 0xF8, 0x00,
  0x0E, 0x3E, 0x01, 0xCF, 0xF0, 0x33, 0xFF, 0x0E, 0xC1, 0xE1, 0xF0, 0x1C,
  0x3C, 0x01, 0x87, 0x00, 0x38, 0xE0, 0x07, 0x18, 0x00, 0xE7, 0x00, 0x38,
  0xE0, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x07, 0x0E, 0x01, 0xE3,
  0xA0, 0x78, 0x77, 0xFE, 0x0E, 0x7F, 0x81, 0xC7, 0xE0, 0x38, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0xE1, 0xC3, 0xFE, 0x61, 0xFF, 0xD8, 0xF8, 0x3E, 0x38,
  0x07, 0x9E, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x0C, 0xE0, 0x03, 0x38, 0x01,
  0xCE, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x0F, 0x38, 0x03, 0x8E, 0x01, 0xE1,
  0xE1, 0xF8, 0x7F, 0xEE, 0x0F, 0xF3, 0x81, 0xF0, 0xE0, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0xFF, 0x0F, 0xFF, 0x9F, 0xFF, 0xDF, 0xE0, 0xEC, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0x83, 0xFF,
  0xE3, 0xC0, 0xF3, 0x80, 0x11, 0xC0, 0x00, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0xF8, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x39,
  0x80, 0x1D, 0xF0, 0x3C, 0x7F, 0xFE, 0x1F, 0xFC, 0x03, 0xF8, 0x00, 0x01,
  0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x06, 0x1C,
  0x0F, 0x1C, 0x3F, 0x1C, 0x7C, 0x1D, 0xF8, 0x1F, 0xE0, 0x1F, 0xC0, 0x0F,
  0x00, 0x38, 0x03, 0x9C, 0x03, 0x8C, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0x73,
  0x80, 0x39, 0xC0, 0x1C, 0xE0, 0x1C, 0x60, 0x0E, 0x70, 0x07, 0x38, 0x03,
  0x9C, 0x01, 0xCE, 0x01, 0xE7, 0x01, 0xE3, 0x81, 0xF1, 0xE1, 0xB8, 0x7F,
  0x9C, 0x3F, 0xCE, 0x07, 0x87, 0x00, 0x7E, 0x03, 0xBF, 0x01, 0xFF, 0x80,
  0xE1, 0xC0, 0x70, 0xE0, 0x18, 0x70, 0x0C, 0x30, 0x0E, 0x18, 0x07, 0x1C,
  0x03, 0x8E, 0x01, 0xC7, 0x01, 0xE3, 0x80, 0xE1, 0xC0, 0xF0, 0xC0, 0xF0,
  0x60, 0xF0, 0x71, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x07, 0xC0, 0x00, 0x30,
  0x70, 0xCC, 0x1C, 0x77, 0x06, 0x0D, 0xC1, 0x83, 0x70, 0x60, 0xD8, 0x38,
  0x36, 0x0E, 0x0D, 0x83, 0x83, 0xE0, 0xC0, 0xF8, 0x30, 0x7E, 0x1C, 0x1F,
  0x07, 0x07, 0xC1, 0xC1, 0xB0, 0x70, 0xEC, 0x3C, 0x7B, 0x9B, 0x1C, 0xFE,
  0xFE, 0x3F, 0x3F, 0x87, 0x87, 0x80, 0x01, 0xC0, 0xF0, 0x1F, 0x1F, 0xC3,
  0xF9, 0xFE, 0x3E, 0xEC, 0x73, 0xC7, 0xC1, 0x98, 0x3E, 0x0C, 0x81, 0xE0,
  0x60, 0x0F, 0x03, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0xC0,
  0xE0, 0x0E, 0x0F, 0x02, 0x70, 0x58, 0x3B, 0x86, 0xC7, 0x9C, 0x77, 0x78,
  0x7F, 0x3F, 0x83, 0xF1, 0xF8, 0x0F, 0x07, 0x80, 0x0E, 0x00, 0xE1, 0xC0,
  0x38, 0x30, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x03, 0x87, 0x00,
  0x60, 0xE0, 0x1C, 0x18, 0x03, 0x83, 0x00, 0x70, 0xE0, 0x0E, 0x1C, 0x01,
  0xC3, 0x80, 0x70, 0x70, 0x1E, 0x0E, 0x07, 0xC1, 0xE1, 0xB8, 0x1F, 0xF7,
  0x03, 0xFC, 0xE0, 0x1E, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x80, 0x3C,
  0x3C, 0x1F, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xF8, 0x00, 0x07, 0xE1,
  0xC7, 0xFE, 0x71, 0xFF, 0xFC, 0xE0, 0xFF, 0x30, 0x07, 0x8C, 0x03, 0xC3,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C,
  0x1C, 0x0E, 0x03, 0x0F, 0x00, 0xC7, 0xE0, 0x3B, 0xFF, 0xCE, 0xFF, 0xFF,
  0xB8, 0xFF, 0xCE, 0x07, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0F, 0x03, 0xFF,
  0x01, 0xFC, 0x00, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xC0, 0x07, 0x07, 0x07, 0x06, 0x06, 0x06, 0x0E, 0x0E, 0x0E, 0x0C, 0x0C,
  0x0C, 0x1C, 0x1C, 0x1C, 0x18, 0x18, 0x18, 0x38, 0x38, 0x38, 0x30, 0x30,
  0x30, 0x70, 0x70, 0x70, 0x60, 0x60, 0x60, 0xE0, 0xE0, 0x07, 0xF8, 0x07,
  0xFC, 0x07, 0xFC, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0xC0, 0x01, 0xFF, 0x00, 0x7F, 0x01, 0xFF, 0x03, 0x80, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x00, 0x0F, 0x00, 0xC7, 0xE0, 0x33, 0xFC, 0x1D, 0xC7, 0x06, 0x60, 0xE3,
  0xB8, 0x3F, 0xCC, 0x07, 0xF3, 0x00, 0xF0,
};

const GFXglyph IBMPlexMono_Italic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 8, 25, 22, 7, -25 },
  { 26, 10, 10, 22, 8, -27 },
  { 39, 22, 25, 22, 0, -25 },
  { 108, 20, 33, 22, 1, -29 },
  { 191, 25, 25, 22, -1, -25 },
  { 270, 21, 25, 22, 0, -25 },
  { 336, 4, 10, 22, 11, -27 },
  { 341, 14, 32, 22, 7, -27 },
  { 397, 14, 32, 22, 1, -27 },
  { 453, 18, 18, 22, 2, -20 },
  { 494, 18, 19, 22, 2, -20 },
  { 537, 8, 10, 22, 5, -5 },
  { 547, 10, 3, 22, 6, -12 },
  { 551, 5, 5, 22, 7, -5 },
  { 555, 20, 32, 22, 1, -27 },
  { 635, 19, 25, 22, 2, -25 },
  { 695, 17, 25, 22, 2, -25 },
  { 749, 19, 25, 22, 1, -25 },
  { 809, 19, 25, 22, 1, -25 },
  { 869, 19, 25, 22, 1, -25 },
  { 929, 19, 25, 22, 2, -25 },
  { 989, 17, 25, 22, 2, -25 },
  { 1043, 18, 25, 22, 4, -25 },
  { 1100, 20, 25, 22, 1, -25 },
  { 1163, 17, 25, 22, 3, -25 },
  { 1217, 8, 19, 22, 7, -19 },
  { 1236, 10, 24, 22, 5, -19 },
  { 1266, 17, 21, 22, 3, -22 },
  { 1311, 18, 10, 22, 2, -16 },
  { 1334, 17, 21, 22, 2, -22 },
  { 1379, 15, 25, 22, 5, -25 },
  { 1426, 18, 29, 22, 2, -25 },
  { 1492, 19, 25, 22, 0, -25 },
  { 1552, 18, 25, 22, 2, -25 },
  { 1609, 18, 25, 22, 3, -25 },
  { 1666, 18, 25, 22, 2, -25 },
  { 1723, 19, 25, 22, 2, -25 },
  { 1783, 20, 25, 22, 2, -25 },
  { 1846, 19, 25, 22, 2, -25 },
  { 1906, 20, 25, 22, 1, -25 },
  { 1969, 20, 25, 22, 1, -25 },
  { 2032, 18, 25, 22, 2, -25 },
  { 2089, 21, 25, 22, 2, -25 },
  { 2155, 15, 25, 22, 3, -25 },
  { 2202, 21, 25, 22, 1, -25 },
  { 2268, 20, 25, 22, 1, -25 },
  { 2331, 19, 25, 22, 2, -25 },
  { 2391, 19, 25, 22, 2, -25 },
  { 2451, 19, 32, 22, 2, -25 },
  { 2527, 19, 25, 22, 2, -25 },
  { 2587, 20, 25, 22, 1, -25 },
  { 2650, 20, 25, 22, 3, -25 },
  { 2713, 18, 25, 22, 3, -25 },
  { 2770, 19, 25, 22, 4, -25 },
  { 2830, 21, 25, 22, 2, -25 },
  { 2896, 24, 25, 22, -1, -25 },
  { 2971, 21, 25, 22, 3, -25 },
  { 3037, 22, 25, 22, 0, -25 },
  { 3106, 15, 32, 22, 6, -27 },
  { 3166, 9, 32, 22, 7, -27 },
  { 3202, 16, 32, 22, 0, -27 },
  { 3266, 19, 15, 22, 2, -25 },
  { 3302, 18, 3, 22, 0, 3 },
  { 3309, 5, 7, 22, 8, -28 },
  { 3314, 17, 19, 22, 2, -19 },
  { 3355, 18, 27, 22, 2, -27 },
  { 3416, 16, 19, 22, 3, -19 },
  { 3454, 19, 27, 22, 2, -27 },
  { 3519, 16, 19, 22, 3, -19 },
  { 3557, 24, 34, 22, -1, -27 },
  { 3659, 19, 26, 22, 1, -19 },
  { 3721, 17, 27, 22, 2, -27 },
  { 3779, 16, 27, 22, 3, -27 },
  { 3833, 17, 34, 22, 2, -27 },
  { 3906, 19, 27, 22, 2, -27 },
  { 3971, 15, 27, 22, 4, -27 },
  { 4022, 20, 19, 22, 0, -19 },
  { 4070, 17, 19, 22, 2, -19 },
  { 4111, 17, 19, 22, 2, -19 },
  { 4152, 19, 26, 22, 1, -19 },
  { 4214, 18, 26, 22, 2, -19 },
  { 4273, 17, 19, 22, 4, -19 },
  { 4314, 17, 19, 22, 2, -19 },
  { 4355, 16, 25, 22, 3, -25 },
  { 4405, 17, 19, 22, 3, -19 },
  { 4446, 17, 19, 22, 2, -19 },
  { 4487, 18, 19, 22, 2, -19 },
  { 4530, 21, 19, 22, 0, -19 },
  { 4580, 19, 26, 22, 1, -19 },
  { 4642, 18, 19, 22, 2, -19 },
  { 4685, 17, 32, 22, 4, -27 },
  { 4753, 8, 32, 22, 7, -27 },
  { 4785, 16, 32, 22, 2, -27 },
  { 4849, 18, 8, 22, 2, -15 },
};

const GFXfont IBMPlexMono_Italic36pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic36pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic36pt7bGlyphs,
  0x20, 0x7E, 47
};

#endif // _IBMPLEXMONO_ITALIC36PT7B_H_
