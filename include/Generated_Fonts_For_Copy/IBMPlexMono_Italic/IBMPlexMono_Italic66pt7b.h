#ifndef _IBMPLEXMONO_ITALIC66PT7B_H_
#define _IBMPLEXMONO_ITALIC66PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic66pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x3F, 0xC0, 0xFF, 0xC1, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x78,
  0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0x8F, 0x81, 0xF1, 0xF0,
  0x3E, 0x3C, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xC7, 0xC0,
  0xF8, 0xF8, 0x1F, 0x1E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x00, 0x3C,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x07,
  0xFF, 0xE0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x07, 0xFF, 0xC0,
  0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x00, 0x07, 0x80, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x03,
  0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xF8, 0xF7, 0xFE, 0x00, 0xFE, 0x07, 0x87, 0xF8, 0x0F, 0xE0, 0x78, 0x0F,
  0xC0, 0x7E, 0x03, 0xC0, 0x3F, 0x07, 0xE0, 0x1E, 0x00, 0xE0, 0x3F, 0x00,
  0xF0, 0x04, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x38, 0x00, 0x00,
  0x7C, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x1F, 0x80, 0xF0,
  0x00, 0x00, 0xFC, 0x07, 0x80, 0x00, 0x07, 0xF0, 0x3C, 0x00, 0x00, 0x1F,
  0xC1, 0xC0, 0x00, 0x00, 0xFF, 0x9E, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x3F, 0xC0, 0x00, 0x01, 0xE0,
  0xFE, 0x00, 0x00, 0x0F, 0x03, 0xF8, 0x00, 0x00, 0x78, 0x0F, 0xC0, 0x00,
  0x07, 0x80, 0x7E, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x0F,
  0x80, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x07, 0xE0, 0x20, 0x03,
  0xC0, 0x3F, 0x03, 0x00, 0x3C, 0x01, 0xF8, 0x3C, 0x01, 0xE0, 0x1F, 0x83,
  0xF0, 0x0F, 0x00, 0xFC, 0x1F, 0xC0, 0x78, 0x1F, 0xC0, 0x7F, 0x83, 0xC1,
  0xFE, 0x01, 0xFF, 0x1E, 0x7F, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0x00, 0x03,
  0xE0, 0x07, 0xE0, 0xF8, 0x00, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x01,
  0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x00, 0x3E, 0x00,
  0x7C, 0x07, 0x80, 0x01, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x00, 0x1E,
  0x07, 0xC0, 0x00, 0x7C, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0x0F, 0x83,
  0xE0, 0x00, 0x0F, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x0F, 0x83, 0xE0,
  0x00, 0x01, 0xFF, 0xFC, 0x1E, 0x00, 0x00, 0x0F, 0xFF, 0xC1, 0xF0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xC1, 0xFF, 0xF0, 0x00, 0x00, 0x7C, 0x1F, 0x07, 0xC0, 0x00, 0x03, 0xC1,
  0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x78, 0x00, 0x03, 0xE0, 0xF0,
  0x03, 0xC0, 0x00, 0x3E, 0x07, 0x80, 0x1E, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0xF8, 0x00, 0x1F, 0x03, 0xC0, 0x07, 0xC0, 0x01, 0xF0, 0x1E, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0xF0, 0x01, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0xF8, 0x00, 0x78, 0x03, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x03, 0xE0, 0x03, 0xC0,
  0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x83, 0xF0, 0x03, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x10, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x1F,
  0xE0, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x00, 0xF8,
  0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x00, 0x7F, 0xFB, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFB, 0xFF, 0x80, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x87, 0xE0,
  0x00, 0xFC, 0x00, 0xCF, 0xC0, 0x00, 0xF8, 0x03, 0xDF, 0x80, 0x03, 0xF8,
  0x0F, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0x7E, 0x00, 0x1D, 0xF0, 0x7C, 0x7E,
  0x00, 0x33, 0xF0, 0xF8, 0xFC, 0x00, 0xE7, 0xE3, 0xE1, 0xFE, 0x07, 0xC7,
  0xEF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFE, 0x01,
  0xFF, 0xF8, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0x00, 0x1F, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x7C, 0x7C, 0x7C,
  0x7C, 0x7C, 0x78, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x18, 0x00, 0x7C, 0x00, 0x6F,
  0x80, 0x3C, 0x01, 0xFF, 0xF8, 0x3E, 0x07, 0xFF, 0xFF, 0x9F, 0x3F, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x01, 0xF8, 0xF8, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x1F,
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0xF8, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x0F,
  0xF0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E,
  0x00, 0x78, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0x1F, 0xEF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xEF, 0xFB, 0xFC, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x07, 0xE0, 0x00,
  0xFC, 0x03, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x00, 0xF8, 0x3F, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x0F, 0x87, 0xE0,
  0x00, 0x03, 0xF1, 0xF0, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x00, 0xFC,
  0xF8, 0x00, 0x00, 0x3E, 0x7E, 0x01, 0xF0, 0x0F, 0x9F, 0x80, 0xFE, 0x03,
  0xE7, 0xE0, 0x7F, 0x80, 0xF9, 0xF0, 0x1F, 0xE0, 0x7E, 0x7C, 0x07, 0xF8,
  0x1F, 0xBF, 0x01, 0xFE, 0x07, 0xEF, 0xC0, 0x7F, 0x01, 0xFB, 0xF0, 0x0F,
  0x80, 0x7C, 0xFC, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x0F, 0xCF, 0x80,
  0x00, 0x03, 0xF3, 0xE0, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x3E, 0x3E,
  0x00, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x1F,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x07,
  0xF0, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03,
  0xFD, 0xF0, 0x00, 0x0F, 0xF3, 0xE0, 0x00, 0x3F, 0x87, 0xC0, 0x00, 0xFE,
  0x1F, 0x80, 0x07, 0xF8, 0x3F, 0x00, 0x1F, 0xE0, 0x7C, 0x00, 0x7F, 0x80,
  0xF8, 0x01, 0xFC, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x01, 0xC0, 0x0F,
  0xC0, 0x01, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x1F, 0xE0, 0x3F, 0xE0, 0x0F, 0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x40, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xE0, 0x3F, 0xE0,
  0x0F, 0xE0, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x1C, 0x00, 0x03, 0xF0, 0x02, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x04, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x04,
  0x00, 0x00, 0x1F, 0x87, 0x80, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x3F, 0x1F, 0x00,
  0x00, 0x07, 0xE1, 0xF0, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x3E, 0x00,
  0x01, 0xF0, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x3E, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x1F, 0xE0, 0x00, 0x1F, 0x0F, 0xFF, 0x00,
  0x03, 0xE7, 0xFF, 0xF8, 0x00, 0x7D, 0xFF, 0xFF, 0x80, 0x0F, 0x7F, 0xFF,
  0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x0F, 0xC0,
  0x00, 0xFE, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x80, 0x00, 0x07, 0xE0, 0x78, 0x00, 0x01, 0xF8, 0x1F,
  0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x07, 0xF0,
  0x07, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x83, 0xFC,
  0x00, 0x3F, 0x1F, 0xFF, 0x00, 0xFC, 0x7F, 0xFF, 0x01, 0xF3, 0xFF, 0xFF,
  0x07, 0xEF, 0xFF, 0xFF, 0x0F, 0xBF, 0x01, 0xFF, 0x1F, 0x70, 0x00, 0xFE,
  0x7F, 0xC0, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xEF, 0xC0,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x7E, 0x3F, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0xF3, 0xE0, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x01, 0xF8, 0xF8,
  0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0xFC, 0x3E,
  0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x00, 0x07, 0xF0, 0x1F,
  0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x03, 0xF0, 0x3E, 0x00,
  0x00, 0x7C, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x07, 0xE0, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80,
  0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x7C,
  0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x00, 0xF8,
  0xFC, 0x00, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x00,
  0xFC, 0x7C, 0x00, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x03, 0xF1, 0xF0, 0x00,
  0x00, 0x7E, 0x3F, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x81, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x03, 0xF8, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00,
  0xFD, 0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x3F, 0xBF,
  0x80, 0x01, 0xFF, 0x3F, 0x80, 0x07, 0xFC, 0x7F, 0xC0, 0x3E, 0xF8, 0x7F,
  0xFF, 0xFB, 0xF0, 0x7F, 0xFF, 0xE7, 0xC0, 0x7F, 0xFF, 0x1F, 0x80, 0x7F,
  0xFC, 0x3E, 0x00, 0x1F, 0xE0, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x1F, 0xF0, 0x7F, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0,
  0xFF, 0x83, 0xFE, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x1F, 0xE0, 0xFF, 0xC3, 0xFF, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFC,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x02, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x7F,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x0F, 0x9F, 0x00, 0x00, 0x7F, 0x78, 0x00, 0x03, 0xF0, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00,
  0xF8, 0xF8, 0x00, 0xF8, 0x7C, 0x7C, 0x01, 0xFF, 0x3E, 0x3E, 0x03, 0xFF,
  0x9F, 0x1E, 0x01, 0xFF, 0xEF, 0x9F, 0x01, 0xF8, 0x37, 0xCF, 0x81, 0xF8,
  0x0F, 0xC7, 0xC0, 0xF8, 0x03, 0xE3, 0xE0, 0xF8, 0x01, 0xF3, 0xE0, 0x7C,
  0x00, 0xF9, 0xF0, 0x7E, 0x00, 0x7C, 0xF8, 0x3E, 0x00, 0x3E, 0x7C, 0x1F,
  0x00, 0x1E, 0x3E, 0x0F, 0x80, 0x0F, 0x1F, 0x07, 0xC0, 0x0F, 0x9F, 0x07,
  0xE0, 0x07, 0xCF, 0x83, 0xE0, 0x03, 0xE7, 0xC1, 0xF0, 0x01, 0xF3, 0xE0,
  0xF8, 0x00, 0xF1, 0xF0, 0x7C, 0x00, 0xF8, 0xF8, 0x3E, 0x00, 0x7C, 0x7C,
  0x1F, 0x00, 0x3E, 0x3C, 0x0F, 0x80, 0x3F, 0x1E, 0x03, 0xC0, 0x3F, 0x8F,
  0x01, 0xF0, 0x37, 0x87, 0x80, 0xFC, 0x3B, 0xC3, 0xC0, 0x3F, 0xFB, 0xE1,
  0xE0, 0x1F, 0xF9, 0xF0, 0xF8, 0x07, 0xF8, 0xF8, 0x7C, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x00, 0x7C, 0x3E, 0x00, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x00, 0xF8, 0x3E,
  0x00, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x1F,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x1F, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x1F,
  0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x01, 0xF0,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x00, 0x00, 0x7C, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x00, 0x7E, 0x1F, 0x80, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x00, 0x3E, 0x3F,
  0x00, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x1F, 0xE0, 0x1F, 0x00, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0,
  0x3E, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0x7E, 0x07, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x7C, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x07, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x07, 0xE0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x0F,
  0xC1, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x03, 0xF0, 0xF8, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x07, 0xF0, 0x7C, 0x00, 0x0F, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFC, 0x07, 0xF0, 0x07, 0xF8,
  0x01, 0xFC, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x07, 0xC1, 0xF8, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x01, 0xC0, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x18, 0x1F, 0x80, 0x00,
  0x0F, 0x07, 0xC0, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x07, 0xC1, 0xF8, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x07, 0xF0, 0x1F, 0xC0,
  0x07, 0xF0, 0x07, 0xF8, 0x0F, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x1F, 0x80, 0x1F, 0xF0, 0x0F, 0xC0, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0xFE,
  0x03, 0xE0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00,
  0x7C, 0x1F, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x0F, 0x87, 0xE0, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x03, 0xE1, 0xF8, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x00, 0xFC, 0x3E, 0x00,
  0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x1F, 0x8F, 0x80,
  0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x07, 0xE1, 0xF0,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0xF8, 0x7C,
  0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x7E, 0x0F,
  0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x83,
  0xE0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x1F, 0xC0, 0xF8, 0x00, 0x3F, 0xC0,
  0x7C, 0x00, 0x7F, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F,
  0xE0, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0x18, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xFE, 0x1F,
  0x80, 0x1F, 0xFF, 0x87, 0xC0, 0x0F, 0xFF, 0xE3, 0xF0, 0x03, 0xFF, 0xF8,
  0xFC, 0x00, 0xFF, 0xFE, 0x3F, 0x00, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x07,
  0xC3, 0xF0, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00,
  0x1F, 0x0F, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xF0, 0x7C, 0x00,
  0x00, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x06, 0xF8, 0x0F, 0xE0, 0x07, 0xBE, 0x01,
  0xFE, 0x07, 0xDF, 0x00, 0x7F, 0xFF, 0xE7, 0xC0, 0x0F, 0xFF, 0xF1, 0xF0,
  0x01, 0xFF, 0xF8, 0x7C, 0x00, 0x3F, 0xFC, 0x1F, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x3F, 0x01, 0xF0,
  0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x3F, 0x00, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00,
  0x7E, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0x7E, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x7C, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x00,
  0xF8, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0xF8, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x00,
  0x00, 0x3F, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x3E, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x3E, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x7E, 0x00,
  0x00, 0x7C, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0xFC, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0xFC, 0x00,
  0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x01, 0xF8, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x07, 0x00, 0x00, 0xFC, 0x0F,
  0x80, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x7F, 0x80,
  0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFF, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x01, 0xF0, 0x00, 0x07, 0xF0, 0x01, 0xF0, 0x00, 0x0F, 0xE0, 0x01, 0xF0,
  0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x01, 0xFC, 0x00, 0x03,
  0xE0, 0x03, 0xF8, 0x00, 0x03, 0xE0, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x0F,
  0xE0, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00,
  0x07, 0xC0, 0x7F, 0x00, 0x00, 0x07, 0xC0, 0xFE, 0x00, 0x00, 0x07, 0xC1,
  0xFC, 0x00, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x00, 0x0F, 0xC7, 0xF0, 0x00,
  0x00, 0x0F, 0xCF, 0xF0, 0x00, 0x00, 0x0F, 0x9F, 0xF8, 0x00, 0x00, 0x0F,
  0x9F, 0xF8, 0x00, 0x00, 0x0F, 0xBF, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x7E, 0x00, 0x00, 0x1F, 0xF8, 0x7E, 0x00, 0x00,
  0x1F, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0xC0,
  0x1F, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x3E, 0xF8, 0x0F,
  0xBC, 0x00, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x01, 0xF3, 0xE0, 0x3E,
  0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x1E, 0x07, 0xC7, 0xC0, 0x7C,
  0x7C, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0xF8, 0xF8, 0x07, 0xC7, 0xC3, 0xC3,
  0xE0, 0x3E, 0x0F, 0x1F, 0x0F, 0x80, 0xF8, 0x3C, 0xF8, 0x3E, 0x03, 0xE0,
  0xFB, 0xE0, 0xF8, 0x0F, 0x83, 0xFF, 0x03, 0xE0, 0x3E, 0x07, 0xF8, 0x1F,
  0x00, 0xF8, 0x1F, 0xE0, 0x7C, 0x07, 0xC0, 0x7F, 0x01, 0xF0, 0x1F, 0x01,
  0xFC, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0x7C,
  0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xE0, 0x0F, 0x80, 0xF8, 0x01,
  0x80, 0x3E, 0x03, 0xE0, 0x04, 0x00, 0xF8, 0x0F, 0x80, 0x10, 0x03, 0xE0,
  0x3E, 0x00, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xF0,
  0x1F, 0xE0, 0x00, 0x1F, 0x01, 0xFF, 0x00, 0x01, 0xF0, 0x1F, 0xF0, 0x00,
  0x3F, 0x01, 0xFF, 0x00, 0x03, 0xE0, 0x3F, 0xF0, 0x00, 0x3E, 0x03, 0xEF,
  0x80, 0x03, 0xE0, 0x3E, 0xF8, 0x00, 0x3E, 0x03, 0xEF, 0x80, 0x03, 0xE0,
  0x3E, 0xF8, 0x00, 0x7E, 0x03, 0xE7, 0x80, 0x07, 0xC0, 0x7C, 0x7C, 0x00,
  0x7C, 0x07, 0xC7, 0xC0, 0x07, 0xC0, 0x7C, 0x7C, 0x00, 0x7C, 0x07, 0xC3,
  0xC0, 0x07, 0xC0, 0x7C, 0x3E, 0x00, 0xF8, 0x07, 0xC3, 0xE0, 0x0F, 0x80,
  0xF8, 0x3E, 0x00, 0xF8, 0x0F, 0x83, 0xE0, 0x0F, 0x80, 0xF8, 0x1E, 0x00,
  0xF8, 0x0F, 0x81, 0xF0, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x0F, 0x81,
  0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x1F, 0x01,
  0xF0, 0x0F, 0x81, 0xF0, 0x1F, 0x00, 0xF8, 0x1F, 0x01, 0xF0, 0x0F, 0x83,
  0xE0, 0x3F, 0x00, 0x78, 0x3E, 0x03, 0xE0, 0x07, 0xC3, 0xE0, 0x3E, 0x00,
  0x7C, 0x3E, 0x03, 0xE0, 0x07, 0xC3, 0xE0, 0x3E, 0x00, 0x3C, 0x3E, 0x03,
  0xE0, 0x03, 0xE7, 0xC0, 0x7E, 0x00, 0x3E, 0x7C, 0x07, 0xC0, 0x03, 0xE7,
  0xC0, 0x7C, 0x00, 0x3E, 0x7C, 0x07, 0xC0, 0x01, 0xE7, 0xC0, 0x7C, 0x00,
  0x1F, 0x7C, 0x07, 0xC0, 0x01, 0xFF, 0x80, 0xFC, 0x00, 0x1F, 0xF8, 0x0F,
  0x80, 0x00, 0xFF, 0x80, 0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0x80, 0x00, 0xFF,
  0x80, 0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0x80,
  0x1F, 0xE0, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x00, 0xFC, 0x7C, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x3E, 0x7E,
  0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x03, 0xF3, 0xE0, 0x00,
  0x00, 0xF8, 0xF8, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0x1F, 0x8F, 0x80,
  0x00, 0x07, 0xC3, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x07, 0xFC,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x00, 0x01,
  0xFC, 0x01, 0xF0, 0x00, 0x0F, 0xE0, 0x1F, 0x00, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x3E, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00,
  0x3E, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0x7C, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x0F,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F,
  0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xF8,
  0x3F, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x00, 0x3E, 0x7E, 0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x03, 0xE7, 0xE0,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x7C,
  0xFC, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x03,
  0xF3, 0xE0, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00,
  0x1F, 0x8F, 0x80, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x00, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x07, 0xF0, 0x03,
  0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x08, 0x00, 0x03, 0xF0, 0x03, 0x00, 0x00, 0x7E,
  0x03, 0xE0, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00,
  0x7E, 0x7F, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0x00, 0x01, 0xFC, 0x01, 0xF0, 0x00, 0x0F, 0xE0, 0x1F, 0x00, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x3E, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x3E, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x3E,
  0x00, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0x7C, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0xFC,
  0x00, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x01, 0xF0,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0xF8, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x3F,
  0x80, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0x1C,
  0x07, 0xE0, 0x00, 0x00, 0x80, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x10, 0x00, 0x00,
  0x1F, 0x83, 0x80, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00,
  0xFC, 0x1F, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0x83, 0xF0, 0x00,
  0x03, 0xE0, 0xFC, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7E, 0x0F, 0x80,
  0x00, 0x1F, 0x83, 0xE0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x01, 0xF0, 0x7E,
  0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0xC1,
  0xF0, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3E,
  0x0F, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01,
  0xF8, 0x3E, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0x07, 0xC1, 0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x7C, 0x1F, 0x00,
  0x00, 0x3F, 0x07, 0xC0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0xFC,
  0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x1F, 0x83,
  0xE0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x00, 0x3E, 0x1F, 0x00,
  0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x7E,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00,
  0x7C, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x03, 0xE0, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x07,
  0xC0, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0xF8,
  0x0F, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x00, 0x7C, 0x7C,
  0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0x3E,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0xF0, 0x00, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x03, 0xC0,
  0xF8, 0x00, 0x00, 0x0F, 0x81, 0xF0, 0x0F, 0xE0, 0x1F, 0x03, 0xE0, 0x1F,
  0xC0, 0x3E, 0x07, 0xC0, 0x7F, 0x80, 0x78, 0x0F, 0x00, 0xFF, 0x01, 0xF0,
  0x1E, 0x01, 0xFE, 0x03, 0xE0, 0x3C, 0x07, 0xFC, 0x07, 0xC0, 0xF8, 0x0F,
  0x78, 0x0F, 0x81, 0xF0, 0x1E, 0xF0, 0x3E, 0x03, 0xE0, 0x79, 0xE0, 0x7C,
  0x07, 0xC0, 0xF3, 0xC0, 0xF8, 0x0F, 0x83, 0xE7, 0x81, 0xF0, 0x1F, 0x07,
  0x8F, 0x07, 0xC0, 0x3E, 0x0F, 0x1E, 0x0F, 0x80, 0x78, 0x3E, 0x3C, 0x1F,
  0x00, 0xF0, 0x78, 0x78, 0x3E, 0x01, 0xE1, 0xF0, 0xF0, 0x78, 0x03, 0xC3,
  0xC1, 0xE1, 0xF0, 0x0F, 0x87, 0x83, 0xC3, 0xE0, 0x1F, 0x1F, 0x07, 0x87,
  0xC0, 0x3E, 0x3C, 0x0F, 0x0F, 0x00, 0x7C, 0x78, 0x1F, 0x3E, 0x00, 0xF9,
  0xF0, 0x3E, 0x7C, 0x01, 0xF3, 0xC0, 0x7C, 0xF8, 0x03, 0xEF, 0x80, 0xF9,
  0xE0, 0x07, 0x9F, 0x01, 0xF7, 0xC0, 0x0F, 0x3C, 0x03, 0xEF, 0x80, 0x1E,
  0xF8, 0x03, 0xDF, 0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x00, 0x7B, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xC0, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xC3, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xBF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x07,
  0xE0, 0x00, 0x00, 0x3E, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xFB, 0xE0, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x00, 0x1F, 0xC3, 0xE0, 0x00, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00, 0x0F, 0x8F, 0xC0, 0x00,
  0x00, 0x3E, 0x7E, 0x00, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xE0, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xF9, 0xF0, 0x00,
  0x00, 0x7E, 0x7C, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x07, 0xE0, 0x7C, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x07, 0xC0, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x7C, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x1F,
  0x80, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x00, 0xF9,
  0xF0, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x07, 0xCE, 0x00, 0x00, 0x01,
  0xC1, 0x00, 0x00, 0x00, 0x40, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x08, 0x78, 0xFC, 0x7C, 0x7C, 0x3E, 0x3E, 0x1E, 0x1E, 0x1F, 0x0F,
  0x0F, 0x04, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x3F, 0x00, 0xFF,
  0xFE, 0x3E, 0x01, 0xFF, 0xFE, 0x3E, 0x03, 0xFF, 0xFF, 0x3E, 0x07, 0xF8,
  0x0F, 0xBE, 0x0F, 0xE0, 0x03, 0xBE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0x80,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x7C, 0x3E, 0x00,
  0x00, 0x7C, 0x7E, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x00, 0xF8, 0xFC, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0xF8, 0xFC, 0x00,
  0x00, 0xF8, 0xF8, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x03, 0xF0, 0xF8, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x07, 0xE0, 0xF8, 0x00,
  0x0F, 0xE0, 0xFC, 0x00, 0x1F, 0xE0, 0xFC, 0x00, 0x3B, 0xE0, 0x7E, 0x00,
  0x73, 0xE0, 0x7F, 0x81, 0xF3, 0xFE, 0x3F, 0xFF, 0xE3, 0xFE, 0x3F, 0xFF,
  0xC3, 0xFE, 0x1F, 0xFF, 0x81, 0xFE, 0x0F, 0xFF, 0x00, 0xFE, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x7F, 0x00, 0x07, 0xC1, 0xFF, 0xE0, 0x03, 0xE1, 0xFF, 0xF8,
  0x01, 0xF1, 0xFF, 0xFE, 0x00, 0xF9, 0xFF, 0xFF, 0x80, 0xFD, 0xF0, 0x3F,
  0xC0, 0x7C, 0xE0, 0x07, 0xF0, 0x3E, 0xE0, 0x01, 0xF8, 0x1F, 0x60, 0x00,
  0x7C, 0x0F, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0x07, 0xC3, 0xF0, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x00, 0xF8, 0x7C, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0x7E, 0x3F, 0x00,
  0x00, 0x3F, 0x1F, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x7E, 0x0F,
  0xF8, 0x00, 0xFF, 0x07, 0xDF, 0x01, 0xFF, 0x03, 0xE7, 0xFF, 0xFF, 0x01,
  0xF1, 0xFF, 0xFF, 0x00, 0xF8, 0x7F, 0xFF, 0x00, 0x7C, 0x1F, 0xFE, 0x00,
  0x40, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03,
  0xFE, 0x07, 0xF8, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x1F, 0x80,
  0x00, 0xF8, 0xF8, 0x00, 0x03, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x18, 0xF8, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0xFC, 0x1F, 0x80, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xF8, 0x07, 0xC0, 0x03, 0xFF,
  0xE0, 0xF8, 0x00, 0xFF, 0xFE, 0x1F, 0x00, 0x3F, 0xFF, 0xE3, 0xE0, 0x0F,
  0xFF, 0xFE, 0xFC, 0x03, 0xFE, 0x03, 0xDF, 0x00, 0xFE, 0x00, 0x1F, 0xE0,
  0x3F, 0x80, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x0F, 0x81, 0xF8, 0x00,
  0x01, 0xF0, 0x3E, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x07, 0xC1, 0xF8,
  0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x1F, 0x81, 0xF0, 0x00,
  0x03, 0xE0, 0x3E, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x3F, 0x80, 0xF8,
  0x00, 0x07, 0xF0, 0x1F, 0x80, 0x01, 0xFE, 0x03, 0xF0, 0x00, 0x7F, 0xC0,
  0x3F, 0x00, 0x3D, 0xF0, 0x07, 0xF8, 0x1F, 0x3E, 0x00, 0x7F, 0xFF, 0xE7,
  0xC0, 0x0F, 0xFF, 0xF8, 0xF8, 0x00, 0xFF, 0xFE, 0x1F, 0x00, 0x0F, 0xFF,
  0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xF8, 0x1F, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC3, 0xF0, 0x00,
  0x3F, 0x1F, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x07, 0xE7,
  0xC0, 0x00, 0x7F, 0x3F, 0x00, 0x0F, 0xFC, 0xFC, 0x07, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x43, 0xF0, 0x00, 0x03, 0xCF, 0xC0, 0x00, 0x1F,
  0x9F, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x3F, 0x83,
  0xFC, 0x07, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x80,
  0x03, 0xE0, 0x00, 0x00, 0x38, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x1F,
  0x00, 0x00, 0x03, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xF1, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC1, 0xF0, 0x03, 0xFF,
  0xF8, 0x7C, 0x01, 0xFF, 0xFF, 0x1F, 0x00, 0xFF, 0xFF, 0xEF, 0xC0, 0x7F,
  0xC0, 0x7B, 0xE0, 0x3F, 0x80, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x07,
  0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8,
  0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1F, 0x83, 0xE0,
  0x00, 0x07, 0xE0, 0xF8, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x37, 0xC0, 0xFE, 0x00, 0x1D, 0xF0,
  0x1F, 0x80, 0x0E, 0xFC, 0x07, 0xF8, 0x1F, 0xBE, 0x00, 0xFF, 0xFF, 0xCF,
  0x80, 0x3F, 0xFF, 0xE3, 0xE0, 0x07, 0xFF, 0xF0, 0xF8, 0x00, 0x7F, 0xF0,
  0x3E, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x10, 0x00, 0x07, 0xE0, 0x0E, 0x00, 0x03, 0xF0, 0x07,
  0xC0, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x03, 0xF0, 0x01, 0xF8, 0x3F, 0xF0, 0x07, 0xE3, 0xFF, 0xF0, 0x1F, 0x1F,
  0xFF, 0xE0, 0x7C, 0x7F, 0xFF, 0x81, 0xF3, 0xC0, 0xFF, 0x07, 0xDC, 0x01,
  0xFC, 0x3F, 0x60, 0x03, 0xF0, 0xFF, 0x00, 0x0F, 0xC3, 0xE8, 0x00, 0x1F,
  0x0F, 0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x07, 0xC7,
  0xE0, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x01, 0xF1, 0xF0,
  0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0xFC, 0x00,
  0x03, 0xE3, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x01,
  0xF8, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x7C,
  0x7E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3F, 0x1F,
  0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x0F, 0x8F, 0x80,
  0x00, 0x3E, 0x3E, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x80, 0x03, 0xE0, 0x03, 0x80, 0x0F, 0xC0,
  0x1F, 0x80, 0x1F, 0x00, 0x7F, 0x80, 0x3E, 0x01, 0xFC, 0x00, 0x7C, 0x07,
  0xF0, 0x00, 0xF8, 0x1F, 0xC0, 0x03, 0xF0, 0x7F, 0x00, 0x07, 0xC3, 0xFC,
  0x00, 0x0F, 0x8F, 0xF0, 0x00, 0x1F, 0x3F, 0xC0, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x10, 0x00,
  0x7C, 0x00, 0x70, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07,
  0xC0, 0x07, 0xF0, 0x0F, 0x80, 0x07, 0xF0, 0x1F, 0x00, 0x0F, 0xE0, 0x3E,
  0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x0F, 0xE3, 0xE0,
  0x00, 0x0F, 0xE7, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x03, 0xF8, 0x00, 0x1F, 0x83, 0xFF, 0x80, 0x07, 0xE3, 0xFF, 0xF0,
  0x01, 0xF1, 0xFF, 0xFE, 0x00, 0x7C, 0x7F, 0xFF, 0x80, 0x1F, 0x3C, 0x0F,
  0xF0, 0x07, 0xDE, 0x00, 0xFC, 0x03, 0xF6, 0x00, 0x3F, 0x00, 0xFF, 0x00,
  0x07, 0xC0, 0x3F, 0x80, 0x01, 0xF0, 0x0F, 0xE0, 0x00, 0x7C, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xE0, 0x1F,
  0x80, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0xFE, 0x00,
  0x7C, 0x00, 0xFE, 0x00, 0x1F, 0x01, 0xFF, 0x00, 0x0F, 0xC3, 0xFF, 0x00,
  0x03, 0xF1, 0xFE, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0x0F, 0x83, 0xF0, 0x00, 0x83, 0xE0, 0x7C, 0x00, 0x71, 0xF8, 0x1F,
  0x80, 0x3E, 0x7E, 0x03, 0xE0, 0x1F, 0xDF, 0x00, 0xFC, 0x0F, 0xE7, 0xC0,
  0x3F, 0x07, 0xF1, 0xF0, 0x07, 0xC3, 0xF8, 0x7C, 0x01, 0xF9, 0xFC, 0x3F,
  0x00, 0x3F, 0xFE, 0x0F, 0x80, 0x0F, 0xFE, 0x03, 0xE0, 0x01, 0xFF, 0x00,
  0xF8, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xFF, 0xC0,
  0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xC0,
  0x3E, 0x00, 0x3C, 0x03, 0xE0, 0x07, 0xE0, 0x3E, 0x00, 0xFF, 0x03, 0xE0,
  0x1F, 0xC0, 0x7E, 0x03, 0xF8, 0x07, 0xC0, 0x7F, 0x00, 0x7C, 0x1F, 0xE0,
  0x07, 0xC3, 0xFC, 0x00, 0x7C, 0x7F, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x7F, 0x83,
  0xFE, 0x07, 0xCF, 0xF8, 0x7F, 0xF0, 0x7D, 0xFF, 0xCF, 0xFF, 0x07, 0xDF,
  0xFC, 0xFF, 0xF0, 0x7F, 0x87, 0xDE, 0x3F, 0x07, 0xB0, 0x7D, 0x81, 0xF0,
  0xFE, 0x03, 0xF0, 0x0F, 0x0F, 0xC0, 0x3F, 0x00, 0xF0, 0xFC, 0x03, 0xE0,
  0x0F, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0xF8, 0x03, 0xE0, 0x1F, 0x0F, 0x00,
  0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x01, 0xE1,
  0xF0, 0x07, 0xC0, 0x1E, 0x1F, 0x00, 0x7C, 0x03, 0xE1, 0xF0, 0x07, 0x80,
  0x3E, 0x1E, 0x00, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x80, 0x3E, 0x3E, 0x00,
  0xF8, 0x03, 0xC3, 0xE0, 0x0F, 0x80, 0x3C, 0x3E, 0x00, 0xF0, 0x07, 0xC3,
  0xE0, 0x0F, 0x00, 0x7C, 0x3C, 0x01, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x00,
  0x7C, 0x7C, 0x01, 0xF0, 0x07, 0x87, 0xC0, 0x1F, 0x00, 0x78, 0x7C, 0x01,
  0xE0, 0x0F, 0x87, 0xC0, 0x1E, 0x00, 0xF8, 0x78, 0x03, 0xE0, 0x0F, 0x8F,
  0x80, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE0, 0x0F, 0x0F, 0x80, 0x3E, 0x00,
  0xF0, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0x83,
  0xFF, 0x00, 0x7E, 0x3F, 0xFF, 0x01, 0xF1, 0xFF, 0xFE, 0x07, 0xC7, 0xFF,
  0xF8, 0x1F, 0x3C, 0x0F, 0xF0, 0x7D, 0xC0, 0x1F, 0xC3, 0xF6, 0x00, 0x3F,
  0x0F, 0xF0, 0x00, 0xFC, 0x3E, 0x80, 0x01, 0xF0, 0xFE, 0x00, 0x07, 0xC3,
  0xF0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x7C, 0x7E, 0x00, 0x01, 0xF1, 0xF8,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xFC, 0x7C, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x3E, 0x3F, 0x00, 0x00,
  0xF8, 0xF8, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x7C,
  0x3E, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x1F, 0x1F,
  0x00, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x3E, 0x3F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x7E, 0x1F, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00,
  0xF9, 0xF8, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x07,
  0xDF, 0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0x7C,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x03, 0xF1, 0xF0,
  0x00, 0x07, 0xE3, 0xE0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x07, 0xE0,
  0x01, 0xFC, 0x0F, 0xF0, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x07, 0xFF, 0x80, 0x03,
  0xE1, 0xFF, 0xF8, 0x00, 0x7C, 0x7F, 0xFF, 0x80, 0x0F, 0x9F, 0xFF, 0xF8,
  0x03, 0xF7, 0xC0, 0xFF, 0x00, 0x7C, 0xE0, 0x07, 0xF0, 0x0F, 0xB8, 0x00,
  0x7E, 0x01, 0xF6, 0x00, 0x07, 0xC0, 0x3F, 0x80, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x3E, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3F,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x7C, 0x0F, 0x80,
  0x00, 0x1F, 0x81, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7C, 0x0F,
  0x80, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x07, 0xE0, 0x3F, 0xE0, 0x03,
  0xFC, 0x07, 0xDF, 0x01, 0xFF, 0x00, 0xF9, 0xFF, 0xFF, 0xC0, 0x1F, 0x1F,
  0xFF, 0xF0, 0x03, 0xE1, 0xFF, 0xFC, 0x00, 0x7C, 0x1F, 0xFE, 0x00, 0x1F,
  0x80, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0xFC, 0x1F, 0x00, 0xFF, 0xFE, 0x1F, 0x01, 0xFF, 0xFF, 0x1F,
  0x03, 0xFF, 0xFF, 0xBF, 0x07, 0xFC, 0x07, 0xBE, 0x0F, 0xE0, 0x01, 0xFE,
  0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E,
  0x3F, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x7C,
  0x7C, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0x7C,
  0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0xF8,
  0xF8, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x01, 0xF8,
  0xF8, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xF0,
  0xF8, 0x00, 0x07, 0xF0, 0xF8, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x0F, 0xF0,
  0xFC, 0x00, 0x1F, 0xE0, 0x7E, 0x00, 0x7B, 0xE0, 0x7F, 0x81, 0xF3, 0xE0,
  0x3F, 0xFF, 0xE3, 0xE0, 0x3F, 0xFF, 0xE3, 0xE0, 0x1F, 0xFF, 0xC7, 0xE0,
  0x0F, 0xFF, 0x07, 0xC0, 0x01, 0xFC, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x7F, 0xFF, 0x01, 0xFF,
  0x7F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFE, 0xFF, 0xFE, 0x3F, 0xFE,
  0xFF, 0xFE, 0x7F, 0xFE, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7C, 0xE0, 0x00,
  0x00, 0x7D, 0xC0, 0x00, 0x00, 0x7D, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x01, 0xFF,
  0x03, 0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x1C, 0x07, 0xC0, 0x00, 0x08,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x10, 0x00, 0x00, 0x7C,
  0x38, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x01, 0xF8, 0xFF, 0x00, 0x03, 0xF8,
  0x7F, 0xE0, 0x0F, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x20, 0x07, 0xC0, 0x01, 0xC0, 0x1F, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0xFE, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xC0, 0x7F, 0xC0, 0x3E,
  0x03, 0xFC, 0x00, 0xF8, 0x3F, 0xE0, 0x03, 0xE1, 0xFE, 0x00, 0x0F, 0x9F,
  0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x1F, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0,
  0x7C, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x3E,
  0x00, 0x01, 0xF0, 0xFC, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0x1F, 0x87, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00,
  0x01, 0xF8, 0x3E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xE1, 0xF8, 0x00,
  0x3F, 0xC1, 0xF0, 0x00, 0xDF, 0x03, 0xF0, 0x01, 0xBE, 0x07, 0xE0, 0x0E,
  0x7C, 0x0F, 0xF0, 0x7C, 0xF8, 0x0F, 0xFF, 0xF1, 0xF0, 0x1F, 0xFF, 0xC7,
  0xE0, 0x1F, 0xFF, 0x0F, 0x80, 0x1F, 0xFC, 0x1F, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x0C, 0x7F, 0xF8, 0x00, 0x7C, 0x7F, 0xF8, 0x00,
  0x7E, 0x7F, 0xF8, 0x00, 0x7E, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3F, 0x01, 0xF0, 0x00,
  0x3F, 0x01, 0xF0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3F, 0x01, 0xF0, 0x00,
  0x3F, 0x03, 0xE0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7E, 0x03, 0xE0, 0x00,
  0x7E, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xFC, 0x07, 0xC0, 0x00,
  0xF8, 0x07, 0xC0, 0x01, 0xF8, 0x07, 0xC0, 0x03, 0xF0, 0x07, 0xC0, 0x03,
  0xF0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0x80, 0x0F, 0xE0, 0x0F, 0x80, 0x1F,
  0xC0, 0x0F, 0x80, 0x7F, 0x80, 0x0F, 0x81, 0xFF, 0x00, 0x0F, 0x8F, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x3C,
  0x01, 0x83, 0xE0, 0x0F, 0x03, 0xE0, 0xF0, 0x07, 0xC0, 0x7C, 0x3C, 0x01,
  0xF0, 0x1F, 0x1F, 0x00, 0x7C, 0x07, 0xC7, 0xC0, 0x1E, 0x01, 0xF1, 0xF0,
  0x07, 0x80, 0x3C, 0x7C, 0x03, 0xE0, 0x0F, 0x1E, 0x00, 0xF8, 0x03, 0xC7,
  0x80, 0x3E, 0x00, 0xF3, 0xE0, 0x0F, 0x80, 0x3C, 0xF8, 0x03, 0xC0, 0x0F,
  0x3E, 0x00, 0xF0, 0x03, 0xCF, 0x80, 0x7C, 0x00, 0xF3, 0xC0, 0x1F, 0x00,
  0x7C, 0xF0, 0x07, 0xC0, 0x1F, 0x7C, 0x01, 0xF0, 0x07, 0xDF, 0x00, 0x78,
  0x01, 0xF7, 0xC0, 0x1E, 0x00, 0x7D, 0xF0, 0x0F, 0x80, 0x1E, 0x78, 0x03,
  0xE0, 0x0F, 0x9E, 0x00, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0x00, 0xFB, 0xE0,
  0x0F, 0x00, 0x7C, 0xF8, 0x07, 0xC0, 0x1F, 0x3E, 0x01, 0xF0, 0x0F, 0xCF,
  0x80, 0xFC, 0x03, 0xE3, 0xE0, 0x3F, 0x01, 0xF8, 0xF8, 0x1F, 0xE0, 0xFC,
  0x3F, 0x0E, 0xF8, 0x7F, 0x0F, 0xFF, 0x9F, 0xFF, 0x83, 0xFF, 0xC7, 0xFF,
  0xC0, 0x7F, 0xE1, 0xFF, 0xE0, 0x0F, 0xF0, 0x3F, 0xF0, 0x01, 0xF8, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0x03, 0xFF, 0xC3, 0xFF, 0xE0, 0x0F, 0xFF,
  0x87, 0xFF, 0xE0, 0x3F, 0xDF, 0x1F, 0x0F, 0xC1, 0xFE, 0x1E, 0x3C, 0x0F,
  0x87, 0xF0, 0x3C, 0xF0, 0x1F, 0x1F, 0xC0, 0x79, 0xC0, 0x3E, 0x1E, 0x00,
  0xF7, 0x80, 0x7C, 0x30, 0x01, 0xEE, 0x00, 0xF8, 0x00, 0x03, 0xDC, 0x01,
  0xF0, 0x00, 0x07, 0xF0, 0x03, 0xE0, 0x00, 0x0F, 0xE0, 0x04, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0x00, 0x3F, 0x00, 0x00, 0x3C, 0x00, 0xFE, 0x00, 0x00, 0x78,
  0x01, 0xFC, 0x00, 0x41, 0xF0, 0x03, 0x78, 0x01, 0xC3, 0xE0, 0x0E, 0xF0,
  0x07, 0xC7, 0xC0, 0x3D, 0xF0, 0x3F, 0x8F, 0xC0, 0x73, 0xE0, 0xFE, 0x0F,
  0x81, 0xE7, 0xC3, 0xF8, 0x1F, 0x8F, 0xCF, 0x9F, 0xE0, 0x3F, 0xFF, 0x0F,
  0xFF, 0x00, 0x7F, 0xFC, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x00,
  0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x07,
  0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00,
  0x7C, 0x07, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x7C, 0x00,
  0x03, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF8, 0x0F,
  0x80, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x3E, 0x00, 0x07, 0xF0, 0x0F, 0x80, 0x01, 0xFC, 0x03, 0xE0, 0x00, 0xFF,
  0x00, 0xFC, 0x00, 0x6F, 0x80, 0x3F, 0x80, 0x7B, 0xE0, 0x0F, 0xF0, 0x3C,
  0xF8, 0x01, 0xFF, 0xFE, 0x3E, 0x00, 0x7F, 0xFF, 0x1F, 0x80, 0x0F, 0xFF,
  0xC7, 0xE0, 0x01, 0xFF, 0xC1, 0xF0, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x80, 0x00, 0x3F, 0x80,
  0x30, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x01, 0xF0, 0x1F, 0xFF, 0xE0, 0xFC, 0x0F,
  0xFF, 0xFC, 0x3F, 0x07, 0xFF, 0xFF, 0xCF, 0x81, 0xF8, 0x1F, 0xFF, 0xE0,
  0x7C, 0x00, 0xFF, 0xF8, 0x3E, 0x00, 0x07, 0xFC, 0x0F, 0x80, 0x00, 0x7E,
  0x03, 0xC0, 0x00, 0x3F, 0x00, 0xF0, 0x00, 0x3F, 0x80, 0x3C, 0x00, 0x1F,
  0x80, 0x0F, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x0E, 0x00, 0x07, 0xE0, 0x07, 0xC0,
  0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x3C, 0x01, 0xFC, 0x00, 0x0F,
  0x80, 0xFC, 0x00, 0x03, 0xE0, 0x7F, 0x80, 0x00, 0xF8, 0x3F, 0xFE, 0x00,
  0x1E, 0x1F, 0xFF, 0xFC, 0x07, 0xC7, 0xDF, 0xFF, 0xF1, 0xF1, 0xF0, 0xFF,
  0xFF, 0xF8, 0x7C, 0x07, 0xFF, 0xFE, 0x1F, 0x00, 0x3F, 0xFF, 0x0F, 0xC0,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x78,
  0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0x00, 0x3F, 0xE0, 0x00, 0x7C, 0x0F, 0xFE, 0x00,
  0x0F, 0x03, 0xFF, 0xC0, 0x03, 0xE0, 0xFF, 0xFC, 0x00, 0x78, 0x3F, 0x0F,
  0xC0, 0x1F, 0x07, 0xC0, 0xF8, 0x03, 0xE1, 0xF0, 0x1F, 0x80, 0xF8, 0x3E,
  0x01, 0xF8, 0x3F, 0x07, 0x80, 0x1F, 0x8F, 0xC1, 0xF0, 0x03, 0xFF, 0xF0,
  0x3C, 0x00, 0x3F, 0xFE, 0x0F, 0x80, 0x03, 0xFF, 0x81, 0xF0, 0x00, 0x3F,
  0xE0, 0x0C, 0x00, 0x01, 0xF0, 0x00,
};

const GFXglyph IBMPlexMono_Italic66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 40, 0, -1 },
  { 1, 15, 47, 40, 13, -46 },
  { 90, 19, 18, 40, 14, -49 },
  { 133, 40, 46, 40, 1, -46 },
  { 363, 37, 62, 40, 2, -54 },
  { 650, 45, 48, 40, -2, -47 },
  { 920, 39, 48, 40, 0, -47 },
  { 1154, 8, 18, 40, 20, -49 },
  { 1172, 24, 59, 40, 14, -50 },
  { 1349, 24, 59, 40, 3, -50 },
  { 1526, 33, 33, 40, 4, -36 },
  { 1663, 32, 33, 40, 4, -37 },
  { 1795, 15, 18, 40, 9, -9 },
  { 1829, 20, 5, 40, 10, -23 },
  { 1842, 10, 9, 40, 13, -8 },
  { 1854, 37, 59, 40, 2, -50 },
  { 2127, 34, 48, 40, 4, -47 },
  { 2331, 31, 46, 40, 3, -46 },
  { 2510, 34, 47, 40, 2, -47 },
  { 2710, 34, 48, 40, 2, -47 },
  { 2914, 36, 46, 40, 1, -46 },
  { 3121, 35, 47, 40, 3, -46 },
  { 3327, 31, 47, 40, 4, -46 },
  { 3510, 33, 46, 40, 7, -46 },
  { 3700, 35, 48, 40, 3, -47 },
  { 3910, 31, 47, 40, 6, -47 },
  { 4093, 14, 35, 40, 13, -34 },
  { 4155, 18, 43, 40, 9, -34 },
  { 4252, 32, 38, 40, 6, -39 },
  { 4404, 34, 18, 40, 3, -29 },
  { 4481, 32, 38, 40, 3, -39 },
  { 4633, 29, 48, 40, 8, -47 },
  { 4807, 33, 54, 40, 4, -47 },
  { 5030, 36, 46, 40, -1, -46 },
  { 5237, 34, 46, 40, 3, -46 },
  { 5433, 33, 48, 40, 5, -47 },
  { 5631, 33, 46, 40, 4, -46 },
  { 5821, 36, 46, 40, 3, -46 },
  { 6028, 37, 46, 40, 3, -46 },
  { 6241, 34, 48, 40, 4, -47 },
  { 6445, 36, 46, 40, 3, -46 },
  { 6652, 36, 46, 40, 3, -46 },
  { 6859, 33, 47, 40, 4, -46 },
  { 7053, 40, 46, 40, 3, -46 },
  { 7283, 28, 46, 40, 5, -46 },
  { 7444, 38, 46, 40, 2, -46 },
  { 7663, 36, 46, 40, 3, -46 },
  { 7870, 34, 48, 40, 4, -47 },
  { 8074, 36, 46, 40, 3, -46 },
  { 8281, 34, 59, 40, 4, -47 },
  { 8532, 36, 46, 40, 3, -46 },
  { 8739, 36, 48, 40, 2, -47 },
  { 8955, 37, 46, 40, 6, -46 },
  { 9168, 34, 47, 40, 5, -46 },
  { 9368, 35, 46, 40, 7, -46 },
  { 9570, 39, 46, 40, 3, -46 },
  { 9795, 43, 46, 40, -1, -46 },
  { 10043, 37, 46, 40, 6, -46 },
  { 10256, 40, 46, 40, 0, -46 },
  { 10486, 28, 59, 40, 11, -50 },
  { 10693, 17, 59, 40, 12, -50 },
  { 10819, 28, 59, 40, 1, -50 },
  { 11026, 34, 27, 40, 4, -46 },
  { 11141, 32, 5, 40, 0, 6 },
  { 11161, 8, 13, 40, 15, -52 },
  { 11174, 32, 36, 40, 4, -35 },
  { 11318, 33, 50, 40, 3, -49 },
  { 11525, 29, 36, 40, 5, -35 },
  { 11656, 35, 50, 40, 4, -49 },
  { 11875, 30, 36, 40, 5, -35 },
  { 12010, 43, 63, 40, -1, -49 },
  { 12349, 34, 49, 40, 2, -35 },
  { 12558, 30, 49, 40, 4, -49 },
  { 12742, 31, 51, 40, 5, -50 },
  { 12940, 31, 64, 40, 4, -50 },
  { 13188, 34, 50, 40, 4, -49 },
  { 13401, 28, 50, 40, 7, -49 },
  { 13576, 36, 35, 40, 1, -35 },
  { 13734, 30, 35, 40, 4, -35 },
  { 13866, 31, 36, 40, 4, -35 },
  { 14006, 35, 48, 40, 1, -35 },
  { 14216, 32, 48, 40, 4, -35 },
  { 14408, 32, 34, 40, 7, -34 },
  { 14544, 32, 36, 40, 3, -35 },
  { 14688, 30, 47, 40, 5, -46 },
  { 14865, 31, 35, 40, 5, -34 },
  { 15001, 32, 35, 40, 4, -34 },
  { 15141, 34, 35, 40, 3, -34 },
  { 15290, 39, 36, 40, 0, -35 },
  { 15466, 34, 48, 40, 2, -34 },
  { 15670, 34, 36, 40, 3, -35 },
  { 15823, 31, 59, 40, 7, -50 },
  { 16052, 15, 59, 40, 13, -50 },
  { 16163, 31, 59, 40, 3, -50 },
  { 16392, 35, 15, 40, 3, -28 },
};

const GFXfont IBMPlexMono_Italic66pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic66pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic66pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _IBMPLEXMONO_ITALIC66PT7B_H_
