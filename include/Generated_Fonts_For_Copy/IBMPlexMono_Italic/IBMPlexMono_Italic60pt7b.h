#ifndef _IBMPLEXMONO_ITALIC60PT7B_H_
#define _IBMPLEXMONO_ITALIC60PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic60pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x07,
  0xF0, 0x7F, 0xC3, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF0, 0x1F, 0x00, 0x3E,
  0x07, 0x9F, 0x03, 0xCF, 0x03, 0xE7, 0x81, 0xF3, 0xC0, 0xFB, 0xE0, 0x79,
  0xF0, 0x3C, 0xF8, 0x1E, 0x78, 0x1F, 0x3C, 0x0F, 0x9E, 0x07, 0xDF, 0x03,
  0xCF, 0x81, 0xE7, 0xC0, 0xF3, 0xC0, 0xF9, 0xE0, 0x7C, 0xF0, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0xF8,
  0x0F, 0x00, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0x1F, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x07, 0x80, 0xF8, 0x00, 0xFF,
  0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xFF,
  0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x1E, 0x03,
  0xE0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F,
  0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xF1, 0xCF, 0xF0, 0x07, 0xF0, 0x70, 0xFE,
  0x01, 0xF0, 0x3C, 0x0F, 0xC0, 0xFC, 0x0F, 0x01, 0xE0, 0x3E, 0x03, 0xC0,
  0x30, 0x1F, 0x80, 0xF0, 0x00, 0x07, 0xC0, 0x38, 0x00, 0x01, 0xF0, 0x0E,
  0x00, 0x00, 0x7C, 0x03, 0x80, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x78, 0x00, 0x01, 0xF8, 0x1E, 0x00, 0x00, 0x3F, 0x07, 0x00, 0x00, 0x0F,
  0xE1, 0xC0, 0x00, 0x01, 0xFE, 0x70, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0E, 0x7F, 0x80, 0x00, 0x07, 0x87,
  0xF0, 0x00, 0x01, 0xE0, 0xFC, 0x00, 0x00, 0x78, 0x1F, 0x80, 0x00, 0x1C,
  0x03, 0xE0, 0x00, 0x07, 0x00, 0xF8, 0x00, 0x01, 0xC0, 0x3E, 0x00, 0x00,
  0xF0, 0x0F, 0x80, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0xF8, 0x18,
  0x03, 0xC0, 0x7C, 0x0E, 0x00, 0xE0, 0x1F, 0x07, 0xC0, 0x38, 0x0F, 0xC3,
  0xF8, 0x1E, 0x07, 0xE0, 0x3F, 0x87, 0x83, 0xF0, 0x0F, 0xF9, 0xE7, 0xFC,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0x00, 0x7F, 0xF8, 0x00, 0x1E, 0x00, 0xFF,
  0xFC, 0x00, 0x3E, 0x01, 0xF8, 0x7C, 0x00, 0x3C, 0x03, 0xE0, 0x1E, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x07,
  0xC0, 0x1E, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0x07, 0x80, 0x1E,
  0x07, 0xC0, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x07, 0x80, 0x3E, 0x0F, 0x00,
  0x07, 0x80, 0x3C, 0x1F, 0x00, 0x07, 0x80, 0x7C, 0x1E, 0x00, 0x07, 0x80,
  0x78, 0x3C, 0x00, 0x07, 0xC1, 0xF8, 0x7C, 0x00, 0x03, 0xFF, 0xF0, 0x78,
  0x00, 0x03, 0xFF, 0xE0, 0xF0, 0x00, 0x00, 0xFF, 0xC1, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0x07, 0xFF, 0x80, 0x00, 0x1E, 0x0F, 0xFF, 0xC0, 0x00, 0x3E,
  0x1F, 0x83, 0xE0, 0x00, 0x3C, 0x1E, 0x01, 0xE0, 0x00, 0x78, 0x3C, 0x01,
  0xE0, 0x00, 0xF8, 0x3C, 0x01, 0xE0, 0x00, 0xF0, 0x7C, 0x01, 0xE0, 0x01,
  0xE0, 0x78, 0x01, 0xE0, 0x03, 0xE0, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x00,
  0x7C, 0x1F, 0x80, 0x7C, 0x00, 0x3F, 0xFF, 0x00, 0x78, 0x00, 0x1F, 0xFE,
  0x00, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x7C, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x01, 0xF0, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x0F, 0xF9, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03,
  0xF1, 0xFE, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x0F, 0x80, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x9F,
  0x00, 0x07, 0xC0, 0x3F, 0xE0, 0x00, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0x81,
  0xEF, 0x80, 0x06, 0xF8, 0x7C, 0xF8, 0x01, 0xDF, 0x0F, 0x1F, 0x80, 0x73,
  0xF3, 0xE1, 0xF8, 0x1E, 0x3E, 0x78, 0x3F, 0xFF, 0x87, 0xFF, 0x03, 0xFF,
  0xE0, 0x7F, 0xC0, 0x3F, 0xF8, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7C, 0x00,
  0x3E, 0x7C, 0xF9, 0xE3, 0xC7, 0x9F, 0x3E, 0x7C, 0xF1, 0xE3, 0xCF, 0x9F,
  0x3E, 0x78, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x40, 0x07, 0x80, 0x09, 0xF0, 0x0F, 0x00, 0xF3, 0xFC, 0x1E,
  0x0F, 0xFF, 0xFF, 0x3D, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xDF, 0x00,
  0x00, 0x3F, 0x1F, 0x00, 0x00, 0xFC, 0x1E, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80,
  0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3C, 0x01,
  0xF0, 0x07, 0x80, 0x3E, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3E, 0x3F, 0xBF, 0xFF, 0xEF, 0xF7, 0xFB, 0xF8, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0xFE, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0xF0, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7D,
  0xF0, 0x00, 0x01, 0xF7, 0xC0, 0x7C, 0x07, 0xDF, 0x03, 0xF8, 0x1F, 0xFC,
  0x1F, 0xE0, 0x7F, 0xF0, 0x7F, 0x81, 0xFF, 0x81, 0xFC, 0x0F, 0xFE, 0x07,
  0xF0, 0x3E, 0xF8, 0x0F, 0x80, 0xFB, 0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x0F, 0xBE, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x07,
  0xCF, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0,
  0x7F, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xBE, 0x00, 0x07,
  0xF3, 0xE0, 0x00, 0xFE, 0x7C, 0x00, 0x1F, 0x87, 0xC0, 0x07, 0xF0, 0x7C,
  0x00, 0xFE, 0x07, 0xC0, 0x1F, 0xC0, 0x7C, 0x01, 0xF8, 0x07, 0xC0, 0x0F,
  0x00, 0xF8, 0x00, 0x60, 0x0F, 0x80, 0x04, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80,
  0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0x03,
  0xF0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x7C, 0x06,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x7F, 0x81, 0xFE, 0x00, 0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0xF0, 0x00, 0x3F, 0x00, 0x60, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x08,
  0x00, 0x01, 0xF8, 0x18, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xF0, 0xFE,
  0x00, 0x07, 0xE0, 0x7F, 0x00, 0x0F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x00, 0x7C, 0x7C, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0xF8, 0xF8, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x7C, 0x01, 0xF0, 0x00,
  0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x03, 0xE0, 0x1F,
  0x00, 0x03, 0xE0, 0x3E, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x83, 0xF8, 0x00, 0x0F, 0x1F, 0xFE,
  0x00, 0x3E, 0x7F, 0xFE, 0x00, 0x7B, 0xFF, 0xFE, 0x00, 0xFF, 0x01, 0xFE,
  0x01, 0xF8, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0xFC, 0x01, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x20,
  0x00, 0x07, 0xE0, 0xE0, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x07,
  0xF8, 0x01, 0xF1, 0xFF, 0xE0, 0x3E, 0x3F, 0xFF, 0x83, 0xEF, 0xFF, 0xFC,
  0x3D, 0xF0, 0x1F, 0xC7, 0xFC, 0x00, 0x7E, 0x7F, 0x00, 0x03, 0xE7, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x3E, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xFC, 0x7C, 0x00, 0x1F, 0x87,
  0xE0, 0x03, 0xF0, 0x3F, 0x80, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0x7C, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x1F, 0x1E,
  0x00, 0x00, 0xFC, 0x78, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0xFC, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x3E, 0x03,
  0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x7C, 0x01, 0xF0, 0x01, 0xF8, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x0F,
  0xC0, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x3E,
  0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x7C, 0x7C,
  0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0x7C, 0xFC,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0xF8, 0x7C,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0x81,
  0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x3E,
  0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x3E, 0xF8,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F,
  0xBF, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0xFE, 0x3F,
  0x80, 0x0F, 0xF0, 0xFF, 0x03, 0xEF, 0x83, 0xFF, 0xFE, 0xF8, 0x0F, 0xFF,
  0xE7, 0xC0, 0x3F, 0xFC, 0x7C, 0x00, 0x7F, 0x83, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x7F, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF1, 0xFF, 0x0F, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x07, 0xF0, 0xFF, 0x8F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x7F, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF8, 0x04, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1,
  0xFC, 0x0F, 0xF1, 0xF8, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xCC, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x80, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0x3F,
  0x80, 0x3F, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1E,
  0x07, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF8,
  0x7C, 0x00, 0x00, 0xF0, 0xF0, 0x07, 0xE3, 0xE3, 0xE0, 0x1F, 0xE7, 0xC7,
  0xC0, 0xFF, 0xEF, 0x0F, 0x01, 0xFF, 0xDE, 0x1E, 0x07, 0xE1, 0xFC, 0x7C,
  0x1F, 0x00, 0xF8, 0xF8, 0x3E, 0x01, 0xF1, 0xF0, 0xF8, 0x03, 0xE3, 0xC1,
  0xF0, 0x07, 0x87, 0x83, 0xC0, 0x0F, 0x0F, 0x07, 0x80, 0x1E, 0x3E, 0x1F,
  0x00, 0x3C, 0x7C, 0x3E, 0x00, 0x78, 0xF8, 0x7C, 0x01, 0xF1, 0xE0, 0xF8,
  0x03, 0xE3, 0xC1, 0xE0, 0x07, 0x87, 0x83, 0xC0, 0x0F, 0x0F, 0x07, 0x80,
  0x3E, 0x1E, 0x0F, 0x00, 0x7C, 0x7C, 0x1F, 0x01, 0xF8, 0xF8, 0x3E, 0x07,
  0xF1, 0xF0, 0x3F, 0x3B, 0xC3, 0xE0, 0x7F, 0xF7, 0x87, 0xC0, 0x7F, 0xCF,
  0x07, 0x80, 0x7F, 0x1E, 0x0F, 0x00, 0x30, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x00, 0xF3, 0xE0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xC0,
  0x1E, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x01, 0xF0,
  0x03, 0xE0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F,
  0x80, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x07,
  0xE0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x7C,
  0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x01, 0xF8, 0x0F, 0x80, 0x03, 0xF0,
  0x3C, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0x80,
  0x00, 0x7C, 0x1E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x7E, 0x0F, 0x80, 0x03, 0xF0, 0x3E, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x01,
  0xF0, 0x00, 0xFE, 0x07, 0xC0, 0x00, 0xFC, 0x1F, 0x00, 0x01, 0xF0, 0x78,
  0x00, 0x03, 0xC3, 0xE0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3E, 0x3E, 0x00,
  0x00, 0xF8, 0xF8, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x9F, 0x00, 0x00,
  0x7E, 0x7C, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3E,
  0x1F, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x0F, 0xC0, 0x00,
  0x7C, 0x3E, 0x00, 0x01, 0xE1, 0xF8, 0x00, 0x04, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x01, 0x83, 0xE0, 0x00, 0x0F, 0x8F, 0x80,
  0x00, 0x7E, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x81, 0xF8, 0x00,
  0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xF0, 0x3F, 0x80, 0x1F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0xFF, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x1F, 0x07, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x00,
  0x00, 0xF8, 0x7C, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x07, 0xE1, 0xF0, 0x00,
  0x0F, 0x83, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0x7C, 0x3E, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x7C,
  0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0xC0,
  0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7E, 0x07, 0xC0, 0x03, 0xF8, 0x0F,
  0x80, 0x1F, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFE,
  0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0x81, 0xF8, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x04,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0xFF, 0x3F, 0x00, 0x7F,
  0xFC, 0xF8, 0x03, 0xFF, 0xF3, 0xE0, 0x0F, 0xFF, 0xCF, 0x80, 0x00, 0x1F,
  0x3E, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xF0, 0x7C, 0x00,
  0x1F, 0xC1, 0xF8, 0x00, 0x7F, 0x03, 0xF0, 0x07, 0x7C, 0x0F, 0xE0, 0x79,
  0xE0, 0x1F, 0xFF, 0xE7, 0x80, 0x3F, 0xFF, 0x3E, 0x00, 0x7F, 0xF0, 0xF8,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x03,
  0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0xF0, 0x0F, 0x80,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x3E,
  0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1E, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x01, 0xF0,
  0x0F, 0x80, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x81, 0xE0, 0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x07,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x3E, 0x00, 0x00, 0xFC,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x03, 0xF0, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x1F, 0x80, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x7E,
  0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x00, 0xF8,
  0x3F, 0x00, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00,
  0x1F, 0x1F, 0xC0, 0x00, 0x01, 0xF3, 0xFE, 0x00, 0x00, 0x1F, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xF9, 0xF0, 0x00, 0x01, 0xFF,
  0x1F, 0x00, 0x00, 0x3F, 0xE0, 0xF8, 0x00, 0x03, 0xFC, 0x0F, 0x80, 0x00,
  0x3F, 0x80, 0x7C, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x01,
  0xFC, 0x0F, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x00,
  0x1F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF8, 0x1F, 0xF0, 0x03, 0xDE, 0x07, 0xFE,
  0x01, 0xFF, 0x81, 0xE7, 0x80, 0x7B, 0xE0, 0x79, 0xE0, 0x3C, 0xF8, 0x1E,
  0x78, 0x1F, 0x3C, 0x0F, 0x9F, 0x07, 0x8F, 0x03, 0xE3, 0xC3, 0xE3, 0xC0,
  0xF8, 0xF0, 0xF1, 0xF0, 0x3C, 0x3C, 0x78, 0x7C, 0x0F, 0x0F, 0x9E, 0x1F,
  0x03, 0xC1, 0xEF, 0x07, 0x81, 0xF0, 0x7F, 0xC1, 0xE0, 0x7C, 0x1F, 0xE0,
  0x78, 0x1F, 0x07, 0xF8, 0x3E, 0x07, 0x80, 0xFC, 0x0F, 0x81, 0xE0, 0x3E,
  0x03, 0xE0, 0x78, 0x0F, 0x80, 0xF0, 0x3E, 0x03, 0xC0, 0x3C, 0x0F, 0x80,
  0x70, 0x0F, 0x03, 0xE0, 0x18, 0x07, 0xC0, 0xF0, 0x04, 0x01, 0xF0, 0x3C,
  0x01, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x07, 0x81,
  0xF0, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x3E,
  0x07, 0x80, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x00,
  0xF0, 0x3E, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x1F, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0xF0, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xC0, 0x7F, 0x80, 0x01, 0xE0, 0x1F, 0xE0, 0x00, 0x78,
  0x07, 0xF8, 0x00, 0x3E, 0x01, 0xFE, 0x00, 0x0F, 0x80, 0xFF, 0xC0, 0x03,
  0xE0, 0x3E, 0xF0, 0x00, 0xF0, 0x0F, 0xBC, 0x00, 0x3C, 0x03, 0xEF, 0x00,
  0x0F, 0x00, 0xF3, 0xE0, 0x07, 0xC0, 0x3C, 0xF8, 0x01, 0xF0, 0x1F, 0x1E,
  0x00, 0x7C, 0x07, 0xC7, 0x80, 0x1E, 0x01, 0xF1, 0xE0, 0x07, 0x80, 0x7C,
  0x7C, 0x01, 0xE0, 0x1E, 0x0F, 0x00, 0xF8, 0x07, 0x83, 0xC0, 0x3E, 0x03,
  0xE0, 0xF0, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xC0, 0x3E, 0x0F, 0x80, 0xF0,
  0x0F, 0x81, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x1F, 0x00, 0xF0, 0x1E, 0x07,
  0xC0, 0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x00, 0xF0, 0x78, 0x07, 0xC0, 0x3C,
  0x1E, 0x01, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x03, 0xE3, 0xE0, 0x1E, 0x00,
  0xF8, 0xF8, 0x0F, 0x80, 0x1E, 0x3E, 0x03, 0xE0, 0x07, 0x8F, 0x00, 0xF8,
  0x01, 0xE3, 0xC0, 0x3E, 0x00, 0x7C, 0xF0, 0x0F, 0x00, 0x1F, 0x7C, 0x03,
  0xC0, 0x03, 0xDF, 0x01, 0xF0, 0x00, 0xF7, 0xC0, 0x7C, 0x00, 0x3F, 0xE0,
  0x1F, 0x00, 0x0F, 0xF8, 0x07, 0xC0, 0x01, 0xFE, 0x01, 0xE0, 0x00, 0x7F,
  0x80, 0x78, 0x00, 0x1F, 0xE0, 0x3E, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF1,
  0xF8, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7C, 0xF8,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x1F, 0x7C, 0x00,
  0x00, 0x7D, 0xF0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07, 0xDF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0xF8, 0xF8, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x7C, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03,
  0xE0, 0x00, 0xFE, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3F, 0x03,
  0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xFC, 0x0F,
  0x80, 0x03, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFE,
  0x07, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7D, 0xF0,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x3E, 0xF8, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x0F,
  0xBE, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x1F, 0x81, 0xF0, 0x00, 0x7C, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x7F,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x01, 0x80,
  0x00, 0xF8, 0x0F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x0F, 0x9F, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xE0,
  0x00, 0xFE, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3F, 0x03, 0xC0,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xFC, 0x0F, 0x80,
  0x03, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x7C, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x03, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x80, 0x00, 0x07, 0xC0, 0xE0,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x7E, 0x03,
  0xF8, 0x00, 0x3F, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x0F, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C,
  0x1F, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8,
  0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF0,
  0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0,
  0x7C, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFB,
  0xE0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x0F, 0x9F,
  0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0xF8, 0x78,
  0x00, 0x03, 0xE0, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00,
  0x07, 0xC0, 0x1E, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x1F, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x0F, 0x00, 0xF8,
  0x00, 0x1E, 0x01, 0xF0, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80,
  0x00, 0xF8, 0x1E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x03, 0xC3, 0xE0, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x0F, 0x1F, 0x00, 0x00,
  0x1E, 0x3E, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00,
  0xFB, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x0F,
  0x8F, 0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x0F, 0x87, 0x80, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x3E, 0x1F,
  0x01, 0xF8, 0x07, 0x83, 0xE0, 0x3F, 0x00, 0xF0, 0x7C, 0x07, 0xE0, 0x1E,
  0x0F, 0x01, 0xFC, 0x07, 0xC1, 0xE0, 0x3F, 0x80, 0xF0, 0x3C, 0x07, 0xF0,
  0x1E, 0x07, 0x81, 0xEF, 0x03, 0xC0, 0xF0, 0x3D, 0xE0, 0xF8, 0x1E, 0x0F,
  0x3C, 0x1E, 0x03, 0xC1, 0xE7, 0x83, 0xC0, 0x78, 0x3C, 0xF0, 0x78, 0x1F,
  0x0F, 0x1E, 0x1F, 0x03, 0xE1, 0xE3, 0xC3, 0xC0, 0x7C, 0x38, 0x78, 0x78,
  0x0F, 0x0F, 0x0F, 0x0F, 0x01, 0xE1, 0xE1, 0xE3, 0xE0, 0x3C, 0x78, 0x3C,
  0x7C, 0x07, 0x8F, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0xF1, 0xE0, 0x1E, 0x78,
  0x1E, 0x7C, 0x03, 0xCF, 0x03, 0xCF, 0x80, 0x79, 0xE0, 0x79, 0xE0, 0x1F,
  0x78, 0x0F, 0x3C, 0x03, 0xEF, 0x01, 0xE7, 0x80, 0x7B, 0xC0, 0x3D, 0xF0,
  0x0F, 0x78, 0x03, 0xBC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F,
  0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x07, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x1F, 0x80,
  0x00, 0x0F, 0x80, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0x03, 0xE1, 0xF8,
  0x00, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xEF, 0x80,
  0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00,
  0x0F, 0xDF, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x01, 0xF8, 0xF8, 0x00,
  0x00, 0xFC, 0x3E, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x03, 0xF0, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x3E, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x7C, 0x3F,
  0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00, 0x7B,
  0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x01, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x01, 0xF1, 0xF0, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x01,
  0xF0, 0x3E, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x3E, 0x01, 0xF0, 0x01, 0xF0,
  0x03, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x7C, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x78, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x0F,
  0x8F, 0x80, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xCC, 0x00, 0x00, 0x0C, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x10, 0xF3,
  0xE7, 0xC7, 0x8F, 0x8F, 0x1E, 0x1E, 0x3C, 0x38, 0x60, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xFF, 0x83, 0xC0, 0x7F, 0xFF, 0x3E, 0x07, 0xFF, 0xF9, 0xF0,
  0x7F, 0x81, 0xEF, 0x83, 0xF0, 0x03, 0x7C, 0x3F, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00,
  0x7C, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0xF1,
  0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x1F, 0x3E, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x07, 0x8F, 0x80, 0x00,
  0x7C, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3F, 0x1F, 0x00, 0x01, 0xF8,
  0x78, 0x00, 0x1F, 0xC3, 0xE0, 0x01, 0xBC, 0x1F, 0x00, 0x0F, 0xE0, 0xFC,
  0x01, 0xDF, 0x03, 0xF8, 0x3C, 0xFF, 0x9F, 0xFF, 0xE7, 0xFC, 0x7F, 0xFE,
  0x1F, 0xE1, 0xFF, 0xC0, 0x7F, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0xFE, 0x00, 0x1F, 0x0F,
  0xFE, 0x00, 0x7C, 0x7F, 0xFE, 0x01, 0xF3, 0xFF, 0xF8, 0x07, 0x9E, 0x07,
  0xF0, 0x1E, 0xE0, 0x07, 0xE0, 0xFB, 0x00, 0x0F, 0x83, 0xF8, 0x00, 0x3E,
  0x0F, 0xC0, 0x00, 0xF8, 0x3F, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x01, 0xF1, 0xF0,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0xF8, 0x78, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x00,
  0xF8, 0xF8, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0xFC,
  0x7E, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x1F,
  0xC0, 0x07, 0xE0, 0x7D, 0xC0, 0x7F, 0x81, 0xE7, 0xFF, 0xFC, 0x0F, 0x8F,
  0xFF, 0xE0, 0x3E, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x00, 0xF8, 0x7C, 0x00,
  0x0F, 0x1F, 0x00, 0x01, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x04,
  0x1E, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x1E, 0x7C, 0x00, 0x07, 0xCF, 0x80,
  0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x1F, 0x80, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x1F, 0xE0, 0x7C, 0x00, 0x7F, 0xF8, 0x7C, 0x00, 0xFF,
  0xFC, 0x7C, 0x03, 0xFF, 0xFE, 0x78, 0x07, 0xF8, 0x0E, 0xF8, 0x07, 0xE0,
  0x07, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x00,
  0x01, 0xF8, 0x3E, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x01, 0xE0, 0x7C, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x0F, 0xC0, 0x78, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x1F, 0xC0, 0x7C, 0x00,
  0x37, 0xC0, 0x7E, 0x00, 0x77, 0x80, 0x3F, 0x81, 0xE7, 0x80, 0x3F, 0xFF,
  0xCF, 0x80, 0x1F, 0xFF, 0x8F, 0x80, 0x0F, 0xFF, 0x0F, 0x80, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x7E, 0x00, 0x3E, 0x0F,
  0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF1, 0xE0, 0x00,
  0x1F, 0x3E, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0xE7,
  0xC0, 0x03, 0xFC, 0x7C, 0x07, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x01, 0x07, 0xC0,
  0x00, 0x3C, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x0F,
  0x83, 0xF0, 0x03, 0xF0, 0x1F, 0xC0, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x80, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x1F, 0x00,
  0x00, 0x1F, 0x80, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x07, 0xC0,
  0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x1E, 0x00, 0x00, 0x00,
  0x3F, 0x3C, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x7C, 0x01, 0xFF, 0xF8, 0xF8,
  0x0F, 0xFF, 0xF9, 0xE0, 0x3F, 0xC0, 0x77, 0xC0, 0x7E, 0x00, 0x7F, 0x81,
  0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0xFC, 0x3E,
  0x00, 0x00, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x00,
  0x00, 0x78, 0x3E, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00,
  0x7C, 0x0F, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x0F,
  0xE0, 0x7E, 0x00, 0x37, 0xC0, 0xFC, 0x00, 0xEF, 0x80, 0xFE, 0x07, 0x9E,
  0x00, 0xFF, 0xFE, 0x3C, 0x01, 0xFF, 0xF8, 0xF8, 0x00, 0xFF, 0xE1, 0xF0,
  0x00, 0x7F, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x0C, 0x00, 0x0F, 0xC0, 0x3C, 0x00, 0x3F, 0x00, 0xFE,
  0x01, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x78, 0x1F, 0xC0, 0x0F, 0x0F, 0xFE, 0x01, 0xE3, 0xFF, 0xE0, 0x7C, 0xFF,
  0xFE, 0x0F, 0xBC, 0x0F, 0xC1, 0xF7, 0x00, 0xFC, 0x3D, 0xC0, 0x0F, 0x87,
  0xB0, 0x01, 0xF1, 0xFC, 0x00, 0x3E, 0x3F, 0x00, 0x07, 0xC7, 0xE0, 0x00,
  0xF8, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x7C, 0xF8,
  0x00, 0x0F, 0x9F, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x3C, 0x7C, 0x00, 0x0F,
  0x8F, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0xF1, 0xF0, 0x00, 0x1E, 0x3E, 0x00, 0x07, 0xC7, 0x80, 0x00, 0xF8,
  0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x78, 0xF8, 0x00,
  0x0F, 0x1F, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x7C, 0x78, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x01, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0x78,
  0x07, 0xE0, 0x0F, 0x01, 0xF8, 0x03, 0xE0, 0x7E, 0x00, 0x7C, 0x1F, 0x80,
  0x0F, 0x87, 0xE0, 0x01, 0xF3, 0xF8, 0x00, 0x3C, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x01, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x03, 0xF0,
  0x07, 0xC0, 0x0F, 0xC0, 0x3E, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0xFC, 0x0F,
  0x80, 0x03, 0xF0, 0x78, 0x00, 0x0F, 0xC3, 0xC0, 0x00, 0x3F, 0x3E, 0x00,
  0x00, 0xFD, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x1E, 0x0F, 0xFC, 0x00,
  0x78, 0xFF, 0xF8, 0x03, 0xE7, 0xFF, 0xF0, 0x0F, 0x9C, 0x0F, 0xE0, 0x3E,
  0xE0, 0x1F, 0x80, 0xF6, 0x00, 0x3E, 0x03, 0xD8, 0x00, 0xF8, 0x1F, 0xC0,
  0x03, 0xE0, 0x7E, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF0,
  0x0F, 0x80, 0x1F, 0x80, 0x3E, 0x01, 0xFC, 0x00, 0xF8, 0x1F, 0xC0, 0x03,
  0xC7, 0xF8, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0,
  0x7C, 0x00, 0x47, 0xC1, 0xF0, 0x01, 0x9F, 0x03, 0xC0, 0x1F, 0x78, 0x0F,
  0x80, 0xFD, 0xE0, 0x3E, 0x07, 0xEF, 0x80, 0x7C, 0x3F, 0x3E, 0x01, 0xF1,
  0xF8, 0xF8, 0x03, 0xEF, 0xC3, 0xE0, 0x0F, 0xFE, 0x0F, 0x00, 0x1F, 0xF0,
  0x3C, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x7F, 0xFF, 0x80, 0x1F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x0C, 0x03, 0xE0, 0x07, 0x80, 0xF0, 0x07, 0xF0, 0x7C,
  0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x07, 0xC0, 0xFC, 0x01, 0xF0, 0x7E, 0x00,
  0x78, 0x7F, 0x00, 0x3E, 0x3F, 0x00, 0x0F, 0x9F, 0x80, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x7C, 0x03, 0xCF, 0xF0, 0xFF, 0x81, 0xE7, 0xFC, 0xFF, 0xC1,
  0xF7, 0xFE, 0x7F, 0xF0, 0xFF, 0x1F, 0x70, 0xF8, 0x7E, 0x07, 0xB0, 0x7C,
  0x3F, 0x03, 0xF0, 0x1E, 0x1F, 0x01, 0xF0, 0x0F, 0x0F, 0x00, 0xF8, 0x07,
  0x8F, 0x80, 0x7C, 0x07, 0xC7, 0xC0, 0x3C, 0x03, 0xE3, 0xC0, 0x1E, 0x01,
  0xE1, 0xE0, 0x1F, 0x00, 0xF0, 0xF0, 0x0F, 0x80, 0x78, 0x78, 0x07, 0xC0,
  0x3C, 0x7C, 0x03, 0xC0, 0x3E, 0x3E, 0x01, 0xE0, 0x1F, 0x1E, 0x00, 0xF0,
  0x0F, 0x0F, 0x00, 0xF8, 0x07, 0x87, 0x80, 0x7C, 0x03, 0xC3, 0xC0, 0x3E,
  0x01, 0xE3, 0xE0, 0x1E, 0x01, 0xF1, 0xF0, 0x0F, 0x00, 0xF8, 0xF0, 0x07,
  0x80, 0x78, 0x78, 0x07, 0xC0, 0x3C, 0x3C, 0x03, 0xE0, 0x1E, 0x1E, 0x01,
  0xF0, 0x0F, 0x1F, 0x00, 0xF0, 0x0F, 0x8F, 0x80, 0x78, 0x07, 0xC7, 0x80,
  0x3C, 0x03, 0xC3, 0xC0, 0x3E, 0x01, 0xE1, 0xE0, 0x1F, 0x00, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0xF0, 0xFF, 0xE0, 0x3E, 0x3F, 0xFE, 0x07, 0xCF, 0xFF,
  0xE0, 0xFB, 0xC0, 0xFC, 0x1F, 0x70, 0x0F, 0xC3, 0xDC, 0x00, 0xF8, 0x7B,
  0x00, 0x1F, 0x1F, 0xC0, 0x03, 0xE3, 0xF0, 0x00, 0x7C, 0x7E, 0x00, 0x0F,
  0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x3C, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0xF9, 0xF0, 0x00, 0x1E, 0x3E, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0xF8,
  0xF0, 0x00, 0x1F, 0x1E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C, 0xF8, 0x00,
  0x0F, 0x1F, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x7C, 0x78, 0x00, 0x0F, 0x8F,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0x8F, 0x80, 0x00,
  0xF1, 0xF0, 0x00, 0x3E, 0x3C, 0x00, 0x07, 0xC7, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0xFC, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE1,
  0xF0, 0x00, 0x1E, 0x3F, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x7E, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x7C, 0xF8,
  0x00, 0x0F, 0xC7, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x03,
  0xF0, 0x3F, 0x80, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x01,
  0xF0, 0xFF, 0xE0, 0x01, 0xF1, 0xFF, 0xF8, 0x01, 0xF3, 0xFF, 0xF8, 0x01,
  0xE7, 0x81, 0xFC, 0x01, 0xEE, 0x00, 0x7E, 0x03, 0xEC, 0x00, 0x3E, 0x03,
  0xF8, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x1E, 0x03,
  0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x07,
  0x80, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x0F,
  0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xF8, 0x1F,
  0x80, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0xC0, 0x07, 0xE0, 0x1F,
  0x70, 0x1F, 0xE0, 0x1E, 0x7F, 0xFF, 0xC0, 0x3E, 0x3F, 0xFF, 0x80, 0x3E,
  0x1F, 0xFE, 0x00, 0x3E, 0x07, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0xE1, 0xF0, 0x0F,
  0xFF, 0xC7, 0xC0, 0xFF, 0xFF, 0x9E, 0x07, 0xF8, 0x0E, 0xF8, 0x1F, 0x80,
  0x1F, 0xE0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x01,
  0xF8, 0xF8, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C,
  0x7C, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x1F, 0x1F,
  0x00, 0x00, 0x78, 0x7C, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x0F, 0x8F, 0x80,
  0x00, 0x3E, 0x3E, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xF0, 0x78, 0x00, 0x0F,
  0xC1, 0xF0, 0x00, 0x7F, 0x07, 0xC0, 0x03, 0x7C, 0x1F, 0x80, 0x1D, 0xE0,
  0x3F, 0x81, 0xE7, 0x80, 0xFF, 0xFF, 0x3E, 0x01, 0xFF, 0xF8, 0xF8, 0x03,
  0xFF, 0xC3, 0xE0, 0x01, 0xFC, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x7F, 0xFE, 0x07, 0xFB, 0xFF, 0xE0, 0xFF, 0xDF, 0xFF, 0x1F, 0xFE, 0xFF,
  0xF9, 0xFF, 0xF8, 0x07, 0xDF, 0x00, 0x00, 0x3E, 0xE0, 0x00, 0x01, 0xEC,
  0x00, 0x00, 0x0F, 0x40, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0x7F, 0x83,
  0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0x81, 0xF0, 0x00, 0x08, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x10, 0x00, 0x03, 0xE1,
  0x80, 0x00, 0x1E, 0x1F, 0x00, 0x01, 0xF1, 0xFC, 0x00, 0x1F, 0x87, 0xF8,
  0x03, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x60, 0x1F, 0x00, 0x1C, 0x03, 0xC0, 0x0F, 0xC0, 0x78, 0x03, 0xFC,
  0x1F, 0x01, 0xFC, 0x03, 0xE0, 0x7F, 0x00, 0x7C, 0x3F, 0xC0, 0x0F, 0x8F,
  0xE0, 0x01, 0xF7, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xF1, 0xF0,
  0x00, 0x1E, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x03,
  0xE1, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3C, 0x3E,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x07, 0xC3, 0xC0, 0x00,
  0x7C, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x78, 0x7C, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0xF8, 0x78, 0x00, 0x0F, 0x87, 0x80, 0x00, 0xF8, 0xF8, 0x00,
  0x0F, 0x8F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0,
  0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xF0, 0xF8, 0x00, 0x5F, 0x0F, 0x80,
  0x0D, 0xE0, 0xFC, 0x03, 0x9E, 0x07, 0xE0, 0x7B, 0xE0, 0x7F, 0xFF, 0x3E,
  0x03, 0xFF, 0xE3, 0xE0, 0x1F, 0xFC, 0x3E, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x6F, 0xFF, 0x00, 0x3E, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00,
  0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF0,
  0x3E, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F,
  0x07, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x3E, 0x07, 0x80, 0x03, 0xE0, 0x78,
  0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x0F,
  0x80, 0xF0, 0x01, 0xF8, 0x0F, 0x00, 0x3F, 0x00, 0xF0, 0x07, 0xE0, 0x1F,
  0x00, 0xFC, 0x01, 0xF0, 0x3F, 0x80, 0x1F, 0x1F, 0xF0, 0x01, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0xF0, 0x0C, 0x3C, 0x01, 0xE0, 0xF8, 0x78, 0x07, 0xC0, 0xF0,
  0xF0, 0x0F, 0x01, 0xE1, 0xE0, 0x1E, 0x03, 0xE3, 0xC0, 0x3C, 0x03, 0xCF,
  0x80, 0x78, 0x07, 0x9E, 0x00, 0xF0, 0x0F, 0x3C, 0x03, 0xE0, 0x1E, 0x78,
  0x07, 0x80, 0x3C, 0xF0, 0x0F, 0x00, 0x79, 0xE0, 0x1E, 0x00, 0xF7, 0xC0,
  0x3C, 0x01, 0xEF, 0x80, 0x78, 0x03, 0xDE, 0x01, 0xF0, 0x0F, 0xBC, 0x03,
  0xC0, 0x1F, 0x78, 0x07, 0x80, 0x3C, 0xF0, 0x0F, 0x00, 0x7B, 0xE0, 0x1E,
  0x00, 0xF7, 0xC0, 0x3C, 0x03, 0xEF, 0x00, 0xF8, 0x07, 0xDE, 0x01, 0xF0,
  0x0F, 0x3C, 0x03, 0xC0, 0x3E, 0x78, 0x07, 0x80, 0x78, 0xF0, 0x1F, 0x01,
  0xF1, 0xE0, 0x2E, 0x03, 0xE3, 0xC0, 0xDE, 0x0F, 0x87, 0xC7, 0x3C, 0x3E,
  0x0F, 0xFE, 0x7F, 0xF8, 0x1F, 0xF8, 0x7F, 0xE0, 0x1F, 0xE0, 0xFF, 0x80,
  0x1F, 0x80, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x03, 0xFC, 0x07,
  0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0xE0, 0x1F, 0xFE, 0x1F, 0xFE, 0x03, 0xF9,
  0xE3, 0xC3, 0xE0, 0x7E, 0x1E, 0x38, 0x1E, 0x1F, 0xC1, 0xE7, 0x01, 0xF1,
  0xF0, 0x0E, 0x70, 0x1F, 0x0E, 0x00, 0xEE, 0x01, 0xF0, 0x80, 0x0E, 0xE0,
  0x1F, 0x00, 0x00, 0xEC, 0x01, 0xE0, 0x00, 0x0F, 0xC0, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0x80, 0x3F, 0x00, 0x00, 0x78, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x7F, 0x00, 0x30, 0xF8, 0x06, 0x70, 0x07, 0x0F, 0x80, 0xE7, 0x01,
  0xF8, 0xF8, 0x0E, 0x78, 0x3F, 0x07, 0x81, 0xC7, 0x8F, 0xE0, 0x7C, 0x3C,
  0x79, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x03,
  0xFE, 0x03, 0xFC, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x78, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x03,
  0xE0, 0x3C, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF0,
  0x1E, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0xF8, 0x0F,
  0x00, 0x01, 0xF0, 0x1E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xFC, 0x07, 0xC0,
  0x01, 0xF8, 0x0F, 0x80, 0x07, 0xF0, 0x1F, 0x80, 0x1B, 0xE0, 0x1F, 0x00,
  0x77, 0x80, 0x3F, 0x83, 0xCF, 0x00, 0x7F, 0xFF, 0x3E, 0x00, 0x7F, 0xFC,
  0x7C, 0x00, 0x7F, 0xF0, 0xF8, 0x00, 0x3F, 0x81, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x06, 0x00, 0x07, 0xC0,
  0x1E, 0x00, 0x1F, 0x80, 0x7F, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x7C, 0x0F, 0xFF, 0xE0, 0xF0,
  0x3F, 0xFF, 0xE3, 0xE0, 0xFC, 0x1F, 0xF7, 0xC1, 0xE0, 0x07, 0xFF, 0x83,
  0xC0, 0x03, 0xFE, 0x0F, 0x00, 0x01, 0xF8, 0x1E, 0x00, 0x07, 0xE0, 0x3C,
  0x00, 0x1F, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x06, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x3F, 0x00,
  0x3C, 0x00, 0xFC, 0x00, 0x78, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x01,
  0xF0, 0x3F, 0x00, 0x01, 0xE0, 0xFF, 0xE0, 0x03, 0xC3, 0xFF, 0xFC, 0x07,
  0x87, 0x8F, 0xFF, 0xCF, 0x1F, 0x03, 0xFF, 0xFE, 0x3E, 0x00, 0xFF, 0xFC,
  0x7C, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x18, 0x07, 0xF8,
  0x00, 0x3C, 0x1F, 0xF8, 0x00, 0x78, 0x7F, 0xF8, 0x01, 0xE1, 0xF1, 0xF8,
  0x03, 0xC7, 0xC1, 0xF0, 0x0F, 0x0F, 0x01, 0xF0, 0x1E, 0x3E, 0x01, 0xF0,
  0x78, 0x78, 0x03, 0xF1, 0xF0, 0xF0, 0x03, 0xFF, 0xC3, 0xC0, 0x03, 0xFF,
  0x07, 0x80, 0x03, 0xFC, 0x03, 0x00, 0x03, 0xE0, 0x00,
};

const GFXglyph IBMPlexMono_Italic60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 36, 0, -1 },
  { 1, 13, 43, 36, 12, -42 },
  { 71, 17, 17, 36, 13, -44 },
  { 108, 36, 42, 36, 1, -42 },
  { 297, 34, 56, 36, 1, -49 },
  { 535, 40, 44, 36, -1, -43 },
  { 755, 35, 44, 36, 0, -43 },
  { 948, 7, 17, 36, 18, -44 },
  { 963, 23, 54, 36, 12, -46 },
  { 1119, 23, 54, 36, 2, -46 },
  { 1275, 31, 30, 36, 3, -33 },
  { 1392, 29, 30, 36, 4, -33 },
  { 1501, 14, 16, 36, 8, -8 },
  { 1529, 18, 4, 36, 9, -20 },
  { 1538, 9, 8, 36, 12, -7 },
  { 1547, 35, 54, 36, 1, -46 },
  { 1784, 30, 44, 36, 4, -43 },
  { 1949, 28, 42, 36, 3, -42 },
  { 2096, 31, 43, 36, 2, -43 },
  { 2263, 32, 44, 36, 1, -43 },
  { 2439, 32, 42, 36, 1, -42 },
  { 2607, 31, 43, 36, 3, -42 },
  { 2774, 28, 43, 36, 4, -42 },
  { 2925, 30, 42, 36, 6, -42 },
  { 3083, 32, 44, 36, 2, -43 },
  { 3259, 29, 43, 36, 5, -43 },
  { 3415, 12, 32, 36, 12, -31 },
  { 3463, 16, 39, 36, 8, -31 },
  { 3541, 29, 34, 36, 5, -35 },
  { 3665, 31, 16, 36, 3, -26 },
  { 3727, 29, 34, 36, 3, -35 },
  { 3851, 25, 44, 36, 8, -43 },
  { 3989, 31, 50, 36, 3, -43 },
  { 4183, 33, 42, 36, -1, -42 },
  { 4357, 30, 42, 36, 3, -42 },
  { 4515, 30, 44, 36, 5, -43 },
  { 4680, 31, 42, 36, 3, -42 },
  { 4843, 33, 42, 36, 3, -42 },
  { 5017, 33, 42, 36, 3, -42 },
  { 5191, 30, 44, 36, 4, -43 },
  { 5356, 34, 42, 36, 2, -42 },
  { 5535, 33, 42, 36, 2, -42 },
  { 5709, 30, 43, 36, 3, -42 },
  { 5871, 36, 42, 36, 3, -42 },
  { 6060, 25, 42, 36, 5, -42 },
  { 6192, 34, 42, 36, 2, -42 },
  { 6371, 34, 42, 36, 2, -42 },
  { 6550, 30, 44, 36, 4, -43 },
  { 6715, 32, 42, 36, 3, -42 },
  { 6883, 30, 54, 36, 4, -43 },
  { 7086, 32, 42, 36, 3, -42 },
  { 7254, 34, 44, 36, 1, -43 },
  { 7441, 34, 42, 36, 5, -42 },
  { 7620, 32, 43, 36, 4, -42 },
  { 7792, 31, 42, 36, 7, -42 },
  { 7955, 35, 42, 36, 3, -42 },
  { 8139, 40, 42, 36, -1, -42 },
  { 8349, 34, 42, 36, 5, -42 },
  { 8528, 37, 42, 36, 0, -42 },
  { 8723, 25, 54, 36, 10, -46 },
  { 8892, 16, 54, 36, 11, -46 },
  { 9000, 25, 54, 36, 1, -46 },
  { 9169, 30, 24, 36, 4, -42 },
  { 9259, 29, 4, 36, 0, 6 },
  { 9274, 7, 12, 36, 14, -47 },
  { 9285, 29, 33, 36, 3, -32 },
  { 9405, 30, 45, 36, 3, -44 },
  { 9574, 27, 33, 36, 4, -32 },
  { 9686, 32, 45, 36, 3, -44 },
  { 9866, 28, 33, 36, 4, -32 },
  { 9982, 39, 57, 36, -1, -44 },
  { 10260, 31, 45, 36, 2, -32 },
  { 10435, 27, 44, 36, 4, -44 },
  { 10584, 27, 46, 36, 5, -45 },
  { 10740, 29, 58, 36, 3, -45 },
  { 10951, 30, 45, 36, 4, -44 },
  { 11120, 26, 45, 36, 6, -44 },
  { 11267, 33, 32, 36, 1, -32 },
  { 11399, 27, 32, 36, 4, -32 },
  { 11507, 28, 33, 36, 4, -32 },
  { 11623, 32, 44, 36, 1, -32 },
  { 11799, 30, 44, 36, 3, -32 },
  { 11964, 29, 31, 36, 6, -31 },
  { 12077, 29, 33, 36, 3, -32 },
  { 12197, 27, 43, 36, 5, -42 },
  { 12343, 28, 32, 36, 5, -31 },
  { 12455, 28, 31, 36, 4, -31 },
  { 12564, 31, 32, 36, 3, -31 },
  { 12688, 36, 33, 36, 0, -32 },
  { 12837, 31, 44, 36, 2, -31 },
  { 13008, 31, 33, 36, 3, -32 },
  { 13136, 28, 54, 36, 7, -46 },
  { 13325, 13, 54, 36, 12, -46 },
  { 13413, 28, 54, 36, 3, -46 },
  { 13602, 31, 13, 36, 3, -25 },
};

const GFXfont IBMPlexMono_Italic60pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic60pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic60pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _IBMPLEXMONO_ITALIC60PT7B_H_
