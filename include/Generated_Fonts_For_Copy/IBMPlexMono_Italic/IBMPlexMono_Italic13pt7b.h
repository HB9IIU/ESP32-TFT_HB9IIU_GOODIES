#ifndef _IBMPLEXMONO_ITALIC13PT7B_H_
#define _IBMPLEXMONO_ITALIC13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0x94, 0x82, 0xC0, 0xBA, 0xAA, 0x0A, 0x12, 0x12, 0x77, 0x24,
  0xEE, 0x28, 0x48, 0x50, 0x08, 0x1E, 0x2B, 0x48, 0x68, 0x1C, 0x12, 0x12,
  0xD6, 0x7C, 0x10, 0x31, 0xA5, 0x12, 0x8E, 0x80, 0x01, 0x71, 0x28, 0xA4,
  0x8E, 0x00, 0x1C, 0x24, 0x24, 0x24, 0x78, 0x90, 0x8A, 0x8B, 0x76, 0xF0,
  0x19, 0x11, 0x08, 0x42, 0x10, 0x84, 0x20, 0xC0, 0x61, 0x11, 0x11, 0x11,
  0x22, 0x48, 0x10, 0x4D, 0x4E, 0x73, 0x20, 0x10, 0x41, 0x3F, 0x20, 0x82,
  0x00, 0x6A, 0x40, 0xF0, 0x70, 0x03, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10,
  0x10, 0x20, 0x20, 0x40, 0xC0, 0x3D, 0x1C, 0x6D, 0xB6, 0x18, 0x62, 0x70,
  0x39, 0xCD, 0x04, 0x10, 0x41, 0x08, 0xFC, 0x1C, 0x45, 0x08, 0x10, 0x41,
  0x0C, 0x20, 0xFE, 0x1C, 0x44, 0x08, 0x31, 0x80, 0x81, 0xE2, 0x78, 0x06,
  0x14, 0x50, 0xA2, 0x48, 0xBF, 0x82, 0x08, 0x7D, 0x04, 0x1E, 0xCC, 0x10,
  0x62, 0x70, 0x1C, 0x84, 0x1E, 0xC6, 0x18, 0x62, 0x70, 0x7E, 0x8A, 0x10,
  0x41, 0x82, 0x08, 0x10, 0x40, 0x3D, 0x14, 0x51, 0x3B, 0x38, 0x63, 0xF8,
  0x39, 0x18, 0x61, 0xCD, 0xE0, 0x84, 0x60, 0x2C, 0x00, 0xB0, 0x2C, 0x00,
  0xD4, 0x80, 0x04, 0x66, 0x20, 0x60, 0x40, 0x80, 0xFC, 0x00, 0x3F, 0x40,
  0x81, 0x81, 0x19, 0x88, 0x00, 0x74, 0x62, 0x17, 0x20, 0x18, 0xC0, 0x39,
  0x18, 0x67, 0xA6, 0x9A, 0x6F, 0x81, 0xC0, 0x0C, 0x28, 0x51, 0x22, 0x47,
  0x91, 0xA1, 0x82, 0x7D, 0x14, 0x51, 0xFA, 0x18, 0x63, 0xF8, 0x3C, 0xC9,
  0x0C, 0x08, 0x10, 0x21, 0x64, 0x70, 0x79, 0x14, 0x51, 0xC6, 0x18, 0x62,
  0xF0, 0x7E, 0x81, 0x02, 0x0F, 0xD0, 0x20, 0x40, 0xF8, 0x7E, 0x81, 0x02,
  0x0F, 0xD0, 0x20, 0x40, 0x80, 0x3D, 0x14, 0x20, 0x9E, 0x18, 0x62, 0x78,
  0x21, 0x22, 0x22, 0x62, 0x7E, 0x42, 0x42, 0x44, 0xC4, 0x7E, 0x20, 0x40,
  0x81, 0x04, 0x08, 0x10, 0xF8, 0x3C, 0x10, 0x41, 0x08, 0x20, 0xA2, 0x70,
  0x42, 0x89, 0x26, 0x8B, 0x1A, 0x22, 0x44, 0x8C, 0x61, 0x04, 0x10, 0x41,
  0x08, 0x20, 0xFC, 0x23, 0x33, 0x56, 0x5A, 0x5A, 0x52, 0x42, 0x42, 0x84,
  0x31, 0x32, 0x32, 0x52, 0x4A, 0x4A, 0x4A, 0x4C, 0xC4, 0x3D, 0x1C, 0x61,
  0x86, 0x18, 0x62, 0x70, 0x7C, 0x8D, 0x1A, 0x2F, 0x90, 0x20, 0x40, 0x80,
  0x3D, 0x1C, 0x61, 0x86, 0x18, 0x62, 0x70, 0xD1, 0x80, 0x7C, 0x8D, 0x1A,
  0x2F, 0x92, 0x24, 0x44, 0x8C, 0x1E, 0x23, 0x40, 0x20, 0x1C, 0x02, 0x02,
  0xC6, 0x7C, 0xFE, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x42, 0x89,
  0x14, 0x28, 0x50, 0xA3, 0x44, 0x70, 0xC2, 0x8D, 0x12, 0x24, 0x89, 0x14,
  0x28, 0x20, 0x83, 0x06, 0x4D, 0xAB, 0x5A, 0xB5, 0x6C, 0x98, 0x61, 0x22,
  0x14, 0x1C, 0x18, 0x18, 0x24, 0x44, 0x82, 0xC3, 0x44, 0x48, 0x38, 0x30,
  0x20, 0x20, 0x20, 0x20, 0x3F, 0x02, 0x04, 0x0C, 0x18, 0x30, 0x20, 0x40,
  0xFE, 0x3C, 0x82, 0x10, 0x41, 0x04, 0x10, 0x42, 0x08, 0x3C, 0x84, 0x44,
  0x44, 0x22, 0x22, 0x21, 0x3C, 0x20, 0x82, 0x08, 0x20, 0x84, 0x10, 0x41,
  0x3C, 0x18, 0xA2, 0x91, 0x84, 0xFC, 0xA4, 0x77, 0x38, 0x62, 0x8A, 0x6E,
  0xC0, 0x41, 0x04, 0x16, 0x67, 0x18, 0x61, 0x8B, 0xC0, 0x39, 0x18, 0x20,
  0x8A, 0x37, 0x00, 0x02, 0x08, 0x13, 0xAC, 0xD0, 0xA1, 0x44, 0x89, 0xF0,
  0x39, 0x18, 0xFC, 0x82, 0x37, 0x00, 0x07, 0x08, 0x08, 0x3F, 0x08, 0x08,
  0x08, 0x10, 0x10, 0x10, 0x90, 0x50, 0x20, 0x3A, 0xCD, 0x0A, 0x14, 0x48,
  0x9F, 0x02, 0x8C, 0xF0, 0x41, 0x04, 0x16, 0x67, 0x18, 0x62, 0x8A, 0x20,
  0x10, 0x40, 0x3C, 0x20, 0x82, 0x09, 0x38, 0xC0, 0x0C, 0x30, 0x1E, 0x08,
  0x20, 0x84, 0x10, 0x49, 0x14, 0x20, 0x41, 0x04, 0x16, 0x67, 0x19, 0xA9,
  0x96, 0x60, 0xF0, 0x42, 0x08, 0x20, 0x82, 0x0B, 0x59, 0x80, 0x56, 0xD5,
  0x2A, 0x95, 0x32, 0x64, 0x80, 0x59, 0x9C, 0x61, 0x8A, 0x28, 0x80, 0x39,
  0x18, 0x61, 0x86, 0x27, 0x00, 0x2C, 0x65, 0x8A, 0x14, 0x28, 0x9E, 0x20,
  0x81, 0x00, 0x77, 0x38, 0x61, 0x8A, 0x2F, 0x82, 0x08, 0x20, 0xEE, 0x60,
  0x81, 0x02, 0x04, 0x10, 0x00, 0x79, 0x34, 0x1E, 0x0A, 0x2F, 0x80, 0x30,
  0x8F, 0xC8, 0x20, 0x84, 0x56, 0x60, 0x45, 0x18, 0x63, 0x8A, 0x66, 0x80,
  0xC5, 0x14, 0x51, 0x49, 0x66, 0x00, 0x96, 0x59, 0x69, 0xA6, 0x9D, 0x80,
  0x36, 0x59, 0x19, 0x10, 0x90, 0xB2, 0xEC, 0x22, 0x45, 0x0A, 0x34, 0x49,
  0x8D, 0x02, 0x8C, 0xF0, 0x76, 0x31, 0x8C, 0x4B, 0x1B, 0xC0, 0x1E, 0x20,
  0x40, 0x81, 0x0C, 0x24, 0x08, 0x20, 0x81, 0x03, 0xC0, 0x55, 0x5A, 0xAA,
  0x78, 0x21, 0x08, 0x20, 0x72, 0x08, 0x20, 0x82, 0x38, 0x66, 0xD9, 0x80,
};

const GFXglyph IBMPlexMono_Italic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 3, 9, 8, 2, -9 },
  { 5, 4, 4, 8, 3, -10 },
  { 7, 8, 9, 8, 0, -9 },
  { 16, 8, 11, 8, 0, -10 },
  { 27, 9, 9, 8, 0, -9 },
  { 38, 8, 9, 8, 0, -9 },
  { 47, 1, 4, 8, 4, -10 },
  { 48, 5, 12, 8, 3, -10 },
  { 56, 4, 12, 8, 1, -10 },
  { 62, 6, 6, 8, 1, -7 },
  { 67, 6, 7, 8, 1, -7 },
  { 73, 3, 4, 8, 2, -2 },
  { 75, 4, 1, 8, 2, -4 },
  { 76, 2, 2, 8, 2, -2 },
  { 77, 8, 12, 8, 0, -10 },
  { 89, 6, 9, 8, 1, -9 },
  { 96, 6, 9, 8, 1, -9 },
  { 103, 7, 9, 8, 0, -9 },
  { 111, 7, 9, 8, 0, -9 },
  { 119, 7, 9, 8, 0, -9 },
  { 127, 6, 9, 8, 1, -9 },
  { 134, 6, 9, 8, 1, -9 },
  { 141, 7, 9, 8, 1, -9 },
  { 149, 6, 9, 8, 1, -9 },
  { 156, 6, 9, 8, 1, -9 },
  { 163, 3, 7, 8, 2, -7 },
  { 166, 3, 9, 8, 2, -7 },
  { 170, 6, 7, 8, 1, -7 },
  { 176, 6, 4, 8, 1, -6 },
  { 179, 6, 7, 8, 1, -7 },
  { 185, 5, 9, 8, 2, -9 },
  { 191, 6, 10, 8, 1, -9 },
  { 199, 7, 9, 8, 0, -9 },
  { 207, 6, 9, 8, 1, -9 },
  { 214, 7, 9, 8, 1, -9 },
  { 222, 6, 9, 8, 1, -9 },
  { 229, 7, 9, 8, 1, -9 },
  { 237, 7, 9, 8, 1, -9 },
  { 245, 6, 9, 8, 1, -9 },
  { 252, 8, 9, 8, 0, -9 },
  { 261, 7, 9, 8, 1, -9 },
  { 269, 6, 9, 8, 1, -9 },
  { 276, 7, 9, 8, 1, -9 },
  { 284, 6, 9, 8, 1, -9 },
  { 291, 8, 9, 8, 0, -9 },
  { 300, 8, 9, 8, 0, -9 },
  { 309, 6, 9, 8, 1, -9 },
  { 316, 7, 9, 8, 1, -9 },
  { 324, 6, 11, 8, 1, -9 },
  { 333, 7, 9, 8, 1, -9 },
  { 341, 8, 9, 8, 0, -9 },
  { 350, 7, 9, 8, 1, -9 },
  { 358, 7, 9, 8, 1, -9 },
  { 366, 7, 9, 8, 1, -9 },
  { 374, 7, 9, 8, 1, -9 },
  { 382, 8, 9, 8, 0, -9 },
  { 391, 8, 9, 8, 1, -9 },
  { 400, 8, 9, 8, 0, -9 },
  { 409, 6, 12, 8, 2, -10 },
  { 418, 4, 12, 8, 2, -10 },
  { 424, 6, 12, 8, 0, -10 },
  { 433, 6, 5, 8, 1, -9 },
  { 437, 6, 1, 8, 0, 1 },
  { 438, 2, 3, 8, 3, -11 },
  { 439, 6, 7, 8, 1, -7 },
  { 445, 6, 10, 8, 1, -10 },
  { 453, 6, 7, 8, 1, -7 },
  { 459, 7, 10, 8, 1, -10 },
  { 468, 6, 7, 8, 1, -7 },
  { 474, 8, 13, 8, 0, -10 },
  { 487, 7, 10, 8, 0, -7 },
  { 496, 6, 10, 8, 1, -10 },
  { 504, 6, 10, 8, 1, -10 },
  { 512, 6, 13, 8, 1, -10 },
  { 522, 6, 10, 8, 1, -10 },
  { 530, 6, 10, 8, 1, -10 },
  { 538, 7, 7, 8, 0, -7 },
  { 545, 6, 7, 8, 1, -7 },
  { 551, 6, 7, 8, 1, -7 },
  { 557, 7, 10, 8, 0, -7 },
  { 566, 6, 10, 8, 1, -7 },
  { 574, 7, 7, 8, 1, -7 },
  { 581, 6, 7, 8, 1, -7 },
  { 587, 6, 9, 8, 1, -9 },
  { 594, 6, 7, 8, 1, -7 },
  { 600, 6, 7, 8, 1, -7 },
  { 606, 6, 7, 8, 1, -7 },
  { 612, 8, 7, 8, 0, -7 },
  { 619, 7, 10, 8, 0, -7 },
  { 628, 6, 7, 8, 1, -7 },
  { 634, 7, 12, 8, 1, -10 },
  { 645, 2, 12, 8, 3, -10 },
  { 648, 6, 12, 8, 1, -10 },
  { 657, 6, 3, 8, 1, -5 },
};

const GFXfont IBMPlexMono_Italic13pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic13pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic13pt7bGlyphs,
  0x20, 0x7E, 17
};

#endif // _IBMPLEXMONO_ITALIC13PT7B_H_
