#ifndef _IBMPLEXMONO_ITALIC6PT7B_H_
#define _IBMPLEXMONO_ITALIC6PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic6pt7bBitmaps[] PROGMEM = {
  0x00, 0xEA, 0xC0, 0x6F, 0xAC, 0x6F, 0xC6, 0xE4, 0xFE, 0xEE, 0xE6, 0xCF,
  0x80, 0x6A, 0xB0, 0x55, 0x60, 0x5E, 0x80, 0x5D, 0x00, 0xC0, 0xC0, 0x80,
  0x12, 0x44, 0x88, 0xF7, 0xF0, 0x69, 0x70, 0xE5, 0x70, 0xE5, 0xF0, 0x6E,
  0xB0, 0xF5, 0xF0, 0x77, 0xF0, 0xEA, 0x40, 0xF7, 0xF0, 0xF6, 0xA0, 0xB0,
  0x69, 0x7C, 0x8C, 0xE0, 0xDA, 0xFF, 0xE6, 0x2D, 0xD0, 0xF7, 0xF0, 0x72,
  0x70, 0xF6, 0xF0, 0xF8, 0xEE, 0xF8, 0xE8, 0xF2, 0xF0, 0xBA, 0xEA, 0x74,
  0x4E, 0x64, 0xF0, 0xBC, 0xCA, 0x52, 0x70, 0x56, 0xEA, 0x7E, 0xEA, 0xF6,
  0xF0, 0xEB, 0xC8, 0xF6, 0xD6, 0xEB, 0xCA, 0xF8, 0x6E, 0xF2, 0x40, 0xBA,
  0xAE, 0xFB, 0x40, 0x9E, 0xEE, 0x76, 0x4A, 0xFA, 0x40, 0x74, 0x4E, 0x72,
  0x49, 0x80, 0xAA, 0x90, 0x69, 0x25, 0x80, 0x3C, 0xE0, 0x80, 0xF7, 0x80,
  0xCE, 0xF0, 0xF3, 0x80, 0x3E, 0xAE, 0xFB, 0x80, 0x77, 0x44, 0xC0, 0xF6,
  0xF0, 0xCE, 0xD0, 0x19, 0x30, 0x2C, 0xAC, 0xCF, 0x70, 0xAB, 0xFF, 0x80,
  0x76, 0x80, 0xF7, 0x80, 0x76, 0xE0, 0xF6, 0xB0, 0xF2, 0x00, 0xEF, 0x80,
  0x5D, 0x70, 0xB7, 0x80, 0xF7, 0x80, 0xFF, 0x80, 0xF4, 0xE0, 0xB6, 0xF0,
  0xEB, 0x80, 0x6E, 0xB0, 0x6A, 0xA0, 0x45, 0x35, 0x80, 0xE0,
};

const GFXglyph IBMPlexMono_Italic6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 4, 4, 1, -4 },
  { 2, 2, 1, 4, 1, -4 },
  { 3, 4, 4, 4, 0, -4 },
  { 5, 4, 6, 4, 0, -5 },
  { 8, 4, 4, 4, 0, -4 },
  { 10, 4, 4, 4, 0, -4 },
  { 12, 1, 1, 4, 2, -4 },
  { 13, 2, 6, 4, 1, -5 },
  { 15, 2, 6, 4, 0, -5 },
  { 17, 3, 3, 4, 0, -3 },
  { 19, 3, 3, 4, 0, -3 },
  { 21, 1, 2, 4, 1, -1 },
  { 22, 2, 1, 4, 1, -2 },
  { 23, 1, 1, 4, 1, -1 },
  { 24, 4, 6, 4, 0, -5 },
  { 27, 3, 4, 4, 0, -4 },
  { 29, 3, 4, 4, 0, -4 },
  { 31, 3, 4, 4, 0, -4 },
  { 33, 3, 4, 4, 0, -4 },
  { 35, 3, 4, 4, 0, -4 },
  { 37, 3, 4, 4, 0, -4 },
  { 39, 3, 4, 4, 0, -4 },
  { 41, 3, 4, 4, 1, -4 },
  { 43, 3, 4, 4, 0, -4 },
  { 45, 2, 4, 4, 1, -4 },
  { 46, 1, 3, 4, 1, -3 },
  { 47, 1, 4, 4, 1, -3 },
  { 48, 2, 4, 4, 1, -4 },
  { 49, 3, 2, 4, 0, -3 },
  { 50, 3, 4, 4, 0, -4 },
  { 52, 2, 4, 4, 1, -4 },
  { 53, 3, 5, 4, 0, -4 },
  { 55, 3, 4, 4, 0, -4 },
  { 57, 3, 4, 4, 0, -4 },
  { 59, 3, 4, 4, 0, -4 },
  { 61, 3, 4, 4, 0, -4 },
  { 63, 4, 4, 4, 0, -4 },
  { 65, 4, 4, 4, 0, -4 },
  { 67, 3, 4, 4, 0, -4 },
  { 69, 4, 4, 4, 0, -4 },
  { 71, 4, 4, 4, 0, -4 },
  { 73, 3, 4, 4, 0, -4 },
  { 75, 4, 4, 4, 0, -4 },
  { 77, 3, 4, 4, 0, -4 },
  { 79, 4, 4, 4, 0, -4 },
  { 81, 4, 4, 4, 0, -4 },
  { 83, 3, 4, 4, 0, -4 },
  { 85, 4, 4, 4, 0, -4 },
  { 87, 3, 5, 4, 0, -4 },
  { 89, 4, 4, 4, 0, -4 },
  { 91, 4, 4, 4, 0, -4 },
  { 93, 3, 4, 4, 1, -4 },
  { 95, 4, 4, 4, 0, -4 },
  { 97, 3, 4, 4, 1, -4 },
  { 99, 4, 4, 4, 0, -4 },
  { 101, 4, 4, 4, 0, -4 },
  { 103, 3, 4, 4, 1, -4 },
  { 105, 4, 4, 4, 0, -4 },
  { 107, 3, 6, 4, 1, -5 },
  { 110, 2, 6, 4, 1, -5 },
  { 112, 3, 6, 4, 0, -5 },
  { 115, 3, 2, 4, 0, -4 },
  { 116, 3, 1, 4, 0, 0 },
  { 117, 1, 1, 4, 1, -5 },
  { 118, 3, 3, 4, 0, -3 },
  { 120, 3, 4, 4, 0, -4 },
  { 122, 3, 3, 4, 0, -3 },
  { 124, 4, 4, 4, 0, -4 },
  { 126, 3, 3, 4, 0, -3 },
  { 128, 4, 5, 4, 0, -4 },
  { 131, 3, 4, 4, 0, -3 },
  { 133, 3, 4, 4, 0, -4 },
  { 135, 3, 4, 4, 0, -4 },
  { 137, 3, 5, 4, 0, -4 },
  { 139, 3, 4, 4, 0, -4 },
  { 141, 2, 4, 4, 1, -4 },
  { 142, 3, 3, 4, 0, -3 },
  { 144, 3, 3, 4, 0, -3 },
  { 146, 3, 3, 4, 0, -3 },
  { 148, 3, 4, 4, 0, -3 },
  { 150, 3, 4, 4, 0, -3 },
  { 152, 3, 3, 4, 1, -3 },
  { 154, 3, 3, 4, 0, -3 },
  { 156, 3, 4, 4, 0, -4 },
  { 158, 3, 3, 4, 0, -3 },
  { 160, 3, 3, 4, 0, -3 },
  { 162, 3, 3, 4, 0, -3 },
  { 164, 4, 3, 4, 0, -3 },
  { 166, 3, 4, 4, 0, -3 },
  { 168, 3, 3, 4, 0, -3 },
  { 170, 2, 6, 4, 1, -5 },
  { 172, 2, 6, 4, 1, -5 },
  { 174, 3, 6, 4, 0, -5 },
  { 177, 3, 1, 4, 0, -2 },
};

const GFXfont IBMPlexMono_Italic6pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic6pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _IBMPLEXMONO_ITALIC6PT7B_H_
