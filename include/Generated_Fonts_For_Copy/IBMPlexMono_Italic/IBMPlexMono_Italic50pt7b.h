#ifndef _IBMPLEXMONO_ITALIC50PT7B_H_
#define _IBMPLEXMONO_ITALIC50PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3E,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x03, 0xC0, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0x81,
  0xE0, 0x00, 0x3C, 0x3C, 0xE0, 0xF7, 0x83, 0xDE, 0x0F, 0x78, 0x3D, 0xE0,
  0xE7, 0x07, 0x9C, 0x1E, 0xF0, 0x7B, 0xC1, 0xEF, 0x07, 0xBC, 0x1C, 0xE0,
  0xF3, 0x83, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0E, 0x07, 0x80, 0x00,
  0x78, 0x1C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x3C,
  0x0E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1E, 0x07,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0xFF, 0xC0, 0xFF, 0xC7, 0xFF, 0x03, 0xFF,
  0x1F, 0xFC, 0x1F, 0xFC, 0x7F, 0xE0, 0x7F, 0xE0, 0x07, 0x81, 0xC0, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x38, 0x1E, 0x00, 0x01, 0xE0, 0x70, 0x03, 0xFF, 0x83,
  0xFF, 0x8F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xF0, 0xFF, 0xC1, 0xFF,
  0xC0, 0x0E, 0x07, 0x80, 0x00, 0x38, 0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x07, 0x03, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03,
  0x81, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC0,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F,
  0x9C, 0xFE, 0x07, 0xE1, 0xC3, 0xF0, 0x7C, 0x1C, 0x0F, 0x07, 0x81, 0xC0,
  0x60, 0xF8, 0x1C, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x0F,
  0x03, 0x80, 0x00, 0xF8, 0x38, 0x00, 0x0F, 0x83, 0x80, 0x00, 0x7E, 0x38,
  0x00, 0x07, 0xFB, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0x1F, 0x80, 0x00, 0xE0, 0xF8, 0x00, 0x0E, 0x07, 0xC0, 0x00, 0xE0, 0x7C,
  0x00, 0x0E, 0x07, 0xC0, 0x00, 0xE0, 0x7C, 0x00, 0x0E, 0x07, 0xC3, 0x01,
  0xC0, 0x78, 0x70, 0x1C, 0x0F, 0x8F, 0x81, 0xC0, 0xF8, 0x7E, 0x1C, 0x3F,
  0x03, 0xF9, 0xCF, 0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xF0, 0x1F, 0xFC, 0x00,
  0x78, 0x0F, 0x87, 0x80, 0x3C, 0x03, 0x80, 0xE0, 0x0E, 0x01, 0xE0, 0x38,
  0x07, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0xE0, 0x0F, 0x00,
  0xE0, 0x78, 0x03, 0xC0, 0x38, 0x3C, 0x00, 0xF0, 0x1E, 0x0E, 0x00, 0x38,
  0x07, 0x87, 0x00, 0x0E, 0x01, 0xC3, 0xC0, 0x03, 0xC0, 0xF1, 0xE0, 0x00,
  0x78, 0x78, 0x70, 0x00, 0x1F, 0xFC, 0x3C, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0x1F, 0xFC, 0x00, 0x07, 0x8F,
  0x87, 0x80, 0x03, 0xC3, 0x80, 0xE0, 0x00, 0xE1, 0xE0, 0x38, 0x00, 0x78,
  0x70, 0x0E, 0x00, 0x3C, 0x1C, 0x03, 0x80, 0x0E, 0x0F, 0x00, 0xE0, 0x07,
  0x83, 0xC0, 0x38, 0x03, 0xC0, 0xF0, 0x0E, 0x00, 0xE0, 0x3C, 0x07, 0x80,
  0x78, 0x0F, 0x01, 0xC0, 0x3C, 0x01, 0xC0, 0xF0, 0x0E, 0x00, 0x78, 0x78,
  0x07, 0x00, 0x1F, 0xFE, 0x03, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x78, 0x07, 0x80,
  0x03, 0xC0, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x01, 0xC0, 0x0F, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x78, 0x07, 0x80, 0x01, 0xE0, 0x7C, 0x00, 0x0F, 0x07, 0xC0,
  0x00, 0xFC, 0x7C, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x3E,
  0x3F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3E, 0x07, 0x80, 0x01, 0xE0, 0x3C,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x07, 0x80, 0x07, 0x80, 0x1E, 0x00,
  0x3C, 0x00, 0xF0, 0x09, 0xE0, 0x03, 0xC0, 0x6F, 0x00, 0x1F, 0x07, 0xF8,
  0x01, 0xF8, 0x3F, 0xE0, 0x0F, 0xE3, 0xCF, 0x00, 0xCF, 0x1E, 0x7C, 0x1E,
  0x7D, 0xE1, 0xFF, 0xF1, 0xFF, 0x0F, 0xFF, 0x0F, 0xF0, 0x3F, 0xF0, 0x3F,
  0x00, 0x7E, 0x00, 0xF0, 0x00, 0x3C, 0xF3, 0x8E, 0x79, 0xE7, 0x9E, 0x71,
  0xCF, 0x3C, 0xF3, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x70, 0x1E, 0x03, 0xFF, 0x0F, 0x0F, 0xFF, 0xF7, 0x7F,
  0xE7, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xEF, 0x00, 0x01, 0xF3, 0xC0, 0x01, 0xF1,
  0xE0, 0x01, 0xF0, 0x78, 0x01, 0xF0, 0x3C, 0x01, 0xF0, 0x0F, 0x00, 0xF0,
  0x07, 0x80, 0x30, 0x01, 0xA0, 0x10, 0x00, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x3E, 0x07,
  0xC1, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xE0, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF,
  0x9E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03,
  0xF0, 0x3F, 0x01, 0xF0, 0x03, 0xC0, 0x78, 0x00, 0xF8, 0x3C, 0x00, 0x1E,
  0x1F, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x38, 0xF0, 0x00,
  0x0E, 0x3C, 0x00, 0x07, 0xCF, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x79, 0xE0,
  0x00, 0x1E, 0x78, 0x1E, 0x07, 0x9E, 0x0F, 0xC1, 0xE7, 0x83, 0xF0, 0x7B,
  0xE0, 0xFC, 0x1E, 0xF8, 0x3E, 0x0F, 0xBC, 0x0F, 0x83, 0xEF, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x1F, 0x3C, 0x00, 0x07, 0x8F, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0xF8, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x1F, 0x07,
  0x80, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0x3E, 0x07, 0xF0, 0x0F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0xFD, 0xE0, 0x01, 0xF9, 0xE0, 0x03, 0xF1, 0xE0, 0x07, 0xE1, 0xE0, 0x0F,
  0xC1, 0xE0, 0x1F, 0x03, 0xC0, 0x0E, 0x03, 0xC0, 0x0C, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0x81,
  0xF8, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x3C, 0x00, 0x1E, 0x0F,
  0x80, 0x03, 0xE0, 0x20, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0,
  0x1F, 0x81, 0xFC, 0x07, 0xC0, 0x0F, 0x80, 0xF0, 0x00, 0xF0, 0x0C, 0x00,
  0x1E, 0x01, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x81, 0x00, 0x01, 0xF0,
  0x60, 0x00, 0x3C, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0x7F, 0x01,
  0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x79, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC0, 0xE0, 0x00,
  0xF0, 0x3C, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x00, 0xF0, 0x01, 0xC0, 0x1E,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x01, 0xE0,
  0x03, 0xC0, 0x38, 0x00, 0x78, 0x0E, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x1F,
  0xC0, 0x03, 0xCF, 0xFE, 0x00, 0x7B, 0xFF, 0xE0, 0x0E, 0xFF, 0xFE, 0x01,
  0xF8, 0x0F, 0xC0, 0x7C, 0x00, 0xFC, 0x0F, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x08, 0x00, 0x0F,
  0x83, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x01, 0xF8,
  0x0F, 0xC0, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x1F, 0xC0, 0x1E, 0x7F,
  0xF0, 0x3E, 0xFF, 0xF8, 0x3D, 0xFF, 0xFC, 0x7F, 0xC0, 0xFE, 0x7F, 0x00,
  0x3E, 0x7E, 0x00, 0x1E, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1E, 0xF0, 0x00,
  0x1E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x7C, 0x7C, 0x00,
  0xF8, 0x7E, 0x03, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0xF1, 0xE0,
  0x00, 0x78, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x7C, 0x78, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0x81, 0xFC, 0x0F,
  0xC0, 0x0F, 0x81, 0xE0, 0x00, 0xF0, 0x7C, 0x00, 0x1E, 0x0F, 0x00, 0x03,
  0xE1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0xF0,
  0x00, 0x78, 0x0F, 0x00, 0x1E, 0x01, 0xF8, 0x0F, 0x80, 0x1F, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xE0,
  0x3F, 0x01, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x1E, 0x1F, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x7C, 0x78, 0x00, 0x07, 0x9F, 0x00, 0x01, 0xF3, 0xC0, 0x00,
  0x3E, 0x78, 0x00, 0x07, 0xCF, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x3E, 0x3E,
  0x00, 0x0F, 0xC3, 0xE0, 0x03, 0xF0, 0x7F, 0x01, 0xFC, 0x07, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F,
  0xC0, 0x7E, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x7C,
  0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0x78,
  0x00, 0x3E, 0x7C, 0x00, 0xDE, 0x7F, 0x03, 0xFE, 0x3F, 0xFF, 0xBC, 0x1F,
  0xFF, 0x7C, 0x0F, 0xFE, 0x78, 0x03, 0xF8, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0x83, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x07, 0x80, 0x00, 0xF0, 0x0F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x3F, 0x01, 0xF0,
  0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F,
  0x00, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x10, 0x3F, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xF0, 0x04, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0x81,
  0xF8, 0xF8, 0x03, 0xE7, 0xC0, 0x07, 0xDE, 0x00, 0x1F, 0xF8, 0x00, 0x7C,
  0x40, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x07, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0xC0, 0x3F, 0x03, 0xF0, 0x3E, 0x00, 0x78, 0x3E, 0x00, 0x1E,
  0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xC7, 0x00, 0xF0,
  0xE7, 0x81, 0xFE, 0x73, 0xC1, 0xFF, 0x79, 0xE1, 0xFF, 0xFC, 0xE0, 0xF8,
  0x7E, 0xF0, 0xF8, 0x1E, 0x78, 0x78, 0x07, 0x3C, 0x3C, 0x03, 0x9E, 0x3C,
  0x03, 0xCE, 0x1E, 0x01, 0xEF, 0x0F, 0x00, 0xF7, 0x87, 0x80, 0x73, 0xC3,
  0xC0, 0x39, 0xE1, 0xC0, 0x3C, 0xF0, 0xE0, 0x1E, 0x70, 0x78, 0x1F, 0x38,
  0x3C, 0x1F, 0x9C, 0x1F, 0xBB, 0x8E, 0x0F, 0xFD, 0xC7, 0x03, 0xFD, 0xE3,
  0x80, 0xFC, 0xF1, 0xE0, 0x10, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x79,
  0xC0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0x87, 0x80, 0x01,
  0xE1, 0xE0, 0x00, 0x70, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80,
  0x07, 0x80, 0xF0, 0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x0F, 0x00, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83,
  0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07,
  0x8F, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x3D, 0xF0, 0x00, 0x0F, 0x78, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3C, 0x03, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0x80, 0x0F,
  0x81, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0x7C, 0x1E, 0x00, 0x0F, 0x07, 0x80,
  0x03, 0xC1, 0xE0, 0x01, 0xF0, 0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x1E, 0x0F,
  0x00, 0x0F, 0x83, 0xC0, 0x03, 0xC0, 0xF0, 0x03, 0xE0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x78, 0x00,
  0xF8, 0x1E, 0x00, 0x1F, 0x07, 0x80, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0,
  0x00, 0x3E, 0x3C, 0x00, 0x0F, 0x8F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0,
  0xF0, 0x00, 0x7C, 0x78, 0x00, 0x1F, 0x1E, 0x00, 0x0F, 0x87, 0x80, 0x0F,
  0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x3F, 0x03, 0xF0, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0x3E,
  0x1E, 0x00, 0x0F, 0x1F, 0x00, 0x07, 0x8F, 0x00, 0x04, 0x0F, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x04, 0x1E, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xE3, 0xC0, 0x03, 0xE1,
  0xE0, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x78,
  0x07, 0xE0, 0x3C, 0x00, 0xF8, 0x3E, 0x00, 0x3C, 0x1E, 0x00, 0x1F, 0x0F,
  0x00, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF1,
  0xF0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x0F,
  0x1E, 0x00, 0x07, 0x8F, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7, 0x80, 0x01,
  0xF3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x78, 0x00,
  0x3E, 0x7C, 0x00, 0x1E, 0x3C, 0x00, 0x1F, 0x1E, 0x00, 0x0F, 0x8F, 0x00,
  0x0F, 0x87, 0x80, 0x0F, 0x83, 0xC0, 0x0F, 0xC3, 0xE0, 0x1F, 0xC1, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFE, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xF8, 0x3F, 0x01, 0xF8,
  0x03, 0xE0, 0x7C, 0x00, 0x78, 0x3E, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC7,
  0x80, 0x01, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x7F, 0xF1, 0xE0, 0x1F, 0xFC, 0xF8,
  0x0F, 0xFE, 0x3E, 0x03, 0xFF, 0x8F, 0x80, 0x01, 0xE3, 0xE0, 0x00, 0x78,
  0xF8, 0x00, 0x1E, 0x3E, 0x00, 0x07, 0x8F, 0x80, 0x01, 0xE3, 0xE0, 0x00,
  0xF0, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x1F, 0x07, 0xC0, 0x0F, 0xC1, 0xF0,
  0x06, 0xF0, 0x3F, 0x07, 0xBC, 0x0F, 0xFF, 0xCE, 0x01, 0xFF, 0xE7, 0x80,
  0x3F, 0xF1, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x3C,
  0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01,
  0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xE0, 0x78, 0x00, 0x3C, 0x0F,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x3C, 0x0F, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x81,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0,
  0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x1F, 0x03, 0xC0,
  0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E,
  0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x3E, 0x07, 0x80, 0x03, 0xC0, 0xF0,
  0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x1F, 0x07, 0xC0, 0x0F, 0x81, 0xE0,
  0x0F, 0x80, 0xFC, 0x1F, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x0F, 0x00,
  0x03, 0xE0, 0x3C, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0x80, 0x07,
  0xC0, 0x1E, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x01, 0xE0, 0x0F, 0x80,
  0x07, 0x80, 0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xF0, 0x1F, 0x00, 0x03,
  0xC0, 0xF8, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0xF1,
  0xF0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x1E, 0x7F, 0x00, 0x00, 0x7B, 0xFE,
  0x00, 0x01, 0xFF, 0x78, 0x00, 0x07, 0xF9, 0xE0, 0x00, 0x1F, 0xC3, 0xC0,
  0x00, 0xFE, 0x0F, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x0F, 0x80, 0x78, 0x00,
  0x3C, 0x01, 0xF0, 0x00, 0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0xF0, 0x07, 0x80,
  0x03, 0xC0, 0x1E, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x1E, 0x03, 0xE0, 0x00,
  0x7C, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00,
  0x7E, 0x07, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x83, 0xF8, 0x03, 0xF8,
  0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xDE, 0x07, 0x38, 0x1E, 0xF0, 0x39,
  0xC1, 0xE7, 0x83, 0xCF, 0x0F, 0x3C, 0x1E, 0x78, 0xF1, 0xC0, 0xF1, 0xC7,
  0x1E, 0x07, 0x8E, 0x78, 0xF0, 0x38, 0x7B, 0x87, 0x81, 0xC3, 0xFC, 0x3C,
  0x1E, 0x0F, 0xC1, 0xE0, 0xF0, 0x7C, 0x0E, 0x07, 0x83, 0xE0, 0xF0, 0x3C,
  0x1E, 0x07, 0x81, 0xC0, 0x70, 0x3C, 0x0E, 0x03, 0x01, 0xE0, 0xF0, 0x18,
  0x0F, 0x07, 0x80, 0x80, 0x70, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C,
  0x0E, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x3C,
  0x00, 0x03, 0x81, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x70, 0x00,
  0x0F, 0x03, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC0, 0x03, 0xF0, 0x00,
  0xF0, 0x3F, 0x00, 0x0E, 0x07, 0xF0, 0x01, 0xE0, 0x7F, 0x80, 0x1E, 0x07,
  0xF8, 0x01, 0xE0, 0x7F, 0x80, 0x1E, 0x07, 0xB8, 0x01, 0xE0, 0x73, 0x80,
  0x1C, 0x0F, 0x3C, 0x03, 0xC0, 0xF3, 0xC0, 0x3C, 0x0F, 0x3C, 0x03, 0xC0,
  0xF1, 0xC0, 0x3C, 0x0F, 0x1E, 0x03, 0xC0, 0xE1, 0xE0, 0x38, 0x1E, 0x1E,
  0x07, 0x81, 0xE0, 0xE0, 0x78, 0x1E, 0x0E, 0x07, 0x81, 0xE0, 0xF0, 0x78,
  0x1E, 0x0F, 0x07, 0x81, 0xC0, 0xF0, 0x70, 0x3C, 0x07, 0x0F, 0x03, 0xC0,
  0x70, 0xF0, 0x3C, 0x07, 0x8F, 0x03, 0xC0, 0x78, 0xF0, 0x3C, 0x07, 0x8F,
  0x03, 0x80, 0x38, 0xE0, 0x78, 0x03, 0xDE, 0x07, 0x80, 0x3D, 0xE0, 0x78,
  0x03, 0xDE, 0x07, 0x80, 0x1D, 0xE0, 0x78, 0x01, 0xFE, 0x07, 0x00, 0x1F,
  0xC0, 0xF0, 0x01, 0xFC, 0x0F, 0x00, 0x1F, 0xC0, 0xF0, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF8, 0x03, 0xF0, 0x3F, 0x01, 0xF0, 0x03, 0xC0, 0xF8, 0x00, 0xF8, 0x3C,
  0x00, 0x1E, 0x1F, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78,
  0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0xCF, 0x00, 0x01, 0xE7, 0xC0, 0x00,
  0x79, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x7B, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBC, 0x00, 0x03, 0xEF,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x1F, 0x3C, 0x00, 0x07,
  0x8F, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0xF8, 0xF0, 0x00, 0x3C, 0x1E, 0x00,
  0x1F, 0x07, 0x80, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0x3E, 0x07, 0xF0, 0x0F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0x7E, 0x0F, 0x00, 0x07, 0xC1, 0xE0, 0x00,
  0x78, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x3E,
  0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x07,
  0x83, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF8, 0x03, 0xF0, 0x3F, 0x01, 0xF0, 0x03, 0xC0, 0xF8, 0x00, 0xF8, 0x3C,
  0x00, 0x1E, 0x1F, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78,
  0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0xCF, 0x00, 0x01, 0xE7, 0xC0, 0x00,
  0x79, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x7B, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBC, 0x00, 0x03, 0xEF,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x1F, 0x3C, 0x00, 0x07,
  0x8F, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0xF8, 0xF0, 0x00, 0x3C, 0x1E, 0x00,
  0x1F, 0x07, 0x80, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0x3E, 0x07, 0xF0, 0x0F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1E, 0x01, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x1F,
  0x3E, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0x7E, 0x0F, 0x00, 0x07, 0xC1,
  0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00,
  0x3C, 0x3E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xF0, 0xF0, 0x00, 0x3E, 0x1E,
  0x00, 0x07, 0x83, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0xFC, 0x1F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x01, 0xE0,
  0x78, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x80, 0xF0, 0x01, 0xE0, 0x1E, 0x00,
  0x3C, 0x03, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x07, 0xC0, 0x0F, 0x00, 0xF0, 0x01, 0xF0, 0x1E, 0x00, 0x1E, 0x03,
  0xC0, 0x03, 0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x83, 0xE0, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x7E, 0x00, 0x3F, 0x07,
  0xC0, 0x01, 0xF0, 0x78, 0x00, 0x0C, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x78, 0x10, 0x00, 0x07, 0x87, 0x00, 0x00, 0xF8, 0xF8,
  0x00, 0x0F, 0x87, 0xE0, 0x03, 0xF0, 0x3F, 0x80, 0xFE, 0x01, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xE1, 0xE0, 0x00,
  0x78, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0,
  0x00, 0xF8, 0xF8, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x1F, 0x1F, 0x00, 0x07,
  0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x1E, 0x00,
  0x07, 0x87, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C,
  0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x78,
  0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x03, 0xE0, 0xF0, 0x00,
  0xF0, 0x3C, 0x00, 0x7C, 0x0F, 0x80, 0x3F, 0x03, 0xF0, 0x1F, 0x80, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0xF0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x1F, 0x3C, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0xF8, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0xF0, 0x38, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x80, 0xF0, 0x00,
  0xF0, 0x1E, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0x80, 0x78, 0x01, 0xF0, 0x0F,
  0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x1C, 0x01, 0xE0, 0x03, 0xC0, 0x3C,
  0x00, 0x78, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0x3C,
  0x0F, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x70, 0x78, 0x00, 0x0E, 0x1E, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x78, 0x78, 0x00, 0x01, 0xE1, 0xC0, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0xF0, 0x70, 0x3E, 0x03,
  0xC3, 0xC0, 0xF8, 0x0E, 0x0F, 0x03, 0xE0, 0x78, 0x3C, 0x1F, 0xC1, 0xE0,
  0xF0, 0x7F, 0x07, 0x83, 0xC1, 0xDC, 0x1C, 0x0F, 0x0E, 0x70, 0xF0, 0x38,
  0x39, 0xC3, 0xC0, 0xE1, 0xE7, 0x0F, 0x03, 0x87, 0x1C, 0x38, 0x0E, 0x1C,
  0x71, 0xE0, 0x38, 0xF1, 0xC7, 0x81, 0xE3, 0x87, 0x1E, 0x07, 0x8E, 0x1C,
  0x70, 0x1E, 0x78, 0x71, 0xC0, 0x79, 0xC1, 0xCF, 0x01, 0xE7, 0x07, 0x3C,
  0x07, 0xB8, 0x1C, 0xE0, 0x1C, 0xE0, 0x73, 0x80, 0x77, 0x81, 0xDE, 0x01,
  0xDC, 0x07, 0x78, 0x07, 0x70, 0x1D, 0xC0, 0x1F, 0xC0, 0x7F, 0x00, 0x7E,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x0F, 0x80,
  0x1F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0,
  0x00, 0xF0, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x0F, 0x03, 0xE0, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x01, 0xE3, 0xE0,
  0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0xF8,
  0x78, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x3E,
  0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0xF8, 0x78,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x07, 0xC0, 0x78, 0x00,
  0x7C, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x7C, 0x03, 0xE0,
  0x01, 0xE0, 0x3E, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x01,
  0xE1, 0xF0, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x02, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7B,
  0x80, 0x00, 0x3E, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x03,
  0xC1, 0xE0, 0x00, 0xF0, 0x38, 0x00, 0x78, 0x0F, 0x00, 0x3C, 0x03, 0xC0,
  0x1F, 0x00, 0x78, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0x03, 0x81, 0xE0, 0x00,
  0xF0, 0xF8, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x38, 0xC0, 0x00, 0x0D, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x10, 0xF3, 0xE3, 0xC3, 0x87, 0x87, 0x0E,
  0x0E, 0x10, 0x00, 0xFE, 0x0F, 0x03, 0xFF, 0x8F, 0x07, 0xFF, 0xCF, 0x0F,
  0xFF, 0xCE, 0x1F, 0xC0, 0xFE, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3C,
  0x00, 0x1E, 0x7C, 0x00, 0x1E, 0x78, 0x00, 0x1C, 0x78, 0x00, 0x3C, 0xF8,
  0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0,
  0x00, 0x38, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF8, 0xF0,
  0x00, 0xF8, 0xF0, 0x01, 0x78, 0xF8, 0x03, 0xF0, 0x7E, 0x0E, 0xFF, 0x7F,
  0xFC, 0xFF, 0x3F, 0xFC, 0x7E, 0x1F, 0xF8, 0x3E, 0x07, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x07, 0xE0, 0x0F,
  0x1F, 0xF8, 0x0F, 0x3F, 0xFC, 0x1E, 0x7F, 0xFE, 0x1E, 0xF0, 0x7E, 0x1E,
  0xC0, 0x1F, 0x1F, 0x80, 0x0F, 0x1F, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x3E,
  0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x3C,
  0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1E, 0x78,
  0x00, 0x1E, 0x78, 0x00, 0x3E, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x7C, 0xFC,
  0x00, 0xF8, 0xF7, 0x03, 0xF8, 0xF7, 0xFF, 0xF0, 0xF3, 0xFF, 0xE0, 0xF1,
  0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0x00, 0x3F,
  0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xC0, 0xF8, 0x7C, 0x01, 0xF3, 0xE0, 0x03,
  0xCF, 0x00, 0x0C, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0xCF, 0x00, 0x07, 0xBC, 0x00, 0x3E,
  0xF8, 0x01, 0xF1, 0xE0, 0x0F, 0x87, 0xE0, 0x7C, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x01, 0xF8, 0x1C, 0x01,
  0xFF, 0x8F, 0x01, 0xFF, 0xF3, 0xC0, 0xFF, 0xFE, 0xF0, 0x7F, 0x03, 0xBC,
  0x1F, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0x83, 0xC0, 0x01, 0xE1, 0xF0, 0x00,
  0x78, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x8F, 0x80, 0x01, 0xC3, 0xC0,
  0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x0F,
  0x83, 0xC0, 0x07, 0xE0, 0xF8, 0x03, 0x78, 0x1F, 0x83, 0xDE, 0x07, 0xFF,
  0xE7, 0x00, 0xFF, 0xF3, 0xC0, 0x1F, 0xF8, 0xF0, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0xFC, 0x07, 0xC3, 0xE0, 0x07, 0x8F, 0x80, 0x0F, 0x9E, 0x00, 0x0F, 0x78,
  0x00, 0x3C, 0xF0, 0x00, 0xFB, 0xC0, 0x07, 0xE7, 0x80, 0xFF, 0x8F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x43, 0xC0, 0x00, 0xE7, 0x80, 0x03, 0xEF, 0x80, 0x0F,
  0x8F, 0x00, 0x3E, 0x1F, 0x81, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00,
  0x78, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0xF8,
  0x1E, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x03,
  0xE3, 0xC0, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x07, 0x80, 0x7F, 0xE3, 0xC0, 0xFF, 0xF9, 0xE0, 0xFF, 0xFE,
  0xF0, 0xFE, 0x07, 0x78, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0x3C, 0x3C, 0x00,
  0x1E, 0x3E, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xCF, 0x80,
  0x01, 0xC7, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x78, 0xF0,
  0x00, 0x3C, 0x78, 0x00, 0x3E, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x1F, 0x0F,
  0x80, 0x1F, 0x87, 0xC0, 0x1B, 0xC1, 0xF8, 0x3D, 0xE0, 0xFF, 0xFC, 0xF0,
  0x3F, 0xFC, 0x78, 0x0F, 0xFC, 0x78, 0x01, 0xF8, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x81, 0x00, 0x07,
  0xC0, 0xC0, 0x07, 0xC0, 0xF8, 0x0F, 0xE0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x3F, 0x00, 0xF1, 0xFF, 0x81, 0xE7, 0xFF,
  0x83, 0xCF, 0xFF, 0x07, 0xB8, 0x3F, 0x1F, 0xC0, 0x3E, 0x3D, 0x00, 0x3C,
  0x7A, 0x00, 0x78, 0xF8, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xCF,
  0x00, 0x07, 0x9E, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0,
  0x00, 0xF1, 0xE0, 0x01, 0xE7, 0x80, 0x03, 0xCF, 0x00, 0x0F, 0x1E, 0x00,
  0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xE0, 0x00, 0xF3, 0xC0, 0x01,
  0xC7, 0x80, 0x07, 0x8F, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x20, 0x0F, 0x00, 0xC0, 0x1E, 0x03, 0xC0, 0x3C, 0x0F, 0xC0, 0x70, 0x3F,
  0x01, 0xE0, 0xFC, 0x03, 0xC3, 0xE0, 0x07, 0x9F, 0x80, 0x0F, 0x7E, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x04, 0x00,
  0xF0, 0x1C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x7C, 0x0F, 0x00, 0x7C, 0x1E,
  0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x78, 0x00, 0xFD, 0xE0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x1F, 0x80,
  0x0F, 0x1F, 0xF8, 0x03, 0xCF, 0xFF, 0x00, 0xF7, 0xFF, 0xC0, 0x3D, 0xC1,
  0xF8, 0x1E, 0xE0, 0x3E, 0x07, 0xA0, 0x07, 0x81, 0xF8, 0x01, 0xE0, 0x7C,
  0x00, 0x78, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x0F, 0x80,
  0xF0, 0x07, 0xC0, 0x3C, 0x0F, 0xE0, 0x0F, 0x1F, 0xE0, 0x03, 0xCF, 0xC0,
  0x00, 0xF1, 0xE0, 0x00, 0x78, 0x78, 0x01, 0x1E, 0x0F, 0x00, 0xC7, 0x83,
  0xC0, 0x79, 0xE0, 0x78, 0x7F, 0x78, 0x1E, 0x3F, 0x1C, 0x03, 0xDF, 0x8F,
  0x00, 0xFF, 0xC3, 0xC0, 0x3F, 0xE0, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x01, 0x01, 0xE0, 0x0C,
  0x0F, 0x01, 0xF0, 0x78, 0x1F, 0x87, 0x81, 0xF8, 0x3C, 0x1F, 0x81, 0xE1,
  0xF8, 0x0F, 0x1F, 0x00, 0x7B, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x3E, 0x07, 0x81, 0xCF, 0xE3, 0xF8,
  0x7B, 0xFC, 0xFF, 0x8F, 0x7F, 0xDF, 0xF1, 0xF8, 0x7F, 0x1E, 0x3E, 0x0F,
  0xC1, 0xC7, 0x81, 0xF0, 0x38, 0xF0, 0x3C, 0x07, 0x3C, 0x07, 0x81, 0xE7,
  0x80, 0xF0, 0x3C, 0xF0, 0x1C, 0x07, 0x9E, 0x03, 0x80, 0xF3, 0xC0, 0xF0,
  0x1C, 0x70, 0x1E, 0x03, 0x9E, 0x03, 0xC0, 0xF3, 0xC0, 0x78, 0x1E, 0x78,
  0x0E, 0x03, 0xCF, 0x01, 0xC0, 0x79, 0xE0, 0x78, 0x0E, 0x38, 0x0F, 0x01,
  0xCF, 0x01, 0xE0, 0x79, 0xE0, 0x38, 0x0F, 0x3C, 0x07, 0x01, 0xE7, 0x81,
  0xE0, 0x38, 0xE0, 0x3C, 0x07, 0x1C, 0x07, 0x81, 0xE0, 0x0F, 0x07, 0xE0,
  0x1E, 0x3F, 0xF0, 0x3C, 0xFF, 0xF0, 0x79, 0xFF, 0xE1, 0xF7, 0x07, 0xE3,
  0xD8, 0x07, 0xC7, 0xA0, 0x07, 0x8F, 0x40, 0x0F, 0x1F, 0x00, 0x1E, 0x3C,
  0x00, 0x3C, 0xF8, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x03, 0xC7, 0x80,
  0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0xF0, 0x00,
  0x79, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x0F,
  0x1C, 0x00, 0x1E, 0x78, 0x00, 0x38, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x0F, 0xC0, 0xFC, 0x1F, 0x00, 0x3E, 0x1E, 0x00, 0x1E, 0x3E, 0x00, 0x1E,
  0x3C, 0x00, 0x0F, 0x7C, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1E,
  0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x7C,
  0x78, 0x00, 0x78, 0x7C, 0x00, 0xF8, 0x3F, 0x03, 0xF0, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xC1, 0xF8,
  0x00, 0xF1, 0xFF, 0x80, 0x38, 0xFF, 0xF0, 0x1E, 0x7F, 0xFE, 0x07, 0xBC,
  0x1F, 0x81, 0xEC, 0x01, 0xF0, 0x7E, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x07,
  0x80, 0x03, 0xC3, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F,
  0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x78, 0x00,
  0x1F, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0xF8, 0x78,
  0x00, 0x3C, 0x1E, 0x00, 0x1F, 0x0F, 0xC0, 0x0F, 0x83, 0xDC, 0x0F, 0xE0,
  0xF7, 0xFF, 0xF0, 0x3C, 0xFF, 0xF8, 0x0F, 0x1F, 0xF8, 0x03, 0x81, 0xFC,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x0F, 0x01, 0xFF, 0x8F,
  0x07, 0xFF, 0xCF, 0x0F, 0xFF, 0xEF, 0x1F, 0xC0, 0xEF, 0x1F, 0x00, 0x3E,
  0x3E, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x7C, 0x00, 0x1E, 0x78, 0x00, 0x1E,
  0x78, 0x00, 0x1E, 0xF8, 0x00, 0x1C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C,
  0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x78,
  0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF8, 0xF0, 0x01, 0xF8, 0xF8, 0x03, 0x78,
  0x7E, 0x0F, 0x78, 0x7F, 0xFE, 0x70, 0x3F, 0xFC, 0xF0, 0x1F, 0xF8, 0xF0,
  0x07, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x7F, 0xF0, 0x7F, 0x7F, 0xF0, 0xFF,
  0x7F, 0xF3, 0xFF, 0xFF, 0xF7, 0xFF, 0x00, 0xE7, 0x00, 0x01, 0xEC, 0x00,
  0x01, 0xE8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x7E, 0x03, 0xF8, 0x7C, 0x00, 0x30, 0x3C, 0x00, 0x10, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC3, 0x00, 0x01, 0xE3, 0xE0, 0x01, 0xE3, 0xFC, 0x03, 0xF0,
  0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xC0, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x30, 0x1E, 0x01, 0xF0, 0x3C, 0x07, 0xE0, 0x78, 0x3F,
  0x80, 0xE0, 0xFE, 0x03, 0xC7, 0xF0, 0x07, 0x9F, 0xC0, 0x0F, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x1E,
  0x3C, 0x00, 0x3C, 0x78, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x03, 0xC7,
  0x80, 0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0xF0,
  0x00, 0x79, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00,
  0x0F, 0x1E, 0x00, 0x1E, 0x38, 0x00, 0x3C, 0xF0, 0x00, 0xF1, 0xE0, 0x01,
  0xE3, 0xC0, 0x07, 0xC7, 0x80, 0x1F, 0x8F, 0x80, 0x2F, 0x1F, 0x00, 0xDE,
  0x1F, 0x07, 0x78, 0x3F, 0xFC, 0xF0, 0x3F, 0xF9, 0xE0, 0x3F, 0xE3, 0xC0,
  0x3F, 0x00, 0x00, 0x7F, 0xC0, 0x06, 0x7F, 0xC0, 0x1E, 0xFF, 0xC0, 0x1E,
  0xFF, 0xC0, 0x0F, 0x03, 0x80, 0x0F, 0x03, 0x80, 0x0F, 0x07, 0x80, 0x0F,
  0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F,
  0x07, 0x00, 0x1F, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x3E,
  0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x7C, 0x0E, 0x00, 0xF8, 0x0E, 0x01, 0xF0,
  0x1E, 0x03, 0xF0, 0x1E, 0x0F, 0xE0, 0x1E, 0x3F, 0xC0, 0x1F, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1E, 0x03, 0x81,
  0x87, 0x81, 0xE0, 0xF1, 0xE0, 0x78, 0x3C, 0x70, 0x1E, 0x0F, 0x1C, 0x07,
  0x01, 0xC7, 0x01, 0xC0, 0x73, 0xC0, 0x70, 0x1C, 0xF0, 0x3C, 0x07, 0x3C,
  0x0F, 0x01, 0xCE, 0x03, 0xC0, 0x73, 0x80, 0xE0, 0x1C, 0xE0, 0x38, 0x07,
  0x78, 0x0E, 0x03, 0xDE, 0x07, 0x80, 0xF7, 0x81, 0xE0, 0x3D, 0xC0, 0x78,
  0x0F, 0x70, 0x1C, 0x07, 0x9C, 0x07, 0x01, 0xEF, 0x03, 0xC0, 0x7B, 0xC0,
  0xF0, 0x3C, 0xF0, 0x3C, 0x0F, 0x3C, 0x1F, 0x07, 0x8F, 0x8D, 0xE3, 0xE3,
  0xFF, 0x7F, 0xF0, 0x7F, 0x8F, 0xF8, 0x1F, 0xC3, 0xFC, 0x03, 0xE0, 0x7C,
  0x00, 0x00, 0x3C, 0x03, 0xE0, 0x01, 0xF8, 0x3F, 0xC0, 0x1F, 0xF1, 0xFF,
  0x80, 0xFF, 0xC7, 0xFE, 0x07, 0xEF, 0x3C, 0x78, 0x7E, 0x1C, 0xE0, 0xF3,
  0xF0, 0x77, 0x03, 0xC7, 0x01, 0xD8, 0x0F, 0x10, 0x07, 0x60, 0x3C, 0x00,
  0x1F, 0x00, 0xF0, 0x00, 0x7C, 0x04, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x10, 0x0F, 0x80, 0x03, 0xC0, 0x3E, 0x00, 0x0F, 0x01, 0xB8, 0x04,
  0x3C, 0x06, 0xE0, 0x78, 0xF0, 0x3B, 0x83, 0xF3, 0xC1, 0xCE, 0x1F, 0x0F,
  0x8F, 0x3D, 0xF8, 0x1F, 0xF8, 0xFF, 0xC0, 0x7F, 0xE3, 0xFE, 0x00, 0xFF,
  0x07, 0xE0, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0xF0,
  0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x81,
  0xE0, 0x01, 0xE0, 0x78, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x07,
  0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x0F, 0x00,
  0x0F, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x7C, 0x1E,
  0x00, 0x1E, 0x07, 0x80, 0x0F, 0x81, 0xE0, 0x03, 0xE0, 0x7C, 0x01, 0x78,
  0x1F, 0x00, 0xDE, 0x03, 0xE0, 0xE7, 0x80, 0xFF, 0xFB, 0xC0, 0x1F, 0xFC,
  0xF0, 0x03, 0xFE, 0x3C, 0x00, 0x7E, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x02, 0x00, 0x0F, 0x80,
  0xC0, 0x07, 0xC0, 0x7C, 0x07, 0xF0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x07, 0x83,
  0xFF, 0xC3, 0xC3, 0xFF, 0xF9, 0xE3, 0xFF, 0xFF, 0xF1, 0xE0, 0x7F, 0xF1,
  0xE0, 0x07, 0xF8, 0xF0, 0x00, 0xF8, 0x70, 0x00, 0xF8, 0x38, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x10, 0x03, 0xE0,
  0x3C, 0x03, 0xE0, 0x0E, 0x03, 0xE0, 0x07, 0x03, 0xC0, 0x03, 0xC3, 0xF0,
  0x01, 0xE7, 0xFF, 0x80, 0x73, 0xFF, 0xFE, 0x39, 0xE3, 0xFF, 0xFC, 0xF0,
  0x3F, 0xFE, 0x78, 0x03, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x01, 0x81, 0xFE,
  0x00, 0x70, 0xFF, 0xC0, 0x3C, 0x7F, 0xF0, 0x0F, 0x1E, 0x3E, 0x07, 0x8F,
  0x07, 0xC1, 0xE3, 0x80, 0xF8, 0xF1, 0xE0, 0x3F, 0xFC, 0x70, 0x07, 0xFE,
  0x3C, 0x00, 0xFF, 0x03, 0x00, 0x1F, 0x00,
};

const GFXglyph IBMPlexMono_Italic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 30, 0, -1 },
  { 1, 11, 35, 30, 10, -35 },
  { 50, 14, 14, 30, 11, -37 },
  { 75, 30, 35, 30, 1, -35 },
  { 207, 28, 47, 30, 1, -41 },
  { 372, 34, 37, 30, -1, -36 },
  { 530, 29, 37, 30, 0, -36 },
  { 665, 6, 14, 30, 15, -37 },
  { 676, 19, 45, 30, 10, -38 },
  { 783, 19, 45, 30, 2, -38 },
  { 890, 25, 25, 30, 3, -27 },
  { 969, 24, 26, 30, 3, -28 },
  { 1047, 11, 14, 30, 7, -7 },
  { 1067, 15, 4, 30, 8, -17 },
  { 1075, 7, 7, 30, 10, -7 },
  { 1082, 29, 45, 30, 1, -38 },
  { 1246, 26, 37, 30, 3, -36 },
  { 1367, 24, 35, 30, 2, -35 },
  { 1472, 27, 36, 30, 1, -36 },
  { 1594, 27, 37, 30, 1, -36 },
  { 1719, 27, 35, 30, 1, -35 },
  { 1838, 27, 36, 30, 2, -35 },
  { 1960, 24, 36, 30, 3, -35 },
  { 2068, 25, 35, 30, 5, -35 },
  { 2178, 27, 37, 30, 2, -36 },
  { 2303, 24, 36, 30, 4, -36 },
  { 2411, 10, 27, 30, 10, -27 },
  { 2445, 13, 34, 30, 7, -27 },
  { 2501, 24, 29, 30, 4, -30 },
  { 2588, 25, 14, 30, 3, -22 },
  { 2632, 25, 29, 30, 2, -30 },
  { 2723, 22, 36, 30, 6, -36 },
  { 2822, 25, 42, 30, 3, -36 },
  { 2954, 26, 35, 30, 0, -35 },
  { 3068, 26, 35, 30, 2, -35 },
  { 3182, 25, 37, 30, 4, -36 },
  { 3298, 25, 35, 30, 3, -35 },
  { 3408, 28, 35, 30, 2, -35 },
  { 3531, 28, 35, 30, 2, -35 },
  { 3654, 26, 37, 30, 3, -36 },
  { 3775, 28, 35, 30, 2, -35 },
  { 3898, 28, 35, 30, 2, -35 },
  { 4021, 25, 36, 30, 3, -35 },
  { 4134, 30, 35, 30, 2, -35 },
  { 4266, 21, 35, 30, 4, -35 },
  { 4358, 29, 35, 30, 1, -35 },
  { 4485, 28, 35, 30, 2, -35 },
  { 4608, 26, 37, 30, 3, -36 },
  { 4729, 27, 35, 30, 2, -35 },
  { 4848, 26, 45, 30, 3, -36 },
  { 4995, 27, 35, 30, 2, -35 },
  { 5114, 28, 37, 30, 1, -36 },
  { 5244, 28, 35, 30, 4, -35 },
  { 5367, 26, 36, 30, 4, -35 },
  { 5484, 27, 35, 30, 5, -35 },
  { 5603, 30, 35, 30, 2, -35 },
  { 5735, 33, 35, 30, -1, -35 },
  { 5880, 29, 35, 30, 4, -35 },
  { 6007, 30, 35, 30, 0, -35 },
  { 6139, 21, 45, 30, 8, -38 },
  { 6258, 13, 45, 30, 9, -38 },
  { 6332, 22, 45, 30, 0, -38 },
  { 6456, 26, 20, 30, 3, -35 },
  { 6521, 24, 4, 30, 0, 5 },
  { 6533, 7, 10, 30, 11, -39 },
  { 6542, 24, 27, 30, 3, -26 },
  { 6623, 24, 38, 30, 3, -37 },
  { 6737, 22, 27, 30, 4, -26 },
  { 6812, 26, 38, 30, 3, -37 },
  { 6936, 23, 27, 30, 4, -26 },
  { 7014, 33, 48, 30, -1, -37 },
  { 7212, 25, 37, 30, 2, -26 },
  { 7328, 23, 37, 30, 3, -37 },
  { 7435, 23, 39, 30, 4, -38 },
  { 7548, 23, 49, 30, 3, -38 },
  { 7689, 26, 38, 30, 3, -37 },
  { 7813, 21, 38, 30, 5, -37 },
  { 7913, 27, 26, 30, 1, -26 },
  { 8001, 23, 26, 30, 3, -26 },
  { 8076, 24, 27, 30, 3, -26 },
  { 8157, 26, 36, 30, 1, -26 },
  { 8274, 24, 36, 30, 3, -26 },
  { 8382, 24, 26, 30, 5, -26 },
  { 8460, 25, 27, 30, 2, -26 },
  { 8545, 23, 36, 30, 4, -35 },
  { 8649, 23, 27, 30, 4, -26 },
  { 8727, 24, 26, 30, 3, -26 },
  { 8805, 26, 27, 30, 2, -26 },
  { 8893, 30, 27, 30, 0, -26 },
  { 8995, 26, 37, 30, 1, -26 },
  { 9116, 25, 27, 30, 3, -26 },
  { 9201, 23, 45, 30, 6, -38 },
  { 9331, 11, 45, 30, 10, -38 },
  { 9393, 23, 45, 30, 2, -38 },
  { 9523, 26, 11, 30, 2, -21 },
};

const GFXfont IBMPlexMono_Italic50pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic50pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic50pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _IBMPLEXMONO_ITALIC50PT7B_H_
