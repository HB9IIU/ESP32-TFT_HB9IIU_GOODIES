#ifndef _IBMPLEXMONO_ITALIC42PT7B_H_
#define _IBMPLEXMONO_ITALIC42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xC0, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x0F,
  0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x7C, 0x3F, 0x0F, 0xC3, 0xF0,
  0x78, 0x00, 0x38, 0x73, 0x87, 0x78, 0x77, 0x07, 0x70, 0xE7, 0x0E, 0x70,
  0xE7, 0x0E, 0xF0, 0xEE, 0x0E, 0xE1, 0xCE, 0x1C, 0x00, 0x07, 0x0F, 0x00,
  0x03, 0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x1C,
  0x00, 0x07, 0x07, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x38,
  0x38, 0x03, 0xFE, 0x1F, 0xF0, 0xFF, 0x07, 0xFC, 0x7F, 0xC1, 0xFF, 0x00,
  0x70, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x87, 0x00,
  0x01, 0xC1, 0xC0, 0x1F, 0xF0, 0x7F, 0x87, 0xFC, 0x3F, 0xE1, 0xFE, 0x0F,
  0xF8, 0x83, 0x87, 0x80, 0x01, 0xE1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x1C,
  0x3C, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE1, 0xE0, 0x00,
  0x70, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x07, 0xC6, 0x7E, 0x0F, 0x86, 0x1E, 0x0F, 0x0E,
  0x0F, 0x1E, 0x0E, 0x08, 0x1E, 0x0E, 0x00, 0x1E, 0x0C, 0x00, 0x1E, 0x0C,
  0x00, 0x0F, 0x0C, 0x00, 0x0F, 0x9C, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x19, 0xF0, 0x00, 0x38,
  0x78, 0x00, 0x38, 0x78, 0x00, 0x38, 0x38, 0x00, 0x30, 0x38, 0x00, 0x30,
  0x38, 0x20, 0x70, 0x78, 0xF0, 0x70, 0x78, 0xF8, 0x70, 0xF0, 0x7E, 0x63,
  0xE0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x78, 0x0F, 0xF0, 0x07, 0x80, 0xFF, 0xC0, 0x38, 0x0F, 0x0E, 0x03,
  0x80, 0xF0, 0x30, 0x38, 0x07, 0x01, 0x81, 0xC0, 0x38, 0x1C, 0x1C, 0x01,
  0xC0, 0xE1, 0xC0, 0x0C, 0x07, 0x0E, 0x00, 0x70, 0x78, 0xE0, 0x03, 0x87,
  0x8E, 0x00, 0x1F, 0xF8, 0xF0, 0x00, 0x7F, 0x87, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x71, 0xFF, 0x00,
  0x07, 0x1F, 0xF8, 0x00, 0x71, 0xE1, 0xE0, 0x03, 0x8E, 0x07, 0x00, 0x38,
  0xF0, 0x38, 0x03, 0x87, 0x01, 0xC0, 0x3C, 0x38, 0x0E, 0x01, 0xC1, 0xC0,
  0xF0, 0x1C, 0x0E, 0x07, 0x01, 0xC0, 0x78, 0x78, 0x0E, 0x01, 0xFF, 0x80,
  0xE0, 0x0F, 0xF8, 0x0E, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x3C, 0x1E, 0x00, 0x1C, 0x07, 0x80,
  0x1E, 0x03, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0xC0, 0x78,
  0x00, 0xE0, 0x3C, 0x00, 0x70, 0x1C, 0x00, 0x3C, 0x1E, 0x00, 0x0E, 0x1E,
  0x00, 0x3F, 0xBE, 0x00, 0x7F, 0xFC, 0x00, 0x78, 0xF0, 0x00, 0x78, 0x38,
  0x00, 0x38, 0x1E, 0x00, 0x3C, 0x07, 0x00, 0x1E, 0x03, 0xC0, 0x0F, 0x00,
  0xE0, 0x07, 0x80, 0x78, 0x1B, 0xC0, 0x3C, 0x1F, 0xE0, 0x17, 0x0E, 0xF0,
  0x1B, 0xCE, 0x3C, 0x1C, 0xEF, 0x1F, 0xFC, 0x7F, 0x07, 0xFC, 0x1F, 0x80,
  0xFC, 0x07, 0x00, 0x3C, 0xE3, 0x8E, 0x39, 0xE7, 0x1C, 0x71, 0xC7, 0x3C,
  0x00, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x04, 0x03, 0x80, 0x9E, 0x0E, 0x0E, 0x7F, 0x3B,
  0xFE, 0xFF, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x3D, 0xC0, 0x01, 0xE3, 0x80, 0x0F, 0x0F, 0x00, 0x78,
  0x1C, 0x03, 0xC0, 0x78, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x0F, 0x8F, 0x87, 0xC3, 0xC3, 0xE1, 0xE0, 0xF0, 0xF0,
  0x78, 0x38, 0x38, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3D, 0xFF,
  0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0x83, 0xE0, 0xF0, 0x0F, 0x0F, 0x00,
  0x38, 0xF0, 0x01, 0xE7, 0x80, 0x07, 0x38, 0x00, 0x3B, 0xC0, 0x01, 0xDC,
  0x00, 0x0E, 0xE0, 0x00, 0xFF, 0x07, 0x87, 0xF8, 0x7C, 0x3F, 0xC3, 0xE1,
  0xFC, 0x1F, 0x0E, 0xE0, 0xF0, 0x77, 0x00, 0x07, 0xB8, 0x00, 0x3D, 0xC0,
  0x01, 0xCE, 0x00, 0x1E, 0x70, 0x00, 0xF3, 0x80, 0x0F, 0x1E, 0x00, 0x70,
  0xF0, 0x07, 0x83, 0xE0, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0x70,
  0x03, 0xEF, 0x00, 0xFC, 0xF0, 0x1F, 0x0E, 0x03, 0xE0, 0xE0, 0x1C, 0x0E,
  0x01, 0x80, 0xE0, 0x10, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0xF8, 0x3E, 0x07, 0x80, 0x7C, 0x3C, 0x00, 0xF0, 0xE0, 0x03, 0xC5, 0x80,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xC0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xF8, 0x3F, 0x07, 0x80,
  0x3C, 0x1C, 0x00, 0xF0, 0x20, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xC0, 0x03,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC2,
  0x00, 0x0F, 0x1C, 0x00, 0x78, 0xF8, 0x01, 0xE1, 0xF0, 0x1F, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0x78, 0x00, 0x3D, 0xC0,
  0x01, 0xE7, 0x00, 0x0F, 0x1C, 0x00, 0x38, 0x70, 0x01, 0xC3, 0xC0, 0x0E,
  0x0F, 0x00, 0x78, 0x38, 0x03, 0xC0, 0xE0, 0x1E, 0x03, 0x80, 0x70, 0x0E,
  0x03, 0x80, 0x78, 0x1C, 0x01, 0xC0, 0xE0, 0x07, 0x07, 0x80, 0x1C, 0x3C,
  0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x1F, 0xC0,
  0x1C, 0xFF, 0xC0, 0x77, 0xFF, 0x81, 0xF0, 0x3E, 0x07, 0x00, 0x7C, 0x20,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC2, 0x00, 0x0E, 0x1C, 0x00, 0x78, 0xF8, 0x03, 0xC1,
  0xF0, 0x3F, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x1E, 0x3F, 0x07, 0x9F, 0xF8, 0xF7, 0xFF, 0x9D, 0xC1, 0xFF, 0xE0,
  0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1E, 0xF0, 0x07, 0x8F, 0x83,
  0xF1, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xFB, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFE, 0xE0, 0x00, 0xE7, 0x00, 0x0F, 0x38, 0x00, 0x71,
  0xC0, 0x07, 0x9E, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xF0, 0x3E,
  0x0F, 0x00, 0x3C, 0x38, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1C,
  0x00, 0x38, 0x78, 0x00, 0xE0, 0xE0, 0x07, 0x03, 0xE0, 0x78, 0x07, 0xFF,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xFC, 0x07, 0xC0, 0xF8, 0x3C, 0x00, 0xF1,
  0xE0, 0x01, 0xCF, 0x00, 0x07, 0x3C, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80,
  0x01, 0xCE, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x01, 0xE1, 0xF0, 0x1F,
  0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x7F, 0xF0, 0x0F, 0xFF, 0xC3, 0xF0, 0x3C, 0x3C, 0x01, 0xE7, 0x80, 0x0E,
  0x70, 0x00, 0xEF, 0x00, 0x0E, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xEE, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x7E, 0xFC, 0x0F, 0xC7, 0xFF,
  0xDC, 0x3F, 0xF3, 0xC0, 0xFE, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x0F,
  0xC7, 0xE3, 0xF1, 0xF8, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x1F, 0x1F, 0x8F, 0xC7, 0xE1, 0xE0,
  0x03, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x7C, 0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x01,
  0xC0, 0x70, 0x0E, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x00, 0x00, 0x10, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFC, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x08, 0x00,
  0x00, 0x01, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xF8, 0xF8, 0x3F, 0x3C, 0x03,
  0xDE, 0x00, 0xFF, 0x00, 0x1C, 0xC0, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x0F,
  0x80, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF,
  0x80, 0x3F, 0xFF, 0x01, 0xF0, 0x3E, 0x07, 0x00, 0x78, 0x3C, 0x00, 0xE0,
  0xE0, 0x03, 0xC7, 0x00, 0x07, 0x1C, 0x0F, 0x1C, 0xF0, 0xFE, 0x63, 0x87,
  0xFF, 0x8E, 0x1E, 0x1E, 0x38, 0xF0, 0x39, 0xE3, 0x80, 0xE7, 0x0E, 0x03,
  0x9C, 0x78, 0x0C, 0x71, 0xE0, 0x71, 0xC7, 0x01, 0xC7, 0x1C, 0x07, 0x1C,
  0x70, 0x3C, 0xE1, 0xC0, 0xF3, 0x87, 0x87, 0x8E, 0x1F, 0xFE, 0x38, 0x3F,
  0xB8, 0xE0, 0x7C, 0xE1, 0x80, 0x80, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x73, 0x80, 0x03, 0xCE,
  0x00, 0x0E, 0x38, 0x00, 0x78, 0xE0, 0x01, 0xC3, 0x80, 0x0F, 0x0F, 0x00,
  0x38, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0x81, 0xC0, 0x1C, 0x07, 0x00, 0xF0,
  0x1C, 0x03, 0x80, 0x70, 0x1E, 0x01, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x78, 0x00, 0xE1, 0xC0, 0x03, 0x8F, 0x00, 0x0E, 0x38,
  0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3C, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x03, 0xFF, 0xFC, 0x1E, 0x01, 0xF0,
  0xE0, 0x07, 0x87, 0x00, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x1E, 0x00,
  0x38, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x38, 0x01, 0xE1, 0xC0, 0x1E, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3C, 0x01, 0xE1, 0xC0, 0x07,
  0x8E, 0x00, 0x1C, 0x70, 0x00, 0xE7, 0x80, 0x07, 0x3C, 0x00, 0x79, 0xC0,
  0x03, 0xCE, 0x00, 0x1E, 0x70, 0x01, 0xE3, 0x80, 0x3E, 0x3F, 0xFF, 0xF1,
  0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x00,
  0xFF, 0xFC, 0x0F, 0x81, 0xE0, 0xF8, 0x07, 0x87, 0x80, 0x1C, 0x78, 0x00,
  0xE3, 0x80, 0x04, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x08, 0x78, 0x00, 0x71, 0xC0, 0x07, 0x8F, 0x00, 0x78, 0x78, 0x03, 0xC1,
  0xF0, 0x7C, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xC0, 0x7C, 0x0F, 0x00,
  0x78, 0x3C, 0x01, 0xE0, 0xF0, 0x03, 0x83, 0x80, 0x0F, 0x0E, 0x00, 0x3C,
  0x38, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x70,
  0x00, 0xF1, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x3C, 0x00, 0x78, 0xF0, 0x01,
  0xE3, 0xC0, 0x07, 0x8E, 0x00, 0x1C, 0x38, 0x00, 0xF0, 0xE0, 0x03, 0xC7,
  0x80, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x03, 0xC1, 0xC0, 0x3E, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF8, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE,
  0x00, 0xFF, 0xF8, 0x0F, 0x83, 0xE0, 0xF0, 0x0F, 0x0F, 0x00, 0x3C, 0x70,
  0x01, 0xE7, 0x80, 0x08, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0xFF, 0xDE, 0x07,
  0xFC, 0xF0, 0x3F, 0xE7, 0x00, 0x07, 0x38, 0x00, 0x39, 0xC0, 0x03, 0xCE,
  0x00, 0x1E, 0x70, 0x00, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0x78, 0x05,
  0xC3, 0xE0, 0xFE, 0x0F, 0xFE, 0xF0, 0x3F, 0xE7, 0x00, 0xFC, 0x38, 0x00,
  0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x70, 0x70, 0x00, 0xE0,
  0xE0, 0x01, 0xC1, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E,
  0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0, 0x03, 0xC3, 0xC0,
  0x07, 0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x38, 0x00,
  0x70, 0x70, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0E,
  0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0xF0, 0xF0, 0x01, 0xE1,
  0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x3C, 0x00,
  0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x08, 0x01, 0xE3, 0xC0, 0x0E,
  0x0E, 0x00, 0xF0, 0x78, 0x0F, 0x83, 0xE0, 0xF8, 0x0F, 0xFF, 0x80, 0x3F,
  0xF8, 0x00, 0x7F, 0x00, 0x00, 0x07, 0x00, 0x0F, 0x87, 0x80, 0x0F, 0x83,
  0xC0, 0x0F, 0x81, 0xE0, 0x0F, 0x80, 0xE0, 0x0F, 0x80, 0x70, 0x0F, 0x80,
  0x38, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x0F, 0x00,
  0x07, 0x0F, 0x00, 0x03, 0x8F, 0x00, 0x01, 0xCF, 0x80, 0x01, 0xEF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0x78, 0x00, 0x3F, 0x1E, 0x00, 0x1F, 0x0F,
  0x00, 0x0F, 0x03, 0x80, 0x0F, 0x01, 0xE0, 0x07, 0x80, 0x70, 0x03, 0xC0,
  0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x80, 0x70, 0x03, 0xC0, 0x78,
  0x00, 0xF0, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x0E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x0F, 0x07, 0xC0, 0x1F,
  0x07, 0xC0, 0x1F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x7F, 0x0E, 0xE0, 0x7E,
  0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0xE1, 0xCE, 0x1E, 0x73, 0xCE,
  0x1C, 0x73, 0x9E, 0x1C, 0x77, 0x1C, 0x1C, 0x77, 0x1C, 0x1C, 0x3E, 0x1C,
  0x1C, 0x3E, 0x1C, 0x3C, 0x3C, 0x1C, 0x38, 0x38, 0x3C, 0x38, 0x18, 0x38,
  0x38, 0x10, 0x38, 0x38, 0x10, 0x38, 0x38, 0x00, 0x38, 0x78, 0x00, 0x38,
  0x70, 0x00, 0x78, 0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0x70,
  0xF0, 0x00, 0x70, 0xF0, 0x00, 0x70, 0xE0, 0x00, 0xF0, 0x0F, 0xC0, 0x0E,
  0x1F, 0x80, 0x3C, 0x3F, 0x00, 0x70, 0x7E, 0x00, 0xE0, 0xFE, 0x01, 0xC1,
  0xDC, 0x03, 0x87, 0xB8, 0x07, 0x0F, 0x70, 0x1E, 0x1C, 0xE0, 0x38, 0x38,
  0xE0, 0x70, 0x71, 0xC0, 0xE0, 0xE3, 0x81, 0xC3, 0xC7, 0x03, 0x87, 0x0F,
  0x0F, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0x70, 0x70, 0x70,
  0xE1, 0xE0, 0x71, 0xC3, 0x80, 0xE7, 0x87, 0x01, 0xCE, 0x0E, 0x03, 0x9C,
  0x1C, 0x07, 0xB8, 0x38, 0x07, 0x70, 0xF0, 0x0E, 0xE1, 0xC0, 0x1F, 0xC3,
  0x80, 0x3F, 0x07, 0x00, 0x3E, 0x0E, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00,
  0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0x83, 0xE0, 0xF0, 0x0F, 0x0F, 0x00,
  0x38, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x38, 0x00, 0x3B, 0xC0, 0x01, 0xDC,
  0x00, 0x1E, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0E, 0xE0, 0x00, 0xF7, 0x00, 0x07, 0xB8, 0x00, 0x3D, 0xC0,
  0x01, 0xCE, 0x00, 0x1E, 0x70, 0x00, 0xF3, 0x80, 0x0F, 0x1E, 0x00, 0x70,
  0xF0, 0x07, 0x83, 0xE0, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x78,
  0x03, 0xE0, 0xF0, 0x03, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x87, 0x00,
  0x0F, 0x1E, 0x00, 0x1C, 0x3C, 0x00, 0x38, 0x78, 0x00, 0xF0, 0xE0, 0x01,
  0xE1, 0xC0, 0x07, 0x83, 0x80, 0x1F, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0x83,
  0xE0, 0xF0, 0x0F, 0x0F, 0x00, 0x38, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x38,
  0x00, 0x3B, 0xC0, 0x01, 0xDC, 0x00, 0x1E, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0E, 0xE0, 0x00, 0xF7, 0x00,
  0x07, 0xB8, 0x00, 0x3D, 0xC0, 0x01, 0xCE, 0x00, 0x1E, 0x70, 0x00, 0xF3,
  0x80, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x07, 0x83, 0xE0, 0xF8, 0x1F, 0xFF,
  0x80, 0x7F, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x81, 0x00,
  0x1E, 0x0C, 0x00, 0x70, 0xF0, 0x03, 0xDE, 0x00, 0x0F, 0xE0, 0x00, 0x3E,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x78, 0x03, 0xE0, 0xF0, 0x03, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x07,
  0x87, 0x00, 0x0F, 0x1E, 0x00, 0x1C, 0x3C, 0x00, 0x38, 0x78, 0x00, 0xF0,
  0xE0, 0x01, 0xE1, 0xC0, 0x07, 0x83, 0x80, 0x1F, 0x0F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x70, 0x01, 0xC0,
  0xF0, 0x07, 0x80, 0xE0, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x03,
  0xC0, 0x70, 0x07, 0x80, 0xE0, 0x07, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x0E,
  0x0F, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x3E, 0x03, 0xF0, 0xF8, 0x01, 0xE1, 0xE0, 0x01, 0xC3, 0x80, 0x02,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x08, 0x00, 0x1E, 0x78, 0x00,
  0x3C, 0xF8, 0x00, 0xF0, 0xFC, 0x07, 0xC0, 0xFF, 0xFF, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xC0, 0x03,
  0x87, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x70, 0x01, 0xE3, 0xC0, 0x07, 0x8F,
  0x00, 0x1E, 0x38, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x1E, 0x00,
  0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x00, 0x0E, 0x1C, 0x00, 0x38,
  0x70, 0x00, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x70, 0xF0,
  0x01, 0xC3, 0x80, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xE0, 0xF0, 0x07,
  0x81, 0xE0, 0x7C, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xE0, 0x00, 0x3F, 0x80, 0x01, 0xEE, 0x00, 0x07, 0xB8, 0x00, 0x3C, 0xE0,
  0x00, 0xF3, 0xC0, 0x03, 0x8F, 0x00, 0x1E, 0x1C, 0x00, 0x70, 0x70, 0x03,
  0xC1, 0xC0, 0x0E, 0x07, 0x00, 0x78, 0x1C, 0x01, 0xC0, 0x70, 0x0F, 0x01,
  0xE0, 0x38, 0x03, 0x81, 0xE0, 0x0E, 0x07, 0x00, 0x38, 0x1C, 0x00, 0xE0,
  0xF0, 0x03, 0x83, 0x80, 0x0E, 0x1E, 0x00, 0x38, 0x70, 0x00, 0xF3, 0xC0,
  0x01, 0xCE, 0x00, 0x07, 0x78, 0x00, 0x1D, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x07, 0x9C,
  0x00, 0x03, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x71,
  0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x38, 0x3C, 0x0E,
  0x1C, 0x1E, 0x0E, 0x0E, 0x1F, 0x07, 0x0E, 0x0F, 0x83, 0x87, 0x06, 0xC1,
  0xC3, 0x87, 0x71, 0xC1, 0xC3, 0xB8, 0xE0, 0xE3, 0x9C, 0x70, 0x71, 0xCE,
  0x38, 0x38, 0xC7, 0x38, 0x1C, 0xE3, 0x9C, 0x0E, 0x71, 0xCE, 0x07, 0x70,
  0xE7, 0x03, 0xB8, 0x77, 0x03, 0x9C, 0x3B, 0x81, 0xDC, 0x1D, 0xC0, 0xEE,
  0x0E, 0xE0, 0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F,
  0x80, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x01, 0xE0,
  0x03, 0xC0, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x78, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x38, 0x78, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x0F, 0x1E,
  0x00, 0x01, 0xE0, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0, 0x70, 0x00,
  0x78, 0x07, 0x80, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x03, 0xC0, 0x3C, 0x00,
  0x1C, 0x03, 0xC0, 0x01, 0xE0, 0xF8, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x3C, 0x70, 0x00, 0x3C, 0x78, 0x00, 0x78, 0x38, 0x00, 0xF0,
  0x3C, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x1E, 0x07, 0x80,
  0x0E, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x1E, 0x00, 0x07, 0x3C, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8,
  0x00, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x06, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x06, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x30, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x30, 0x07, 0x00,
  0xE0, 0x1C, 0x01, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x38,
  0x07, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x81, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xEE, 0x00, 0x0E, 0x78, 0x00, 0xF1, 0xC0,
  0x0F, 0x0E, 0x00, 0x70, 0x78, 0x07, 0x01, 0xC0, 0x78, 0x0F, 0x07, 0x80,
  0x38, 0x38, 0x01, 0xC3, 0x80, 0x0F, 0x3C, 0x00, 0x3B, 0xC0, 0x01, 0xDC,
  0x00, 0x07, 0x60, 0x00, 0x30, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFC, 0x67, 0x3C, 0xE7, 0x18, 0xE2, 0x01, 0xF8, 0x78, 0x1F, 0xF3, 0x83,
  0xFF, 0xDC, 0x3F, 0x06, 0xE1, 0xE0, 0x1F, 0x1E, 0x00, 0x78, 0xE0, 0x03,
  0xCF, 0x00, 0x1C, 0x78, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x39, 0xE0,
  0x03, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0xE3, 0xC0, 0x07, 0x1E, 0x00, 0x78,
  0x70, 0x05, 0xC3, 0xC0, 0x7E, 0x1F, 0x06, 0xF0, 0x7F, 0xE7, 0xF1, 0xFE,
  0x1F, 0x07, 0xE0, 0xF8, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0xFC, 0x03, 0x9F, 0xF8, 0x3D, 0xFF, 0xC1,
  0xEC, 0x1F, 0x0E, 0xC0, 0x38, 0x7C, 0x01, 0xE3, 0xC0, 0x0F, 0x1C, 0x00,
  0x39, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x70, 0x00, 0xF3, 0x80, 0x07, 0x9C,
  0x00, 0x38, 0xE0, 0x01, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0xE3, 0xC0, 0x0F,
  0x1E, 0x00, 0xF0, 0xEC, 0x0F, 0x87, 0x7F, 0xF8, 0x79, 0xFF, 0x83, 0xC3,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xFE, 0x0F, 0x81, 0xE1,
  0xE0, 0x1E, 0x78, 0x01, 0x9E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x67, 0x80, 0x0E, 0x70, 0x03, 0x8F, 0x00, 0xF1, 0xF0, 0x7C, 0x1F,
  0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x03, 0xF0, 0x70,
  0x0F, 0xF8, 0xE0, 0x7F, 0xFB, 0xC1, 0xF8, 0x3F, 0x03, 0xC0, 0x1E, 0x0F,
  0x00, 0x3C, 0x1C, 0x00, 0x38, 0x78, 0x00, 0x70, 0xF0, 0x01, 0xE1, 0xC0,
  0x03, 0x83, 0x80, 0x07, 0x0F, 0x00, 0x0E, 0x1E, 0x00, 0x1C, 0x3C, 0x00,
  0x78, 0x78, 0x00, 0xF0, 0xF0, 0x03, 0xC0, 0xE0, 0x07, 0x81, 0xE0, 0x37,
  0x03, 0xE0, 0xCE, 0x03, 0xFF, 0xBC, 0x03, 0xFE, 0x78, 0x03, 0xF0, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xC1, 0xF1, 0xE0,
  0x0E, 0x78, 0x01, 0xDE, 0x00, 0x3B, 0x80, 0x0F, 0x70, 0x03, 0xFE, 0x07,
  0xFB, 0xFF, 0xFC, 0x7F, 0xFE, 0x0F, 0xFC, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x06, 0xF0, 0x01, 0xEF, 0x00, 0x79, 0xF0, 0x3E, 0x1F, 0xFF,
  0x81, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x02,
  0x01, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x0F, 0x81, 0xC0, 0x00, 0x7C, 0x3C,
  0x00, 0x03, 0xE3, 0x80, 0x00, 0x1F, 0x38, 0x00, 0x00, 0xFB, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x1C, 0x07, 0xFC, 0xF0, 0x7F, 0xFB, 0xC1, 0xF0, 0x7E, 0x0F, 0x00,
  0x78, 0x78, 0x01, 0xE1, 0xC0, 0x03, 0x8F, 0x00, 0x0E, 0x3C, 0x00, 0x78,
  0xE0, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x78, 0x00, 0x71, 0xE0,
  0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x78, 0x38, 0x01, 0xE0, 0xF0, 0x0B,
  0x83, 0xE0, 0xEE, 0x07, 0xFF, 0x78, 0x0F, 0xF9, 0xE0, 0x1F, 0x87, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x80, 0x1E, 0x07, 0x81,
  0xF0, 0x3F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE1, 0xF8, 0x0E,
  0x3F, 0xC0, 0xE7, 0xFE, 0x0E, 0xE1, 0xE1, 0xF8, 0x0F, 0x1F, 0x00, 0xF1,
  0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xC0, 0x0F, 0x1C, 0x00, 0xE3, 0xC0, 0x0E,
  0x3C, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x1E, 0x38, 0x01,
  0xC7, 0x80, 0x1C, 0x78, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x03, 0xC7, 0x00,
  0x3C, 0xF0, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x08, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x40, 0x38, 0x0E, 0x03, 0x81, 0xF0, 0x38, 0x7C, 0x03, 0x8F, 0x80,
  0x79, 0xF0, 0x07, 0x3E, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x20, 0x1C, 0x07, 0x01, 0xC0, 0xF8, 0x1C, 0x03, 0xC1,
  0xC0, 0x1E, 0x3C, 0x01, 0xF3, 0xC0, 0x0F, 0xB8, 0x00, 0x7F, 0x80, 0x03,
  0xF8, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x7E, 0x00, 0xE3, 0xFC, 0x03, 0x9F,
  0xF8, 0x0E, 0xE1, 0xF0, 0x7E, 0x03, 0xC1, 0xF0, 0x0F, 0x07, 0x80, 0x3C,
  0x1E, 0x00, 0xE0, 0x70, 0x07, 0x81, 0xC0, 0x3C, 0x0F, 0x03, 0xE0, 0x3C,
  0x3E, 0x00, 0xE7, 0xE0, 0x03, 0x8E, 0x00, 0x0E, 0x3C, 0x04, 0x38, 0x70,
  0x19, 0xE1, 0xE1, 0xF7, 0x83, 0x8F, 0x9C, 0x0F, 0x7C, 0x70, 0x1F, 0xC1,
  0xC0, 0x7E, 0x0F, 0x00, 0xF0, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF,
  0x02, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x60, 0xF0, 0x3C, 0x38, 0x1E,
  0x0E, 0x0F, 0x03, 0x87, 0x81, 0xE7, 0xC0, 0x7B, 0xE0, 0x1F, 0xF0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x0E, 0x78, 0x3C, 0x0E, 0xFC, 0x7E, 0x0E, 0xFE,
  0xFF, 0x0F, 0x9E, 0x8F, 0x1F, 0x0F, 0x07, 0x1E, 0x0F, 0x07, 0x1C, 0x0E,
  0x07, 0x1C, 0x0E, 0x0E, 0x1C, 0x0E, 0x0E, 0x1C, 0x1C, 0x0E, 0x3C, 0x1C,
  0x0E, 0x38, 0x1C, 0x0E, 0x38, 0x1C, 0x0E, 0x38, 0x1C, 0x1C, 0x38, 0x1C,
  0x1C, 0x38, 0x38, 0x1C, 0x70, 0x38, 0x1C, 0x70, 0x38, 0x1C, 0x70, 0x38,
  0x1C, 0x70, 0x38, 0x38, 0x70, 0x38, 0x38, 0xF0, 0x70, 0x38, 0x0E, 0x1F,
  0x80, 0xE3, 0xFC, 0x0E, 0x7F, 0xE0, 0xEE, 0x1E, 0x1F, 0x80, 0xF1, 0xF0,
  0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x1C, 0x00, 0xF1, 0xC0, 0x0E, 0x3C,
  0x00, 0xE3, 0xC0, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x01, 0xE3,
  0x80, 0x1C, 0x78, 0x01, 0xC7, 0x80, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x3C,
  0x70, 0x03, 0xCF, 0x00, 0x38, 0x00, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF,
  0x81, 0xF0, 0x3C, 0x3C, 0x01, 0xE3, 0x80, 0x0E, 0x78, 0x00, 0xE7, 0x00,
  0x0E, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0,
  0x00, 0xEE, 0x00, 0x1E, 0xE0, 0x01, 0xEE, 0x00, 0x3C, 0xE0, 0x03, 0xC7,
  0x00, 0x78, 0x7C, 0x1F, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7E, 0x00,
  0x07, 0x0F, 0xC0, 0x1C, 0xFF, 0xC0, 0xF7, 0xFF, 0x03, 0xD8, 0x3E, 0x0E,
  0xC0, 0x38, 0x3E, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0x80, 0x07, 0x1E, 0x00,
  0x3C, 0x78, 0x00, 0xF1, 0xC0, 0x03, 0xC7, 0x00, 0x0F, 0x1C, 0x00, 0x38,
  0x70, 0x00, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1C, 0x3C, 0x00, 0xF0, 0xF0,
  0x07, 0x83, 0xB0, 0x3E, 0x0E, 0xFF, 0xF0, 0x79, 0xFF, 0x81, 0xE1, 0xF8,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x38, 0x1F, 0xF3, 0xC3, 0xFF, 0xDE, 0x3F, 0x07, 0xE1, 0xE0, 0x0F,
  0x1E, 0x00, 0x78, 0xE0, 0x01, 0xCF, 0x00, 0x0E, 0x78, 0x00, 0xF3, 0x80,
  0x07, 0x1C, 0x00, 0x39, 0xE0, 0x01, 0xCF, 0x00, 0x0E, 0x78, 0x00, 0xF3,
  0xC0, 0x07, 0x9E, 0x00, 0x78, 0x70, 0x03, 0xC3, 0xC0, 0x6E, 0x1F, 0x07,
  0x70, 0x7F, 0xF7, 0x81, 0xFF, 0x3C, 0x07, 0xE1, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0xFF, 0x83, 0xFF, 0xF8, 0xFE, 0xFF,
  0x9F, 0xE0, 0x3B, 0x80, 0x07, 0xE0, 0x00, 0x74, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF0, 0xF8, 0x1F, 0x1E,
  0x00, 0x61, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x20, 0x01, 0xE7, 0x00, 0x1C, 0xFC, 0x07,
  0xC7, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x03, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x0C, 0x0E, 0x03,
  0xC3, 0xC1, 0xF8, 0x78, 0x7C, 0x0E, 0x3F, 0x01, 0xCF, 0x80, 0x3F, 0xE0,
  0x07, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0xF1, 0xC0, 0x0F, 0x3C, 0x00,
  0xE3, 0xC0, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x01, 0xE3, 0x80,
  0x1E, 0x78, 0x01, 0xC7, 0x80, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x1C, 0x70,
  0x03, 0xC7, 0x00, 0x3C, 0x70, 0x03, 0x8F, 0x00, 0x78, 0xF0, 0x0B, 0x87,
  0x01, 0xB8, 0x78, 0x37, 0x87, 0xFF, 0x78, 0x3F, 0xE7, 0x00, 0xF8, 0x70,
  0xFF, 0x00, 0x6F, 0xF0, 0x1E, 0xFF, 0x00, 0xE0, 0xF0, 0x0E, 0x0E, 0x00,
  0xF0, 0xE0, 0x0F, 0x0E, 0x00, 0xF0, 0xE0, 0x0F, 0x0E, 0x00, 0xF1, 0xE0,
  0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x1E, 0x1C, 0x01, 0xC1, 0xC0, 0x3C, 0x1C,
  0x03, 0x83, 0xC0, 0x78, 0x3C, 0x0F, 0x03, 0x83, 0xE0, 0x38, 0xFC, 0x03,
  0xFF, 0x80, 0x3F, 0xE0, 0x01, 0xF8, 0x00, 0x38, 0x1C, 0x18, 0xE0, 0x70,
  0xE3, 0x81, 0xC3, 0x8E, 0x07, 0x07, 0x38, 0x38, 0x1C, 0xE0, 0xE0, 0x77,
  0x03, 0x81, 0xDC, 0x0E, 0x07, 0x70, 0x38, 0x1D, 0xC0, 0xE0, 0x77, 0x07,
  0x03, 0xDC, 0x1C, 0x0E, 0xE0, 0x70, 0x3B, 0x81, 0xC0, 0xEE, 0x07, 0x07,
  0xB8, 0x3C, 0x1C, 0xE0, 0xF0, 0xF3, 0x87, 0xC3, 0x8E, 0x37, 0x1E, 0x3F,
  0xDF, 0xF0, 0xFE, 0x3F, 0x81, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x3E, 0x00,
  0xFC, 0x3F, 0x81, 0xFE, 0x3F, 0xC1, 0xF7, 0x38, 0xF1, 0xE1, 0xD8, 0x39,
  0xE0, 0xF8, 0x1C, 0x40, 0x7C, 0x0E, 0x00, 0x3C, 0x07, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xC0, 0xD8, 0x18, 0xE0, 0x6C,
  0x1E, 0x78, 0x66, 0x1E, 0x3C, 0x73, 0xBE, 0x0F, 0xF1, 0xFE, 0x07, 0xF0,
  0xFE, 0x01, 0xF0, 0x3C, 0x00, 0x07, 0x00, 0x3C, 0x1C, 0x00, 0xF0, 0x70,
  0x03, 0x83, 0xC0, 0x0E, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xE0, 0xE0, 0x07,
  0x83, 0x80, 0x1E, 0x0E, 0x00, 0x70, 0x78, 0x01, 0xC1, 0xC0, 0x07, 0x07,
  0x00, 0x1C, 0x1C, 0x00, 0xF0, 0x70, 0x03, 0xC1, 0xC0, 0x0E, 0x07, 0x00,
  0x78, 0x1C, 0x03, 0xE0, 0x78, 0x1B, 0x81, 0xF0, 0xDE, 0x03, 0xFF, 0x78,
  0x0F, 0xF9, 0xC0, 0x0F, 0x87, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x80, 0x1E, 0x07, 0x81, 0xF0, 0x3F, 0xFF, 0x80, 0x3F, 0xFC,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x38, 0x7F, 0xF1, 0xC3, 0xFF, 0xEE,
  0x3C, 0x1F, 0xF1, 0xC0, 0x3F, 0x1C, 0x00, 0xF0, 0xE0, 0x0F, 0x07, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x70, 0x1E, 0x03, 0x81, 0xC0, 0x1C, 0x3C, 0x00,
  0x73, 0xFE, 0x03, 0x9F, 0xFF, 0x1D, 0xEF, 0xFF, 0xEF, 0x0F, 0xFE, 0x78,
  0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x70, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x1F, 0xF8, 0x03, 0xF8, 0x00, 0x7F,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x01, 0xC0, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x81,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x00, 0x03, 0xFE, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0xF0, 0x1F, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x7F, 0xF0, 0x0F, 0xFC,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x18, 0x3F, 0x80, 0x71, 0xFE, 0x03,
  0x8F, 0x3C, 0x0E, 0x78, 0x78, 0x71, 0xC0, 0xF3, 0xC6, 0x03, 0xFE, 0x38,
  0x07, 0xF0, 0x60, 0x07, 0x80,
};

const GFXglyph IBMPlexMono_Italic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 10, 29, 25, 8, -29 },
  { 38, 12, 12, 25, 9, -31 },
  { 56, 26, 29, 25, 0, -29 },
  { 151, 24, 37, 25, 1, -33 },
  { 262, 29, 29, 25, -1, -29 },
  { 368, 25, 29, 25, 0, -29 },
  { 459, 6, 12, 25, 12, -31 },
  { 468, 15, 38, 25, 9, -32 },
  { 540, 15, 38, 25, 2, -32 },
  { 612, 22, 21, 25, 2, -23 },
  { 670, 20, 21, 25, 3, -23 },
  { 723, 9, 12, 25, 6, -6 },
  { 737, 12, 3, 25, 7, -14 },
  { 742, 6, 6, 25, 8, -6 },
  { 747, 24, 38, 25, 1, -32 },
  { 861, 21, 29, 25, 3, -29 },
  { 938, 20, 29, 25, 2, -29 },
  { 1011, 22, 29, 25, 1, -29 },
  { 1091, 22, 29, 25, 1, -29 },
  { 1171, 22, 29, 25, 1, -29 },
  { 1251, 22, 29, 25, 2, -29 },
  { 1331, 19, 29, 25, 3, -29 },
  { 1400, 21, 29, 25, 4, -29 },
  { 1477, 22, 29, 25, 2, -29 },
  { 1557, 20, 29, 25, 4, -29 },
  { 1630, 9, 23, 25, 8, -23 },
  { 1656, 11, 29, 25, 6, -23 },
  { 1696, 20, 24, 25, 4, -25 },
  { 1756, 22, 12, 25, 2, -19 },
  { 1789, 20, 24, 25, 2, -25 },
  { 1849, 18, 29, 25, 5, -29 },
  { 1915, 22, 34, 25, 2, -29 },
  { 2009, 22, 29, 25, 0, -29 },
  { 2089, 21, 29, 25, 2, -29 },
  { 2166, 21, 29, 25, 3, -29 },
  { 2243, 22, 29, 25, 2, -29 },
  { 2323, 23, 29, 25, 2, -29 },
  { 2407, 23, 29, 25, 2, -29 },
  { 2491, 21, 29, 25, 3, -29 },
  { 2568, 23, 29, 25, 2, -29 },
  { 2652, 23, 29, 25, 2, -29 },
  { 2736, 21, 29, 25, 2, -29 },
  { 2813, 25, 29, 25, 2, -29 },
  { 2904, 18, 29, 25, 3, -29 },
  { 2970, 24, 29, 25, 1, -29 },
  { 3057, 23, 29, 25, 2, -29 },
  { 3141, 21, 29, 25, 3, -29 },
  { 3218, 23, 29, 25, 2, -29 },
  { 3302, 21, 37, 25, 3, -29 },
  { 3400, 23, 29, 25, 2, -29 },
  { 3484, 23, 29, 25, 1, -29 },
  { 3568, 23, 29, 25, 4, -29 },
  { 3652, 22, 29, 25, 3, -29 },
  { 3732, 22, 29, 25, 5, -29 },
  { 3812, 25, 29, 25, 2, -29 },
  { 3903, 28, 29, 25, -1, -29 },
  { 4005, 24, 29, 25, 4, -29 },
  { 4092, 26, 29, 25, 0, -29 },
  { 4187, 18, 38, 25, 7, -32 },
  { 4273, 11, 38, 25, 8, -32 },
  { 4326, 18, 38, 25, 0, -32 },
  { 4412, 21, 17, 25, 3, -29 },
  { 4457, 21, 3, 25, 0, 4 },
  { 4465, 5, 8, 25, 10, -33 },
  { 4470, 21, 22, 25, 2, -22 },
  { 4528, 21, 31, 25, 2, -31 },
  { 4610, 19, 22, 25, 3, -22 },
  { 4663, 23, 31, 25, 2, -31 },
  { 4753, 19, 22, 25, 3, -22 },
  { 4806, 28, 39, 25, -1, -31 },
  { 4943, 22, 30, 25, 1, -22 },
  { 5026, 20, 31, 25, 2, -31 },
  { 5104, 20, 32, 25, 3, -32 },
  { 5184, 20, 40, 25, 2, -32 },
  { 5284, 22, 31, 25, 2, -31 },
  { 5370, 18, 31, 25, 4, -31 },
  { 5440, 24, 22, 25, 0, -22 },
  { 5506, 20, 22, 25, 2, -22 },
  { 5561, 20, 22, 25, 3, -22 },
  { 5616, 22, 30, 25, 1, -22 },
  { 5699, 21, 30, 25, 2, -22 },
  { 5778, 20, 22, 25, 5, -22 },
  { 5833, 20, 22, 25, 2, -22 },
  { 5888, 19, 29, 25, 3, -29 },
  { 5957, 20, 22, 25, 3, -22 },
  { 6012, 20, 22, 25, 3, -22 },
  { 6067, 22, 22, 25, 2, -22 },
  { 6128, 25, 22, 25, 0, -22 },
  { 6197, 22, 30, 25, 1, -22 },
  { 6280, 21, 22, 25, 2, -22 },
  { 6338, 19, 38, 25, 5, -32 },
  { 6429, 10, 38, 25, 8, -32 },
  { 6477, 19, 38, 25, 2, -32 },
  { 6568, 22, 9, 25, 2, -17 },
};

const GFXfont IBMPlexMono_Italic42pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic42pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic42pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _IBMPLEXMONO_ITALIC42PT7B_H_
