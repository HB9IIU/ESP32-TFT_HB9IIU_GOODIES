#ifndef _IBMPLEXMONO_ITALIC58PT7B_H_
#define _IBMPLEXMONO_ITALIC58PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic58pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x1F, 0xE0, 0xFF, 0x0F,
  0xF8, 0x7F, 0xC3, 0xFC, 0x1F, 0xE0, 0x7E, 0x00, 0x1E, 0x07, 0x8F, 0x03,
  0xCF, 0x81, 0xE7, 0xC1, 0xF3, 0xC0, 0xF9, 0xE0, 0x78, 0xF0, 0x3C, 0x78,
  0x1E, 0x7C, 0x0F, 0x3E, 0x0F, 0x9E, 0x07, 0xCF, 0x03, 0xC7, 0x81, 0xE3,
  0xC0, 0xF3, 0xE0, 0x79, 0xF0, 0x7C, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xF8, 0x1E, 0x00,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xF8, 0x1E,
  0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x00, 0xF8,
  0x1E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0xFF,
  0xF8, 0x1F, 0xFE, 0x1F, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xF8,
  0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0xF8,
  0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0xF8, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0xF8, 0x00, 0xFF, 0xF8, 0x1F, 0xFE, 0x1F, 0xFE, 0x03, 0xFF, 0xC3,
  0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0xF8, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x1E,
  0x07, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0x1E, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0x8F, 0x7F, 0x80, 0x3F,
  0x07, 0x07, 0xE0, 0x3F, 0x03, 0x81, 0xF8, 0x1F, 0x01, 0xC0, 0x78, 0x1F,
  0x01, 0xE0, 0x10, 0x0F, 0x80, 0xF0, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x03,
  0xE0, 0x38, 0x00, 0x01, 0xF0, 0x1C, 0x00, 0x00, 0xF8, 0x0E, 0x00, 0x00,
  0x7C, 0x0F, 0x00, 0x00, 0x3F, 0x07, 0x80, 0x00, 0x0F, 0xC3, 0xC0, 0x00,
  0x07, 0xF9, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x0E, 0x7F, 0x80, 0x00, 0x07, 0x07, 0xE0, 0x00, 0x03, 0x81,
  0xF0, 0x00, 0x03, 0xC0, 0xFC, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0xF0,
  0x1F, 0x00, 0x00, 0x70, 0x0F, 0x80, 0x00, 0x38, 0x07, 0xC0, 0x00, 0x1C,
  0x03, 0xE0, 0x40, 0x0E, 0x01, 0xF0, 0x70, 0x0F, 0x01, 0xF0, 0x7C, 0x07,
  0x81, 0xF8, 0x7F, 0x03, 0x80, 0xF8, 0x1F, 0xC1, 0xC1, 0xFC, 0x07, 0xFC,
  0xE3, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3C, 0x03, 0xFF, 0xE0, 0x00, 0xF0, 0x0F,
  0xFF, 0xC0, 0x03, 0xC0, 0x1F, 0x07, 0xC0, 0x0F, 0x80, 0x7C, 0x07, 0x80,
  0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x01, 0xF0, 0x07,
  0x80, 0x3C, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0x1E, 0x00, 0xF0,
  0x3C, 0x00, 0x3C, 0x01, 0xE0, 0x78, 0x00, 0x70, 0x07, 0xC1, 0xE0, 0x00,
  0xF0, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0x3E, 0x1F, 0x00, 0x03, 0xE0, 0xF8,
  0x3C, 0x00, 0x03, 0xFF, 0xF0, 0xF0, 0x00, 0x07, 0xFF, 0xC3, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0x0F, 0xFF, 0x00, 0x00, 0x7C,
  0x3F, 0xFF, 0x00, 0x00, 0xF0, 0xFC, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x1E,
  0x00, 0x0F, 0x87, 0xC0, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x78, 0x00, 0x78,
  0x1E, 0x00, 0xF0, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x03, 0xC0, 0xF0, 0x03,
  0xC0, 0x0F, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF8,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0xF8, 0x07, 0x80, 0x0F, 0x83,
  0xE0, 0x1F, 0x00, 0x1F, 0xFF, 0x80, 0x3C, 0x00, 0x1F, 0xFE, 0x00, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x07,
  0xC0, 0x0F, 0x80, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x01, 0xE0, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x0F,
  0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x07, 0xFC, 0xFE, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x03, 0xF3, 0xFE, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0xF8,
  0x1F, 0x00, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x1F, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x23, 0xE0, 0x01, 0xF0,
  0x0E, 0xF8, 0x00, 0x7E, 0x03, 0xFE, 0x00, 0x17, 0x81, 0xEF, 0x80, 0x0D,
  0xF0, 0xF9, 0xF0, 0x03, 0x7C, 0x3C, 0x7C, 0x01, 0xCF, 0x9F, 0x1F, 0xC1,
  0xE3, 0xE7, 0x83, 0xFF, 0xF8, 0x7F, 0xE0, 0x7F, 0xFC, 0x1F, 0xF0, 0x0F,
  0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x1E, 0x3C, 0xF9, 0xF3,
  0xC7, 0x8F, 0x1E, 0x7C, 0xF9, 0xE3, 0xC7, 0x8F, 0x3E, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0x1F, 0x00, 0x67, 0xE0, 0x7C,
  0x0F, 0x9F, 0xF1, 0xE3, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x01,
  0xF9, 0xF0, 0x00, 0x0F, 0xC3, 0xC0, 0x00, 0x7E, 0x0F, 0x80, 0x01, 0xF0,
  0x1F, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x01,
  0xE0, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x10, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x7E, 0x03, 0xF0,
  0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1E,
  0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x3F, 0x3F,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFC, 0xFC, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0xFE,
  0x01, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0xF8, 0x78, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3E, 0x3C, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0xFB, 0xE0, 0x7C, 0x07, 0xDF,
  0x07, 0xF0, 0x3F, 0xF0, 0x3F, 0x81, 0xFF, 0x81, 0xFC, 0x0F, 0xFC, 0x0F,
  0xE0, 0xFB, 0xE0, 0x7E, 0x07, 0xDF, 0x03, 0xE0, 0x3E, 0xF8, 0x00, 0x01,
  0xF7, 0x80, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x07, 0xCF,
  0x00, 0x00, 0x3E, 0x78, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1F, 0x1E, 0x00,
  0x00, 0xF8, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x7C, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xBE, 0x00, 0x07, 0xF3, 0xE0,
  0x00, 0xFE, 0x3C, 0x00, 0x1F, 0xC3, 0xC0, 0x03, 0xF8, 0x7C, 0x00, 0x7E,
  0x07, 0xC0, 0x0F, 0xC0, 0x7C, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0x00, 0x78,
  0x00, 0x20, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFC, 0x01, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x3E, 0x00,
  0x0F, 0x81, 0xF8, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x01,
  0xF0, 0x18, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x7C, 0x00, 0x1F,
  0x80, 0x70, 0x00, 0x3F, 0x00, 0x40, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x30, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F,
  0x87, 0xE0, 0x00, 0x3E, 0x07, 0xF0, 0x00, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x00, 0xF8, 0xF0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x07, 0xC3, 0xC0, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x07,
  0xC0, 0x78, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xF8,
  0x07, 0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x78, 0x01, 0xF0, 0x01, 0xF0, 0x07, 0xC0, 0x03,
  0xE0, 0x1F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE1, 0xFE, 0x00, 0x0F, 0x1F, 0xFE, 0x00, 0x3C, 0xFF, 0xFC, 0x00, 0xF7,
  0xFF, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x7C, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x30, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x3F, 0x0F, 0xC0,
  0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x3F, 0x80, 0x1F, 0x1F, 0xFC, 0x07, 0xCF,
  0xFF, 0xE0, 0xFB, 0xFF, 0xFE, 0x3E, 0xF0, 0x1F, 0xE7, 0xF8, 0x00, 0xFC,
  0xFE, 0x00, 0x0F, 0xBF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xF7, 0x80, 0x00,
  0x3E, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0x3E,
  0x00, 0x3F, 0x03, 0xF0, 0x1F, 0xE0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE7, 0x80,
  0x00, 0x1F, 0x3C, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x0F, 0x8F, 0x00, 0x00,
  0xF8, 0xF8, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x7C, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xE0, 0x3F, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F,
  0x81, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C,
  0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xC0,
  0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x7C, 0x03,
  0xE0, 0x01, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x01, 0xE0, 0xF8, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00,
  0x7C, 0xF8, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF8, 0x07, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0xFC, 0x00,
  0x7C, 0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xE7,
  0xC0, 0x00, 0x1E, 0x7C, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E,
  0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xE7, 0xC0,
  0x01, 0xFC, 0x7E, 0x00, 0x3F, 0xC3, 0xF8, 0x0F, 0x7C, 0x3F, 0xFF, 0xEF,
  0x81, 0xFF, 0xFC, 0xF8, 0x07, 0xFF, 0x1F, 0x00, 0x1F, 0xC1, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0x83, 0xFE, 0x1F, 0xF0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x7F, 0x83, 0xFC, 0x3F, 0xE1,
  0xFF, 0x0F, 0xF0, 0x7F, 0x81, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0xFE, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x02, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0x04, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC1, 0xFC, 0x07, 0xF1, 0xF8, 0x01, 0xF8, 0xF8, 0x00,
  0x7E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xC2, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xC0,
  0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x78, 0x3E, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x0F,
  0x1F, 0x00, 0x7C, 0x7C, 0x78, 0x07, 0xF9, 0xE1, 0xE0, 0x3F, 0xF7, 0x87,
  0x81, 0xFF, 0xDE, 0x3E, 0x0F, 0xC1, 0xF8, 0xF0, 0x3E, 0x03, 0xE3, 0xC1,
  0xF0, 0x0F, 0x8F, 0x07, 0x80, 0x3C, 0x3C, 0x3E, 0x00, 0xF1, 0xF0, 0xF8,
  0x03, 0xC7, 0xC3, 0xE0, 0x0F, 0x1E, 0x0F, 0x00, 0x3C, 0x78, 0x3C, 0x00,
  0xF1, 0xE0, 0xF0, 0x07, 0xC7, 0x87, 0xC0, 0x1E, 0x1E, 0x1F, 0x00, 0x78,
  0xF8, 0x7C, 0x03, 0xE3, 0xE0, 0xF0, 0x0F, 0x8F, 0x03, 0xC0, 0x7E, 0x3C,
  0x0F, 0x03, 0xF8, 0xF0, 0x3F, 0x3F, 0xC3, 0xC0, 0xFF, 0xEF, 0x0F, 0x01,
  0xFF, 0x3C, 0x3C, 0x03, 0xF8, 0xF0, 0x78, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7B, 0xE0, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x07, 0x81, 0xF0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x3C, 0x0F,
  0x80, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3E, 0x1F,
  0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x1F, 0x03, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3C, 0x00,
  0x3F, 0x03, 0xE0, 0x00, 0xFC, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x3E, 0x1F,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x3E, 0x00,
  0x07, 0xC1, 0xE0, 0x00, 0x7C, 0x0F, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x0F,
  0x00, 0x07, 0xE0, 0x78, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00,
  0x01, 0xE1, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C, 0x78, 0x00, 0x03,
  0xE3, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xE3, 0xC0, 0x00, 0x3E, 0x1E, 0x00,
  0x03, 0xF1, 0xF0, 0x00, 0x7F, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xC0, 0xFE, 0x01, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xC0, 0xF8, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x08,
  0x1F, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7C, 0x3F,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0xC0,
  0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x0F, 0xE0,
  0x0F, 0x80, 0x0F, 0xC0, 0x3E, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x3E, 0x03,
  0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1E, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x0F, 0xC3, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8,
  0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x1F,
  0x00, 0x01, 0xF8, 0x78, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x7E, 0x0F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7E,
  0x07, 0xC0, 0x03, 0xF0, 0x1F, 0x00, 0x7F, 0x80, 0x7F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xF0, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x01, 0xF8,
  0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x7C,
  0x00, 0x03, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x01, 0xFF, 0xF3, 0xE0, 0x0F,
  0xFF, 0x9F, 0x00, 0x7F, 0xFC, 0xF8, 0x03, 0xFF, 0xE7, 0xC0, 0x00, 0x1E,
  0x3E, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x7C, 0x7C,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xF0, 0xF8, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x7F,
  0x07, 0xE0, 0x06, 0xF8, 0x1F, 0xC0, 0xF7, 0x80, 0x7F, 0xFF, 0x3C, 0x03,
  0xFF, 0xF1, 0xE0, 0x07, 0xFF, 0x0F, 0x00, 0x0F, 0xE0, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1E, 0x03,
  0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3C, 0x07,
  0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x7C, 0x0F,
  0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x78, 0x0F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF0, 0x1F,
  0x00, 0x01, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xE0, 0x3E,
  0x00, 0x03, 0xE0, 0x3C, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xC0, 0x7C,
  0x00, 0x07, 0xC0, 0x78, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x07, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x07,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x3F, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x00,
  0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x07, 0xE0, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x07, 0xE0, 0x00, 0x78, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x1F, 0x80, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x0F, 0x81, 0xF8,
  0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0x3C, 0x1F, 0x80, 0x00, 0x0F, 0x87,
  0xE0, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x00, 0x3E, 0x7F, 0x80, 0x00, 0x07,
  0xDF, 0xF0, 0x00, 0x00, 0xFF, 0xDF, 0x00, 0x00, 0x1F, 0xF3, 0xE0, 0x00,
  0x07, 0xFC, 0x3E, 0x00, 0x00, 0xFF, 0x07, 0xC0, 0x00, 0x1F, 0xC0, 0x7C,
  0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x0F, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x07, 0x80, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0x00,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF0, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xF0,
  0x3F, 0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xF0, 0x07, 0xFC,
  0x0F, 0x78, 0x03, 0xDE, 0x07, 0xBC, 0x03, 0xDF, 0x03, 0xDE, 0x01, 0xEF,
  0x83, 0xE7, 0x81, 0xE7, 0x81, 0xF3, 0xC1, 0xF3, 0xC0, 0xF9, 0xE0, 0xF1,
  0xE0, 0x78, 0xF0, 0xF1, 0xF0, 0x3C, 0x3C, 0x78, 0xF8, 0x1E, 0x1E, 0x78,
  0x78, 0x1F, 0x0F, 0x7C, 0x3C, 0x0F, 0x87, 0xBC, 0x1E, 0x07, 0x81, 0xFE,
  0x0F, 0x03, 0xC0, 0xFE, 0x0F, 0x81, 0xE0, 0x7E, 0x07, 0xC0, 0xF0, 0x3F,
  0x03, 0xC0, 0xF8, 0x0F, 0x01, 0xE0, 0x7C, 0x07, 0x80, 0xF0, 0x3C, 0x03,
  0x80, 0x78, 0x1E, 0x01, 0x80, 0x7C, 0x0F, 0x00, 0x40, 0x3E, 0x07, 0x80,
  0x40, 0x1E, 0x07, 0xC0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x01, 0xF0, 0x3C,
  0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x0F, 0x81,
  0xE0, 0x00, 0x07, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0x01, 0xFC, 0x00, 0x0F,
  0x01, 0xFE, 0x00, 0x1F, 0x03, 0xFE, 0x00, 0x1F, 0x03, 0xFE, 0x00, 0x1F,
  0x03, 0xFE, 0x00, 0x1E, 0x03, 0xDE, 0x00, 0x1E, 0x03, 0xDF, 0x00, 0x1E,
  0x03, 0xCF, 0x00, 0x3E, 0x07, 0xCF, 0x00, 0x3E, 0x07, 0xCF, 0x00, 0x3E,
  0x07, 0xCF, 0x80, 0x3C, 0x07, 0x8F, 0x80, 0x3C, 0x07, 0x87, 0x80, 0x3C,
  0x07, 0x87, 0x80, 0x7C, 0x0F, 0x87, 0x80, 0x7C, 0x0F, 0x87, 0xC0, 0x7C,
  0x0F, 0x83, 0xC0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xC0, 0x78,
  0x0F, 0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x01, 0xE0, 0xF8,
  0x1E, 0x01, 0xE0, 0xF0, 0x1E, 0x01, 0xE0, 0xF0, 0x1E, 0x01, 0xF0, 0xF0,
  0x1E, 0x00, 0xF1, 0xF0, 0x3E, 0x00, 0xF1, 0xF0, 0x3E, 0x00, 0xF1, 0xF0,
  0x3C, 0x00, 0xF9, 0xE0, 0x3C, 0x00, 0x79, 0xE0, 0x3C, 0x00, 0x79, 0xE0,
  0x3C, 0x00, 0x7B, 0xE0, 0x7C, 0x00, 0x7B, 0xE0, 0x7C, 0x00, 0x7F, 0xE0,
  0x78, 0x00, 0x3F, 0xC0, 0x78, 0x00, 0x3F, 0xC0, 0x78, 0x00, 0x3F, 0xC0,
  0xF8, 0x00, 0x3F, 0xC0, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xC0, 0xFE, 0x01, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xC0, 0xF8, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3E,
  0x3C, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7C, 0xF0,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3E, 0xF8,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0xF9, 0xE0, 0x00,
  0x07, 0xCF, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1F,
  0x1E, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x3E,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x80,
  0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3E, 0x00, 0x1F,
  0xC0, 0x78, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8,
  0x3C, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x1E,
  0x00, 0x03, 0xF0, 0x7C, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0xFE, 0x01, 0xF8,
  0x01, 0xF0, 0x1F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0xF8, 0xF8, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3E, 0x3C, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x1F, 0x7C, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFB,
  0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x0F, 0xBC, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x07, 0xCF, 0x00, 0x00,
  0x3E, 0x78, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0xF8,
  0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x7C, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x01, 0x80, 0x01, 0xF0, 0x1E, 0x00,
  0x07, 0xC1, 0xF8, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3E, 0x00, 0x1F, 0xC0, 0x78, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x1E, 0x00, 0x03, 0xF0, 0x7C,
  0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x3E, 0x01,
  0xE0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x07,
  0xC0, 0x03, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x7C,
  0x01, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF8,
  0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x0F, 0xC0, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x1E, 0x03, 0xE0, 0x00,
  0x04, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x10, 0x00, 0x00, 0xF8, 0x1C, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7E,
  0x1F, 0xC0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x7E, 0x01, 0xFF, 0x00, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x1E, 0x00, 0x01, 0xF0, 0x78,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00,
  0x01, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0xF8, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3C,
  0x1F, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0x83, 0xE0,
  0x00, 0x3E, 0x0F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x07,
  0xC1, 0xE0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3E,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0,
  0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x01,
  0xF3, 0xC0, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3E,
  0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0,
  0x78, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x1F,
  0x00, 0x0F, 0x80, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78,
  0x01, 0xF0, 0x00, 0xF0, 0x03, 0xE0, 0x01, 0xE0, 0x0F, 0x80, 0x03, 0xE0,
  0x1F, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x3E,
  0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x03, 0xCF, 0x80, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x1E, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x0F, 0x87, 0x80, 0x00,
  0x03, 0xE1, 0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x3C, 0x3E, 0x00,
  0x00, 0x0F, 0x0F, 0x80, 0x00, 0x07, 0xC3, 0xC0, 0x3E, 0x01, 0xE0, 0xF0,
  0x1F, 0xC0, 0x78, 0x3C, 0x07, 0xF0, 0x1E, 0x0F, 0x01, 0xFC, 0x0F, 0x83,
  0xC0, 0xFF, 0x03, 0xC0, 0xF0, 0x3F, 0xC0, 0xF0, 0x3C, 0x0E, 0xF0, 0x3C,
  0x0F, 0x07, 0xBC, 0x1F, 0x03, 0xC1, 0xEF, 0x07, 0x81, 0xF0, 0xF3, 0xC1,
  0xE0, 0x7C, 0x3C, 0xF0, 0x78, 0x1E, 0x0E, 0x3C, 0x3E, 0x07, 0x87, 0x8F,
  0x0F, 0x01, 0xE1, 0xE3, 0xC3, 0xC0, 0x78, 0x70, 0xF0, 0xF0, 0x1E, 0x3C,
  0x3C, 0x7C, 0x07, 0x8F, 0x07, 0x1E, 0x01, 0xE7, 0x81, 0xC7, 0x80, 0x79,
  0xE0, 0x71, 0xE0, 0x1E, 0x78, 0x1C, 0xF8, 0x0F, 0xBC, 0x07, 0x3C, 0x03,
  0xCF, 0x01, 0xCF, 0x00, 0xF3, 0x80, 0x7B, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0,
  0x0F, 0x78, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x3E, 0x01,
  0xF8, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x00, 0x1E, 0x7E,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0x0F,
  0xC1, 0xF0, 0x00, 0x00, 0x7E, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x07, 0xC0,
  0xFC, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x0F,
  0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x07,
  0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0xF8, 0x03,
  0xF0, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0xF8,
  0xF8, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xF0, 0x10, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x00, 0xE0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC0,
  0x78, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x0F, 0x00, 0x3E, 0x00, 0x78,
  0x01, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x7C, 0x1F,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x7C, 0xF8, 0x00,
  0x01, 0xEF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x01,
  0xC0, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x18, 0xF8, 0x78, 0x7C, 0x3C, 0x3C, 0x1E, 0x1E, 0x1E,
  0x0E, 0x0D, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0x0F, 0x01, 0xFF, 0xF9,
  0xF0, 0x3F, 0xFF, 0xDF, 0x07, 0xF0, 0x3D, 0xF0, 0xFC, 0x00, 0xFF, 0x0F,
  0x80, 0x07, 0xE1, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x3E, 0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xC7,
  0xC0, 0x00, 0x3C, 0x7C, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x7C, 0xF8, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x78,
  0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x8F, 0x80,
  0x01, 0xF8, 0x78, 0x00, 0x3F, 0x07, 0xC0, 0x06, 0xF0, 0x7E, 0x00, 0xDF,
  0x03, 0xF0, 0x3D, 0xFF, 0x3F, 0xFF, 0x8F, 0xF1, 0xFF, 0xF0, 0xFF, 0x0F,
  0xFE, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x0F, 0xE0, 0x03, 0xE1, 0xFF, 0xC0, 0x1E, 0x3F, 0xFF,
  0x00, 0xF3, 0xFF, 0xFC, 0x0F, 0x9E, 0x0F, 0xE0, 0x7D, 0xC0, 0x1F, 0x83,
  0xFC, 0x00, 0x7C, 0x1F, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x0F, 0x07, 0xC0,
  0x00, 0x78, 0x7E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00,
  0xF8, 0xF8, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0x3E, 0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00,
  0xF8, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x3F, 0x00, 0x07, 0xC1,
  0xEC, 0x00, 0xFE, 0x0F, 0x78, 0x1F, 0xE0, 0xF9, 0xFF, 0xFE, 0x07, 0xC7,
  0xFF, 0xE0, 0x3E, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07,
  0xF0, 0x1F, 0x81, 0xF0, 0x03, 0xF0, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x0F,
  0x1F, 0x00, 0x02, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xC7, 0x80, 0x00,
  0x79, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0xC3, 0xE0,
  0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xFC, 0x0F, 0x80, 0x1F, 0xFE, 0x1F,
  0x00, 0x7F, 0xFE, 0x3E, 0x01, 0xFF, 0xFE, 0x78, 0x07, 0xF0, 0x1E, 0xF0,
  0x1F, 0x80, 0x0F, 0xE0, 0x3E, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x1F, 0x81,
  0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x78, 0x3E,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x0F, 0x83, 0xC0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x3C, 0x1F, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0xFC, 0x07, 0x80, 0x03, 0xF8, 0x0F, 0x80, 0x0D, 0xF0, 0x1F, 0x80, 0x3B,
  0xE0, 0x1F, 0x81, 0xE7, 0x80, 0x3F, 0xFF, 0x8F, 0x00, 0x3F, 0xFE, 0x3E,
  0x00, 0x3F, 0xF8, 0x7C, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x3F,
  0x80, 0xFC, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x1F,
  0x1E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C, 0xF0, 0x00, 0x1F, 0x3E, 0x00,
  0x07, 0xE7, 0xC0, 0x07, 0xF8, 0xF0, 0x1F, 0xFE, 0x1F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x04, 0x3E,
  0x00, 0x00, 0xE3, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x03,
  0xE0, 0xF8, 0x00, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0xF8,
  0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x3C, 0x00, 0x00, 0x07, 0xE0, 0xF0, 0x00, 0x00, 0x0F, 0xC7, 0xC0,
  0x00, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFF, 0xE1, 0xF0, 0x0F, 0xFF, 0xC7, 0x80, 0x7F, 0xFF, 0x9E, 0x03, 0xF8,
  0x0F, 0x78, 0x1F, 0x80, 0x0F, 0xE0, 0x7C, 0x00, 0x1F, 0x83, 0xE0, 0x00,
  0x7E, 0x0F, 0x80, 0x00, 0xF0, 0x7C, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x0F,
  0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x01, 0xE1, 0xF0,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0xFC, 0x0F, 0x80, 0x06,
  0xF0, 0x3E, 0x00, 0x3F, 0xC0, 0xFC, 0x01, 0xDF, 0x01, 0xFC, 0x1E, 0x78,
  0x07, 0xFF, 0xF9, 0xE0, 0x0F, 0xFF, 0xC7, 0x80, 0x1F, 0xFC, 0x3E, 0x00,
  0x1F, 0xC0, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x20, 0x00,
  0x3E, 0x01, 0xE0, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x3F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x0F, 0x87, 0xFE,
  0x01, 0xF1, 0xFF, 0xE0, 0x3E, 0x7F, 0xFE, 0x07, 0x9E, 0x0F, 0xC0, 0xF7,
  0x00, 0xFC, 0x3E, 0xC0, 0x0F, 0x87, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0x3E,
  0x1F, 0x80, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x1F, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x0F, 0x80, 0x01, 0xE1,
  0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x00,
  0x3E, 0x3E, 0x00, 0x07, 0x87, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x1E,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x03,
  0xC3, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x04, 0x00,
  0xF0, 0x03, 0x80, 0x3C, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0xFC,
  0x01, 0xF0, 0x7E, 0x00, 0x78, 0x3F, 0x00, 0x1E, 0x1F, 0x80, 0x0F, 0x8F,
  0xC0, 0x03, 0xE7, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x10, 0x01, 0xF0,
  0x03, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0xC0, 0x1E, 0x00, 0x3E,
  0x01, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xFC, 0x3E,
  0x00, 0x07, 0xE3, 0xC0, 0x00, 0x3F, 0x3C, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0xFE, 0x00, 0x1F,
  0x0F, 0xFC, 0x00, 0x7C, 0x7F, 0xF8, 0x01, 0xF3, 0xFF, 0xF0, 0x07, 0x9E,
  0x0F, 0xE0, 0x1E, 0xE0, 0x1F, 0x80, 0xFB, 0x00, 0x3E, 0x03, 0xF8, 0x00,
  0xF8, 0x0F, 0xC0, 0x03, 0xE0, 0x3F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x01,
  0xF0, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x1E, 0x03, 0xF8, 0x00, 0x78,
  0x7F, 0x80, 0x03, 0xE3, 0xF0, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x3E, 0x1F,
  0x00, 0x00, 0xF8, 0x7C, 0x00, 0x43, 0xC0, 0xF8, 0x03, 0x8F, 0x03, 0xE0,
  0x1F, 0x7C, 0x07, 0xC0, 0xF9, 0xF0, 0x1F, 0x07, 0xC7, 0xC0, 0x3C, 0x7E,
  0x1F, 0x00, 0xFB, 0xF0, 0x78, 0x01, 0xFF, 0x81, 0xE0, 0x07, 0xFC, 0x0F,
  0x80, 0x0F, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x18, 0x0F, 0x80, 0x1E, 0x07,
  0xC0, 0x1F, 0x83, 0xE0, 0x1F, 0x01, 0xF0, 0x3F, 0x00, 0xF0, 0x3F, 0x00,
  0x78, 0x3F, 0x00, 0x7C, 0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x3F, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0xF8, 0x07, 0x9F, 0xC1, 0xFE, 0x0F, 0xBF, 0xE3,
  0xFE, 0x0F, 0x3F, 0xE7, 0xFF, 0x0F, 0x61, 0xEE, 0x1F, 0x0F, 0x41, 0xEC,
  0x1F, 0x0F, 0x81, 0xF8, 0x0F, 0x0F, 0x00, 0xF8, 0x0F, 0x1F, 0x01, 0xF0,
  0x0F, 0x1F, 0x01, 0xF0, 0x1F, 0x1E, 0x01, 0xE0, 0x1E, 0x1E, 0x01, 0xE0,
  0x1E, 0x1E, 0x01, 0xE0, 0x1E, 0x1E, 0x01, 0xE0, 0x1E, 0x3E, 0x01, 0xE0,
  0x1E, 0x3C, 0x03, 0xE0, 0x3E, 0x3C, 0x03, 0xC0, 0x3C, 0x3C, 0x03, 0xC0,
  0x3C, 0x3C, 0x03, 0xC0, 0x3C, 0x3C, 0x03, 0xC0, 0x3C, 0x7C, 0x03, 0xC0,
  0x3C, 0x78, 0x07, 0xC0, 0x7C, 0x78, 0x07, 0x80, 0x78, 0x78, 0x07, 0x80,
  0x78, 0x78, 0x07, 0x80, 0x78, 0x78, 0x07, 0x80, 0x78, 0xF8, 0x07, 0x80,
  0x78, 0xF0, 0x0F, 0x80, 0xF8, 0xF0, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x00,
  0xF0, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0xF8, 0x7F, 0xE0,
  0x1F, 0x1F, 0xFE, 0x03, 0xE7, 0xFF, 0xE0, 0x79, 0xE0, 0xFC, 0x0F, 0x70,
  0x0F, 0xC3, 0xEC, 0x00, 0xF8, 0x7F, 0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xE1,
  0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF1, 0xF0, 0x00,
  0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x1E, 0x1E,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x78, 0x7C, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3C,
  0x3E, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x3E, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0x03, 0xF8, 0x1F, 0x80, 0x1F, 0x07, 0xE0,
  0x01, 0xF0, 0xF8, 0x00, 0x1E, 0x3E, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x7D,
  0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xEF, 0x00, 0x00,
  0x7D, 0xE0, 0x00, 0x0F, 0xBC, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C, 0x78,
  0x00, 0x1F, 0x0F, 0x80, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xE1, 0xFF, 0xC0, 0x07, 0x8F,
  0xFF, 0xC0, 0x0F, 0x3F, 0xFF, 0xC0, 0x3E, 0x78, 0x3F, 0x80, 0x7D, 0xC0,
  0x1F, 0x80, 0xFF, 0x00, 0x1F, 0x01, 0xFC, 0x00, 0x3E, 0x03, 0xF0, 0x00,
  0x3C, 0x07, 0xC0, 0x00, 0x78, 0x1F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x1F,
  0x00, 0x01, 0xF0, 0x3F, 0x00, 0x07, 0xC0, 0x7B, 0x00, 0x1F, 0x80, 0xF7,
  0x81, 0xFE, 0x03, 0xE7, 0xFF, 0xF8, 0x07, 0xC7, 0xFF, 0xE0, 0x0F, 0x87,
  0xFF, 0x00, 0x1F, 0x03, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0x87, 0xC0, 0x7F, 0xFE, 0x3C,
  0x07, 0xFF, 0xF9, 0xE0, 0x7F, 0x01, 0xEF, 0x07, 0xE0, 0x03, 0xF8, 0x3E,
  0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x01, 0xE1, 0xF0, 0x00,
  0x0F, 0x0F, 0x80, 0x00, 0x78, 0xF8, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3E,
  0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x78, 0xF8,
  0x00, 0x03, 0xC7, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E,
  0x1F, 0x00, 0x03, 0xF0, 0x78, 0x00, 0x3F, 0x83, 0xE0, 0x03, 0x7C, 0x1F,
  0x80, 0x3B, 0xE0, 0x7E, 0x07, 0x9E, 0x03, 0xFF, 0xF8, 0xF0, 0x0F, 0xFF,
  0x8F, 0x80, 0x3F, 0xF8, 0x7C, 0x00, 0x7F, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x7F, 0xFC, 0x0F, 0xF7, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0xB8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE,
  0x03, 0xF0, 0x0F, 0xF0, 0x7C, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0xC0, 0xF8,
  0x00, 0x08, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC2, 0x00, 0x00, 0x7C, 0x30, 0x00,
  0x07, 0xC7, 0x80, 0x00, 0xF8, 0xFE, 0x00, 0x1F, 0x87, 0xF8, 0x07, 0xF0,
  0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE0,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x02,
  0x00, 0xF0, 0x01, 0xC0, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0xFF, 0x07, 0xC0,
  0x7F, 0x01, 0xF0, 0x7F, 0x00, 0x78, 0x3F, 0x80, 0x1E, 0x3F, 0xC0, 0x07,
  0x9F, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x78, 0x78,
  0x00, 0x0F, 0x0F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x0F,
  0x8F, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80,
  0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF0,
  0xF8, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF8, 0xF8, 0x00,
  0x1F, 0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x78, 0x7C, 0x00, 0x1F, 0x0F,
  0x00, 0x03, 0xE1, 0xE0, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x87, 0xC0, 0x07,
  0xF0, 0xF8, 0x01, 0xBC, 0x1F, 0x80, 0x77, 0x81, 0xF8, 0x3C, 0xF0, 0x3F,
  0xFF, 0x3E, 0x03, 0xFF, 0xC7, 0xC0, 0x3F, 0xF0, 0xF8, 0x01, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0xDF, 0xFC, 0x00, 0xFB, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0x80, 0x07, 0xC0, 0xF0, 0x00,
  0x78, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0xF8, 0x00, 0x3C, 0x1F,
  0x00, 0x07, 0x83, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x3E, 0x0F, 0x00, 0x07,
  0xC1, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF0,
  0x01, 0xF0, 0x3C, 0x00, 0x3E, 0x07, 0x80, 0x0F, 0x80, 0xF0, 0x03, 0xF0,
  0x1E, 0x00, 0x7C, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x0F, 0xE0, 0x1E, 0x07,
  0xF8, 0x03, 0xC3, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x0C, 0x1E,
  0x01, 0xE0, 0xF8, 0x3C, 0x03, 0xC0, 0xF0, 0x78, 0x07, 0x81, 0xE0, 0xF0,
  0x1F, 0x03, 0xE3, 0xC0, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0x07, 0x8F, 0x00,
  0xF0, 0x0F, 0x1E, 0x01, 0xE0, 0x1E, 0x3C, 0x03, 0xC0, 0x3C, 0x78, 0x0F,
  0x80, 0x79, 0xE0, 0x1E, 0x00, 0xF3, 0xC0, 0x3C, 0x01, 0xE7, 0x80, 0x78,
  0x07, 0xCF, 0x00, 0xF0, 0x0F, 0x9E, 0x01, 0xE0, 0x1E, 0x3C, 0x07, 0xC0,
  0x3C, 0xF8, 0x0F, 0x00, 0x79, 0xE0, 0x1E, 0x00, 0xF3, 0xC0, 0x3C, 0x03,
  0xE7, 0x80, 0x78, 0x07, 0x8F, 0x01, 0xF0, 0x0F, 0x1E, 0x03, 0xE0, 0x3E,
  0x3C, 0x07, 0xC0, 0x78, 0xF8, 0x1F, 0x81, 0xF0, 0xF0, 0x6F, 0x07, 0xC1,
  0xF1, 0xDF, 0x1F, 0x03, 0xFF, 0x1F, 0xFE, 0x07, 0xFE, 0x3F, 0xF8, 0x07,
  0xF8, 0x3F, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x3E,
  0x00, 0x0F, 0xE0, 0x3F, 0xE0, 0x0F, 0xFC, 0x1F, 0xF8, 0x07, 0xFF, 0x0F,
  0xFF, 0x03, 0xFB, 0xC7, 0xC7, 0xC3, 0xF8, 0x79, 0xC0, 0xF1, 0xF8, 0x1E,
  0xE0, 0x3C, 0xFC, 0x07, 0xB8, 0x0F, 0x0C, 0x01, 0xEC, 0x03, 0xC2, 0x00,
  0x7F, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x3C, 0x00, 0x07, 0xE0, 0x10, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x08, 0x03, 0xF0,
  0x00, 0x1E, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x6F, 0x00, 0x43, 0xE0, 0x1B,
  0xC0, 0x38, 0xF8, 0x0E, 0xF0, 0x3F, 0x3E, 0x07, 0x3C, 0x1F, 0x8F, 0x83,
  0xCF, 0x0F, 0xC1, 0xF1, 0xE3, 0xEF, 0xE0, 0x7F, 0xF8, 0x7F, 0xF0, 0x1F,
  0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x7E, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01,
  0xE0, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF8,
  0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3C, 0x07,
  0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x3F, 0x01, 0xF0,
  0x01, 0xFC, 0x07, 0xC0, 0x0D, 0xF0, 0x1F, 0x80, 0x77, 0x80, 0x3F, 0x07,
  0x9E, 0x00, 0xFF, 0xFC, 0x78, 0x01, 0xFF, 0xF3, 0xE0, 0x03, 0xFF, 0x0F,
  0x80, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x08,
  0x00, 0x1F, 0x80, 0x70, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xFE, 0x03, 0xC1, 0xFF, 0xFC,
  0x1E, 0x0F, 0xFF, 0xF9, 0xF0, 0xF8, 0x1F, 0xEF, 0x87, 0x80, 0x1F, 0xFC,
  0x78, 0x00, 0x3F, 0xC3, 0xC0, 0x00, 0xF8, 0x1E, 0x00, 0x0F, 0x80, 0xF0,
  0x00, 0xF8, 0x07, 0x80, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x20, 0x01,
  0xF0, 0x07, 0x00, 0x1F, 0x00, 0x3C, 0x01, 0xF0, 0x01, 0xE0, 0x1F, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x3C, 0x1F, 0x00, 0x01, 0xE1, 0xFF, 0x80, 0x0F,
  0x1F, 0xFF, 0xC0, 0x79, 0xF3, 0xFF, 0xF3, 0xCF, 0x83, 0xFF, 0xFE, 0x7C,
  0x03, 0xFF, 0xF3, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF0,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x08, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x30, 0x1F, 0xF0, 0x00, 0xF0, 0xFF, 0xE0,
  0x03, 0xC3, 0xFF, 0x80, 0x1E, 0x1F, 0x1F, 0x00, 0x78, 0xF8, 0x3C, 0x03,
  0xC3, 0xC0, 0x78, 0x0F, 0x1E, 0x01, 0xF0, 0x78, 0x78, 0x03, 0xE3, 0xE3,
  0xC0, 0x0F, 0xFF, 0x0F, 0x00, 0x1F, 0xF8, 0x3C, 0x00, 0x3F, 0xC0, 0x20,
  0x00, 0x3E, 0x00,
};

const GFXglyph IBMPlexMono_Italic58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 13, 41, 35, 11, -40 },
  { 68, 17, 16, 35, 12, -43 },
  { 102, 35, 40, 35, 1, -40 },
  { 277, 33, 54, 35, 1, -47 },
  { 500, 39, 42, 35, -1, -41 },
  { 705, 34, 42, 35, 0, -41 },
  { 884, 7, 16, 35, 17, -43 },
  { 898, 22, 52, 35, 12, -44 },
  { 1041, 22, 52, 35, 2, -44 },
  { 1184, 30, 29, 35, 3, -32 },
  { 1293, 28, 28, 35, 4, -32 },
  { 1391, 13, 16, 35, 8, -8 },
  { 1417, 18, 4, 35, 9, -20 },
  { 1426, 9, 8, 35, 11, -7 },
  { 1435, 33, 52, 35, 1, -44 },
  { 1650, 29, 42, 35, 4, -41 },
  { 1803, 28, 40, 35, 2, -40 },
  { 1943, 30, 41, 35, 2, -41 },
  { 2097, 31, 42, 35, 1, -41 },
  { 2260, 31, 40, 35, 1, -40 },
  { 2415, 30, 41, 35, 3, -40 },
  { 2569, 27, 41, 35, 4, -40 },
  { 2708, 29, 40, 35, 6, -40 },
  { 2853, 31, 42, 35, 2, -41 },
  { 3016, 28, 41, 35, 5, -41 },
  { 3160, 13, 31, 35, 11, -30 },
  { 3211, 16, 38, 35, 8, -30 },
  { 3287, 28, 33, 35, 5, -34 },
  { 3403, 30, 16, 35, 3, -26 },
  { 3463, 28, 33, 35, 3, -34 },
  { 3579, 25, 42, 35, 7, -41 },
  { 3711, 30, 48, 35, 3, -41 },
  { 3891, 32, 40, 35, -1, -40 },
  { 4051, 29, 40, 35, 3, -40 },
  { 4196, 29, 42, 35, 5, -41 },
  { 4349, 30, 40, 35, 3, -40 },
  { 4499, 31, 40, 35, 3, -40 },
  { 4654, 32, 40, 35, 3, -40 },
  { 4814, 29, 42, 35, 4, -41 },
  { 4967, 32, 40, 35, 2, -40 },
  { 5127, 32, 40, 35, 2, -40 },
  { 5287, 29, 41, 35, 3, -40 },
  { 5436, 35, 40, 35, 2, -40 },
  { 5611, 24, 40, 35, 5, -40 },
  { 5731, 33, 40, 35, 2, -40 },
  { 5896, 32, 40, 35, 2, -40 },
  { 6056, 29, 42, 35, 4, -41 },
  { 6209, 31, 40, 35, 3, -40 },
  { 6364, 29, 52, 35, 4, -41 },
  { 6553, 31, 40, 35, 3, -40 },
  { 6708, 33, 42, 35, 1, -41 },
  { 6882, 33, 40, 35, 5, -40 },
  { 7047, 30, 41, 35, 4, -40 },
  { 7201, 31, 40, 35, 6, -40 },
  { 7356, 34, 40, 35, 3, -40 },
  { 7526, 38, 40, 35, -1, -40 },
  { 7716, 33, 40, 35, 5, -40 },
  { 7881, 35, 40, 35, 0, -40 },
  { 8056, 25, 52, 35, 9, -44 },
  { 8219, 15, 52, 35, 11, -44 },
  { 8317, 24, 52, 35, 1, -44 },
  { 8473, 29, 23, 35, 4, -40 },
  { 8557, 28, 4, 35, 0, 6 },
  { 8571, 8, 11, 35, 13, -45 },
  { 8582, 28, 32, 35, 3, -31 },
  { 8694, 29, 44, 35, 3, -43 },
  { 8854, 26, 32, 35, 4, -31 },
  { 8958, 31, 44, 35, 3, -43 },
  { 9129, 27, 32, 35, 4, -31 },
  { 9237, 38, 55, 35, -1, -43 },
  { 9499, 30, 43, 35, 2, -31 },
  { 9661, 27, 43, 35, 3, -43 },
  { 9807, 26, 45, 35, 5, -44 },
  { 9954, 28, 56, 35, 3, -44 },
  { 10150, 30, 44, 35, 3, -43 },
  { 10315, 25, 44, 35, 6, -43 },
  { 10453, 32, 31, 35, 1, -31 },
  { 10577, 27, 31, 35, 3, -31 },
  { 10682, 27, 32, 35, 4, -31 },
  { 10790, 31, 43, 35, 1, -31 },
  { 10957, 29, 43, 35, 3, -31 },
  { 11113, 28, 30, 35, 6, -30 },
  { 11218, 28, 32, 35, 3, -31 },
  { 11330, 26, 41, 35, 5, -40 },
  { 11464, 27, 31, 35, 5, -30 },
  { 11569, 27, 30, 35, 4, -30 },
  { 11671, 31, 31, 35, 2, -30 },
  { 11792, 34, 32, 35, 0, -31 },
  { 11928, 30, 42, 35, 2, -30 },
  { 12086, 29, 32, 35, 3, -31 },
  { 12202, 27, 52, 35, 6, -44 },
  { 12378, 12, 52, 35, 12, -44 },
  { 12456, 28, 52, 35, 2, -44 },
  { 12638, 30, 13, 35, 3, -24 },
};

const GFXfont IBMPlexMono_Italic58pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic58pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic58pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _IBMPLEXMONO_ITALIC58PT7B_H_
