#ifndef _IBMPLEXMONO_ITALIC71PT7B_H_
#define _IBMPLEXMONO_ITALIC71PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic71pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0x80, 0xFF, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0xF8, 0xF8, 0x0F,
  0xC7, 0xC0, 0x7C, 0x3E, 0x03, 0xE3, 0xF0, 0x1F, 0x1F, 0x80, 0xF8, 0xF8,
  0x07, 0xC7, 0xC0, 0x7E, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x1F, 0x80, 0xF8,
  0xFC, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x03, 0xF1, 0xF0, 0x1F, 0x0F, 0x80,
  0xF8, 0xFC, 0x07, 0xC7, 0xE0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x01, 0xFF,
  0xFC, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x83, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x01,
  0xF0, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x01,
  0xF0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xE7, 0xDF, 0xFC, 0x00, 0xFF,
  0x07, 0x83, 0xFC, 0x01, 0xFC, 0x07, 0x80, 0xFE, 0x01, 0xF8, 0x07, 0x80,
  0x7F, 0x03, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xF0, 0x07, 0x80, 0x10, 0x03,
  0xF0, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x0F, 0x00, 0x00, 0x07, 0xE0, 0x0F,
  0x00, 0x00, 0x07, 0xE0, 0x0F, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0x00, 0x00,
  0x07, 0xE0, 0x0F, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0x00, 0x00, 0x03, 0xF0,
  0x1E, 0x00, 0x00, 0x03, 0xFC, 0x1E, 0x00, 0x00, 0x01, 0xFE, 0x1E, 0x00,
  0x00, 0x01, 0xFF, 0xDE, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0x3C, 0xFF, 0xC0, 0x00, 0x00, 0x7C, 0x3F, 0xE0, 0x00, 0x00,
  0x78, 0x0F, 0xE0, 0x00, 0x00, 0x78, 0x07, 0xE0, 0x00, 0x00, 0x78, 0x07,
  0xF0, 0x00, 0x00, 0x78, 0x03, 0xF0, 0x00, 0x00, 0x78, 0x03, 0xF0, 0x00,
  0x00, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0xF0,
  0x03, 0xF0, 0x00, 0x00, 0xF0, 0x03, 0xF0, 0x18, 0x00, 0xF0, 0x07, 0xE0,
  0x38, 0x00, 0xF0, 0x07, 0xE0, 0x7C, 0x01, 0xF0, 0x0F, 0xE0, 0xFE, 0x01,
  0xE0, 0x1F, 0xC0, 0xFF, 0x01, 0xE0, 0x3F, 0xC0, 0x7F, 0xC1, 0xE0, 0x7F,
  0x80, 0x3F, 0xF9, 0xE3, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x0F,
  0x80, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x07, 0xC0, 0x07,
  0xC0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0xF0, 0x01, 0xF0, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x7C, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0x80, 0x07, 0xC1,
  0xF0, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0x01, 0xE0, 0x03, 0xE0,
  0xF8, 0x00, 0x00, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x78, 0x01, 0xF0,
  0x7C, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x0F, 0x81, 0xF8,
  0x7C, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x83, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0x83, 0xF0, 0x7E, 0x00, 0x00, 0x0F, 0x83, 0xF0, 0x0F, 0x80, 0x00, 0x0F,
  0xC1, 0xF0, 0x07, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x1F, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x0F, 0x80, 0x01,
  0xF0, 0x07, 0xC0, 0x07, 0xC0, 0x01, 0xF0, 0x03, 0xC0, 0x03, 0xE0, 0x00,
  0xF8, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x7C, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x20, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFC,
  0x0F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0xC7, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x01, 0x8F, 0xC0, 0x00, 0x7E, 0x00, 0x7B, 0xF0, 0x00, 0x1F, 0xC0,
  0x3F, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xBF, 0x00, 0x03, 0x7E, 0x07, 0xC7,
  0xE0, 0x01, 0xDF, 0x83, 0xF1, 0xF8, 0x00, 0x73, 0xF0, 0xF8, 0x7F, 0x00,
  0x3C, 0xFC, 0x7E, 0x0F, 0xF0, 0x3E, 0x1F, 0x9F, 0x03, 0xFF, 0xFF, 0x07,
  0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xF0,
  0x00, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x8F, 0x87, 0xC3, 0xE1, 0xF1, 0xF8, 0xFC, 0x7C, 0x3E, 0x1F, 0x0F, 0x8F,
  0xC7, 0xE3, 0xE1, 0xF0, 0xF8, 0x7C, 0x7E, 0x3F, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0x00, 0x0F, 0x80, 0x06,
  0x7E, 0x00, 0xF8, 0x03, 0xF7, 0xFC, 0x0F, 0x81, 0xFF, 0xFF, 0xF8, 0xF9,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x0F,
  0xE1, 0xF0, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0xF8, 0x00,
  0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x07,
  0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F,
  0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x9F, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x9F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x0F, 0xE0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x00,
  0x1F, 0x1F, 0x00, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x00, 0x1F, 0x3F, 0x00,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0xFC, 0x03, 0xF7,
  0xF0, 0x1F, 0xE0, 0x3F, 0x7E, 0x03, 0xFE, 0x03, 0xF7, 0xE0, 0x3F, 0xE0,
  0x3F, 0x7E, 0x03, 0xFE, 0x07, 0xF7, 0xE0, 0x3F, 0xC0, 0x7F, 0x7E, 0x03,
  0xFC, 0x07, 0xE7, 0xE0, 0x1F, 0x80, 0x7E, 0x7C, 0x00, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x01, 0xF8, 0xFC, 0x00,
  0x00, 0x1F, 0x87, 0xC0, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x00, 0x3F, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x3F, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x07, 0xF0, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFE, 0xF8, 0x00, 0x01, 0xFE, 0x3E, 0x00,
  0x00, 0xFF, 0x1F, 0x80, 0x00, 0x7F, 0x87, 0xE0, 0x00, 0x3F, 0xC1, 0xF8,
  0x00, 0x1F, 0xE0, 0x7E, 0x00, 0x1F, 0xE0, 0x1F, 0x00, 0x0F, 0xF0, 0x0F,
  0xC0, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x0C, 0x00,
  0x3F, 0x00, 0x02, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x1F, 0xC0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00,
  0x1F, 0xC0, 0xFC, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x0E,
  0x00, 0x00, 0x1F, 0x80, 0x10, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x0C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x10, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x01, 0x00, 0x00, 0x03, 0xF0,
  0x18, 0x00, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00,
  0x1F, 0xC1, 0xFE, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x1F,
  0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x00,
  0x1F, 0x8F, 0x80, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x03, 0xE1, 0xF8,
  0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x7C, 0x00, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x01, 0xF8, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xF8, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x1F, 0xF0, 0x00,
  0x03, 0xE1, 0xFF, 0xF0, 0x00, 0x0F, 0x8F, 0xFF, 0xF0, 0x00, 0x3E, 0xFF,
  0xFF, 0xE0, 0x01, 0xF7, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x02, 0x00, 0x00, 0x07, 0xE0, 0x0C,
  0x00, 0x00, 0x3F, 0x80, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0xFF,
  0xC0, 0x3F, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0x81, 0xFE, 0x00, 0x0F, 0xC3, 0xFF, 0xF0, 0x03, 0xF1, 0xFF,
  0xFE, 0x01, 0xF8, 0xFF, 0xFF, 0xE0, 0x7E, 0xFF, 0xFF, 0xF8, 0x3F, 0x7E,
  0x01, 0xFF, 0x0F, 0xDC, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x03, 0xF9, 0xFF,
  0x00, 0x00, 0x7E, 0x7F, 0x80, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x03, 0xF7,
  0xF0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x01, 0xF9, 0xF0, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0x3F, 0x1F, 0x80,
  0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x07, 0xF0, 0x3F,
  0x80, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFF, 0xE3, 0xE0, 0x00, 0x00, 0xFE, 0x3E, 0x00, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0x1F, 0x87, 0xC0, 0x00,
  0x03, 0xF0, 0x7C, 0x00, 0x00, 0x7F, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x7C,
  0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x1F,
  0xC0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x1F, 0x81, 0xF0, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x7C, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFC, 0x03, 0xFE, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x00, 0x3F, 0x9F, 0x80, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x0F, 0xC7,
  0xF0, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0x80,
  0x7F, 0x80, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x07, 0xF9,
  0xF8, 0x00, 0x03, 0xFE, 0x7F, 0x00, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0xFF,
  0xC3, 0xFF, 0x01, 0xFB, 0xE0, 0x7F, 0xFF, 0xFD, 0xF8, 0x0F, 0xFF, 0xFE,
  0x7E, 0x01, 0xFF, 0xFE, 0x3F, 0x00, 0x3F, 0xFF, 0x0F, 0x80, 0x01, 0xFE,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xF8, 0x1F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0xC3, 0xFF, 0x07, 0xFE, 0x07, 0xF8,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF,
  0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xF8,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xF0, 0x3F, 0xE0, 0x3F, 0xE1, 0xFC, 0x00, 0x3F, 0x8F, 0xE0,
  0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0x1C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFC, 0x07, 0xFC, 0x00,
  0xFE, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00, 0x1F, 0x0F,
  0x80, 0x0F, 0xC1, 0xF0, 0xF8, 0x03, 0xFF, 0x1F, 0x1F, 0x80, 0x7F, 0xF1,
  0xF1, 0xF0, 0x0F, 0xFF, 0x9F, 0x1F, 0x01, 0xFF, 0xF9, 0xE1, 0xF0, 0x1F,
  0xC1, 0xFE, 0x3F, 0x03, 0xF0, 0x0F, 0xE3, 0xE0, 0x3F, 0x00, 0x7E, 0x3E,
  0x07, 0xE0, 0x03, 0xE3, 0xE0, 0x7E, 0x00, 0x3E, 0x3E, 0x07, 0xC0, 0x07,
  0xC7, 0xE0, 0xFC, 0x00, 0x7C, 0x7E, 0x0F, 0xC0, 0x07, 0xC7, 0xC0, 0xF8,
  0x00, 0x7C, 0x7C, 0x0F, 0x80, 0x07, 0xC7, 0xC1, 0xF8, 0x00, 0x7C, 0x7C,
  0x1F, 0x80, 0x0F, 0x87, 0xC1, 0xF8, 0x00, 0xF8, 0xFC, 0x1F, 0x80, 0x0F,
  0x8F, 0x81, 0xF0, 0x00, 0xF8, 0xF8, 0x1F, 0x00, 0x1F, 0x8F, 0x81, 0xF0,
  0x01, 0xF8, 0xF8, 0x1F, 0x80, 0x3F, 0x0F, 0x80, 0xF8, 0x07, 0xF0, 0xF8,
  0x0F, 0xC0, 0xFF, 0x0F, 0x80, 0xFE, 0x1D, 0xF0, 0xF8, 0x0F, 0xFF, 0xDF,
  0x0F, 0x80, 0x7F, 0xF9, 0xF0, 0xF8, 0x03, 0xFF, 0x3E, 0x0F, 0x80, 0x1F,
  0xE3, 0xE0, 0xF8, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x7D, 0xF0, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x0F, 0x9F, 0x80,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x0F,
  0xC3, 0xE0, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x3E, 0x00,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x7C, 0x00,
  0x00, 0x7C, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x81, 0xFC,
  0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x00, 0x3F, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0x80, 0x01, 0xFE, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x1F,
  0x80, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x7E, 0x00, 0x07, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00,
  0x0F, 0xE3, 0xF0, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x7E, 0x00, 0x03,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0x80, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x7E, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x01, 0xE0, 0xFC, 0x00, 0x00, 0x20, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0x01, 0xF8, 0x00, 0x00, 0x78, 0x3F, 0x00,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFE, 0x0F,
  0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x01, 0xFC,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x0F, 0xF8, 0x01,
  0xF8, 0x00, 0x3F, 0xC0, 0x1F, 0x80, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x1F, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0xFC, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0xF8, 0x00,
  0x00, 0x7E, 0x1F, 0x80, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0x7E, 0x1F,
  0x80, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x0F,
  0xC1, 0xF0, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x1F, 0xC3, 0xF0, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFE,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x03, 0xFC, 0x07, 0xE0, 0x00,
  0x7F, 0x80, 0x7E, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x3F, 0xC0,
  0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x0F, 0x87, 0xF0, 0x00, 0x01, 0xE0,
  0xFC, 0x00, 0x00, 0x20, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xFF,
  0xF3, 0xF0, 0x01, 0xFF, 0xFE, 0x7E, 0x00, 0x3F, 0xFF, 0xCF, 0xC0, 0x07,
  0xFF, 0xF9, 0xF8, 0x00, 0xFF, 0xFE, 0x3F, 0x00, 0x00, 0x07, 0xC7, 0xE0,
  0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x03,
  0xE1, 0xF8, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x3F, 0x81, 0xF8,
  0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x03, 0xBE, 0x03, 0xF8, 0x00, 0xE7, 0xC0,
  0x7F, 0xC0, 0x7D, 0xF8, 0x07, 0xFF, 0xFF, 0x3F, 0x00, 0x7F, 0xFF, 0xC7,
  0xE0, 0x07, 0xFF, 0xF0, 0xF8, 0x00, 0x7F, 0xFC, 0x1F, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0xF8, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x1F,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x20, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x01, 0x00, 0x00,
  0x7E, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x80,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x07, 0xF0, 0x07,
  0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0xFC,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x00, 0x03, 0xE0, 0x1F,
  0xC0, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x81, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xC7, 0xF8, 0x00, 0x00, 0x01, 0xF1, 0xFF, 0x00, 0x00, 0x00, 0x7E,
  0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xCF, 0xFE, 0x00, 0x00, 0x01, 0xFB, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFC, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x1F, 0x80,
  0x00, 0x00, 0xFF, 0xC1, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x3F, 0x00, 0x00,
  0x07, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0xC0, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x3F, 0xE0,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x0F,
  0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0xFB, 0xC0, 0x07, 0xDF, 0x00,
  0xFD, 0xF0, 0x03, 0xEF, 0x80, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x3E, 0x7C,
  0x01, 0xF3, 0xE0, 0x1F, 0x1E, 0x01, 0xF3, 0xF0, 0x0F, 0x8F, 0x81, 0xF1,
  0xF8, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x07, 0xE3, 0xE0, 0xF8, 0x7C, 0x03,
  0xF0, 0xF0, 0x7C, 0x3E, 0x01, 0xF0, 0x7C, 0x7C, 0x1F, 0x00, 0xF8, 0x3E,
  0x3E, 0x1F, 0x80, 0x7C, 0x1F, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F, 0x9E, 0x07,
  0xC0, 0x3F, 0x03, 0xDF, 0x03, 0xE0, 0x1F, 0x81, 0xFF, 0x01, 0xF0, 0x0F,
  0x80, 0xFF, 0x80, 0xF8, 0x07, 0xC0, 0x7F, 0x80, 0xFC, 0x03, 0xE0, 0x1F,
  0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x1F,
  0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x00, 0xE0, 0x07, 0xC0, 0x3E,
  0x00, 0x70, 0x07, 0xE0, 0x1F, 0x00, 0x30, 0x03, 0xF0, 0x0F, 0x80, 0x18,
  0x01, 0xF0, 0x0F, 0xC0, 0x08, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00,
  0x07, 0xC0, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x0F, 0x80, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3E, 0x01, 0xFF, 0x00, 0x00, 0xFC, 0x03,
  0xFE, 0x00, 0x01, 0xF8, 0x0F, 0xFC, 0x00, 0x03, 0xE0, 0x1F, 0xFC, 0x00,
  0x07, 0xC0, 0x3F, 0xF8, 0x00, 0x0F, 0x80, 0x7F, 0xF0, 0x00, 0x1F, 0x00,
  0xFB, 0xE0, 0x00, 0x7E, 0x01, 0xF7, 0xC0, 0x00, 0xFC, 0x07, 0xEF, 0xC0,
  0x01, 0xF0, 0x0F, 0xCF, 0x80, 0x03, 0xE0, 0x1F, 0x9F, 0x00, 0x07, 0xC0,
  0x3E, 0x3E, 0x00, 0x0F, 0x80, 0x7C, 0x7C, 0x00, 0x3F, 0x00, 0xF8, 0x7C,
  0x00, 0x7E, 0x03, 0xF0, 0xF8, 0x00, 0xF8, 0x07, 0xE1, 0xF0, 0x01, 0xF0,
  0x0F, 0xC3, 0xE0, 0x03, 0xE0, 0x1F, 0x07, 0xE0, 0x07, 0xC0, 0x3E, 0x07,
  0xC0, 0x1F, 0x80, 0x7C, 0x0F, 0x80, 0x3F, 0x01, 0xF8, 0x1F, 0x00, 0x7C,
  0x03, 0xF0, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x1F,
  0x80, 0xFC, 0x03, 0xF0, 0x3E, 0x01, 0xF8, 0x03, 0xE0, 0x7C, 0x03, 0xF0,
  0x07, 0xC0, 0xF8, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x0F, 0x80, 0x1F, 0x07,
  0xE0, 0x1F, 0x00, 0x3F, 0x0F, 0xC0, 0x7E, 0x00, 0x3E, 0x1F, 0x00, 0xFC,
  0x00, 0x7C, 0x3E, 0x01, 0xF8, 0x00, 0xF8, 0x7C, 0x03, 0xE0, 0x01, 0xF8,
  0xF8, 0x07, 0xC0, 0x01, 0xF3, 0xF0, 0x0F, 0x80, 0x03, 0xE7, 0xE0, 0x3F,
  0x00, 0x07, 0xCF, 0x80, 0x7E, 0x00, 0x0F, 0x9F, 0x00, 0xFC, 0x00, 0x1F,
  0xBE, 0x01, 0xF0, 0x00, 0x1F, 0x7C, 0x03, 0xE0, 0x00, 0x3F, 0xF8, 0x07,
  0xC0, 0x00, 0x7F, 0xF0, 0x1F, 0x80, 0x00, 0xFF, 0xC0, 0x3F, 0x00, 0x00,
  0xFF, 0x80, 0x7E, 0x00, 0x01, 0xFF, 0x00, 0xF8, 0x00, 0x03, 0xFE, 0x01,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F,
  0xC0, 0x0F, 0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x80,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x01,
  0xF1, 0xF8, 0x00, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x01, 0xF1, 0xF8, 0x00,
  0x00, 0x1F, 0x3F, 0x80, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x03,
  0xF7, 0xF0, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x00, 0x7F, 0x7E,
  0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x3F, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x3F,
  0x80, 0x07, 0xF0, 0x01, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x1F, 0xE0,
  0x0F, 0x80, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00,
  0x1F, 0xC1, 0xF8, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xFF, 0x01, 0xF8, 0x00, 0x0F,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F,
  0xC0, 0x0F, 0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x80,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x01,
  0xF1, 0xF8, 0x00, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x01, 0xF1, 0xF8, 0x00,
  0x00, 0x1F, 0x3F, 0x80, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x03,
  0xF7, 0xF0, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x00, 0x7F, 0x7E,
  0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x3F,
  0x80, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x01, 0x00, 0x00, 0x3F, 0x00, 0x38, 0x00, 0x01, 0xF8, 0x0F,
  0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x07,
  0xE7, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x3F, 0x01, 0xF0,
  0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x00, 0xFF, 0x01, 0xF8, 0x00, 0x0F, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x1F,
  0xC0, 0x7C, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x00, 0x78,
  0x0F, 0xC0, 0x00, 0x00, 0x40, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x0C, 0x00, 0x00,
  0x03, 0xF0, 0x38, 0x00, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x7E, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x3E,
  0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x1F, 0x81, 0xF0, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x7C, 0x00,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x00, 0x3F, 0x0F, 0x80,
  0x00, 0x01, 0xF8, 0x7C, 0x00, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x00, 0x3E, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x00, 0xFC, 0x1F, 0x00, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x0F, 0xDF, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC3,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00,
  0x00, 0x3E, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xF8, 0x07,
  0xE0, 0x7C, 0x01, 0xFE, 0x01, 0xF0, 0x1F, 0x00, 0xFF, 0x80, 0x7C, 0x07,
  0xC0, 0x3F, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0xF8, 0x07, 0xC0, 0x7C, 0x07,
  0xFE, 0x03, 0xF0, 0x1F, 0x01, 0xFF, 0x80, 0xF8, 0x07, 0xC0, 0x79, 0xE0,
  0x3E, 0x01, 0xF0, 0x3E, 0x78, 0x0F, 0x80, 0x7C, 0x0F, 0x9E, 0x07, 0xE0,
  0x3F, 0x03, 0xC7, 0x81, 0xF0, 0x0F, 0x81, 0xF1, 0xE0, 0x7C, 0x03, 0xE0,
  0x78, 0x78, 0x1F, 0x00, 0xF8, 0x3E, 0x1E, 0x0F, 0xC0, 0x3E, 0x0F, 0x87,
  0x83, 0xE0, 0x0F, 0x83, 0xC1, 0xE0, 0xF8, 0x03, 0xE1, 0xF0, 0x78, 0x3E,
  0x00, 0xF8, 0x7C, 0x1E, 0x1F, 0x80, 0x3E, 0x1E, 0x07, 0x87, 0xC0, 0x0F,
  0x8F, 0x81, 0xE1, 0xF0, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x00, 0xF1, 0xF0,
  0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x07, 0xCF, 0x80, 0x1F, 0x1E, 0x01, 0xF3,
  0xE0, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x00,
  0x7C, 0xF0, 0x07, 0xDF, 0x00, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x07, 0xDF,
  0x00, 0x7D, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0x7C, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xE0, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x7E, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xBF, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00,
  0x00, 0x3F, 0x87, 0xE0, 0x00, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x3F,
  0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x07, 0xF0, 0x00, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x07, 0xC1, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x00, 0x3E, 0xF8, 0x00, 0x00, 0x03, 0xE3, 0x80, 0x00, 0x00, 0x3D, 0x10,
  0x00, 0x00, 0x01, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x04, 0x1E, 0x3F, 0x0F, 0x87, 0xE1, 0xF0, 0xF8, 0x3E, 0x1F,
  0x07, 0x83, 0xE1, 0xF0, 0x78, 0x30, 0x00, 0x07, 0xF8, 0x07, 0xC0, 0x0F,
  0xFF, 0x83, 0xF0, 0x07, 0xFF, 0xF0, 0xFC, 0x03, 0xFF, 0xFE, 0x3F, 0x01,
  0xFF, 0xFF, 0xCF, 0xC0, 0xFF, 0x80, 0xFB, 0xE0, 0x7F, 0x80, 0x0E, 0xF8,
  0x3F, 0x80, 0x01, 0xFE, 0x0F, 0xC0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00,
  0x1F, 0x1F, 0x80, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x00, 0xFC, 0x7E, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x0F, 0x8F, 0xC0,
  0x00, 0x03, 0xE3, 0xF0, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0x7E, 0x3F,
  0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x01, 0xF0,
  0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F,
  0xC3, 0xF0, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0x80, 0x01,
  0xBE, 0x07, 0xE0, 0x00, 0xEF, 0x81, 0xFC, 0x00, 0x73, 0xE0, 0x3F, 0xC0,
  0xF9, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xF1, 0xFF, 0xFF, 0x0F, 0xFC, 0x3F,
  0xFF, 0x81, 0xFE, 0x07, 0xFF, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x1F, 0xE0, 0x00, 0x7C, 0x0F, 0xFF, 0x00, 0x1F, 0x87, 0xFF, 0xF8, 0x03,
  0xF1, 0xFF, 0xFF, 0x80, 0x7E, 0x7F, 0xFF, 0xF0, 0x0F, 0xCF, 0x81, 0xFF,
  0x01, 0xF3, 0xC0, 0x0F, 0xE0, 0x3E, 0xE0, 0x00, 0xFE, 0x0F, 0xD8, 0x00,
  0x0F, 0xC1, 0xFE, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x1F, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0x1F, 0x87,
  0xC0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00,
  0x7F, 0x03, 0xEE, 0x00, 0x1F, 0xE0, 0xFD, 0xF0, 0x1F, 0xF8, 0x1F, 0x9F,
  0xFF, 0xFE, 0x03, 0xF1, 0xFF, 0xFF, 0x80, 0x7E, 0x1F, 0xFF, 0xE0, 0x0F,
  0x81, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xF8, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x3F, 0x1F, 0xC0, 0x00,
  0x1E, 0x1F, 0x80, 0x00, 0x10, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x10, 0xFC, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x07,
  0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xE0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF8,
  0x07, 0xE0, 0x00, 0x7F, 0xFC, 0x1F, 0x80, 0x07, 0xFF, 0xF8, 0x7C, 0x00,
  0x3F, 0xFF, 0xF1, 0xF0, 0x01, 0xFF, 0xFF, 0xE7, 0xC0, 0x0F, 0xF8, 0x07,
  0x9F, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x07,
  0xC0, 0x7E, 0x00, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x3E,
  0x03, 0xF0, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x03, 0xF8,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0xFC, 0x00,
  0x03, 0x7C, 0x01, 0xF8, 0x00, 0x1F, 0xF0, 0x07, 0xE0, 0x00, 0xEF, 0xC0,
  0x1F, 0xC0, 0x07, 0x3F, 0x00, 0x3F, 0xC0, 0x7C, 0xFC, 0x00, 0xFF, 0xFF,
  0xE3, 0xE0, 0x01, 0xFF, 0xFF, 0x0F, 0x80, 0x03, 0xFF, 0xF8, 0x7E, 0x00,
  0x07, 0xFF, 0xC1, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x1F, 0x8F,
  0xE0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x01, 0xFC,
  0xFC, 0x00, 0x03, 0xFC, 0x7E, 0x00, 0x0F, 0xFC, 0x3F, 0x01, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x08, 0x3F, 0x00, 0x00,
  0x07, 0x0F, 0x80, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x07, 0xF3, 0xF0, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0x1F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x80,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x3F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x01, 0xF8, 0x00, 0x3F, 0xFE, 0x0F,
  0xC0, 0x07, 0xFF, 0xF8, 0x7C, 0x00, 0x7F, 0xFF, 0xE3, 0xE0, 0x07, 0xFF,
  0xFF, 0x9F, 0x00, 0x7F, 0xC0, 0x7D, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0xC0,
  0x7F, 0x00, 0x01, 0xFE, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x1F,
  0x03, 0xF0, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0xFC, 0x00,
  0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x00, 0xFE,
  0x01, 0xF8, 0x00, 0x0D, 0xF0, 0x0F, 0xE0, 0x00, 0xEF, 0x80, 0x7F, 0x00,
  0x1E, 0xFC, 0x01, 0xFE, 0x03, 0xE7, 0xE0, 0x0F, 0xFF, 0xFE, 0x3E, 0x00,
  0x3F, 0xFF, 0xF1, 0xF0, 0x00, 0xFF, 0xFE, 0x0F, 0x80, 0x03, 0xFF, 0xE0,
  0xFC, 0x00, 0x03, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x20, 0x00,
  0x07, 0xF0, 0x01, 0x80, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x07, 0xF8, 0x01,
  0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x1F, 0xE0, 0x01, 0xF8, 0x3F, 0xFC, 0x00, 0xFC, 0x3F, 0xFF, 0x00, 0x7C,
  0x3F, 0xFF, 0xC0, 0x3E, 0x3F, 0xFF, 0xE0, 0x3F, 0x3E, 0x07, 0xF8, 0x1F,
  0x9C, 0x01, 0xFC, 0x0F, 0xDC, 0x00, 0x7F, 0x07, 0xFC, 0x00, 0x1F, 0x83,
  0xFC, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x03, 0xF0,
  0xFE, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03,
  0xF0, 0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x1F, 0x87, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07, 0xC3, 0xF0, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x00, 0xFC, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3E, 0x1F, 0x80,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x0C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x7C, 0x03, 0xFC, 0x00,
  0x7C, 0x07, 0xF8, 0x00, 0x7C, 0x0F, 0xF0, 0x00, 0xFC, 0x1F, 0xC0, 0x00,
  0xFC, 0x3F, 0x80, 0x00, 0xF8, 0x7F, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x02, 0x00, 0x07, 0xE0, 0x03, 0x80, 0x03, 0xF0, 0x03, 0xE0, 0x01,
  0xF0, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x3F, 0x80,
  0x7E, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0xFE,
  0x0F, 0x80, 0x00, 0x3F, 0x87, 0xC0, 0x00, 0x1F, 0xE3, 0xE0, 0x00, 0x07,
  0xFB, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x07, 0xFF, 0x80, 0x03, 0xF0, 0xFF,
  0xFC, 0x00, 0x3E, 0x1F, 0xFF, 0xE0, 0x03, 0xE3, 0xFF, 0xFF, 0x00, 0x7E,
  0x7C, 0x0F, 0xF0, 0x07, 0xEF, 0x00, 0x3F, 0x80, 0x7E, 0xE0, 0x01, 0xF8,
  0x07, 0xFC, 0x00, 0x1F, 0x80, 0x7D, 0x80, 0x01, 0xF8, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0xFE, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x0F, 0x80, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F,
  0xE0, 0x01, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0x83, 0xFF, 0x00, 0x01, 0xF0,
  0xFF, 0x80, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x83, 0xF0, 0x3F, 0x00, 0x0C, 0x3F, 0x03, 0xF0,
  0x01, 0xE3, 0xE0, 0x1F, 0x80, 0x3F, 0x3E, 0x01, 0xF8, 0x07, 0xF7, 0xE0,
  0x0F, 0x80, 0xFE, 0x7E, 0x00, 0xFC, 0x1F, 0xC7, 0xE0, 0x0F, 0xC3, 0xF8,
  0x7E, 0x00, 0x7E, 0x7F, 0x07, 0xC0, 0x07, 0xFF, 0xE0, 0x7C, 0x00, 0x3F,
  0xFC, 0x0F, 0xC0, 0x03, 0xFF, 0x80, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x30, 0x0F, 0xC0, 0x03,
  0xC0, 0x7E, 0x00, 0x3F, 0x03, 0xE0, 0x07, 0xF8, 0x1F, 0x00, 0x7F, 0x01,
  0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x7F, 0x00, 0x7E, 0x07, 0xF0, 0x03, 0xE0,
  0x7F, 0x00, 0x1F, 0x0F, 0xF0, 0x01, 0xF8, 0xFF, 0x00, 0x0F, 0xCF, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0xF8, 0x03, 0xF0,
  0x07, 0xC7, 0xF8, 0x1F, 0xF0, 0x0F, 0x9F, 0xF8, 0x7F, 0xF0, 0x3F, 0x7F,
  0xF9, 0xFF, 0xF0, 0x7C, 0xFF, 0xF3, 0xFF, 0xE0, 0xFB, 0x87, 0xEF, 0x0F,
  0xC1, 0xF6, 0x07, 0xFC, 0x0F, 0x83, 0xF8, 0x0F, 0xF0, 0x1F, 0x07, 0xE0,
  0x1F, 0xC0, 0x3E, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x3F, 0x00, 0x7E, 0x00,
  0xF8, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0x03, 0xE1, 0xF0,
  0x03, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC0, 0x1F, 0x0F, 0xC0, 0x1F, 0x80,
  0x3E, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0x07, 0xE1, 0xF0, 0x03, 0xE0,
  0x0F, 0x87, 0xE0, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8,
  0x03, 0xF0, 0xF8, 0x03, 0xF0, 0x07, 0xC3, 0xF0, 0x07, 0xC0, 0x0F, 0x87,
  0xC0, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x7C, 0x01, 0xF8, 0x03, 0xE1,
  0xF8, 0x03, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC0, 0x0F, 0x87, 0xC0, 0x0F,
  0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0xE0,
  0x01, 0xF8, 0x3F, 0xFC, 0x00, 0xF8, 0x3F, 0xFF, 0x00, 0x7C, 0x3F, 0xFF,
  0xC0, 0x3E, 0x3F, 0xFF, 0xE0, 0x3F, 0x3E, 0x07, 0xF8, 0x1F, 0x9C, 0x01,
  0xFC, 0x0F, 0xDC, 0x00, 0x7F, 0x07, 0xFC, 0x00, 0x1F, 0x83, 0xEC, 0x00,
  0x0F, 0xC1, 0xFC, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x03, 0xF0, 0xFE, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0xF8,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x87,
  0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFC,
  0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0,
  0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0x8F, 0xC0,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFB,
  0xE0, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x3F,
  0x7C, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x1F,
  0x8F, 0xC0, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x0F,
  0xE0, 0x7E, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7C, 0x03, 0xFC, 0x00, 0x01,
  0xF0, 0x3F, 0xFC, 0x00, 0x0F, 0xC3, 0xFF, 0xFC, 0x00, 0x3F, 0x1F, 0xFF,
  0xF8, 0x00, 0xFC, 0xFF, 0xFF, 0xE0, 0x03, 0xF3, 0xE0, 0x7F, 0xC0, 0x0F,
  0x9E, 0x00, 0x7F, 0x00, 0x3E, 0xE0, 0x00, 0xFE, 0x01, 0xFB, 0x00, 0x01,
  0xF8, 0x07, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x0F, 0x80, 0x7F,
  0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x1F,
  0x80, 0xF8, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0xFC,
  0x07, 0xC0, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x03, 0xEE, 0x00,
  0x1F, 0xE0, 0x1F, 0xBE, 0x03, 0xFF, 0x00, 0x7E, 0x7F, 0xFF, 0xF8, 0x01,
  0xF8, 0xFF, 0xFF, 0xC0, 0x07, 0xE1, 0xFF, 0xFE, 0x00, 0x1F, 0x03, 0xFF,
  0xE0, 0x00, 0x7C, 0x03, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x07, 0xE0, 0x03, 0xFF, 0xE0, 0xFC, 0x01, 0xFF, 0xFE, 0x1F, 0x00, 0x7F,
  0xFF, 0xE3, 0xE0, 0x1F, 0xFF, 0xFE, 0x7C, 0x07, 0xFC, 0x03, 0xDF, 0x81,
  0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0x00, 0x01, 0xFE, 0x0F, 0xC0, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x3F, 0x1F, 0x80,
  0x00, 0x07, 0xC3, 0xF0, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0x1F, 0x0F,
  0xC0, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x1F,
  0x8F, 0xC0, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00,
  0x0F, 0x87, 0xE0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFE, 0x0F,
  0xC0, 0x00, 0x37, 0xC0, 0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0x80, 0x03, 0xBF,
  0x03, 0xF8, 0x00, 0xF7, 0xE0, 0x3F, 0xC0, 0x7C, 0xF8, 0x07, 0xFF, 0xFF,
  0x1F, 0x00, 0x7F, 0xFF, 0xC3, 0xE0, 0x07, 0xFF, 0xF0, 0xFC, 0x00, 0x7F,
  0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFB, 0xFF, 0xFC, 0x7F, 0xFE, 0xFF, 0xFF,
  0x3F, 0xFF, 0x80, 0x0F, 0x9F, 0x00, 0x00, 0x03, 0xE7, 0x00, 0x00, 0x00,
  0xFB, 0x80, 0x00, 0x00, 0x7E, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0x00,
  0x03, 0xF0, 0x1F, 0x80, 0x00, 0x3C, 0x03, 0xF0, 0x00, 0x03, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x80, 0x00,
  0x01, 0xF0, 0x78, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F, 0x87, 0xFC,
  0x00, 0x07, 0xF0, 0x3F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x08, 0x01, 0xF8, 0x00, 0x18, 0x01, 0xF0,
  0x00, 0x7C, 0x01, 0xF0, 0x00, 0xFE, 0x03, 0xF0, 0x03, 0xFE, 0x03, 0xF0,
  0x07, 0xF8, 0x03, 0xF0, 0x1F, 0xF0, 0x03, 0xF0, 0x3F, 0xE0, 0x03, 0xE0,
  0xFF, 0x80, 0x03, 0xE1, 0xFF, 0x00, 0x03, 0xF7, 0xFC, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xC0,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x00, 0xF8, 0x3E,
  0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE1,
  0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F,
  0x0F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03,
  0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00,
  0xFE, 0x0F, 0xC0, 0x00, 0xFF, 0x07, 0xE0, 0x00, 0xDF, 0x83, 0xF8, 0x00,
  0xEF, 0xC1, 0xFC, 0x00, 0xE7, 0xC0, 0x7F, 0x81, 0xF3, 0xE0, 0x3F, 0xFF,
  0xF3, 0xF0, 0x0F, 0xFF, 0xF1, 0xF8, 0x03, 0xFF, 0xF0, 0xFC, 0x00, 0xFF,
  0xF0, 0x7E, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x06, 0x7F,
  0xFC, 0x00, 0x1F, 0xBF, 0xFE, 0x00, 0x0F, 0xDF, 0xFF, 0x00, 0x03, 0xEF,
  0xFF, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00,
  0xF8, 0x1F, 0x80, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xC0, 0x00,
  0x3F, 0x03, 0xE0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x3E, 0x00,
  0x03, 0xF0, 0x1F, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x01, 0xF8, 0x07, 0xC0,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xFE, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0x3E,
  0x01, 0xFF, 0x00, 0x1F, 0x03, 0xFF, 0x00, 0x0F, 0x8F, 0xFE, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x00,
  0x30, 0x7C, 0x00, 0xF8, 0x0F, 0x83, 0xE0, 0x07, 0xC0, 0x7C, 0x1F, 0x00,
  0x3E, 0x03, 0xE0, 0xF8, 0x01, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x00, 0x7C,
  0x3E, 0x00, 0xF8, 0x03, 0xE3, 0xE0, 0x07, 0xC0, 0x1F, 0x1F, 0x00, 0x3E,
  0x00, 0xF8, 0xF8, 0x01, 0xF0, 0x07, 0xC7, 0xC0, 0x0F, 0x80, 0x3E, 0x3E,
  0x00, 0xF8, 0x01, 0xF1, 0xF0, 0x07, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x00,
  0x7C, 0xF8, 0x01, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x80, 0x1F, 0x3E, 0x00,
  0x7C, 0x00, 0xF9, 0xF0, 0x07, 0xC0, 0x07, 0xCF, 0x80, 0x3E, 0x00, 0x3E,
  0xF8, 0x01, 0xF0, 0x03, 0xF7, 0xC0, 0x0F, 0x80, 0x1F, 0x3E, 0x00, 0x7C,
  0x00, 0xF9, 0xF0, 0x07, 0xE0, 0x07, 0xCF, 0x80, 0x3E, 0x00, 0x7E, 0x7C,
  0x01, 0xF0, 0x03, 0xE3, 0xE0, 0x0F, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0x01,
  0xF9, 0xF0, 0x07, 0xE0, 0x0F, 0x8F, 0x80, 0x3F, 0x00, 0xFC, 0x7C, 0x03,
  0xF8, 0x07, 0xE3, 0xE0, 0x1B, 0xC0, 0x7E, 0x1F, 0x81, 0xDE, 0x07, 0xE0,
  0xFE, 0x3C, 0xF8, 0x7F, 0x07, 0xFF, 0xE7, 0xFF, 0xF0, 0x1F, 0xFE, 0x3F,
  0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x07,
  0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x7F,
  0xFE, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xCF, 0x8F, 0x87, 0xF0,
  0x3F, 0xC3, 0xE7, 0xC0, 0xFC, 0x3F, 0xC0, 0xF9, 0xE0, 0x1F, 0x1F, 0xE0,
  0x3E, 0x70, 0x07, 0xC3, 0xE0, 0x0F, 0xBC, 0x01, 0xF0, 0xF0, 0x01, 0xEE,
  0x00, 0x7C, 0x10, 0x00, 0x7B, 0x80, 0x1F, 0x00, 0x00, 0x1E, 0xC0, 0x07,
  0xC0, 0x00, 0x07, 0xF0, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xC0, 0x0E, 0xF0,
  0x00, 0x81, 0xF0, 0x07, 0xBC, 0x00, 0xF0, 0xFC, 0x01, 0xCF, 0x00, 0x7E,
  0x3F, 0x00, 0xF3, 0xC0, 0x7F, 0x07, 0xC0, 0x3C, 0xF0, 0x3F, 0x81, 0xF0,
  0x1E, 0x3E, 0x3F, 0xC0, 0x7E, 0x1F, 0x8F, 0x9F, 0xE0, 0x1F, 0xFF, 0xC3,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x03, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x3E, 0x00,
  0x00, 0x7C, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00,
  0x7C, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x7E,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x03, 0xF8,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x01, 0xFE, 0x00, 0xFC, 0x00,
  0x1F, 0xF0, 0x07, 0xF0, 0x01, 0xDF, 0x80, 0x1F, 0xC0, 0x1C, 0xFC, 0x00,
  0xFF, 0x03, 0xE7, 0xC0, 0x07, 0xFF, 0xFE, 0x3E, 0x00, 0x1F, 0xFF, 0xE3,
  0xF0, 0x00, 0x7F, 0xFE, 0x1F, 0x80, 0x01, 0xFF, 0xE0, 0xFC, 0x00, 0x03,
  0xFC, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x20, 0x00, 0x07, 0xE0, 0x03,
  0x80, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x03, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0x01, 0xFF,
  0xFF, 0x83, 0xE0, 0x3F, 0xFF, 0xFE, 0x3E, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7E, 0x07, 0xFF, 0xFE, 0x0F, 0xC0, 0x07, 0xFF, 0xE0, 0xF8, 0x00, 0x1F,
  0xFC, 0x0F, 0x00, 0x00, 0x7F, 0x81, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0x00,
  0x00, 0xFC, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x0E, 0x00, 0x07, 0xF0, 0x03,
  0xE0, 0x00, 0xFE, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x83,
  0xFF, 0x00, 0x00, 0xF8, 0x7F, 0xFF, 0x00, 0x0F, 0x8F, 0xFF, 0xFF, 0x80,
  0xF8, 0xFC, 0xFF, 0xFF, 0x8F, 0x8F, 0xC1, 0xFF, 0xFF, 0xF8, 0xFC, 0x03,
  0xFF, 0xFF, 0x8F, 0x80, 0x07, 0xFF, 0xF0, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x60, 0x07, 0xFC, 0x00, 0x03, 0xC0, 0x7F, 0xF0,
  0x00, 0x3E, 0x07, 0xFF, 0xC0, 0x01, 0xF0, 0x7F, 0xFF, 0x00, 0x1F, 0x07,
  0xE1, 0xF8, 0x00, 0xF8, 0x3E, 0x07, 0xE0, 0x07, 0xC3, 0xE0, 0x1F, 0x00,
  0x7C, 0x1F, 0x00, 0xFC, 0x07, 0xE1, 0xF0, 0x03, 0xF0, 0x3E, 0x0F, 0x80,
  0x0F, 0xC7, 0xE0, 0xF8, 0x00, 0x7F, 0xFF, 0x07, 0xC0, 0x01, 0xFF, 0xF0,
  0x3C, 0x00, 0x07, 0xFF, 0x03, 0xE0, 0x00, 0x1F, 0xF0, 0x03, 0x00, 0x00,
  0x3E, 0x00,
};

const GFXglyph IBMPlexMono_Italic71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 43, 0, -1 },
  { 1, 16, 51, 43, 14, -50 },
  { 103, 21, 20, 43, 15, -53 },
  { 156, 43, 50, 43, 1, -50 },
  { 425, 40, 65, 43, 2, -57 },
  { 750, 49, 51, 43, -2, -50 },
  { 1063, 42, 51, 43, 0, -50 },
  { 1331, 9, 20, 43, 21, -53 },
  { 1354, 26, 64, 43, 15, -54 },
  { 1562, 26, 64, 43, 3, -54 },
  { 1770, 36, 35, 43, 4, -39 },
  { 1928, 34, 35, 43, 5, -39 },
  { 2077, 16, 20, 43, 10, -10 },
  { 2117, 21, 5, 43, 11, -24 },
  { 2131, 10, 10, 43, 14, -9 },
  { 2144, 40, 64, 43, 2, -54 },
  { 2464, 36, 51, 43, 4, -50 },
  { 2694, 34, 50, 43, 3, -50 },
  { 2907, 37, 50, 43, 2, -50 },
  { 3139, 37, 51, 43, 2, -50 },
  { 3375, 38, 50, 43, 1, -50 },
  { 3613, 38, 51, 43, 3, -50 },
  { 3856, 34, 51, 43, 4, -50 },
  { 4073, 36, 50, 43, 7, -50 },
  { 4298, 37, 51, 43, 3, -50 },
  { 4534, 34, 50, 43, 6, -50 },
  { 4747, 15, 38, 43, 14, -37 },
  { 4819, 19, 47, 43, 10, -37 },
  { 4931, 34, 41, 43, 6, -42 },
  { 5106, 36, 19, 43, 4, -31 },
  { 5192, 35, 41, 43, 3, -42 },
  { 5372, 30, 51, 43, 9, -50 },
  { 5564, 36, 58, 43, 4, -50 },
  { 5825, 38, 50, 43, -1, -50 },
  { 6063, 36, 50, 43, 3, -50 },
  { 6288, 35, 51, 43, 6, -50 },
  { 6512, 36, 50, 43, 4, -50 },
  { 6737, 39, 50, 43, 3, -50 },
  { 6981, 40, 50, 43, 3, -50 },
  { 7231, 35, 51, 43, 5, -50 },
  { 7455, 39, 50, 43, 3, -50 },
  { 7699, 39, 50, 43, 3, -50 },
  { 7943, 35, 51, 43, 4, -50 },
  { 8167, 43, 50, 43, 3, -50 },
  { 8436, 30, 50, 43, 6, -50 },
  { 8624, 41, 50, 43, 2, -50 },
  { 8881, 39, 50, 43, 3, -50 },
  { 9125, 36, 51, 43, 4, -50 },
  { 9355, 38, 50, 43, 3, -50 },
  { 9593, 36, 63, 43, 4, -50 },
  { 9877, 38, 50, 43, 3, -50 },
  { 10115, 39, 51, 43, 2, -50 },
  { 10364, 40, 50, 43, 6, -50 },
  { 10614, 37, 51, 43, 5, -50 },
  { 10850, 37, 50, 43, 8, -50 },
  { 11082, 42, 50, 43, 3, -50 },
  { 11345, 47, 50, 43, -1, -50 },
  { 11639, 41, 50, 43, 6, -50 },
  { 11896, 43, 50, 43, 0, -50 },
  { 12165, 31, 64, 43, 11, -54 },
  { 12413, 18, 64, 43, 13, -54 },
  { 12557, 30, 64, 43, 1, -54 },
  { 12797, 36, 29, 43, 5, -50 },
  { 12928, 35, 5, 43, 0, 7 },
  { 12950, 9, 14, 43, 16, -56 },
  { 12966, 34, 38, 43, 4, -37 },
  { 13128, 35, 54, 43, 4, -53 },
  { 13365, 32, 38, 43, 5, -37 },
  { 13517, 38, 54, 43, 4, -53 },
  { 13774, 33, 38, 43, 5, -37 },
  { 13931, 47, 68, 43, -1, -53 },
  { 14331, 37, 52, 43, 2, -37 },
  { 14572, 33, 53, 43, 4, -53 },
  { 14791, 32, 54, 43, 6, -53 },
  { 15007, 33, 68, 43, 4, -53 },
  { 15288, 36, 54, 43, 4, -53 },
  { 15531, 29, 54, 43, 8, -53 },
  { 15727, 39, 37, 43, 1, -37 },
  { 15908, 33, 37, 43, 4, -37 },
  { 16061, 33, 38, 43, 5, -37 },
  { 16218, 38, 51, 43, 1, -37 },
  { 16461, 35, 51, 43, 4, -37 },
  { 16685, 34, 37, 43, 8, -37 },
  { 16843, 35, 38, 43, 3, -37 },
  { 17010, 32, 51, 43, 6, -50 },
  { 17214, 33, 38, 43, 6, -37 },
  { 17371, 33, 38, 43, 5, -37 },
  { 17528, 37, 38, 43, 3, -37 },
  { 17704, 42, 38, 43, 0, -37 },
  { 17904, 37, 52, 43, 2, -37 },
  { 18145, 36, 38, 43, 4, -37 },
  { 18316, 33, 64, 43, 8, -54 },
  { 18580, 16, 64, 43, 14, -54 },
  { 18708, 33, 64, 43, 3, -54 },
  { 18972, 37, 16, 43, 3, -29 },
};

const GFXfont IBMPlexMono_Italic71pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic71pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic71pt7bGlyphs,
  0x20, 0x7E, 92
};

#endif // _IBMPLEXMONO_ITALIC71PT7B_H_
