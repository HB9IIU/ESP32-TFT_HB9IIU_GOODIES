#ifndef _IBMPLEXMONO_ITALIC44PT7B_H_
#define _IBMPLEXMONO_ITALIC44PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x00,
  0xC0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x07, 0xE1, 0xF8,
  0xFE, 0x3F, 0x07, 0xC0, 0x3C, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0xF3, 0x87,
  0x3C, 0x39, 0xE1, 0xCE, 0x0E, 0x70, 0x73, 0x87, 0x9C, 0x39, 0xE1, 0xC0,
  0x00, 0x0F, 0x0F, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x78,
  0x78, 0x00, 0x1C, 0x1C, 0x00, 0x0F, 0x07, 0x00, 0x03, 0x83, 0x80, 0x00,
  0xE0, 0xE0, 0x00, 0x78, 0x38, 0x07, 0xFC, 0x1F, 0xF1, 0xFF, 0x07, 0xFC,
  0x7F, 0xC1, 0xFF, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x1E, 0x0E,
  0x00, 0x07, 0x07, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x38,
  0x3C, 0x03, 0xFE, 0x0F, 0xF8, 0xFF, 0x83, 0xFE, 0x3F, 0xC1, 0xFF, 0x80,
  0x70, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0F, 0x00, 0x03, 0x83, 0x80,
  0x00, 0xE0, 0xE0, 0x00, 0x70, 0x78, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x07,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF8, 0x0F, 0xCE, 0x7E, 0x07, 0x87, 0x0F, 0x07, 0x83, 0x83,
  0xC3, 0xC1, 0xC0, 0x81, 0xC0, 0xC0, 0x01, 0xE0, 0x60, 0x00, 0xF0, 0x30,
  0x00, 0x38, 0x38, 0x00, 0x1E, 0x1C, 0x00, 0x0F, 0x8E, 0x00, 0x03, 0xF6,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x71, 0xF0, 0x00, 0x30, 0x78, 0x00, 0x18, 0x3C, 0x00,
  0x0C, 0x0E, 0x00, 0x0E, 0x07, 0x80, 0x07, 0x03, 0x80, 0x03, 0x83, 0xC3,
  0x01, 0xC1, 0xE3, 0xC0, 0xC1, 0xE0, 0xF8, 0x61, 0xF0, 0x7E, 0x73, 0xF0,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x3C, 0x07, 0xFC, 0x00, 0xE0, 0x3F, 0xF0, 0x07, 0x01, 0xE1, 0xE0,
  0x38, 0x07, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x00, 0xE0, 0x38, 0x38,
  0x03, 0x80, 0xE1, 0xE0, 0x0E, 0x03, 0x87, 0x00, 0x38, 0x1E, 0x38, 0x00,
  0xE0, 0x71, 0xE0, 0x03, 0xC3, 0xC7, 0x00, 0x07, 0xFE, 0x38, 0x00, 0x1F,
  0xF1, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x07, 0x1F, 0xF8, 0x00, 0x38, 0xF0,
  0xF0, 0x01, 0xC3, 0x81, 0xC0, 0x07, 0x1C, 0x07, 0x00, 0x38, 0x70, 0x1C,
  0x01, 0xC1, 0xC0, 0x70, 0x0F, 0x07, 0x01, 0xC0, 0x38, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x38, 0x0F, 0x01, 0xC0, 0xE0, 0x38, 0x07, 0x87, 0x01, 0xC0,
  0x0F, 0xFC, 0x0E, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xC3, 0xE0, 0x01,
  0xE0, 0x38, 0x00, 0x70, 0x0F, 0x00, 0x1C, 0x03, 0xC0, 0x0F, 0x00, 0xF0,
  0x03, 0xC0, 0x3C, 0x00, 0x70, 0x0F, 0x00, 0x1C, 0x03, 0xC0, 0x07, 0x80,
  0xE0, 0x00, 0xE0, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1F, 0x1E, 0x00, 0x3F,
  0xFF, 0x00, 0x1E, 0x7E, 0x00, 0x0F, 0x0E, 0x00, 0x07, 0x83, 0xC0, 0x01,
  0xC0, 0x70, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x03, 0xC0, 0x0F, 0x00, 0xF0,
  0x03, 0xC0, 0x1E, 0x04, 0xF0, 0x07, 0x81, 0xFC, 0x01, 0xF0, 0xEF, 0x00,
  0xFC, 0x79, 0xC0, 0x77, 0x9C, 0x7C, 0x39, 0xEF, 0x0F, 0xFC, 0x3F, 0x81,
  0xFF, 0x0F, 0xC0, 0x3F, 0x00, 0xE0, 0x39, 0xCE, 0xF7, 0xB9, 0xCE, 0x77,
  0xBD, 0xC0, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x38, 0x1E,
  0x06, 0x7E, 0x38, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0x1F, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x80, 0x01, 0xE7, 0x00,
  0x07, 0x8F, 0x00, 0x1E, 0x0E, 0x00, 0x78, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0x80, 0x18, 0x01, 0x00, 0x20, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0xC3, 0xE0, 0xF8, 0x7C, 0x1E, 0x0F, 0x83, 0xC0, 0xF0,
  0x78, 0x1C, 0x07, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3C, 0xFD,
  0xFF, 0xF7, 0xCF, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80,
  0x3F, 0xFF, 0x01, 0xF0, 0x3E, 0x0F, 0x80, 0x78, 0x3C, 0x00, 0xE1, 0xE0,
  0x03, 0xC7, 0x00, 0x0F, 0x3C, 0x00, 0x1C, 0xE0, 0x00, 0x77, 0x80, 0x01,
  0xDE, 0x00, 0x07, 0x78, 0x00, 0x3D, 0xC1, 0xE0, 0xFF, 0x0F, 0xC3, 0xFC,
  0x3F, 0x0F, 0xF0, 0xF8, 0x3F, 0xC1, 0xE0, 0xEF, 0x00, 0x07, 0xB8, 0x00,
  0x1E, 0xE0, 0x00, 0x7B, 0x80, 0x01, 0xCE, 0x00, 0x0F, 0x38, 0x00, 0x3C,
  0xE0, 0x00, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x3C, 0x1E, 0x01, 0xE0, 0x7C,
  0x1F, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xEF, 0x00, 0x3E, 0x78, 0x03,
  0xE3, 0xC0, 0x3E, 0x1C, 0x03, 0xE0, 0xE0, 0x3E, 0x0F, 0x00, 0xE0, 0x78,
  0x02, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0x03, 0xE0, 0x7C, 0x03, 0xE1, 0xF0,
  0x03, 0xC3, 0xC0, 0x07, 0x83, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x1F,
  0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x60, 0x03, 0xC0, 0x40, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x40, 0x00, 0xF3, 0xC0, 0x03, 0xC7, 0xC0, 0x0F, 0x87, 0xE0,
  0x7E, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0xF7, 0x80, 0x03, 0xCE, 0x00, 0x0F, 0x1C, 0x00, 0x1C, 0x38,
  0x00, 0x78, 0xF0, 0x01, 0xE1, 0xE0, 0x07, 0x83, 0xC0, 0x1E, 0x07, 0x00,
  0x38, 0x0E, 0x00, 0xF0, 0x1C, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x3C,
  0x01, 0xE0, 0x70, 0x03, 0x81, 0xE0, 0x07, 0x07, 0x80, 0x0E, 0x1E, 0x00,
  0x3C, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE3, 0xF0, 0x03, 0xDF, 0xF8, 0x07, 0x7F, 0xF8, 0x0F,
  0xC0, 0xF8, 0x1E, 0x00, 0xF8, 0x08, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x60, 0x01, 0xE1, 0xC0, 0x03, 0xC7, 0xC0, 0x0F,
  0x07, 0xE0, 0x7C, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC7, 0xF0, 0x1E, 0xFF,
  0xE1, 0xEF, 0xFF, 0x8F, 0xE0, 0x7C, 0x7C, 0x01, 0xF7, 0xC0, 0x07, 0xBE,
  0x00, 0x1D, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3B, 0x80, 0x01,
  0xDC, 0x00, 0x1E, 0xE0, 0x00, 0xF7, 0x00, 0x0F, 0x3C, 0x00, 0x78, 0xF0,
  0x07, 0x87, 0xC0, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0xFE, 0x00,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x00,
  0x0F, 0x70, 0x00, 0x7B, 0x80, 0x07, 0x9C, 0x00, 0x78, 0xE0, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x3F, 0x03, 0xE0, 0x78, 0x03,
  0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x1E,
  0x3C, 0x00, 0x3C, 0x78, 0x00, 0x70, 0x70, 0x01, 0xE0, 0xF0, 0x07, 0x80,
  0xF0, 0x3E, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x3E,
  0x03, 0xE0, 0xF0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x00, 0x03, 0x9E, 0x00,
  0x07, 0x3C, 0x00, 0x0F, 0x78, 0x00, 0x1C, 0xF0, 0x00, 0x79, 0xE0, 0x00,
  0xF3, 0xC0, 0x03, 0xE7, 0xC0, 0x0F, 0x87, 0xE0, 0x7E, 0x07, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFC, 0x03,
  0xFF, 0xF0, 0x3E, 0x07, 0xC3, 0xE0, 0x0F, 0x3C, 0x00, 0x39, 0xE0, 0x01,
  0xDE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0x78, 0x00, 0xFB, 0xE0, 0x0F, 0xCF, 0x81, 0xFE,
  0x3F, 0xFD, 0xE0, 0xFF, 0xCF, 0x01, 0xF8, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0x83, 0xF0, 0xFC, 0x7F, 0x1F, 0x83, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC1, 0xF8, 0x7E, 0x3F, 0x87, 0xC1, 0xF0, 0x01, 0xE0,
  0x3F, 0x03, 0xF0, 0x7F, 0x07, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x03,
  0xC0, 0x78, 0x07, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01,
  0xC0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x80, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE0, 0x08, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0xC1, 0xFF, 0xF8, 0xF8, 0x3E,
  0x78, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1D, 0x80, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x0F,
  0xE0, 0x1F, 0xF0, 0x07, 0xF0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xF0, 0x3C,
  0x0F, 0x00, 0x78, 0x78, 0x00, 0xE1, 0xC0, 0x03, 0xC7, 0x00, 0x07, 0x38,
  0x00, 0x1C, 0xE0, 0x3C, 0x77, 0x83, 0xF9, 0xDC, 0x1F, 0xFE, 0x70, 0xF8,
  0x79, 0xC3, 0xC1, 0xE7, 0x0E, 0x03, 0xBC, 0x78, 0x0E, 0xF1, 0xC0, 0x3B,
  0x87, 0x01, 0xCE, 0x1C, 0x07, 0x38, 0xF0, 0x1C, 0xE3, 0xC0, 0x73, 0x8F,
  0x03, 0xCE, 0x1C, 0x0F, 0x38, 0x70, 0x78, 0xE1, 0xFF, 0xE3, 0x87, 0xFB,
  0x8E, 0x0F, 0xCE, 0x38, 0x08, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xEF, 0x00, 0x01, 0xDE, 0x00, 0x07, 0x3C,
  0x00, 0x0E, 0x38, 0x00, 0x3C, 0x70, 0x00, 0x70, 0xE0, 0x01, 0xE1, 0xC0,
  0x03, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x1C, 0x0F, 0x00, 0x78, 0x1E, 0x00,
  0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x1E, 0x00, 0xF0, 0x3F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0x80, 0x0F, 0x0F, 0x00,
  0x0E, 0x1C, 0x00, 0x1C, 0x78, 0x00, 0x38, 0xF0, 0x00, 0x7B, 0xC0, 0x00,
  0xF7, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0x80, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xC0, 0x1F, 0x0F, 0x00, 0x3C,
  0x3C, 0x00, 0x70, 0xF0, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x38,
  0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x78, 0x78, 0x03,
  0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xF0, 0x03, 0xC3,
  0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xE7, 0x80,
  0x07, 0x9E, 0x00, 0x1E, 0x78, 0x00, 0x79, 0xE0, 0x01, 0xC7, 0x00, 0x0F,
  0x1C, 0x00, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0x07, 0xC0,
  0x78, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x07, 0x8F, 0x00, 0x08, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x30, 0x70, 0x00, 0x70,
  0xF0, 0x01, 0xE1, 0xE0, 0x07, 0x81, 0xE0, 0x1F, 0x03, 0xE0, 0x7C, 0x03,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x3C, 0x07, 0xC0, 0x70, 0x07, 0xC0, 0xE0,
  0x07, 0x83, 0xC0, 0x07, 0x07, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00,
  0x3C, 0x38, 0x00, 0x78, 0x70, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x03,
  0xC7, 0x80, 0x07, 0x8F, 0x00, 0x0F, 0x1C, 0x00, 0x3C, 0x38, 0x00, 0x78,
  0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x0F, 0x0E,
  0x00, 0x1E, 0x1C, 0x00, 0x38, 0x78, 0x00, 0xF0, 0xF0, 0x03, 0xC1, 0xE0,
  0x0F, 0x83, 0xC0, 0x7E, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03,
  0xFF, 0x80, 0x1F, 0xFF, 0x01, 0xF8, 0x3E, 0x07, 0x80, 0x78, 0x3C, 0x00,
  0xF1, 0xE0, 0x03, 0xC7, 0x00, 0x04, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x1F, 0xFB, 0xC0, 0x7F, 0xCF, 0x03, 0xFF,
  0x3C, 0x00, 0x1C, 0xF0, 0x00, 0x73, 0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x3C,
  0x00, 0x38, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x87, 0x80, 0x3E, 0x1E, 0x01,
  0xF8, 0x7E, 0x1D, 0xE0, 0xFF, 0xF7, 0x01, 0xFF, 0x1C, 0x01, 0xF8, 0x00,
  0x07, 0x00, 0x0F, 0x07, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0E,
  0x0F, 0x00, 0x0E, 0x0F, 0x00, 0x0E, 0x0E, 0x00, 0x1E, 0x0E, 0x00, 0x1E,
  0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1C, 0x1E, 0x00, 0x1C, 0x1E, 0x00, 0x1C,
  0x1C, 0x00, 0x3C, 0x1C, 0x00, 0x3C, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF8, 0x3C, 0x00, 0x38, 0x38, 0x00, 0x78, 0x38, 0x00, 0x78,
  0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x70, 0x78, 0x00, 0x70,
  0x70, 0x00, 0xF0, 0x70, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0,
  0xF0, 0x00, 0xE0, 0xF0, 0x00, 0xE0, 0xE0, 0x01, 0xE0, 0x07, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x08, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x20, 0x03, 0x87,
  0x00, 0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x1E, 0x07, 0x81, 0xF0, 0x3F, 0xFF,
  0x00, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x07, 0x80, 0x07, 0xC1, 0xC0, 0x03,
  0xE0, 0x70, 0x01, 0xF0, 0x3C, 0x00, 0xF8, 0x0F, 0x00, 0x7C, 0x03, 0xC0,
  0x3E, 0x00, 0xF0, 0x1F, 0x00, 0x38, 0x0F, 0x80, 0x0E, 0x07, 0xC0, 0x07,
  0x83, 0xE0, 0x01, 0xE1, 0xF0, 0x00, 0x78, 0xF8, 0x00, 0x1E, 0x3C, 0x00,
  0x07, 0x1E, 0x00, 0x01, 0xCF, 0xC0, 0x00, 0xF7, 0xF0, 0x00, 0x3F, 0xDE,
  0x00, 0x0F, 0xE7, 0x80, 0x03, 0xF0, 0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x3C,
  0x07, 0x80, 0x1E, 0x01, 0xE0, 0x07, 0x80, 0x38, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1C, 0x00, 0x78, 0x07, 0x00, 0x1E, 0x03, 0xC0, 0x03,
  0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1F,
  0x00, 0x7E, 0x07, 0xE0, 0x1F, 0x83, 0xF8, 0x0F, 0xE0, 0xEE, 0x07, 0xF8,
  0x3B, 0x81, 0xDC, 0x0E, 0x70, 0xE7, 0x03, 0x9C, 0x39, 0xC0, 0xE7, 0x1C,
  0x70, 0x79, 0xC7, 0x3C, 0x1C, 0x3B, 0x8F, 0x07, 0x0E, 0xE3, 0x81, 0xC3,
  0xF0, 0xE0, 0x70, 0xFC, 0x38, 0x1C, 0x1E, 0x0E, 0x0F, 0x07, 0x07, 0x83,
  0xC1, 0xC1, 0xE0, 0xE0, 0x60, 0x70, 0x38, 0x18, 0x1C, 0x0E, 0x04, 0x07,
  0x03, 0x80, 0x01, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1C, 0x00,
  0x0E, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x3C,
  0x00, 0x1E, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x07, 0x07, 0xC0, 0x0F,
  0x0F, 0xE0, 0x0F, 0x0F, 0xE0, 0x0E, 0x0E, 0xE0, 0x0E, 0x0E, 0xE0, 0x0E,
  0x0E, 0xF0, 0x0E, 0x0E, 0x70, 0x1E, 0x1E, 0x70, 0x1E, 0x1E, 0x70, 0x1C,
  0x1C, 0x70, 0x1C, 0x1C, 0x78, 0x1C, 0x1C, 0x38, 0x1C, 0x1C, 0x38, 0x3C,
  0x3C, 0x38, 0x3C, 0x3C, 0x38, 0x38, 0x38, 0x3C, 0x38, 0x38, 0x1C, 0x38,
  0x38, 0x1C, 0x38, 0x38, 0x1C, 0x78, 0x78, 0x1E, 0x78, 0x78, 0x0E, 0x78,
  0x70, 0x0E, 0x70, 0x70, 0x0E, 0x70, 0x70, 0x0E, 0x70, 0x70, 0x0F, 0xF0,
  0xF0, 0x07, 0xF0, 0xF0, 0x07, 0xF0, 0xE0, 0x07, 0xE0, 0xE0, 0x07, 0xE0,
  0xE0, 0x03, 0xE0, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01,
  0xF0, 0x3E, 0x0F, 0x80, 0x78, 0x3C, 0x00, 0xE1, 0xE0, 0x03, 0xC7, 0x00,
  0x0F, 0x3C, 0x00, 0x3C, 0xE0, 0x00, 0x77, 0x80, 0x03, 0xDE, 0x00, 0x0F,
  0x78, 0x00, 0x3D, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xEF, 0x00, 0x07, 0xB8, 0x00, 0x1E, 0xE0, 0x00,
  0x7B, 0x80, 0x01, 0xCE, 0x00, 0x0F, 0x38, 0x00, 0x3C, 0xE0, 0x01, 0xE3,
  0xC0, 0x07, 0x8F, 0x00, 0x3C, 0x1E, 0x01, 0xE0, 0x7C, 0x1F, 0x80, 0xFF,
  0xF8, 0x01, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x07, 0xFF, 0xFC, 0x07, 0x00, 0x3E, 0x0F, 0x00, 0x1E, 0x0F, 0x00,
  0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x0E, 0x00,
  0x0F, 0x1E, 0x00, 0x0E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00,
  0x3C, 0x1E, 0x00, 0x7C, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x80, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0xFF,
  0x01, 0xF0, 0x3E, 0x0F, 0x80, 0x78, 0x3C, 0x00, 0xE1, 0xE0, 0x03, 0xCF,
  0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xDE, 0x00,
  0x0F, 0x78, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xB8, 0x00, 0x1E, 0xE0,
  0x00, 0x7B, 0x80, 0x03, 0xCE, 0x00, 0x0F, 0x38, 0x00, 0x38, 0xF0, 0x01,
  0xE3, 0xC0, 0x0F, 0x07, 0x80, 0x7C, 0x1F, 0x07, 0xE0, 0x3F, 0xFF, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x10, 0x01,
  0xE1, 0xE0, 0x07, 0x8F, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0xC0, 0x00, 0x7E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xFF,
  0xFC, 0x07, 0x00, 0x3E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x0F, 0x00,
  0x0F, 0x0F, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x1E, 0x00,
  0x0E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x1E, 0x00,
  0x7C, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x3C, 0x1E,
  0x00, 0x3C, 0x1E, 0x00, 0x38, 0x0F, 0x00, 0x38, 0x0F, 0x00, 0x78, 0x07,
  0x00, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x70, 0x03,
  0xC0, 0x70, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x00, 0xE0, 0xF0, 0x00,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x7C,
  0x07, 0xE0, 0x78, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x08, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x10, 0x00, 0x1E, 0x3C, 0x00,
  0x1E, 0x0F, 0x80, 0x1F, 0x07, 0xF0, 0x3F, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x1E, 0x1C, 0x00, 0x3C,
  0x78, 0x00, 0x78, 0xF0, 0x00, 0xE1, 0xE0, 0x01, 0xC3, 0xC0, 0x03, 0x87,
  0x00, 0x0F, 0x0E, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0,
  0x00, 0xE1, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x87, 0x00, 0x0F, 0x1E, 0x00,
  0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x70, 0xF0, 0x00, 0xE1, 0xC0, 0x03,
  0xC3, 0x80, 0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x1C, 0x3C, 0x00, 0x38,
  0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0x83, 0xC0, 0x0F, 0x03,
  0xC0, 0x3E, 0x07, 0xC0, 0xF8, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x03,
  0xFC, 0x00, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80,
  0x01, 0xCF, 0x00, 0x07, 0x8E, 0x00, 0x0E, 0x1C, 0x00, 0x3C, 0x38, 0x00,
  0x78, 0x70, 0x01, 0xE0, 0xE0, 0x03, 0xC1, 0xE0, 0x0F, 0x03, 0xC0, 0x1E,
  0x07, 0x80, 0x38, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x1C, 0x07, 0x80,
  0x38, 0x0E, 0x00, 0x70, 0x3C, 0x00, 0xF0, 0x70, 0x01, 0xE1, 0xE0, 0x03,
  0xC3, 0xC0, 0x03, 0x87, 0x00, 0x07, 0x1E, 0x00, 0x0E, 0x38, 0x00, 0x1C,
  0xF0, 0x00, 0x39, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x38, 0xF0, 0x00, 0x0E, 0x3C, 0x00, 0x03,
  0x8E, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38, 0x1E,
  0x07, 0x0E, 0x0F, 0x83, 0xC3, 0x83, 0xE0, 0xE0, 0xE0, 0xF8, 0x38, 0x38,
  0x76, 0x0E, 0x0E, 0x1D, 0x83, 0x87, 0x8E, 0x61, 0xE1, 0xC3, 0x98, 0x70,
  0x70, 0xE6, 0x1C, 0x1C, 0x71, 0x87, 0x07, 0x1C, 0x73, 0xC1, 0xC7, 0x1C,
  0xE0, 0x73, 0x87, 0x38, 0x1C, 0xE1, 0xCE, 0x07, 0x30, 0x77, 0x81, 0xDC,
  0x1D, 0xC0, 0x77, 0x07, 0x70, 0x3F, 0x81, 0xDC, 0x0E, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x80, 0x78, 0x00, 0x78,
  0x01, 0xC0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x38, 0x03, 0xC0, 0x01,
  0xE0, 0x3C, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x3C, 0x3E, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xFB,
  0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x07, 0x81, 0xC0,
  0x00, 0x78, 0x0F, 0x00, 0x07, 0xC0, 0x38, 0x00, 0x3C, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x00, 0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x3E, 0x00,
  0x07, 0x83, 0xE0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x0F, 0xB8, 0x00, 0x0F,
  0x9E, 0x00, 0x07, 0x8F, 0x00, 0x07, 0x83, 0xC0, 0x07, 0xC1, 0xE0, 0x03,
  0xC0, 0x70, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x1E, 0x03, 0xE0, 0x07, 0x81,
  0xE0, 0x03, 0xC1, 0xE0, 0x00, 0xE1, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x3C,
  0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFC,
  0x00, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0x80,
  0x38, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x0C,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0x60, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x03, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x18, 0x01, 0xFF, 0xE0, 0x3F, 0xFC,
  0x07, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF8,
  0x00, 0x1E, 0xE0, 0x00, 0xF3, 0x80, 0x03, 0x8F, 0x00, 0x1E, 0x1C, 0x00,
  0xF0, 0x78, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x0F, 0x07, 0x80,
  0x1C, 0x1C, 0x00, 0x78, 0xF0, 0x00, 0xE7, 0x80, 0x03, 0xBC, 0x00, 0x0F,
  0xE0, 0x00, 0x1C, 0x80, 0x00, 0x40, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0x80, 0x23, 0xCF, 0x1C, 0x78, 0xE3, 0x86, 0x1C, 0x00, 0xFC,
  0x3C, 0x0F, 0xFC, 0xE0, 0x7F, 0xFB, 0x83, 0xE0, 0x6E, 0x1F, 0x00, 0xF8,
  0x78, 0x01, 0xE3, 0xC0, 0x07, 0x8E, 0x00, 0x1E, 0x78, 0x00, 0x71, 0xE0,
  0x01, 0xC7, 0x80, 0x07, 0x1C, 0x00, 0x3C, 0x70, 0x00, 0xF1, 0xC0, 0x03,
  0xCF, 0x00, 0x0E, 0x3C, 0x00, 0x38, 0x70, 0x01, 0xE1, 0xC0, 0x0F, 0x87,
  0x00, 0x3E, 0x1E, 0x01, 0x78, 0x7C, 0x1D, 0xFC, 0xFF, 0xE7, 0xE1, 0xFF,
  0x0F, 0x83, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0xFC, 0x03, 0x8F,
  0xF8, 0x0E, 0x7F, 0xF0, 0x3B, 0x83, 0xE1, 0xE8, 0x07, 0x87, 0xC0, 0x0F,
  0x1F, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x00, 0x0F, 0x3C,
  0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xCE, 0x00, 0x0E, 0x38, 0x00,
  0x38, 0xE0, 0x01, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x3C, 0x78, 0x00, 0xF1,
  0xF0, 0x07, 0x87, 0x60, 0x7C, 0x1C, 0xFF, 0xE0, 0xF3, 0xFF, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xF8, 0x3E,
  0x1E, 0x00, 0xF1, 0xC0, 0x07, 0x3C, 0x00, 0x83, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x08, 0xF0, 0x00, 0xE7, 0x00, 0x1E, 0x70,
  0x03, 0xC7, 0x80, 0x7C, 0x3E, 0x0F, 0x81, 0xFF, 0xF0, 0x0F, 0xFC, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0xFC, 0x1C, 0x03,
  0xFF, 0x3C, 0x07, 0xFF, 0xBC, 0x0F, 0x81, 0xBC, 0x1F, 0x00, 0xF8, 0x1E,
  0x00, 0x78, 0x3C, 0x00, 0x78, 0x38, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78,
  0x00, 0x78, 0x78, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70,
  0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0x70, 0x01, 0xE0, 0x70,
  0x01, 0xE0, 0x70, 0x02, 0xE0, 0x78, 0x07, 0xE0, 0x7C, 0x1D, 0xE0, 0x3F,
  0xF9, 0xE0, 0x1F, 0xF1, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x1F,
  0xFC, 0x07, 0xFF, 0xE0, 0xF8, 0x1F, 0x1E, 0x00, 0xF1, 0xC0, 0x07, 0x3C,
  0x00, 0x77, 0x80, 0x07, 0x78, 0x00, 0xF7, 0x00, 0x3E, 0x70, 0x3F, 0xEF,
  0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFE, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x47, 0x00, 0x0F, 0x70, 0x01, 0xE7, 0x80, 0x3C, 0x3E, 0x0F,
  0x83, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x20, 0x1E, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x3E,
  0x07, 0x00, 0x00, 0x78, 0x38, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x0E, 0x03, 0xFF, 0x3C, 0x0F,
  0xFF, 0x78, 0x3E, 0x06, 0xE0, 0xF8, 0x07, 0xC1, 0xE0, 0x07, 0x87, 0x80,
  0x0F, 0x0E, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x70, 0xF0, 0x00,
  0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x0F, 0x0E, 0x00, 0x1E,
  0x1C, 0x00, 0x38, 0x38, 0x00, 0xF0, 0x78, 0x03, 0xE0, 0xF0, 0x0D, 0xC1,
  0xF0, 0x77, 0x81, 0xFF, 0xCF, 0x01, 0xFF, 0x1C, 0x00, 0xFC, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0x80,
  0x3E, 0x07, 0x80, 0xF8, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x1F, 0x01, 0xE7, 0xFC, 0x1E, 0xFF, 0xE1, 0xDC, 0x1E,
  0x1D, 0x80, 0xF3, 0xF0, 0x0F, 0x3E, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x00,
  0xF3, 0x80, 0x0F, 0x38, 0x00, 0xE7, 0x80, 0x0E, 0x78, 0x00, 0xE7, 0x80,
  0x1E, 0x70, 0x01, 0xE7, 0x00, 0x1E, 0x70, 0x01, 0xCF, 0x00, 0x1C, 0xF0,
  0x01, 0xCF, 0x00, 0x3C, 0xE0, 0x03, 0xCE, 0x00, 0x3C, 0xE0, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x04,
  0x03, 0x80, 0xE0, 0x78, 0x1F, 0x07, 0x83, 0xC0, 0x78, 0x78, 0x07, 0x0F,
  0x00, 0x71, 0xE0, 0x07, 0x3C, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x60, 0x1C, 0x0F,
  0x01, 0xC0, 0xF8, 0x3C, 0x07, 0xC3, 0xC0, 0x3E, 0x38, 0x01, 0xE3, 0x80,
  0x0F, 0x38, 0x00, 0x7F, 0x80, 0x03, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE1, 0xF8, 0x07, 0x9F, 0xF0, 0x1E, 0xFF, 0xE0, 0x77, 0x07,
  0x81, 0xD8, 0x0F, 0x0F, 0xC0, 0x3C, 0x3E, 0x00, 0xF0, 0xF0, 0x03, 0xC3,
  0xC0, 0x0E, 0x0E, 0x00, 0x78, 0x38, 0x03, 0xC1, 0xE0, 0x3E, 0x07, 0x83,
  0xE0, 0x1E, 0x7E, 0x00, 0x79, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x0F, 0x01,
  0xBC, 0x1C, 0x0F, 0xF0, 0x78, 0x7B, 0xC1, 0xE3, 0xCE, 0x03, 0xDE, 0x38,
  0x0F, 0xF0, 0xE0, 0x1F, 0x80, 0x00, 0x3C, 0x00, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFE, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0x02, 0x0E, 0x01, 0xC7, 0x81, 0xF1, 0xE0, 0xF8, 0x78, 0x78, 0x1C,
  0x3C, 0x07, 0x1E, 0x01, 0xCF, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x03, 0xC0,
  0x00, 0x1C, 0x78, 0x3C, 0x1C, 0xFC, 0x7E, 0x1D, 0xFC, 0xFF, 0x1D, 0x1D,
  0x8F, 0x1E, 0x1F, 0x07, 0x3C, 0x0E, 0x07, 0x3C, 0x1E, 0x07, 0x38, 0x1E,
  0x07, 0x38, 0x1C, 0x0F, 0x38, 0x1C, 0x0E, 0x38, 0x1C, 0x0E, 0x78, 0x1C,
  0x0E, 0x78, 0x1C, 0x0E, 0x70, 0x3C, 0x1E, 0x70, 0x38, 0x1C, 0x70, 0x38,
  0x1C, 0x70, 0x38, 0x1C, 0xF0, 0x38, 0x1C, 0xE0, 0x78, 0x1C, 0xE0, 0x78,
  0x3C, 0xE0, 0x70, 0x38, 0xE0, 0x70, 0x38, 0xE0, 0x70, 0x38, 0x1E, 0x1F,
  0x01, 0xE7, 0xFC, 0x1C, 0xFF, 0xE1, 0xDC, 0x1E, 0x1D, 0x80, 0xF3, 0xF0,
  0x0F, 0x3E, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x00, 0xF3, 0x80, 0x0F, 0x38,
  0x00, 0xE7, 0x80, 0x0E, 0x78, 0x00, 0xE7, 0x80, 0x1E, 0x70, 0x01, 0xE7,
  0x00, 0x1E, 0x70, 0x01, 0xCF, 0x00, 0x1C, 0xF0, 0x01, 0xCF, 0x00, 0x3C,
  0xE0, 0x03, 0xCE, 0x00, 0x3C, 0xE0, 0x03, 0x80, 0x00, 0xFE, 0x00, 0x1F,
  0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0x07, 0xC1, 0xE0, 0x0F, 0x1E, 0x00, 0x78,
  0xE0, 0x01, 0xCF, 0x00, 0x0E, 0x70, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0x70, 0x00, 0x7B, 0x80, 0x03, 0xDC,
  0x00, 0x1E, 0xE0, 0x00, 0xE7, 0x80, 0x0F, 0x3C, 0x00, 0xF0, 0xF0, 0x0F,
  0x87, 0xC0, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0xFE, 0x00, 0x07,
  0x87, 0xE0, 0x0E, 0x3F, 0xE0, 0x1C, 0xFF, 0xE0, 0x3B, 0x83, 0xE0, 0xF4,
  0x03, 0xC1, 0xF0, 0x03, 0xC3, 0xE0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00,
  0x1E, 0x1C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x01,
  0xE3, 0x80, 0x03, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x1E, 0x3C, 0x00, 0x3C,
  0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xF0, 0x07, 0x83, 0xB8, 0x3E, 0x07,
  0x3F, 0xF8, 0x1E, 0x7F, 0xE0, 0x3C, 0x3F, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFC, 0x1C, 0x0F, 0xFC,
  0xF0, 0x7F, 0xFB, 0xC3, 0xE0, 0x6F, 0x1F, 0x00, 0xF8, 0x78, 0x01, 0xE3,
  0xC0, 0x07, 0x8E, 0x00, 0x1E, 0x78, 0x00, 0x79, 0xE0, 0x01, 0xE7, 0x80,
  0x07, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x71, 0xC0, 0x03, 0xCF, 0x00, 0x0F,
  0x3C, 0x00, 0x3C, 0x70, 0x01, 0xE1, 0xC0, 0x07, 0x87, 0x00, 0x2E, 0x1E,
  0x01, 0xF8, 0x7C, 0x1D, 0xE0, 0xFF, 0xE7, 0x81, 0xFF, 0x1C, 0x01, 0xF0,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0xFF,
  0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xF7, 0xFC, 0x07, 0x30, 0x00, 0x3B, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x01, 0xFF, 0xFC, 0x1F, 0x01, 0xF0, 0xF0,
  0x03, 0x0F, 0x00, 0x10, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x88,
  0x00, 0x3D, 0xF0, 0x03, 0xC7, 0xE0, 0x7E, 0x1F, 0xFF, 0xE0, 0x7F, 0xFC,
  0x00, 0x7F, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x20, 0x70, 0x0E, 0x07, 0x01, 0xF0, 0x70, 0x3E, 0x0F, 0x0F, 0x80, 0xF1,
  0xF0, 0x0F, 0x7E, 0x00, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0xF3, 0x80, 0x0F, 0x38, 0x00, 0xE3, 0x80, 0x0E, 0x78, 0x00, 0xE7,
  0x80, 0x0E, 0x78, 0x01, 0xE7, 0x00, 0x1E, 0x70, 0x01, 0xE7, 0x00, 0x1C,
  0xF0, 0x01, 0xCF, 0x00, 0x1C, 0xF0, 0x03, 0xCE, 0x00, 0x3C, 0xE0, 0x03,
  0xCE, 0x00, 0x38, 0xE0, 0x07, 0x8E, 0x00, 0xF8, 0xE0, 0x0F, 0x8F, 0x01,
  0xF8, 0xF8, 0x77, 0x87, 0xFE, 0x70, 0x3F, 0xC7, 0x01, 0xF8, 0x00, 0xFF,
  0x80, 0x37, 0xF8, 0x07, 0xBF, 0xC0, 0x1C, 0x0E, 0x00, 0xF0, 0x70, 0x07,
  0x87, 0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xC0, 0x0F, 0x0E, 0x00, 0x78, 0x70,
  0x03, 0xC3, 0x80, 0x1C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x70,
  0x70, 0x07, 0x83, 0x80, 0x78, 0x1C, 0x07, 0xC0, 0xE0, 0x7C, 0x0F, 0x07,
  0xC0, 0x79, 0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x3E, 0x00, 0x00,
  0x1C, 0x0E, 0x0C, 0x78, 0x1C, 0x38, 0xE0, 0x70, 0x79, 0xC0, 0xE0, 0x73,
  0x81, 0xC0, 0xE7, 0x03, 0x81, 0xCE, 0x07, 0x03, 0xBC, 0x0E, 0x07, 0x70,
  0x38, 0x0E, 0xE0, 0x70, 0x1D, 0xC0, 0xE0, 0x3B, 0x81, 0xC0, 0xF7, 0x03,
  0x81, 0xDE, 0x0F, 0x03, 0xB8, 0x1C, 0x07, 0x70, 0x38, 0x1E, 0xE0, 0x70,
  0x39, 0xC1, 0xE0, 0xF3, 0x82, 0xC1, 0xC7, 0x8D, 0xC7, 0x8F, 0xF3, 0xFE,
  0x0F, 0xC7, 0xF8, 0x0F, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x7E,
  0x0F, 0xE0, 0x7F, 0xC7, 0xFC, 0x3E, 0x73, 0x8F, 0x1F, 0x1C, 0xC1, 0xCF,
  0x07, 0x60, 0x71, 0x81, 0xD8, 0x1C, 0x00, 0x34, 0x07, 0x00, 0x0F, 0x01,
  0x80, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x01, 0xC0, 0xF8, 0x00, 0xF0,
  0x3E, 0x02, 0x3C, 0x0B, 0x81, 0xCF, 0x06, 0xE0, 0xF3, 0xC3, 0xB8, 0xF8,
  0xF1, 0xCF, 0x7C, 0x1F, 0xF1, 0xFE, 0x07, 0xF8, 0x7E, 0x00, 0xF8, 0x0F,
  0x00, 0x07, 0x80, 0x1E, 0x0E, 0x00, 0x3C, 0x1C, 0x00, 0x70, 0x38, 0x00,
  0xE0, 0xF0, 0x01, 0xC1, 0xE0, 0x03, 0x83, 0xC0, 0x0F, 0x07, 0x00, 0x1E,
  0x0E, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x78, 0x00, 0xE0, 0xF0, 0x01, 0xC1,
  0xE0, 0x07, 0x83, 0x80, 0x0F, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x78, 0x1C,
  0x00, 0xF0, 0x3C, 0x02, 0xE0, 0x78, 0x0F, 0xC0, 0xF8, 0x77, 0x80, 0xFF,
  0xCE, 0x00, 0xFF, 0x1C, 0x00, 0xFC, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x01, 0x00, 0x3C, 0x07, 0x81, 0xF8,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x1E,
  0x0F, 0xFE, 0x38, 0x3F, 0xFF, 0x70, 0xF0, 0x7F, 0xE1, 0xC0, 0x1F, 0x83,
  0x80, 0x1E, 0x0E, 0x00, 0x78, 0x1C, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x04, 0x00, 0xF0, 0x1C, 0x03, 0xC0, 0x38, 0x0F, 0x00, 0x78, 0x78, 0x00,
  0x71, 0xFF, 0x80, 0xE3, 0xFF, 0xF1, 0xC7, 0x3F, 0xFF, 0x9E, 0x0F, 0xFE,
  0x3C, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x07,
  0x03, 0x80, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0xFF, 0xF0, 0x0F, 0xFE,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x0C, 0x1F, 0xC0, 0x1C, 0x7F, 0xC0,
  0x71, 0xE3, 0x80, 0xE3, 0x87, 0x81, 0xCE, 0x07, 0x87, 0x1C, 0x07, 0x1E,
  0x38, 0x0F, 0xF8, 0xE0, 0x0F, 0xE0, 0xC0, 0x0F, 0x80,
};

const GFXglyph IBMPlexMono_Italic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 10, 31, 26, 8, -31 },
  { 40, 13, 12, 26, 9, -33 },
  { 60, 26, 31, 26, 1, -31 },
  { 161, 25, 40, 26, 1, -35 },
  { 286, 30, 32, 26, -1, -31 },
  { 406, 26, 32, 26, 0, -31 },
  { 510, 5, 12, 26, 13, -33 },
  { 518, 16, 39, 26, 9, -33 },
  { 596, 16, 39, 26, 2, -33 },
  { 674, 23, 22, 26, 2, -24 },
  { 738, 21, 21, 26, 3, -24 },
  { 794, 10, 12, 26, 6, -6 },
  { 809, 13, 3, 26, 7, -15 },
  { 814, 7, 6, 26, 8, -6 },
  { 820, 25, 39, 26, 1, -33 },
  { 942, 22, 32, 26, 3, -31 },
  { 1030, 21, 31, 26, 2, -31 },
  { 1112, 23, 31, 26, 1, -31 },
  { 1202, 23, 32, 26, 1, -31 },
  { 1294, 23, 31, 26, 1, -31 },
  { 1384, 23, 32, 26, 2, -31 },
  { 1476, 21, 32, 26, 3, -31 },
  { 1560, 21, 31, 26, 5, -31 },
  { 1642, 23, 32, 26, 2, -31 },
  { 1734, 21, 31, 26, 4, -31 },
  { 1816, 10, 24, 26, 8, -24 },
  { 1846, 12, 30, 26, 6, -24 },
  { 1891, 21, 25, 26, 4, -26 },
  { 1957, 23, 11, 26, 2, -19 },
  { 1989, 21, 25, 26, 2, -26 },
  { 2055, 18, 31, 26, 6, -31 },
  { 2125, 22, 36, 26, 3, -31 },
  { 2224, 23, 31, 26, 0, -31 },
  { 2314, 22, 31, 26, 2, -31 },
  { 2400, 23, 32, 26, 3, -31 },
  { 2492, 23, 31, 26, 2, -31 },
  { 2582, 24, 31, 26, 2, -31 },
  { 2675, 24, 31, 26, 2, -31 },
  { 2768, 22, 32, 26, 3, -31 },
  { 2856, 24, 31, 26, 2, -31 },
  { 2949, 24, 31, 26, 2, -31 },
  { 3042, 21, 32, 26, 3, -31 },
  { 3126, 26, 31, 26, 2, -31 },
  { 3227, 19, 31, 26, 3, -31 },
  { 3301, 26, 31, 26, 1, -31 },
  { 3402, 24, 31, 26, 2, -31 },
  { 3495, 22, 32, 26, 3, -31 },
  { 3583, 24, 31, 26, 2, -31 },
  { 3676, 22, 39, 26, 3, -31 },
  { 3784, 24, 31, 26, 2, -31 },
  { 3877, 25, 32, 26, 1, -31 },
  { 3977, 25, 31, 26, 4, -31 },
  { 4074, 23, 32, 26, 3, -31 },
  { 4166, 23, 31, 26, 5, -31 },
  { 4256, 26, 31, 26, 2, -31 },
  { 4357, 29, 31, 26, -1, -31 },
  { 4470, 25, 31, 26, 4, -31 },
  { 4567, 27, 31, 26, 0, -31 },
  { 4672, 19, 39, 26, 7, -33 },
  { 4765, 11, 39, 26, 8, -33 },
  { 4819, 19, 39, 26, 0, -33 },
  { 4912, 22, 18, 26, 3, -31 },
  { 4962, 22, 3, 26, 0, 4 },
  { 4971, 6, 9, 26, 10, -35 },
  { 4978, 22, 24, 26, 2, -23 },
  { 5044, 22, 34, 26, 2, -33 },
  { 5138, 20, 24, 26, 3, -23 },
  { 5198, 24, 34, 26, 2, -33 },
  { 5300, 20, 24, 26, 3, -23 },
  { 5360, 29, 42, 26, -1, -33 },
  { 5513, 23, 32, 26, 1, -23 },
  { 5605, 20, 33, 26, 3, -33 },
  { 5688, 20, 34, 26, 4, -33 },
  { 5773, 20, 42, 26, 3, -33 },
  { 5878, 22, 34, 26, 3, -33 },
  { 5972, 18, 34, 26, 5, -33 },
  { 6049, 24, 23, 26, 1, -23 },
  { 6118, 20, 23, 26, 3, -23 },
  { 6176, 21, 24, 26, 3, -23 },
  { 6239, 23, 32, 26, 1, -23 },
  { 6331, 22, 32, 26, 2, -23 },
  { 6419, 21, 23, 26, 5, -23 },
  { 6480, 21, 24, 26, 2, -23 },
  { 6543, 20, 32, 26, 3, -31 },
  { 6623, 20, 24, 26, 4, -23 },
  { 6683, 21, 23, 26, 3, -23 },
  { 6744, 23, 23, 26, 2, -23 },
  { 6811, 26, 24, 26, 0, -23 },
  { 6889, 23, 32, 26, 1, -23 },
  { 6981, 23, 23, 26, 2, -23 },
  { 7048, 20, 39, 26, 5, -33 },
  { 7146, 9, 39, 26, 9, -33 },
  { 7190, 20, 39, 26, 2, -33 },
  { 7288, 23, 10, 26, 2, -18 },
};

const GFXfont IBMPlexMono_Italic44pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic44pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic44pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _IBMPLEXMONO_ITALIC44PT7B_H_
