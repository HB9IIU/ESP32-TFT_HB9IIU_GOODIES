#ifndef _IBMPLEXMONO_ITALIC69PT7B_H_
#define _IBMPLEXMONO_ITALIC69PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic69pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x3F,
  0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F,
  0x80, 0x3F, 0x00, 0x1F, 0x01, 0xF3, 0xF0, 0x3F, 0x3E, 0x03, 0xE3, 0xE0,
  0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE7, 0xE0, 0x7E, 0x7C,
  0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xCF,
  0xC0, 0xFC, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xF8,
  0xF8, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x1E, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00,
  0x00, 0x7E, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF,
  0xFC, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xC7, 0x9F, 0xF0, 0x07, 0xF8, 0x1E, 0x1F, 0xE0, 0x1F, 0xC0,
  0xF8, 0x1F, 0xC0, 0xFE, 0x03, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0x00, 0x70,
  0x1F, 0x80, 0x3C, 0x00, 0x80, 0x7E, 0x00, 0xF0, 0x00, 0x01, 0xF8, 0x03,
  0xC0, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x78, 0x00, 0x00,
  0x7E, 0x01, 0xE0, 0x00, 0x01, 0xF8, 0x07, 0x80, 0x00, 0x07, 0xF0, 0x1E,
  0x00, 0x00, 0x0F, 0xC0, 0x78, 0x00, 0x00, 0x3F, 0xC3, 0xE0, 0x00, 0x00,
  0x7F, 0xCF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x1E, 0x1F, 0xE0, 0x00, 0x00, 0x78, 0x3F, 0xC0, 0x00,
  0x01, 0xE0, 0x7F, 0x00, 0x00, 0x0F, 0x80, 0xFE, 0x00, 0x00, 0x3C, 0x01,
  0xF8, 0x00, 0x00, 0xF0, 0x07, 0xE0, 0x00, 0x03, 0xC0, 0x1F, 0x80, 0x00,
  0x0F, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x07,
  0xE0, 0x40, 0x07, 0x80, 0x3F, 0x03, 0x80, 0x1E, 0x00, 0xFC, 0x1F, 0x00,
  0x78, 0x07, 0xF0, 0xFE, 0x01, 0xE0, 0x1F, 0x83, 0xFC, 0x07, 0x81, 0xFE,
  0x07, 0xFC, 0x3E, 0x0F, 0xF0, 0x0F, 0xFC, 0xF1, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xFE, 0x00, 0x01,
  0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xE0, 0x07, 0xF0, 0x7C, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x07, 0xC0,
  0x03, 0xE0, 0x03, 0xC0, 0x1F, 0x00, 0x07, 0xC0, 0x07, 0x80, 0x3E, 0x00,
  0x0F, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x01,
  0xF0, 0x01, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x07, 0xC1, 0xF0, 0x00, 0x03,
  0xC0, 0x0F, 0x83, 0xE0, 0x00, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x00, 0x0F,
  0xC1, 0xF8, 0x3E, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x7C, 0x00, 0x00, 0x0F,
  0xFF, 0x81, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7C,
  0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x7F, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0xF8, 0x07, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x0F, 0x80, 0x00, 0x3E, 0x07,
  0x80, 0x0F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x78, 0x00, 0x1F, 0x01, 0xF0,
  0x01, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0xC0,
  0x07, 0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x1F, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x01,
  0xF8, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0xFC, 0x1F,
  0x80, 0x0F, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x7C, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x07, 0xE0, 0x00, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x01,
  0xFF, 0xCF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFC, 0xFF,
  0xC0, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00,
  0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x47, 0xE0,
  0x00, 0x3E, 0x00, 0x73, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0xF8, 0x00, 0x1F,
  0xC0, 0x3E, 0xFC, 0x00, 0x0F, 0xF0, 0x3E, 0x3E, 0x00, 0x0E, 0xF8, 0x3F,
  0x1F, 0x80, 0x0E, 0x7E, 0x1F, 0x0F, 0xE0, 0x0F, 0x1F, 0x1F, 0x83, 0xF8,
  0x1F, 0x8F, 0xCF, 0x81, 0xFF, 0xFF, 0x87, 0xFF, 0xC0, 0x7F, 0xFF, 0x81,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x8F, 0xC7, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x7E, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE3, 0xF1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x01, 0x00, 0x03, 0xE0, 0x01,
  0x3C, 0x00, 0x7C, 0x00, 0xE7, 0xF0, 0x1F, 0x00, 0xFD, 0xFF, 0xC3, 0xE1,
  0xFF, 0xFF, 0xFF, 0x7D, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x0F, 0xDF, 0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0xFC, 0x3E,
  0x00, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x0F, 0xE0, 0x7C, 0x00, 0x03, 0xF8,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x81, 0xFE, 0x03, 0xF8, 0x07,
  0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0,
  0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x00,
  0x1F, 0x87, 0xF9, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xBF, 0xF3, 0xFC, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x0F,
  0xE0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00,
  0x3E, 0x1F, 0x80, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x00, 0xF8, 0xFC, 0x00,
  0x00, 0x1F, 0x1F, 0x80, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x00, 0x7C, 0xFC,
  0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x00, 0x7E,
  0xFC, 0x01, 0xF0, 0x0F, 0xDF, 0x80, 0xFF, 0x01, 0xFB, 0xF0, 0x1F, 0xE0,
  0x3F, 0x7E, 0x03, 0xFC, 0x07, 0xEF, 0xC0, 0xFF, 0x80, 0xFD, 0xF8, 0x1F,
  0xF0, 0x3F, 0x3E, 0x01, 0xFC, 0x07, 0xEF, 0xC0, 0x3F, 0x00, 0xFD, 0xF8,
  0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x7C,
  0xFC, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00,
  0x7C, 0x7E, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x03, 0xF0, 0xF8, 0x00,
  0x00, 0xFC, 0x1F, 0x00, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xBF, 0x00, 0x00, 0x7F, 0x9F, 0x00,
  0x00, 0x7F, 0x0F, 0x80, 0x00, 0xFF, 0x0F, 0xC0, 0x00, 0xFF, 0x07, 0xE0,
  0x00, 0xFF, 0x03, 0xF0, 0x00, 0xFF, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x7E, 0x00, 0x06, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x07, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00,
  0xFE, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0x00,
  0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x07,
  0x00, 0x00, 0x3F, 0x00, 0x20, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x01, 0x80, 0x00, 0x03, 0xF0, 0x78, 0x00, 0x00, 0x7F, 0x0F, 0xC0,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x00, 0x7E,
  0x3E, 0x00, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0x3E, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x3E,
  0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x3E, 0x00,
  0x00, 0xF8, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x7C, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x7F, 0x80, 0x00, 0x3E,
  0x3F, 0xFE, 0x00, 0x03, 0xC7, 0xFF, 0xF8, 0x00, 0x7C, 0xFF, 0xFF, 0xC0,
  0x07, 0xDF, 0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x07, 0xF0, 0x00,
  0xFF, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x0C, 0x00, 0x00, 0x3F, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00,
  0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x3F, 0xC0, 0x01, 0xF8, 0x7F, 0xFC,
  0x00, 0xF8, 0xFF, 0xFF, 0x80, 0xFC, 0xFF, 0xFF, 0xE0, 0x7C, 0xFF, 0xFF,
  0xF8, 0x7E, 0xF8, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x00,
  0x3F, 0x9F, 0xE0, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x03, 0xF7, 0xF0, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x01, 0xF9, 0xF0, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x00, 0xFC, 0x7E,
  0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0xFC, 0x0F, 0xE0, 0x01, 0xFE, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFC, 0x7C,
  0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x01, 0xF8,
  0x7C, 0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x03,
  0xF0, 0x3E, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFE,
  0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x3E, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x00, 0x0F, 0x87, 0xE0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x01, 0xFC, 0xFC, 0x00,
  0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x3F, 0x8F,
  0xE0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x3F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x0F, 0x8F, 0xC0, 0x00,
  0x07, 0xCF, 0xC0, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x01, 0xFB, 0xE0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x03, 0xFB, 0xF8,
  0x00, 0x03, 0xFC, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x07, 0xFE, 0x1F,
  0xF0, 0x0F, 0xBF, 0x0F, 0xFF, 0xFF, 0xBF, 0x03, 0xFF, 0xFF, 0x9F, 0x80,
  0xFF, 0xFF, 0x9F, 0x80, 0x1F, 0xFF, 0x0F, 0xC0, 0x03, 0xFE, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x03, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xFC, 0x0F, 0xFC, 0x1F,
  0xF8, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x81, 0xFE, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F,
  0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x40, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x0F, 0xF8,
  0x0F, 0xF8, 0xFF, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7E, 0xF0, 0x00, 0x03, 0xF1,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x00, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x01, 0xF0, 0xFC,
  0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x07, 0xC3, 0xE0, 0x03, 0xE0, 0xF8,
  0xF8, 0x01, 0xFF, 0x1F, 0x1F, 0x00, 0xFF, 0xF3, 0xE3, 0xE0, 0x1F, 0xFE,
  0x78, 0x7C, 0x07, 0xFF, 0xEF, 0x1F, 0x01, 0xFC, 0x1F, 0xE3, 0xE0, 0x3F,
  0x00, 0xFC, 0x7C, 0x0F, 0xC0, 0x1F, 0x8F, 0x81, 0xF0, 0x01, 0xF1, 0xF0,
  0x7E, 0x00, 0x3C, 0x7E, 0x0F, 0x80, 0x0F, 0x8F, 0x81, 0xF0, 0x01, 0xF1,
  0xF0, 0x7E, 0x00, 0x3E, 0x3E, 0x0F, 0xC0, 0x07, 0xC7, 0xC1, 0xF8, 0x00,
  0xF8, 0xF8, 0x3E, 0x00, 0x1E, 0x3F, 0x07, 0xC0, 0x07, 0xC7, 0xC0, 0xF8,
  0x00, 0xF8, 0xF8, 0x1F, 0x00, 0x1F, 0x1F, 0x03, 0xE0, 0x07, 0xE3, 0xE0,
  0x7C, 0x00, 0xFC, 0x7C, 0x0F, 0x80, 0x3F, 0x0F, 0x81, 0xF0, 0x07, 0xE1,
  0xF0, 0x3F, 0x01, 0xFC, 0x3E, 0x07, 0xF0, 0xEF, 0x87, 0xC0, 0x7F, 0xFD,
  0xF0, 0xF8, 0x0F, 0xFF, 0x3E, 0x1F, 0x00, 0xFF, 0xC7, 0x83, 0xE0, 0x0F,
  0xF1, 0xF0, 0x7C, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3E, 0xFC,
  0x00, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0xF8, 0x00, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x00, 0x7C, 0x3E, 0x00,
  0x00, 0x07, 0xE1, 0xF0, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x01, 0xF0, 0xFC, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00,
  0xFD, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x00, 0x7F,
  0x80, 0x7E, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x0F, 0x81, 0xF8,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x7C, 0x00, 0x0F, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x3E, 0x00, 0x03, 0xFC, 0x07, 0xC0, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x0F, 0xC3, 0xE0,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x0F,
  0xE1, 0xF0, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00,
  0x1F, 0xC1, 0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x0F,
  0xE0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xFC,
  0x1F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x01, 0xC0, 0xFC, 0x00, 0x00,
  0x40, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x10, 0x07, 0xC0, 0x00, 0x01, 0x80, 0xF8, 0x00,
  0x00, 0x7C, 0x1F, 0x80, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xE0,
  0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xF0, 0x03, 0xFE, 0x00, 0x7C, 0x00,
  0x1F, 0xE0, 0x0F, 0x80, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x7E,
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x3E, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x00, 0xFC, 0x1F, 0x00, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x01,
  0xF8, 0x7E, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x87, 0xC0, 0x00, 0x07, 0xE0, 0xF8,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x83, 0xE0, 0x00, 0x07,
  0xE0, 0x7C, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x7E, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x01, 0xFE, 0x01, 0xF0,
  0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x1F, 0xE0, 0x03,
  0xF8, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x1E, 0x0F, 0xC0,
  0x00, 0x08, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xCF, 0xC0, 0x0F,
  0xFF, 0xF3, 0xF0, 0x03, 0xFF, 0xFC, 0xFC, 0x00, 0xFF, 0xFE, 0x3F, 0x00,
  0x3F, 0xFF, 0x8F, 0x80, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x00, 0xF8, 0xF8,
  0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x07, 0xE3,
  0xE0, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x01,
  0xFC, 0x1F, 0x80, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x6F, 0x81, 0xFE, 0x00,
  0x7B, 0xE0, 0x3F, 0xE0, 0x7C, 0xF8, 0x07, 0xFF, 0xFE, 0x7E, 0x01, 0xFF,
  0xFF, 0x1F, 0x80, 0x3F, 0xFF, 0x87, 0xC0, 0x03, 0xFF, 0xC1, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x3E, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x7C, 0x00,
  0x00, 0x7E, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x7E, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00,
  0x7C, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x3E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x1F, 0x80,
  0x03, 0xF8, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x3E, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0x80, 0x00, 0x0F,
  0xE0, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x7E, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x3F,
  0x80, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xC3, 0xF8, 0x00, 0x00, 0x03,
  0xF1, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x7F,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xDF, 0x80,
  0x00, 0x00, 0xFF, 0xE3, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x1F, 0x80, 0x00, 0x07, 0xFC, 0x07, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x80, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x03,
  0xEF, 0x80, 0x3F, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0,
  0x7C, 0x7C, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x07, 0xE7, 0xC0, 0xF8, 0xF8,
  0x07, 0xC3, 0xE1, 0xF8, 0xF8, 0x07, 0xC3, 0xE1, 0xF0, 0xF8, 0x07, 0xC3,
  0xE3, 0xE0, 0xF8, 0x07, 0xC3, 0xE3, 0xE1, 0xF8, 0x07, 0xC1, 0xF7, 0xC1,
  0xF0, 0x0F, 0xC1, 0xF7, 0xC1, 0xF0, 0x0F, 0x81, 0xFF, 0x81, 0xF0, 0x0F,
  0x81, 0xFF, 0x01, 0xF0, 0x0F, 0x80, 0xFF, 0x01, 0xF0, 0x0F, 0x80, 0xFE,
  0x03, 0xF0, 0x0F, 0x80, 0xFE, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00,
  0x70, 0x03, 0xE0, 0x1F, 0x00, 0x30, 0x07, 0xE0, 0x1F, 0x00, 0x20, 0x07,
  0xC0, 0x3F, 0x00, 0x40, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00,
  0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7C, 0x07, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0xF8, 0x00, 0x0F, 0x80,
  0x7F, 0xE0, 0x00, 0x3E, 0x01, 0xFF, 0x80, 0x00, 0xF8, 0x07, 0xFE, 0x00,
  0x03, 0xE0, 0x1F, 0xF8, 0x00, 0x1F, 0x80, 0xFD, 0xF0, 0x00, 0x7E, 0x03,
  0xF7, 0xC0, 0x01, 0xF0, 0x0F, 0x9F, 0x00, 0x07, 0xC0, 0x3E, 0x7C, 0x00,
  0x1F, 0x00, 0xF9, 0xF8, 0x00, 0x7C, 0x03, 0xE3, 0xE0, 0x03, 0xF0, 0x1F,
  0x8F, 0x80, 0x0F, 0xC0, 0x7E, 0x3E, 0x00, 0x3E, 0x01, 0xF0, 0xF8, 0x00,
  0xF8, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0x1F, 0x07, 0xC0, 0x0F, 0x80, 0x7C,
  0x1F, 0x00, 0x7E, 0x03, 0xF0, 0x7C, 0x01, 0xF8, 0x0F, 0xC1, 0xF8, 0x07,
  0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x3F,
  0x01, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x1F, 0x00,
  0x7C, 0x0F, 0x80, 0x7C, 0x01, 0xF8, 0x3E, 0x01, 0xF0, 0x03, 0xE1, 0xF8,
  0x0F, 0xC0, 0x0F, 0x87, 0xE0, 0x3F, 0x00, 0x3E, 0x1F, 0x00, 0xF8, 0x00,
  0xF8, 0x7C, 0x03, 0xE0, 0x01, 0xF1, 0xF0, 0x0F, 0x80, 0x07, 0xC7, 0xC0,
  0x3E, 0x00, 0x1F, 0x3F, 0x01, 0xF8, 0x00, 0x7C, 0xFC, 0x07, 0xE0, 0x01,
  0xFB, 0xE0, 0x1F, 0x00, 0x03, 0xEF, 0x80, 0x7C, 0x00, 0x0F, 0xBE, 0x01,
  0xF0, 0x00, 0x3F, 0xF8, 0x07, 0xC0, 0x00, 0xFF, 0xE0, 0x3F, 0x00, 0x01,
  0xFF, 0x80, 0xFC, 0x00, 0x07, 0xFC, 0x03, 0xE0, 0x00, 0x1F, 0xF0, 0x0F,
  0x80, 0x00, 0x7F, 0xC0, 0x3E, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x03, 0xE7,
  0xE0, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0x03, 0xF0, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x1F, 0x83,
  0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x03,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFC, 0x00, 0x07, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x7C,
  0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x7C, 0x00,
  0x00, 0x3F, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x1F, 0xC1,
  0xF8, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00,
  0x7E, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x1F, 0x00, 0x00, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x3F, 0x80, 0x07,
  0xE0, 0x0F, 0xE0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x00, 0xF8,
  0xFC, 0x00, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x00,
  0x7C, 0xFC, 0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x00, 0x7E, 0xFE, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0xFD,
  0xF8, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00,
  0xFD, 0xF8, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x01, 0x00, 0x00, 0x7F, 0x00, 0x70, 0x00, 0x07,
  0xE0, 0x1F, 0x00, 0x00, 0x7E, 0x0F, 0xF0, 0x00, 0x07, 0xE3, 0xF8, 0x00,
  0x00, 0xFE, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x3F,
  0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x0F,
  0xC0, 0x7C, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x7C, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x1F, 0x00, 0x01, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00,
  0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x01, 0xC0, 0x3F, 0x00, 0x00, 0x02,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x01, 0x00, 0x00, 0x00,
  0xFC, 0x0E, 0x00, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0xF0, 0x00, 0x3F,
  0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x7E, 0x00, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7C,
  0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x00, 0xF8,
  0x1F, 0x80, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x1F, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00,
  0x3E, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0xF8, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x7E, 0xF8, 0x00, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x00, 0xFC, 0xF8,
  0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x1F,
  0x87, 0xC0, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x7C,
  0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF8,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x03, 0xF0, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0xFC, 0x00,
  0x00, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0x07, 0xCF, 0xC0, 0x00,
  0x00, 0x7C, 0xFC, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x00, 0x7D, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x01, 0xF8,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0xF8, 0x03, 0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xFC, 0x03, 0xE0, 0x3E, 0x01,
  0xFE, 0x01, 0xF0, 0x1F, 0x00, 0xFF, 0x00, 0xF8, 0x0F, 0x80, 0xFF, 0x80,
  0x7C, 0x07, 0xC0, 0x7F, 0xC0, 0x7C, 0x03, 0xE0, 0x3F, 0xE0, 0x3E, 0x01,
  0xE0, 0x3E, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x78, 0x0F, 0x80, 0xF8, 0x0F,
  0x3C, 0x0F, 0x80, 0x7C, 0x0F, 0x9E, 0x07, 0xC0, 0x3E, 0x07, 0x8F, 0x03,
  0xE0, 0x1F, 0x07, 0xC7, 0x81, 0xF0, 0x0F, 0x83, 0xE3, 0xC1, 0xF0, 0x07,
  0xC1, 0xE1, 0xE0, 0xF8, 0x03, 0xE1, 0xF0, 0xF0, 0x7C, 0x01, 0xF0, 0xF0,
  0x7C, 0x3E, 0x00, 0xF8, 0xF8, 0x3E, 0x3E, 0x00, 0x78, 0x7C, 0x1F, 0x1F,
  0x00, 0x3C, 0x3C, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0x1F,
  0x1F, 0x03, 0xE3, 0xC0, 0x0F, 0x8F, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80,
  0xF9, 0xF0, 0x03, 0xE7, 0x80, 0x7C, 0xF8, 0x01, 0xF7, 0xC0, 0x3E, 0x7C,
  0x00, 0xFB, 0xE0, 0x0F, 0x7C, 0x00, 0x7D, 0xE0, 0x07, 0xBE, 0x00, 0x3F,
  0xF0, 0x03, 0xDF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0x87, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0,
  0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0xFC, 0x00,
  0x00, 0x03, 0xF9, 0xF8, 0x00, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0x1F,
  0xC3, 0xF0, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x7F,
  0x00, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00,
  0x0F, 0x8F, 0xC0, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00, 0x1F, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xF7, 0xC0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x7E, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x7C,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00,
  0x1F, 0x87, 0xC0, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x00, 0x3E, 0x7E, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x0F, 0x04,
  0x00, 0x00, 0x00, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x38, 0x7C, 0x3F, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x7C, 0x1F,
  0x0F, 0x83, 0xC1, 0xE0, 0x48, 0x00, 0x0F, 0xF0, 0x0F, 0x80, 0x1F, 0xFE,
  0x07, 0xC0, 0x3F, 0xFF, 0xC7, 0xE0, 0x3F, 0xFF, 0xF3, 0xF0, 0x3F, 0xFF,
  0xF9, 0xF0, 0x3F, 0xE0, 0x3E, 0xF8, 0x3F, 0xC0, 0x03, 0x7C, 0x1F, 0xC0,
  0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0x0F, 0x87, 0xE0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x03, 0xE3, 0xF0,
  0x00, 0x01, 0xF1, 0xF8, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0xFC, 0x7C,
  0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x1F, 0x1F,
  0x80, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x07, 0xE3,
  0xE0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x01, 0xF8,
  0x7C, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0xFF,
  0x0F, 0xC0, 0x00, 0xFF, 0x83, 0xF0, 0x00, 0xEF, 0x81, 0xFC, 0x00, 0xE7,
  0xC0, 0xFF, 0x81, 0xF3, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0x8F, 0xFF, 0xF0,
  0xFF, 0xC7, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x7F, 0x00, 0x07, 0xE0,
  0xFF, 0xF0, 0x01, 0xF8, 0x7F, 0xFF, 0x00, 0x7E, 0x3F, 0xFF, 0xE0, 0x1F,
  0x1F, 0xFF, 0xF8, 0x07, 0xCF, 0x80, 0xFF, 0x01, 0xF7, 0x80, 0x1F, 0xC0,
  0xFD, 0xC0, 0x03, 0xF8, 0x3F, 0xE0, 0x00, 0x7E, 0x0F, 0xF0, 0x00, 0x1F,
  0x83, 0xF8, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00,
  0x3F, 0x1F, 0x80, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x00, 0xF8, 0x7C, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x7E, 0x3E,
  0x00, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x03, 0xF0,
  0xF8, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x01,
  0xF8, 0x1F, 0x60, 0x01, 0xFE, 0x0F, 0xDE, 0x01, 0xFF, 0x03, 0xF7, 0xFF,
  0xFF, 0x80, 0xF8, 0xFF, 0xFF, 0xC0, 0x3E, 0x1F, 0xFF, 0xE0, 0x0F, 0x81,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0x81, 0xFC, 0x00, 0x3F, 0x07, 0xF0,
  0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x70, 0x7E, 0x00,
  0x00, 0x81, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x10, 0xFC, 0x00, 0x00, 0x71, 0xF8, 0x00, 0x01, 0xF9,
  0xF0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0xFC, 0x0F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x1F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x3F, 0xFE, 0x0F, 0xC0,
  0x0F, 0xFF, 0xF0, 0xF8, 0x01, 0xFF, 0xFF, 0x8F, 0x80, 0x3F, 0xFF, 0xFC,
  0xF8, 0x07, 0xFE, 0x03, 0xCF, 0x80, 0x7F, 0x00, 0x0F, 0xF8, 0x0F, 0xE0,
  0x00, 0x7F, 0x81, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x7E, 0x00,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0x3E, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x00, 0xFC, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x01, 0xFC, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x6F,
  0x80, 0x7E, 0x00, 0x0E, 0xF8, 0x07, 0xF0, 0x03, 0xDF, 0x80, 0x7F, 0xC0,
  0xF9, 0xF8, 0x03, 0xFF, 0xFF, 0x9F, 0x00, 0x1F, 0xFF, 0xF1, 0xF0, 0x00,
  0xFF, 0xFE, 0x1F, 0x00, 0x07, 0xFF, 0x81, 0xF0, 0x00, 0x1F, 0xE0, 0x20,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFE, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0x3E, 0x3E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x03,
  0xFC, 0x7C, 0x00, 0x1F, 0xF8, 0xFC, 0x03, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x20, 0xFC, 0x00, 0x00, 0x38, 0xFC, 0x00, 0x00,
  0x7C, 0x7C, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x03,
  0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x04, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x04, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x07,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFC, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0xF1, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0xFF,
  0xF8, 0x3F, 0x00, 0x1F, 0xFF, 0xC3, 0xE0, 0x07, 0xFF, 0xFE, 0x3E, 0x00,
  0xFF, 0xFF, 0xF3, 0xE0, 0x1F, 0xF8, 0x0F, 0x3E, 0x01, 0xFC, 0x00, 0x3F,
  0xE0, 0x3F, 0x80, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x7C, 0x0F,
  0x80, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x0F, 0x83, 0xF0, 0x00,
  0x00, 0xF8, 0x3F, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x3F,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x3F, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x1B, 0xE0, 0x1F,
  0x80, 0x03, 0xBE, 0x01, 0xFC, 0x00, 0x73, 0xE0, 0x1F, 0xF0, 0x3F, 0x7E,
  0x00, 0xFF, 0xFF, 0xE7, 0xE0, 0x07, 0xFF, 0xFC, 0x7C, 0x00, 0x3F, 0xFF,
  0x87, 0xC0, 0x01, 0xFF, 0xE0, 0x7C, 0x00, 0x07, 0xF8, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x10, 0x00, 0x03, 0xF0, 0x01, 0x80, 0x00, 0x7E, 0x00, 0x3C,
  0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x03,
  0xE0, 0x7F, 0xF0, 0x03, 0xE1, 0xFF, 0xF8, 0x03, 0xE3, 0xFF, 0xFC, 0x07,
  0xE7, 0xFF, 0xFE, 0x07, 0xE7, 0x81, 0xFE, 0x07, 0xEE, 0x00, 0x7E, 0x07,
  0xDC, 0x00, 0x7F, 0x07, 0xD8, 0x00, 0x3F, 0x0F, 0xF0, 0x00, 0x3F, 0x0F,
  0xE0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x3E, 0x1F,
  0x80, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7E, 0x1F,
  0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x7C, 0x3F,
  0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xFC, 0x3E,
  0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0xF8, 0x7E,
  0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF8, 0x7C,
  0x00, 0x01, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x01, 0xF0, 0xFC,
  0x00, 0x01, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x01, 0x00, 0x0F, 0xC0, 0x07, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x7C, 0x01, 0xFC, 0x00, 0xF8,
  0x07, 0xF0, 0x03, 0xF0, 0x1F, 0xC0, 0x07, 0xE0, 0x7F, 0x00, 0x0F, 0x83,
  0xFC, 0x00, 0x1F, 0x0F, 0xF0, 0x00, 0x3E, 0x3F, 0xC0, 0x00, 0xFC, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x10, 0x00, 0x3E, 0x00, 0x38, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7C,
  0x00, 0x3F, 0x80, 0x7C, 0x00, 0x3F, 0x80, 0x7C, 0x00, 0x1F, 0xC0, 0xFC,
  0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x03, 0xF8, 0xF8,
  0x00, 0x01, 0xFC, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0xFE, 0x00, 0x03,
  0xE0, 0x7F, 0xF0, 0x00, 0x7C, 0x3F, 0xFF, 0x00, 0x0F, 0x8F, 0xFF, 0xF0,
  0x03, 0xF3, 0xFF, 0xFF, 0x00, 0x7E, 0x78, 0x1F, 0xE0, 0x0F, 0xDC, 0x00,
  0xFE, 0x01, 0xF7, 0x00, 0x0F, 0xC0, 0x3E, 0xC0, 0x01, 0xF8, 0x0F, 0xF0,
  0x00, 0x3F, 0x01, 0xFE, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0xF8, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x01, 0xF8,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F,
  0xE0, 0x03, 0xE0, 0x07, 0xF8, 0x00, 0x7C, 0x07, 0xFC, 0x00, 0x0F, 0x8F,
  0xFE, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x0F,
  0xC1, 0xF0, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x04, 0x3E, 0x03, 0xE0, 0x03,
  0xC7, 0xC0, 0x7E, 0x00, 0xFD, 0xF8, 0x0F, 0xC0, 0x3F, 0xBF, 0x00, 0xFC,
  0x0F, 0xE7, 0xE0, 0x1F, 0x83, 0xF8, 0xF8, 0x01, 0xF8, 0xFE, 0x1F, 0x00,
  0x3F, 0x3F, 0x83, 0xE0, 0x03, 0xFF, 0xE0, 0xFC, 0x00, 0x7F, 0xF8, 0x1F,
  0x80, 0x07, 0xFE, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x40,
  0x1F, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xE0, 0x7E,
  0x00, 0xFE, 0x03, 0xE0, 0x0F, 0xE0, 0x1F, 0x00, 0xFE, 0x00, 0xF8, 0x1F,
  0xE0, 0x0F, 0xC1, 0xFE, 0x00, 0x7E, 0x1F, 0xC0, 0x03, 0xF1, 0xFC, 0x00,
  0x1F, 0x1F, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE1,
  0xF0, 0x07, 0xE0, 0x1F, 0x8F, 0xF0, 0x7F, 0xC0, 0x7C, 0x7F, 0xC3, 0xFF,
  0x81, 0xF3, 0xFF, 0x9F, 0xFF, 0x07, 0xDF, 0xFE, 0x7F, 0xFC, 0x1F, 0x70,
  0xFB, 0xC3, 0xF0, 0x7F, 0x03, 0xEE, 0x07, 0xC1, 0xF8, 0x07, 0xF0, 0x1F,
  0x0F, 0xE0, 0x1F, 0x80, 0x7C, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0xFC, 0x01,
  0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x00, 0x7C,
  0x3E, 0x00, 0xF8, 0x03, 0xE1, 0xF8, 0x03, 0xE0, 0x0F, 0x87, 0xC0, 0x0F,
  0x80, 0x3E, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0x03, 0xE1,
  0xF0, 0x07, 0xC0, 0x0F, 0x87, 0xC0, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0x7C,
  0x01, 0xF0, 0xF8, 0x01, 0xF0, 0x07, 0xC3, 0xE0, 0x07, 0xC0, 0x1F, 0x0F,
  0x80, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xE0,
  0x0F, 0x87, 0xC0, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x7C,
  0x00, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC0, 0x0F, 0x87, 0xC0, 0x1F, 0x00,
  0x3E, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0x07, 0xC3, 0xE0,
  0x07, 0xC0, 0x1F, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x1F, 0xC0, 0x03, 0xE0, 0x7F, 0xF0, 0x03, 0xE1, 0xFF,
  0xF8, 0x07, 0xE3, 0xFF, 0xFC, 0x07, 0xE7, 0xFF, 0xFE, 0x07, 0xE7, 0x81,
  0xFE, 0x07, 0xEE, 0x00, 0x7E, 0x07, 0xDC, 0x00, 0x7F, 0x07, 0xD8, 0x00,
  0x3F, 0x0F, 0xF0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x3F, 0x0F, 0xE0, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0x80, 0x00,
  0x3E, 0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x80, 0x00,
  0x3E, 0x1F, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00,
  0x7C, 0x3F, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00,
  0x7C, 0x3E, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00,
  0xF8, 0x7E, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00,
  0xF8, 0x7C, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x01,
  0xF0, 0xFC, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xE0, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x7D, 0xF8,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0xFD,
  0xF8, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0x3F,
  0x1F, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F,
  0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0xFF, 0xF0, 0x00, 0x3F, 0x0F, 0xFF, 0xE0,
  0x01, 0xF0, 0xFF, 0xFF, 0x80, 0x0F, 0x8F, 0xFF, 0xFC, 0x00, 0x7C, 0xF8,
  0x0F, 0xF0, 0x07, 0xEF, 0x00, 0x3F, 0x80, 0x3F, 0x70, 0x00, 0xFE, 0x01,
  0xFF, 0x00, 0x03, 0xF0, 0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x00,
  0x7C, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x3F, 0x03,
  0xE0, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00,
  0xFC, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x3E, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x01, 0xF8,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x3E, 0xC0, 0x03, 0xFC, 0x03, 0xF7, 0xC0,
  0x7F, 0xC0, 0x1F, 0xBF, 0xFF, 0xFC, 0x00, 0xF8, 0xFF, 0xFF, 0xC0, 0x07,
  0xC3, 0xFF, 0xFC, 0x00, 0x3E, 0x07, 0xFF, 0x80, 0x01, 0xF0, 0x0F, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x0F, 0xFF, 0x83, 0xF0, 0x0F,
  0xFF, 0xF0, 0xF8, 0x07, 0xFF, 0xFE, 0x3E, 0x03, 0xFF, 0xFF, 0xCF, 0x81,
  0xFF, 0x80, 0xF3, 0xE0, 0x7F, 0x00, 0x0F, 0xF8, 0x3F, 0x80, 0x01, 0xFE,
  0x1F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x00, 0x3E, 0x3F, 0x00, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x00, 0xFC,
  0x3E, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F,
  0xE0, 0xFC, 0x00, 0x06, 0xF8, 0x1F, 0x80, 0x03, 0xFE, 0x07, 0xF0, 0x03,
  0xDF, 0x81, 0xFF, 0x03, 0xE7, 0xE0, 0x3F, 0xFF, 0xF1, 0xF0, 0x07, 0xFF,
  0xFC, 0x7C, 0x00, 0xFF, 0xFE, 0x1F, 0x00, 0x1F, 0xFE, 0x0F, 0xC0, 0x01,
  0xFE, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0xFF, 0xDF, 0xFF, 0xC0, 0xFF, 0xE7, 0xFF, 0xF0, 0xFF, 0xF9,
  0xFF, 0xFC, 0x7F, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF, 0xA0, 0x0F, 0xCF, 0x80,
  0x00, 0x03, 0xF7, 0x00, 0x00, 0x00, 0xFB, 0x80, 0x00, 0x00, 0x3E, 0xC0,
  0x00, 0x00, 0x0F, 0xA0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xF0, 0x3F, 0x80,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x1C, 0x03, 0xE0, 0x00, 0x04, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x20, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0x7E, 0x1F,
  0x80, 0x00, 0x3F, 0x8F, 0xF8, 0x00, 0x1F, 0xC1, 0xFF, 0x80, 0x1F, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x80, 0x1F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x18, 0x00, 0xF8, 0x00, 0x3C, 0x01, 0xF8,
  0x00, 0xFE, 0x01, 0xF8, 0x01, 0xFE, 0x01, 0xF8, 0x07, 0xFC, 0x01, 0xF0,
  0x0F, 0xF0, 0x01, 0xF0, 0x3F, 0xE0, 0x03, 0xF0, 0x7F, 0xC0, 0x03, 0xF1,
  0xFF, 0x00, 0x03, 0xF3, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x7C, 0x7E, 0x00,
  0x00, 0xF8, 0xFC, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x07, 0xE3, 0xE0, 0x00,
  0x0F, 0xC7, 0xC0, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x3E, 0x3F, 0x00, 0x00,
  0x7C, 0x7E, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x07,
  0xE3, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x3E,
  0x3F, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x03, 0xF1,
  0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x1F, 0x1F,
  0x80, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x01, 0xF8, 0xF8,
  0x00, 0x07, 0xE1, 0xF0, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x3F, 0x87, 0xC0,
  0x00, 0xFF, 0x0F, 0xC0, 0x03, 0xFE, 0x1F, 0x80, 0x0E, 0xFC, 0x3F, 0x80,
  0x39, 0xF0, 0x3F, 0x81, 0xF3, 0xE0, 0x7F, 0xFF, 0xC7, 0xC0, 0x7F, 0xFF,
  0x0F, 0x80, 0x7F, 0xFC, 0x3F, 0x00, 0x7F, 0xF0, 0x7E, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0C, 0xFF, 0xF8, 0x00, 0x7E, 0xFF, 0xF8,
  0x00, 0x7E, 0xFF, 0xF8, 0x00, 0x3E, 0xFF, 0xF0, 0x00, 0x3F, 0x01, 0xF0,
  0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x1F, 0x03, 0xF0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x7E, 0x07, 0xC0,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0xFC, 0x0F, 0xC0,
  0x01, 0xF8, 0x0F, 0x80, 0x03, 0xF8, 0x0F, 0x80, 0x07, 0xF0, 0x0F, 0x80,
  0x07, 0xE0, 0x0F, 0x80, 0x1F, 0xE0, 0x0F, 0x80, 0x3F, 0xC0, 0x0F, 0x80,
  0x7F, 0x80, 0x1F, 0x81, 0xFF, 0x00, 0x1F, 0x8F, 0xFE, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x40, 0xF8,
  0x03, 0xE0, 0x3E, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x3E,
  0x0F, 0x80, 0x3E, 0x01, 0xF0, 0xF0, 0x03, 0xE0, 0x1F, 0x1F, 0x00, 0x3C,
  0x01, 0xF1, 0xF0, 0x07, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x01, 0xF1, 0xF0,
  0x07, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x01, 0xF1, 0xE0, 0x07, 0xC0, 0x1F,
  0x3E, 0x00, 0x78, 0x01, 0xF3, 0xE0, 0x0F, 0x80, 0x1F, 0x3E, 0x00, 0xF8,
  0x01, 0xF3, 0xE0, 0x0F, 0x80, 0x1F, 0x3E, 0x00, 0xF8, 0x01, 0xF3, 0xC0,
  0x0F, 0x80, 0x1F, 0x7C, 0x00, 0xF0, 0x01, 0xF7, 0xC0, 0x1F, 0x00, 0x3E,
  0x7C, 0x01, 0xF0, 0x03, 0xE7, 0xC0, 0x1F, 0x00, 0x3E, 0x7C, 0x01, 0xF0,
  0x03, 0xE7, 0x80, 0x1F, 0x00, 0x7C, 0xF8, 0x03, 0xE0, 0x07, 0xCF, 0x80,
  0x3E, 0x00, 0x7C, 0xF8, 0x03, 0xE0, 0x0F, 0x8F, 0x80, 0x7E, 0x00, 0xF8,
  0xF8, 0x07, 0xE0, 0x1F, 0x8F, 0x80, 0xFE, 0x03, 0xF0, 0xF8, 0x1D, 0xF0,
  0x7F, 0x0F, 0xC3, 0xDF, 0x0F, 0xE0, 0xFF, 0xF9, 0xFF, 0xFC, 0x07, 0xFF,
  0x8F, 0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0xF0, 0x03, 0xFE, 0x07, 0xFE, 0x00,
  0x1F, 0x80, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x07,
  0xF8, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x87,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x0F, 0xF3, 0xE3, 0xE1, 0xFC,
  0x0F, 0xF1, 0xF1, 0xE0, 0x7E, 0x1F, 0xE0, 0x79, 0xE0, 0x1F, 0x1F, 0xC0,
  0x3C, 0xE0, 0x0F, 0x87, 0xC0, 0x1E, 0x70, 0x07, 0xC3, 0x80, 0x0F, 0x70,
  0x03, 0xE1, 0x00, 0x07, 0xB8, 0x01, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0xFE, 0x00,
  0x00, 0x3E, 0x00, 0x6F, 0x00, 0x08, 0x3F, 0x00, 0x77, 0x80, 0x1E, 0x1F,
  0x80, 0x3B, 0xC0, 0x1F, 0x8F, 0xC0, 0x39, 0xF0, 0x1F, 0x83, 0xE0, 0x3C,
  0xF8, 0x3F, 0x81, 0xF0, 0x3E, 0x7C, 0x3F, 0x80, 0xFC, 0x3E, 0x3E, 0x7F,
  0x80, 0x7F, 0xFF, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x7C,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00,
  0x7E, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x1F, 0x80,
  0x00, 0x3E, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00,
  0x7C, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x00,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x01, 0xF0, 0x1F,
  0x80, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x03, 0xF8,
  0x0F, 0x80, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x06,
  0xF8, 0x07, 0xE0, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0x37, 0xE0, 0x1F, 0xC0,
  0x1E, 0xFC, 0x01, 0xFE, 0x0F, 0x9F, 0x00, 0x3F, 0xFF, 0xE3, 0xE0, 0x03,
  0xFF, 0xFC, 0x7C, 0x00, 0x3F, 0xFF, 0x0F, 0x80, 0x03, 0xFF, 0x83, 0xF0,
  0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x40, 0x00, 0x1F, 0xC0, 0x1C,
  0x00, 0x07, 0xF0, 0x07, 0xC0, 0x01, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x07, 0xE0, 0x1F, 0xFF, 0x80, 0xF8, 0x0F, 0xFF, 0xFC, 0x1F,
  0x03, 0xFF, 0xFF, 0xE3, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xC0, 0xFF,
  0xFF, 0x83, 0xE0, 0x03, 0xFF, 0xF0, 0x7C, 0x00, 0x1F, 0xFC, 0x1F, 0x00,
  0x00, 0x7F, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x07, 0xE0, 0x0F,
  0x80, 0x01, 0xF8, 0x01, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x10, 0x00,
  0x1F, 0xC0, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xE0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x00, 0xF8, 0x0F, 0xE0, 0x00,
  0x0F, 0x83, 0xFE, 0x00, 0x01, 0xF0, 0xFF, 0xFC, 0x00, 0x3E, 0x3F, 0xFF,
  0xFC, 0x07, 0xC7, 0xEF, 0xFF, 0xF8, 0xF8, 0xFC, 0x3F, 0xFF, 0xFF, 0x1F,
  0x00, 0xFF, 0xFF, 0xE3, 0xE0, 0x03, 0xFF, 0xF8, 0x7C, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0,
  0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xC0, 0x1F,
  0xF0, 0x00, 0x1F, 0x03, 0xFF, 0xC0, 0x01, 0xF0, 0x7F, 0xFC, 0x00, 0x1E,
  0x0F, 0xFF, 0xE0, 0x03, 0xE0, 0xFC, 0x7F, 0x00, 0x3E, 0x1F, 0x81, 0xF0,
  0x07, 0xC1, 0xF0, 0x1F, 0x80, 0x7C, 0x3E, 0x00, 0xFC, 0x0F, 0x83, 0xE0,
  0x07, 0xE1, 0xF8, 0x7C, 0x00, 0x7F, 0xFF, 0x07, 0xC0, 0x03, 0xFF, 0xE0,
  0x78, 0x00, 0x1F, 0xFC, 0x0F, 0x80, 0x00, 0xFF, 0x80, 0x18, 0x00, 0x03,
  0xE0, 0x00,
};

const GFXglyph IBMPlexMono_Italic69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 16, 49, 41, 13, -48 },
  { 99, 20, 19, 41, 15, -51 },
  { 147, 42, 48, 41, 1, -48 },
  { 399, 38, 64, 41, 2, -56 },
  { 703, 47, 50, 41, -2, -49 },
  { 997, 41, 50, 41, 0, -49 },
  { 1254, 9, 19, 41, 20, -51 },
  { 1276, 26, 62, 41, 14, -52 },
  { 1478, 26, 62, 41, 3, -52 },
  { 1680, 35, 34, 41, 4, -38 },
  { 1829, 33, 33, 41, 5, -38 },
  { 1966, 15, 19, 41, 10, -9 },
  { 2002, 21, 5, 41, 11, -23 },
  { 2016, 11, 9, 41, 13, -8 },
  { 2029, 39, 62, 41, 2, -52 },
  { 2332, 35, 50, 41, 4, -49 },
  { 2551, 33, 48, 41, 3, -48 },
  { 2749, 36, 49, 41, 2, -49 },
  { 2970, 36, 50, 41, 2, -49 },
  { 3195, 37, 48, 41, 1, -48 },
  { 3417, 36, 49, 41, 3, -48 },
  { 3638, 33, 49, 41, 4, -48 },
  { 3841, 35, 48, 41, 7, -48 },
  { 4051, 36, 50, 41, 3, -49 },
  { 4276, 33, 49, 41, 6, -49 },
  { 4479, 15, 36, 41, 13, -35 },
  { 4547, 18, 45, 41, 10, -35 },
  { 4649, 33, 40, 41, 6, -41 },
  { 4814, 35, 19, 41, 4, -31 },
  { 4898, 34, 40, 41, 3, -41 },
  { 5068, 29, 50, 41, 9, -49 },
  { 5250, 35, 57, 41, 4, -49 },
  { 5500, 37, 48, 41, -1, -48 },
  { 5722, 35, 48, 41, 3, -48 },
  { 5932, 35, 50, 41, 5, -49 },
  { 6151, 35, 48, 41, 4, -48 },
  { 6361, 38, 48, 41, 3, -48 },
  { 6589, 39, 48, 41, 3, -48 },
  { 6823, 34, 50, 41, 5, -49 },
  { 7036, 38, 48, 41, 3, -48 },
  { 7264, 38, 48, 41, 3, -48 },
  { 7492, 34, 49, 41, 4, -48 },
  { 7701, 42, 48, 41, 3, -48 },
  { 7953, 30, 48, 41, 5, -48 },
  { 8133, 40, 48, 41, 2, -48 },
  { 8373, 38, 48, 41, 3, -48 },
  { 8601, 35, 50, 41, 4, -49 },
  { 8820, 37, 48, 41, 3, -48 },
  { 9042, 35, 62, 41, 4, -49 },
  { 9314, 37, 48, 41, 3, -48 },
  { 9536, 38, 50, 41, 2, -49 },
  { 9774, 39, 48, 41, 6, -48 },
  { 10008, 36, 49, 41, 5, -48 },
  { 10229, 36, 48, 41, 8, -48 },
  { 10445, 41, 48, 41, 3, -48 },
  { 10691, 45, 48, 41, -1, -48 },
  { 10961, 39, 48, 41, 6, -48 },
  { 11195, 42, 48, 41, 0, -48 },
  { 11447, 29, 62, 41, 11, -52 },
  { 11672, 18, 62, 41, 13, -52 },
  { 11812, 29, 62, 41, 1, -52 },
  { 12037, 35, 28, 41, 4, -48 },
  { 12160, 34, 5, 41, 0, 7 },
  { 12182, 9, 13, 41, 16, -53 },
  { 12197, 33, 37, 41, 4, -36 },
  { 12350, 34, 52, 41, 4, -51 },
  { 12571, 31, 37, 41, 5, -36 },
  { 12715, 36, 52, 41, 4, -51 },
  { 12949, 32, 37, 41, 5, -36 },
  { 13097, 45, 66, 41, -1, -51 },
  { 13469, 36, 51, 41, 2, -36 },
  { 13699, 32, 51, 41, 4, -51 },
  { 13903, 31, 53, 41, 6, -52 },
  { 14109, 32, 67, 41, 4, -52 },
  { 14377, 35, 52, 41, 4, -51 },
  { 14605, 29, 52, 41, 7, -51 },
  { 14794, 38, 36, 41, 1, -36 },
  { 14965, 32, 36, 41, 4, -36 },
  { 15109, 33, 37, 41, 4, -36 },
  { 15262, 37, 50, 41, 1, -36 },
  { 15494, 34, 50, 41, 4, -36 },
  { 15707, 34, 36, 41, 7, -36 },
  { 15860, 34, 37, 41, 3, -36 },
  { 16018, 32, 49, 41, 5, -48 },
  { 16214, 31, 37, 41, 6, -36 },
  { 16358, 32, 37, 41, 5, -36 },
  { 16506, 36, 37, 41, 3, -36 },
  { 16673, 41, 37, 41, 0, -36 },
  { 16863, 35, 51, 41, 2, -36 },
  { 17087, 35, 37, 41, 4, -36 },
  { 17249, 32, 62, 41, 8, -52 },
  { 17497, 15, 62, 41, 14, -52 },
  { 17614, 32, 62, 41, 3, -52 },
  { 17862, 36, 15, 41, 3, -29 },
};

const GFXfont IBMPlexMono_Italic69pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic69pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic69pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _IBMPLEXMONO_ITALIC69PT7B_H_
