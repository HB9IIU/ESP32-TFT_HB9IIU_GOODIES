#ifndef _IBMPLEXMONO_ITALIC49PT7B_H_
#define _IBMPLEXMONO_ITALIC49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x07, 0xF0, 0xFE, 0x1F, 0xC7, 0xF0, 0x7E, 0x0F, 0x80,
  0x3C, 0x1E, 0x78, 0x3C, 0xF0, 0x71, 0xE0, 0xE3, 0x83, 0xC7, 0x07, 0x9E,
  0x0F, 0x3C, 0x1E, 0x78, 0x38, 0xF0, 0x71, 0xC1, 0xE3, 0x83, 0xCF, 0x07,
  0x9E, 0x0F, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x70, 0x78, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x07, 0x07, 0x80, 0x3F, 0xF8, 0x3F, 0xF1, 0xFF,
  0x81, 0xFF, 0x8F, 0xFC, 0x1F, 0xFC, 0x01, 0xE0, 0xF0, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x38, 0x1C, 0x00,
  0x03, 0xC1, 0xE0, 0x0F, 0xFE, 0x0F, 0xFC, 0x7F, 0xE0, 0x7F, 0xE3, 0xFF,
  0x07, 0xFF, 0x00, 0x78, 0x38, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x3C, 0x1E,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1E, 0x07, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x78, 0x1C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1C,
  0x0E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xC0, 0x3F, 0x9C, 0xFC, 0x07, 0xC1, 0xC3, 0xE0, 0x78, 0x1C,
  0x1F, 0x0F, 0x81, 0xC0, 0xC0, 0xF0, 0x38, 0x00, 0x0F, 0x03, 0x80, 0x00,
  0xF0, 0x38, 0x00, 0x0F, 0x03, 0x80, 0x00, 0xF8, 0x38, 0x00, 0x0F, 0xC3,
  0x00, 0x00, 0x7E, 0x70, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xE7, 0xF0, 0x00, 0x0E, 0x1F, 0x80, 0x00, 0xE0, 0xF8, 0x00, 0x0E, 0x07,
  0x80, 0x00, 0xE0, 0x78, 0x00, 0x0E, 0x07, 0x80, 0x01, 0xC0, 0x78, 0x10,
  0x1C, 0x07, 0x87, 0x01, 0xC0, 0xF8, 0xF8, 0x1C, 0x1F, 0x07, 0xE1, 0xC3,
  0xF0, 0x3F, 0x9C, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xC0, 0x7F, 0xF0, 0x01,
  0xC0, 0x78, 0x38, 0x01, 0xC0, 0x78, 0x1E, 0x01, 0xE0, 0x38, 0x07, 0x01,
  0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1E, 0x01, 0xC0, 0xF0, 0x0F, 0x01, 0xE0,
  0xF0, 0x07, 0x00, 0xF0, 0x70, 0x03, 0x80, 0x70, 0x78, 0x01, 0xC0, 0x38,
  0x78, 0x00, 0xF0, 0x3C, 0x38, 0x00, 0x38, 0x3C, 0x38, 0x00, 0x1F, 0xFC,
  0x3C, 0x00, 0x07, 0xFC, 0x1C, 0x00, 0x00, 0xF8, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xC3, 0xFE, 0x00, 0x03, 0xC3, 0xFF, 0x80, 0x01, 0xC3, 0xC3, 0xC0, 0x01,
  0xC3, 0xC0, 0xF0, 0x01, 0xE1, 0xC0, 0x38, 0x01, 0xE1, 0xE0, 0x1C, 0x00,
  0xE0, 0xF0, 0x0E, 0x00, 0xF0, 0x78, 0x0F, 0x00, 0xF0, 0x38, 0x07, 0x80,
  0x70, 0x1C, 0x03, 0x80, 0x78, 0x0E, 0x01, 0xC0, 0x78, 0x07, 0x01, 0xE0,
  0x38, 0x01, 0xC1, 0xE0, 0x38, 0x00, 0xFF, 0xE0, 0x3C, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x01, 0xF0, 0x00,
  0x78, 0x07, 0x80, 0x07, 0x80, 0x3C, 0x00, 0x3C, 0x01, 0xE0, 0x01, 0xE0,
  0x07, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x78, 0x03, 0xC0, 0x03, 0xC0, 0x1E,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xC7,
  0xE0, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x07, 0x80,
  0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0xF0, 0x07, 0x80, 0x07,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x11, 0xE0, 0x03, 0xC0, 0xFF, 0x00,
  0x3E, 0x07, 0x78, 0x01, 0x78, 0x79, 0xE0, 0x1B, 0xC3, 0x8F, 0x00, 0xCF,
  0x3C, 0x7C, 0x1C, 0x79, 0xC1, 0xFF, 0xE1, 0xFE, 0x07, 0xFE, 0x0F, 0xE0,
  0x0F, 0xC0, 0x1E, 0x00, 0x39, 0xDE, 0xF7, 0xBD, 0xCE, 0xF7, 0xBD, 0xEE,
  0x70, 0x00, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x01, 0x00, 0x3C, 0x02, 0x70, 0x1C, 0x07, 0x7F,
  0x0E, 0x1F, 0xBF, 0xF7, 0xFF, 0xE3, 0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xEF, 0x00,
  0x01, 0xE7, 0x80, 0x01, 0xE1, 0xE0, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x30, 0x01, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xE1, 0xF8, 0x3E, 0x0F,
  0xC1, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0x38, 0x0F,
  0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3E, 0x7F,
  0x7F, 0x7F, 0xFE, 0x7E, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0x03, 0xF0, 0x3E, 0x00, 0xF8, 0x3E, 0x00,
  0x3C, 0x1E, 0x00, 0x1F, 0x1E, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xCF, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x7B, 0xE0, 0x00, 0x3D, 0xE0,
  0x00, 0x1E, 0xF0, 0x3C, 0x0F, 0x78, 0x3F, 0x0F, 0xBC, 0x1F, 0x87, 0xFE,
  0x1F, 0x83, 0xDE, 0x0F, 0xC1, 0xEF, 0x03, 0xC0, 0xF7, 0x80, 0x00, 0x7B,
  0xC0, 0x00, 0x7D, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x1F,
  0x3C, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x8F, 0x00, 0x07, 0x83, 0xC0, 0x07,
  0xC1, 0xF0, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFD, 0xE0, 0x01,
  0xF9, 0xE0, 0x03, 0xF1, 0xE0, 0x07, 0xC3, 0xC0, 0x1F, 0x83, 0xC0, 0x1F,
  0x03, 0xC0, 0x0E, 0x03, 0xC0, 0x0C, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0xF8, 0x03, 0xE0, 0x7C, 0x00,
  0x7C, 0x1E, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xC0, 0x40, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xF8, 0x1F,
  0x80, 0xF8, 0x01, 0xF0, 0x3C, 0x00, 0x7C, 0x06, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x40, 0x00, 0x78, 0x30, 0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x07,
  0xC1, 0xFC, 0x07, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x8F, 0x00, 0x03,
  0xC3, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x1E, 0x00,
  0x3C, 0x07, 0x80, 0x0E, 0x01, 0xE0, 0x07, 0x80, 0x70, 0x03, 0xC0, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x1C, 0x00,
  0x38, 0x0E, 0x00, 0x1E, 0x07, 0x00, 0x07, 0x83, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x0F, 0xC0, 0x03, 0xCF, 0xFC, 0x00, 0xE7, 0xFF, 0x80, 0x3B, 0xFF, 0xF0,
  0x0F, 0xC0, 0xFE, 0x07, 0xC0, 0x0F, 0x81, 0xE0, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x81, 0x00, 0x01, 0xE0,
  0xC0, 0x00, 0xF8, 0x78, 0x00, 0x7C, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x3F,
  0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF1, 0xFC, 0x03, 0xCF, 0xFE, 0x07, 0x3F, 0xFE, 0x1E, 0xFF, 0xFE,
  0x3B, 0xC0, 0xFC, 0xFE, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xF7, 0x80, 0x03, 0xEF, 0x80,
  0x07, 0x8F, 0x80, 0x1F, 0x1F, 0x80, 0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0x80, 0x01, 0xE3, 0x80,
  0x00, 0xF1, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0xF8, 0xF0, 0x00, 0x78, 0x78,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x03, 0xF0, 0x1F, 0x81, 0xF0,
  0x01, 0xF0, 0x78, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x0F,
  0x01, 0xE0, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3E, 0x01, 0xF0, 0x1E,
  0x00, 0x1E, 0x0F, 0x00, 0x07, 0xC7, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x3C,
  0xF8, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x7C, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x8F, 0xC0, 0x07, 0xE1, 0xFC,
  0x07, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xE0, 0xFC, 0x0F, 0xC3, 0xE0, 0x07, 0xCF, 0x80, 0x07, 0x9E,
  0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x1D, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0x78, 0x00, 0x7E, 0xF8, 0x01, 0xF9, 0xFC, 0x0E, 0xF1, 0xFF, 0xFB,
  0xC1, 0xFF, 0xE7, 0x81, 0xFF, 0x9E, 0x00, 0xFC, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC1, 0xFC, 0x3F,
  0x87, 0xF0, 0xFE, 0x1F, 0x81, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0xFE, 0x1F, 0xC3, 0xF8, 0xFE, 0x0F, 0xC1, 0xF0, 0x00, 0x01, 0xF0,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x3E, 0x03,
  0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xE0,
  0x0E, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x04, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x1F, 0xFE, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xF0, 0x3F, 0x1F, 0x00,
  0x7D, 0xF0, 0x01, 0xEF, 0x00, 0x0F, 0xF0, 0x00, 0x78, 0x80, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x7C, 0x07, 0xC0, 0x7C, 0x01, 0xE0, 0x3C, 0x00, 0x78,
  0x3C, 0x00, 0x1C, 0x3C, 0x00, 0x0E, 0x1E, 0x00, 0x07, 0x0E, 0x00, 0x03,
  0xCF, 0x01, 0xF1, 0xC7, 0x81, 0xFC, 0xE3, 0x81, 0xFF, 0x71, 0xC1, 0xF0,
  0xB9, 0xE0, 0xF0, 0x3C, 0xF0, 0xF0, 0x1E, 0x78, 0x70, 0x0F, 0x38, 0x78,
  0x07, 0x1C, 0x3C, 0x03, 0x9E, 0x1E, 0x01, 0xCF, 0x0F, 0x00, 0xE7, 0x87,
  0x00, 0xF3, 0xC3, 0x80, 0x79, 0xC1, 0xC0, 0x3C, 0xE0, 0xE0, 0x1C, 0x70,
  0x70, 0x1E, 0x38, 0x38, 0x1F, 0x1C, 0x1E, 0x0F, 0x8E, 0x0F, 0xDF, 0xC7,
  0x03, 0xFD, 0xE3, 0x80, 0xFC, 0xE1, 0xE0, 0x10, 0x00, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x3C, 0xF0,
  0x00, 0x0F, 0x3C, 0x00, 0x07, 0x87, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0xF0,
  0x78, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x03,
  0xC0, 0x78, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x0F, 0x80, 0x3C, 0x03, 0xC0, 0x0F, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xC0, 0x01, 0xE1, 0xF0,
  0x00, 0x78, 0x78, 0x00, 0x1E, 0x3E, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xE7,
  0xC0, 0x00, 0x79, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x78, 0x01, 0xF8, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0F,
  0x00, 0x0F, 0x07, 0x80, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1,
  0xE0, 0x01, 0xF0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0xF0,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0x80, 0x1F,
  0x03, 0xC0, 0x03, 0xC1, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x78, 0xF0, 0x00,
  0x3C, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x9E, 0x00,
  0x07, 0xCF, 0x00, 0x07, 0xC7, 0x80, 0x03, 0xE3, 0xC0, 0x07, 0xE1, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x7F, 0x07, 0xE0, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0x3C, 0x3E, 0x00,
  0x1E, 0x1E, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x10, 0x3C, 0x00, 0x0E,
  0x1E, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0x83, 0xC0, 0x07, 0xC1, 0xF0, 0x07,
  0xC0, 0xFE, 0x0F, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x01,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x78, 0x07, 0xE0, 0x7C, 0x01, 0xF8,
  0x3C, 0x00, 0x7C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x03,
  0xC3, 0xC0, 0x01, 0xE3, 0xE0, 0x00, 0xF1, 0xE0, 0x00, 0x78, 0xF0, 0x00,
  0x3C, 0x78, 0x00, 0x3E, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x1E, 0x00,
  0x07, 0x8F, 0x00, 0x03, 0xC7, 0x80, 0x01, 0xE3, 0xC0, 0x01, 0xF1, 0xE0,
  0x00, 0xF8, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x3E, 0x3C,
  0x00, 0x1E, 0x1E, 0x00, 0x1F, 0x0F, 0x00, 0x1F, 0x07, 0x80, 0x1F, 0x07,
  0x80, 0x3F, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F,
  0x03, 0xF0, 0x3F, 0x00, 0xF8, 0x3E, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x1F,
  0x00, 0x07, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x03, 0xFF, 0x9F, 0x01, 0xFF,
  0xCF, 0x80, 0xFF, 0xE7, 0xC0, 0x7F, 0xF3, 0xC0, 0x00, 0x79, 0xE0, 0x00,
  0x38, 0xF0, 0x00, 0x1C, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x1F, 0x00,
  0x07, 0x87, 0x80, 0x07, 0xC3, 0xC0, 0x03, 0xC1, 0xF0, 0x03, 0xE0, 0x78,
  0x03, 0xF0, 0x3F, 0x07, 0x78, 0x0F, 0xFF, 0x3C, 0x03, 0xFF, 0x1E, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00,
  0x07, 0x83, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0xF0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x3C,
  0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1E, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0xF0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0,
  0x7C, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x3C, 0x00,
  0x1E, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x3E, 0x00, 0x0F, 0x07,
  0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0xF0,
  0x01, 0xF0, 0xF0, 0x01, 0xE0, 0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x7E,
  0x0F, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0xFC, 0x0F, 0x00, 0x07, 0xC0, 0x78, 0x00,
  0x3E, 0x01, 0xE0, 0x01, 0xF0, 0x07, 0x80, 0x0F, 0x80, 0x1E, 0x00, 0x7C,
  0x00, 0x78, 0x03, 0xE0, 0x01, 0xE0, 0x1F, 0x00, 0x0F, 0x00, 0xF8, 0x00,
  0x3C, 0x07, 0xC0, 0x00, 0xF0, 0x3E, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x0F,
  0x0F, 0x80, 0x00, 0x3C, 0x7C, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x07, 0x9F,
  0x80, 0x00, 0x1E, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFE, 0x78,
  0x00, 0x07, 0xF1, 0xE0, 0x00, 0x3F, 0x83, 0xC0, 0x00, 0xFC, 0x0F, 0x00,
  0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x3C, 0x01, 0xF0, 0x00,
  0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1E, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0x78, 0x01, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0x03, 0xC0, 0x1E, 0x00,
  0x0F, 0x80, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x1F, 0x00, 0x0F, 0x80,
  0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF8,
  0x07, 0xF8, 0x1F, 0xC0, 0x3B, 0xC0, 0xEF, 0x03, 0xDC, 0x07, 0x38, 0x1C,
  0xE0, 0x79, 0xC1, 0xEF, 0x03, 0xCE, 0x0E, 0x78, 0x1E, 0x78, 0xF3, 0xC0,
  0xF1, 0xCF, 0x1E, 0x07, 0x0E, 0x70, 0xE0, 0x38, 0x77, 0x87, 0x03, 0xC3,
  0xF8, 0x78, 0x1E, 0x1F, 0xC3, 0xC0, 0xF0, 0x7C, 0x1E, 0x07, 0x83, 0xC0,
  0xF0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x1E, 0x03, 0x03, 0xC0,
  0xF0, 0x10, 0x1E, 0x07, 0x80, 0x80, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xC0,
  0x00, 0x38, 0x0E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0xF0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x03, 0xF0, 0x01, 0xE0,
  0xFE, 0x00, 0x3C, 0x1F, 0xC0, 0x07, 0x83, 0xF8, 0x00, 0xE0, 0x7F, 0x00,
  0x1C, 0x0E, 0xF0, 0x07, 0x81, 0xDE, 0x00, 0xF0, 0x79, 0xC0, 0x1E, 0x0F,
  0x38, 0x03, 0xC1, 0xE7, 0x80, 0x70, 0x3C, 0xF0, 0x1E, 0x07, 0x1E, 0x03,
  0xC0, 0xE1, 0xC0, 0x78, 0x3C, 0x38, 0x0F, 0x07, 0x87, 0x81, 0xE0, 0xF0,
  0xF0, 0x38, 0x1E, 0x0E, 0x0F, 0x03, 0x81, 0xC1, 0xE0, 0xF0, 0x3C, 0x3C,
  0x1E, 0x07, 0x87, 0x83, 0xC0, 0xF0, 0xF0, 0x78, 0x0E, 0x1C, 0x0F, 0x01,
  0xC7, 0x81, 0xC0, 0x3C, 0xF0, 0x78, 0x07, 0x9E, 0x0F, 0x00, 0x73, 0xC1,
  0xE0, 0x0E, 0x78, 0x3C, 0x01, 0xEE, 0x07, 0x80, 0x3F, 0xC0, 0xE0, 0x07,
  0xF8, 0x3C, 0x00, 0x7F, 0x07, 0x80, 0x0F, 0xE0, 0xF0, 0x01, 0xFC, 0x1E,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0x03, 0xF0, 0x3E, 0x00, 0xF8, 0x3E, 0x00,
  0x3C, 0x1E, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xCF, 0x80,
  0x01, 0xE7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x7B, 0xE0, 0x00, 0x3D, 0xE0,
  0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0xBC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xDF, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x7B,
  0xC0, 0x00, 0x7D, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x1F,
  0x3C, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0x83, 0xC0, 0x07,
  0xC1, 0xF0, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x78, 0x00,
  0xFC, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1F, 0x07,
  0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x01,
  0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x83, 0xC0, 0x03, 0xE0, 0xF0,
  0x00, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0x03, 0xF0, 0x3E, 0x00, 0xF8, 0x3E, 0x00,
  0x3C, 0x1E, 0x00, 0x1F, 0x1E, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xCF, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x7B, 0xE0, 0x00, 0x3D, 0xE0,
  0x00, 0x1E, 0xF0, 0x00, 0x1F, 0x78, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xBE,
  0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0xFB,
  0xC0, 0x00, 0x79, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x3E, 0x78, 0x00, 0x1E,
  0x3C, 0x00, 0x0F, 0x1F, 0x00, 0x0F, 0x07, 0x80, 0x0F, 0x83, 0xE0, 0x0F,
  0x81, 0xF8, 0x1F, 0x80, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x40, 0x01,
  0xE0, 0xF0, 0x00, 0xF8, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x78,
  0x00, 0xFC, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1F,
  0x07, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x0F, 0x07, 0x80,
  0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x83, 0xC0, 0x03, 0xE0,
  0xF0, 0x00, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0x7C, 0x0F, 0x00, 0x0F,
  0x01, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0x80, 0x3C,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xF8, 0x07, 0x80, 0x0F, 0x00, 0xF0,
  0x01, 0xF0, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0x3C,
  0x1E, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x00,
  0x3E, 0x07, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x0C, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x81, 0x00, 0x00, 0xF8, 0x70, 0x00, 0x0F, 0x0F, 0x80, 0x01,
  0xF0, 0x7E, 0x00, 0x3F, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x07,
  0x8F, 0x00, 0x03, 0xC7, 0x80, 0x01, 0xE3, 0xC0, 0x01, 0xE1, 0xE0, 0x00,
  0xF0, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x3C, 0x00,
  0x0F, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC7, 0x80,
  0x01, 0xE3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0x78,
  0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x8F,
  0x00, 0x03, 0xC7, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0,
  0xF0, 0x00, 0x78, 0x78, 0x00, 0x7C, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E,
  0x0F, 0x00, 0x1F, 0x07, 0xC0, 0x1F, 0x03, 0xF0, 0x3F, 0x80, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xDC, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x3C,
  0x78, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0xC7, 0x80, 0x01, 0xE1, 0xE0, 0x00,
  0xF8, 0x78, 0x00, 0x3C, 0x0E, 0x00, 0x0F, 0x03, 0x80, 0x07, 0x80, 0xF0,
  0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x1C, 0x03, 0xC0, 0x07, 0x00, 0xF0, 0x01, 0xE0, 0x7C,
  0x00, 0x78, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x01, 0xE0,
  0xF0, 0x00, 0x78, 0x78, 0x00, 0x0E, 0x1E, 0x00, 0x03, 0x8F, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xDC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x1E, 0x38, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x78,
  0x70, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x1C, 0x3C, 0x00, 0x01, 0xE1, 0xE0,
  0x7C, 0x0F, 0x0F, 0x03, 0xE0, 0x78, 0x78, 0x3F, 0x03, 0x83, 0xC1, 0xF8,
  0x1C, 0x1E, 0x0F, 0xC1, 0xE0, 0xE0, 0xEE, 0x0F, 0x07, 0x07, 0x70, 0x70,
  0x38, 0x7B, 0x83, 0x81, 0xC3, 0x9C, 0x3C, 0x0E, 0x1C, 0xE1, 0xE0, 0x71,
  0xE7, 0x0E, 0x07, 0x8E, 0x3C, 0x70, 0x3C, 0x71, 0xE7, 0x81, 0xE7, 0x0F,
  0x3C, 0x0F, 0x38, 0x39, 0xC0, 0x7B, 0xC1, 0xCE, 0x03, 0x9C, 0x0E, 0xF0,
  0x1C, 0xE0, 0x77, 0x80, 0xEF, 0x03, 0xB8, 0x07, 0x70, 0x1D, 0xC0, 0x3B,
  0x80, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0xFE, 0x01,
  0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0xF8,
  0x00, 0x0F, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x0F, 0x80, 0x03, 0xC0, 0x0F, 0x80, 0x00, 0xF0, 0x07, 0x80, 0x00,
  0x78, 0x07, 0x80, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x0F, 0x07, 0xC0, 0x00,
  0x03, 0xC7, 0xC0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x01, 0xF3, 0xC0,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x3E,
  0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0xF8, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x03, 0xC0, 0x7C, 0x00,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x3E, 0x7C, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x7C, 0x3C, 0x00, 0x0F, 0x81, 0xE0, 0x01, 0xF0,
  0x1E, 0x00, 0x1E, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x00, 0xF0,
  0x07, 0x80, 0x07, 0x80, 0xF0, 0x00, 0x78, 0x1F, 0x00, 0x07, 0x83, 0xE0,
  0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E, 0xF8, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x78, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x7F, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xCE, 0x00, 0x03, 0xC7, 0x80, 0x01, 0xE3, 0xC0,
  0x01, 0xE0, 0xF0, 0x01, 0xE0, 0x78, 0x01, 0xF0, 0x1C, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x07, 0x80, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x78, 0x00,
  0x38, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xE4, 0x00, 0x00, 0x40, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x11, 0xCF, 0x1E, 0x78, 0xE3, 0xC7, 0x1C,
  0x20, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x3C, 0x1F, 0xFF, 0x78, 0x7E, 0x0E,
  0xF1, 0xF0, 0x07, 0xE3, 0xC0, 0x07, 0xCF, 0x00, 0x0F, 0x9E, 0x00, 0x1E,
  0x78, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF7, 0x80, 0x01, 0xEF,
  0x00, 0x03, 0xDE, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF0,
  0x00, 0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x03, 0xE7, 0x80, 0x07, 0x8F, 0x00,
  0x1F, 0x1E, 0x00, 0x7E, 0x1E, 0x01, 0xBC, 0x3E, 0x0E, 0x7F, 0x3F, 0xFC,
  0xFE, 0x3F, 0xE0, 0xFC, 0x1F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x07, 0xE0, 0x0F, 0x1F, 0xF8, 0x0E, 0x3F, 0xFC, 0x1E, 0x70,
  0x7C, 0x1E, 0xC0, 0x3E, 0x1F, 0x80, 0x1E, 0x1F, 0x00, 0x1E, 0x1E, 0x00,
  0x0E, 0x1E, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x3C, 0x00,
  0x0F, 0x3C, 0x00, 0x1F, 0x3C, 0x00, 0x1E, 0x38, 0x00, 0x1E, 0x78, 0x00,
  0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0x78, 0x00,
  0x3C, 0x78, 0x00, 0x78, 0xF8, 0x00, 0xF8, 0xFC, 0x01, 0xF0, 0xF7, 0x03,
  0xE0, 0xF3, 0xFF, 0xC0, 0xF1, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xF0, 0x7E, 0x1F, 0x00, 0x78,
  0x78, 0x00, 0xE3, 0xC0, 0x03, 0x5F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x02, 0x3C, 0x00, 0x1E, 0xF0, 0x00, 0xF1, 0xE0, 0x07, 0xC7, 0x80,
  0x3E, 0x0F, 0x83, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0xE0,
  0xF0, 0x0F, 0xFE, 0x3C, 0x07, 0xFF, 0xCF, 0x03, 0xF0, 0x3F, 0x81, 0xF0,
  0x07, 0xE0, 0x78, 0x00, 0xF8, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x87,
  0x80, 0x01, 0xE1, 0xE0, 0x00, 0x70, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x0F,
  0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00,
  0x0E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x3C,
  0x00, 0x3E, 0x0F, 0x00, 0x1F, 0x83, 0xC0, 0x0D, 0xC0, 0x78, 0x07, 0xF0,
  0x1F, 0x03, 0xBC, 0x03, 0xFF, 0xCF, 0x00, 0x7F, 0xE3, 0xC0, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x03, 0xF0,
  0x3E, 0x1F, 0x00, 0x7C, 0x78, 0x00, 0xF3, 0xC0, 0x03, 0xDE, 0x00, 0x0F,
  0x78, 0x00, 0x3D, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xBC, 0x00, 0xFE, 0xF0,
  0x3F, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x02, 0x3C, 0x00, 0x0C, 0xF0, 0x00, 0x7B,
  0xE0, 0x03, 0xC7, 0x80, 0x1E, 0x0F, 0x81, 0xF0, 0x3F, 0xFF, 0x80, 0x3F,
  0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x20, 0x0F, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0xF8, 0x0F, 0x00,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1F, 0x0E, 0x00,
  0x00, 0x0F, 0x9E, 0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0xE3, 0xC0, 0xFF, 0xF9, 0xE0, 0xFC, 0x0F, 0xE0, 0xF8, 0x03,
  0xF0, 0x78, 0x00, 0xF8, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x3C, 0x00,
  0x0F, 0x1E, 0x00, 0x07, 0x1F, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xC7, 0x80,
  0x01, 0xE3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0x78,
  0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x1F, 0x0F, 0x00, 0x1F, 0x87,
  0xC0, 0x0B, 0xC1, 0xE0, 0x1D, 0xC0, 0xFC, 0x1D, 0xE0, 0x3F, 0xFC, 0xF0,
  0x0F, 0xFC, 0x78, 0x01, 0xF8, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x81, 0x00, 0x07, 0x80, 0xC0, 0x07,
  0x80, 0xF8, 0x0F, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x7C, 0x03, 0xC7, 0xFC, 0x0F,
  0x3F, 0xF8, 0x3D, 0xFF, 0xF1, 0xF7, 0x0F, 0xC7, 0xB0, 0x0F, 0x1E, 0x80,
  0x3C, 0x7C, 0x00, 0xF1, 0xF0, 0x01, 0xC7, 0x80, 0x0F, 0x3E, 0x00, 0x3C,
  0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xF0,
  0x00, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0x78, 0x00, 0x79, 0xE0, 0x01,
  0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1C, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xCF,
  0x00, 0x0F, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x01, 0x00, 0x78, 0x06, 0x01, 0xC0,
  0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x00, 0xF0, 0xF8, 0x03, 0xC7, 0xC0,
  0x0F, 0x3E, 0x00, 0x39, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x02, 0x00, 0x78,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x02, 0x00, 0xF0,
  0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3E, 0x07, 0x80, 0x3E, 0x0E, 0x00,
  0x3E, 0x3C, 0x00, 0x3E, 0x78, 0x00, 0x3E, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC1, 0xF8, 0x01, 0xE3, 0xFE, 0x00, 0xF3, 0xFF, 0x80, 0x73,
  0x83, 0xE0, 0x7B, 0x00, 0xF0, 0x3D, 0x00, 0x78, 0x1F, 0x00, 0x3C, 0x0F,
  0x80, 0x1E, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0x83, 0xC0, 0x07, 0x81,
  0xE0, 0x07, 0x80, 0xF0, 0x07, 0x80, 0x78, 0x0F, 0x80, 0x3C, 0x1F, 0x00,
  0x1C, 0x7C, 0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80,
  0x33, 0xC1, 0xE0, 0x3D, 0xE0, 0xF0, 0x3C, 0xE0, 0x3C, 0x3C, 0xF0, 0x1E,
  0x3C, 0x78, 0x07, 0xBC, 0x3C, 0x03, 0xFC, 0x1E, 0x00, 0xFC, 0x00, 0x00,
  0x3C, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x01, 0x01, 0xE0,
  0x1C, 0x1E, 0x01, 0xF0, 0xF0, 0x1E, 0x07, 0x81, 0xE0, 0x3C, 0x1E, 0x01,
  0xE3, 0xE0, 0x0F, 0x3E, 0x00, 0x73, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xC0,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x0F, 0x81, 0xCF, 0xC3, 0xF8, 0x3B,
  0xFC, 0xFF, 0x0F, 0x47, 0xB1, 0xF1, 0xF0, 0x74, 0x1E, 0x3C, 0x0F, 0x83,
  0xC7, 0x81, 0xE0, 0x78, 0xE0, 0x3C, 0x0F, 0x1C, 0x07, 0x01, 0xC7, 0x80,
  0xE0, 0x38, 0xF0, 0x3C, 0x07, 0x1E, 0x07, 0x81, 0xE3, 0x80, 0xF0, 0x3C,
  0x70, 0x1C, 0x07, 0x8E, 0x03, 0x80, 0xE3, 0xC0, 0x70, 0x1C, 0x78, 0x1E,
  0x03, 0x8F, 0x03, 0xC0, 0xF1, 0xC0, 0x78, 0x1E, 0x38, 0x0E, 0x03, 0xCF,
  0x01, 0xC0, 0x71, 0xE0, 0x38, 0x0E, 0x3C, 0x0F, 0x01, 0xC7, 0x81, 0xE0,
  0x78, 0xE0, 0x3C, 0x0F, 0x1C, 0x07, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x3C,
  0x7F, 0xC0, 0xF3, 0xFF, 0x83, 0xDC, 0x3F, 0x1E, 0xC0, 0x3C, 0x7A, 0x00,
  0xF1, 0xF0, 0x03, 0xC7, 0xC0, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF3,
  0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0,
  0x03, 0xCE, 0x00, 0x1E, 0x78, 0x00, 0x79, 0xE0, 0x01, 0xE7, 0x80, 0x07,
  0x9E, 0x00, 0x1E, 0x78, 0x00, 0x79, 0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x3C,
  0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xC0, 0x00, 0x3F, 0x80, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3E, 0x07, 0xC0, 0xF0, 0x03, 0xC3, 0xC0,
  0x07, 0x8F, 0x80, 0x07, 0x9E, 0x00, 0x0F, 0x7C, 0x00, 0x1E, 0xF0, 0x00,
  0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7B,
  0xC0, 0x00, 0xF7, 0x80, 0x03, 0xC7, 0x00, 0x07, 0x8F, 0x00, 0x1E, 0x0F,
  0x00, 0x7C, 0x1F, 0x03, 0xF0, 0x1F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xF1, 0xFF, 0x80, 0x38, 0xFF, 0xF0,
  0x1E, 0x70, 0x7C, 0x07, 0xB0, 0x0F, 0x81, 0xF8, 0x01, 0xE0, 0x7C, 0x00,
  0x78, 0x1E, 0x00, 0x0E, 0x07, 0x80, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0,
  0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0xC3, 0xC0, 0x01, 0xE0,
  0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x01,
  0xE1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x80,
  0x0F, 0x83, 0xF0, 0x07, 0xC0, 0xF7, 0x03, 0xE0, 0x3C, 0xFF, 0xF0, 0x0F,
  0x1F, 0xF8, 0x03, 0x83, 0xF8, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xFF, 0x8F, 0x07, 0xFF, 0xCF, 0x0F, 0xC0, 0xFE, 0x1F,
  0x00, 0x7E, 0x1E, 0x00, 0x3E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x78,
  0x00, 0x1E, 0x78, 0x00, 0x1C, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0,
  0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x38, 0xF0,
  0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF8, 0xF0,
  0x01, 0xF8, 0xF0, 0x03, 0x70, 0x78, 0x06, 0xF0, 0x7C, 0x0E, 0xF0, 0x3F,
  0xFC, 0xF0, 0x1F, 0xF8, 0xF0, 0x07, 0xE0, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x7F,
  0xF0, 0x7F, 0x7F, 0xF1, 0xFF, 0xFF, 0xE3, 0xFE, 0x01, 0xE7, 0xFE, 0x01,
  0xEF, 0x00, 0x01, 0xEC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x07,
  0xE0, 0x3F, 0x07, 0x80, 0x0E, 0x0F, 0x00, 0x04, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x30, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0xFC, 0x00, 0x78, 0x7F,
  0x01, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0xE0, 0x78,
  0x07, 0xC1, 0xE0, 0x7E, 0x0F, 0x03, 0xE0, 0x3C, 0x1F, 0x00, 0xF1, 0xF0,
  0x03, 0xCF, 0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x38, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xE3,
  0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x1C, 0x78,
  0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80,
  0x07, 0x8F, 0x00, 0x0E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x00,
  0xF1, 0xE0, 0x03, 0xE3, 0xC0, 0x07, 0xC7, 0x80, 0x1F, 0x0F, 0x00, 0x7E,
  0x1F, 0x01, 0xBC, 0x1F, 0x06, 0x78, 0x3F, 0xFC, 0xF0, 0x3F, 0xF1, 0xC0,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x7F, 0xC0, 0x3E, 0xFF, 0xC0, 0x1E,
  0xFF, 0xC0, 0x1E, 0x03, 0x80, 0x1E, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x0E,
  0x07, 0x80, 0x0F, 0x07, 0x80, 0x0E, 0x07, 0x80, 0x1E, 0x07, 0x00, 0x1E,
  0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x3C,
  0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x78, 0x0E, 0x00, 0xF8, 0x1E, 0x00, 0xF0,
  0x1E, 0x01, 0xE0, 0x1E, 0x07, 0xC0, 0x1E, 0x0F, 0x80, 0x1E, 0x7F, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0x87, 0x81, 0xE1, 0xE1, 0xC0, 0x78, 0x38, 0x70, 0x1C, 0x0E, 0x1C, 0x07,
  0x03, 0xC7, 0x01, 0xC0, 0xF3, 0xC0, 0xF0, 0x3C, 0xF0, 0x3C, 0x0F, 0x38,
  0x0F, 0x03, 0xCE, 0x03, 0x80, 0xF3, 0x80, 0xE0, 0x3D, 0xE0, 0x38, 0x0F,
  0x78, 0x1E, 0x03, 0x9E, 0x07, 0x80, 0xE7, 0x01, 0xE0, 0x39, 0xC0, 0x70,
  0x1E, 0x70, 0x1C, 0x07, 0xBC, 0x0F, 0x01, 0xCF, 0x03, 0xC0, 0xF3, 0xC0,
  0xF0, 0x3C, 0xF0, 0x7C, 0x1E, 0x3C, 0x1F, 0x07, 0x0F, 0x0D, 0xC7, 0xC3,
  0xFE, 0x7F, 0xE0, 0x7F, 0x0F, 0xF0, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0x3C,
  0x03, 0xE0, 0x07, 0xF0, 0x7F, 0x80, 0xFF, 0x87, 0xFC, 0x0F, 0xDE, 0x78,
  0xF1, 0xF8, 0xF3, 0x07, 0x9F, 0x03, 0xB8, 0x3C, 0x70, 0x1D, 0x81, 0xE2,
  0x00, 0xE8, 0x0F, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x3C, 0x07, 0xE0, 0x01, 0xE0, 0x3F, 0x00, 0x8F, 0x03,
  0xF8, 0x1E, 0x78, 0x19, 0xC1, 0xF3, 0xC1, 0xCE, 0x3E, 0x0F, 0x1C, 0x73,
  0xE0, 0x7F, 0xE3, 0xFE, 0x03, 0xFC, 0x0F, 0xE0, 0x07, 0xC0, 0x7C, 0x00,
  0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xE0, 0x78, 0x00, 0x78, 0x1E, 0x00,
  0x1E, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0x78, 0x1E,
  0x00, 0x1C, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xF0,
  0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0x81, 0xE0, 0x01,
  0xE0, 0x78, 0x00, 0x78, 0x1E, 0x00, 0x3E, 0x07, 0x80, 0x0F, 0x81, 0xE0,
  0x05, 0xC0, 0x78, 0x03, 0xF0, 0x0F, 0x01, 0xBC, 0x03, 0xE0, 0xEF, 0x00,
  0xFF, 0xF3, 0xC0, 0x1F, 0xF8, 0xF0, 0x01, 0xF8, 0x38, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x08, 0x00,
  0x3C, 0x03, 0x00, 0x1E, 0x01, 0xF0, 0x1F, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0x83,
  0xC1, 0xFF, 0xF1, 0xE1, 0xE0, 0xFE, 0xF0, 0xE0, 0x0F, 0xF0, 0xF0, 0x01,
  0xF0, 0x70, 0x00, 0xF0, 0x38, 0x00, 0xF0, 0x1C, 0x00, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x18, 0x01, 0xE0, 0x1C, 0x01,
  0xE0, 0x0F, 0x01, 0xE0, 0x07, 0x81, 0xE0, 0x01, 0xC3, 0xF8, 0x00, 0xF3,
  0xFF, 0xC0, 0x79, 0xFF, 0xFF, 0x3C, 0xF1, 0xFF, 0xFC, 0x78, 0x1F, 0xFE,
  0x78, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF8, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x40, 0x7C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x78, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0x38,
  0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0F,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x80, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x07, 0xFF,
  0x80, 0x3E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x00, 0x03, 0xE0, 0x01, 0x81, 0xFC, 0x00, 0xF0, 0xFF, 0x80, 0x38, 0x78,
  0xF0, 0x1E, 0x3C, 0x1E, 0x07, 0x0E, 0x03, 0x83, 0xC7, 0x80, 0xF1, 0xE1,
  0xC0, 0x1F, 0xF0, 0xF0, 0x03, 0xF8, 0x18, 0x00, 0x7C, 0x00,
};

const GFXglyph IBMPlexMono_Italic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 11, 34, 29, 9, -34 },
  { 48, 15, 14, 29, 10, -36 },
  { 75, 29, 34, 29, 1, -34 },
  { 199, 28, 46, 29, 1, -40 },
  { 360, 33, 36, 29, -1, -35 },
  { 509, 29, 36, 29, 0, -35 },
  { 640, 5, 14, 29, 15, -36 },
  { 649, 18, 44, 29, 10, -37 },
  { 748, 18, 44, 29, 2, -37 },
  { 847, 25, 24, 29, 3, -27 },
  { 922, 24, 23, 29, 3, -26 },
  { 991, 11, 14, 29, 7, -7 },
  { 1011, 14, 4, 29, 8, -17 },
  { 1018, 8, 7, 29, 9, -7 },
  { 1025, 28, 44, 29, 1, -37 },
  { 1179, 25, 36, 29, 3, -35 },
  { 1292, 24, 34, 29, 2, -34 },
  { 1394, 26, 35, 29, 1, -35 },
  { 1508, 26, 36, 29, 1, -35 },
  { 1625, 26, 34, 29, 1, -34 },
  { 1736, 26, 35, 29, 2, -34 },
  { 1850, 23, 35, 29, 3, -34 },
  { 1951, 25, 34, 29, 5, -34 },
  { 2058, 26, 36, 29, 2, -35 },
  { 2175, 23, 35, 29, 4, -35 },
  { 2276, 11, 27, 29, 9, -27 },
  { 2314, 13, 34, 29, 7, -27 },
  { 2370, 24, 28, 29, 4, -29 },
  { 2454, 26, 12, 29, 2, -21 },
  { 2493, 24, 28, 29, 2, -29 },
  { 2577, 21, 35, 29, 6, -35 },
  { 2669, 25, 40, 29, 3, -35 },
  { 2794, 26, 34, 29, 0, -34 },
  { 2905, 25, 34, 29, 2, -34 },
  { 3012, 25, 36, 29, 4, -35 },
  { 3125, 25, 34, 29, 3, -34 },
  { 3232, 27, 34, 29, 2, -34 },
  { 3347, 28, 34, 29, 2, -34 },
  { 3466, 25, 36, 29, 3, -35 },
  { 3579, 27, 34, 29, 2, -34 },
  { 3694, 27, 34, 29, 2, -34 },
  { 3809, 24, 35, 29, 3, -34 },
  { 3914, 30, 34, 29, 2, -34 },
  { 4042, 21, 34, 29, 4, -34 },
  { 4132, 29, 34, 29, 1, -34 },
  { 4256, 27, 34, 29, 2, -34 },
  { 4371, 25, 36, 29, 3, -35 },
  { 4484, 27, 34, 29, 2, -34 },
  { 4599, 25, 44, 29, 3, -35 },
  { 4737, 27, 34, 29, 2, -34 },
  { 4852, 28, 36, 29, 1, -35 },
  { 4978, 28, 34, 29, 4, -34 },
  { 5097, 25, 35, 29, 4, -34 },
  { 5207, 26, 34, 29, 5, -34 },
  { 5318, 29, 34, 29, 2, -34 },
  { 5442, 33, 34, 29, -1, -34 },
  { 5583, 28, 34, 29, 4, -34 },
  { 5702, 30, 34, 29, 0, -34 },
  { 5830, 21, 44, 29, 8, -37 },
  { 5946, 13, 44, 29, 9, -37 },
  { 6018, 21, 44, 29, 0, -37 },
  { 6134, 25, 20, 29, 3, -34 },
  { 6197, 24, 4, 29, 0, 4 },
  { 6209, 6, 10, 29, 11, -39 },
  { 6217, 23, 27, 29, 3, -26 },
  { 6295, 24, 37, 29, 3, -36 },
  { 6406, 22, 27, 29, 4, -26 },
  { 6481, 26, 37, 29, 3, -36 },
  { 6602, 22, 27, 29, 4, -26 },
  { 6677, 32, 46, 29, -1, -36 },
  { 6861, 25, 36, 29, 2, -26 },
  { 6974, 22, 36, 29, 3, -36 },
  { 7073, 22, 38, 29, 4, -37 },
  { 7178, 23, 47, 29, 3, -37 },
  { 7314, 25, 37, 29, 3, -36 },
  { 7430, 21, 37, 29, 5, -36 },
  { 7528, 27, 26, 29, 1, -26 },
  { 7616, 22, 26, 29, 3, -26 },
  { 7688, 23, 27, 29, 3, -26 },
  { 7766, 26, 36, 29, 1, -26 },
  { 7883, 24, 36, 29, 3, -26 },
  { 7991, 24, 25, 29, 5, -25 },
  { 8066, 24, 27, 29, 2, -26 },
  { 8147, 22, 35, 29, 4, -34 },
  { 8244, 23, 26, 29, 4, -25 },
  { 8319, 24, 26, 29, 3, -26 },
  { 8397, 26, 26, 29, 2, -26 },
  { 8482, 29, 27, 29, 0, -26 },
  { 8580, 26, 35, 29, 1, -25 },
  { 8694, 25, 26, 29, 2, -26 },
  { 8776, 23, 44, 29, 5, -37 },
  { 8903, 10, 44, 29, 10, -37 },
  { 8958, 23, 44, 29, 2, -37 },
  { 9085, 26, 10, 29, 2, -20 },
};

const GFXfont IBMPlexMono_Italic49pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic49pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic49pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _IBMPLEXMONO_ITALIC49PT7B_H_
