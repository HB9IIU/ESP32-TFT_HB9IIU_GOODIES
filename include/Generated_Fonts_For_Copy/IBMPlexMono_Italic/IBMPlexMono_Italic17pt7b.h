#ifndef _IBMPLEXMONO_ITALIC17PT7B_H_
#define _IBMPLEXMONO_ITALIC17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x13, 0x33, 0x22, 0x24, 0x00, 0xEE, 0xDC, 0xA5, 0x29, 0x00, 0x04,
  0xC0, 0x90, 0x36, 0x04, 0x87, 0x9E, 0x36, 0x04, 0x87, 0x9C, 0x36, 0x04,
  0x80, 0x90, 0x36, 0x00, 0x02, 0x00, 0x80, 0xF8, 0xCB, 0x24, 0x89, 0x03,
  0x40, 0x70, 0x07, 0x01, 0x60, 0x89, 0x26, 0xE9, 0x0F, 0x80, 0x80, 0x60,
  0x3C, 0x24, 0x89, 0x12, 0x22, 0xC4, 0xD0, 0x74, 0x00, 0xE0, 0xA6, 0x24,
  0x4D, 0x99, 0x12, 0x43, 0x80, 0x0E, 0x04, 0x41, 0x10, 0xC4, 0x11, 0x06,
  0x86, 0xC3, 0x30, 0x84, 0x21, 0x9C, 0xA9, 0xCE, 0x5F, 0x80, 0x06, 0x10,
  0x41, 0x02, 0x08, 0x10, 0x20, 0x41, 0x81, 0x02, 0x04, 0x04, 0x0C, 0x00,
  0x30, 0x20, 0x81, 0x04, 0x10, 0x41, 0x0C, 0x20, 0x84, 0x30, 0x8C, 0x00,
  0x0C, 0x04, 0x02, 0x1D, 0xF3, 0xC1, 0xC0, 0x90, 0x8C, 0x0C, 0x08, 0x08,
  0x08, 0xFF, 0x18, 0x18, 0x10, 0x10, 0x36, 0x4C, 0xF8, 0xFC, 0x00, 0x40,
  0x20, 0x18, 0x04, 0x03, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00,
  0xC0, 0x20, 0x18, 0x0C, 0x00, 0x1E, 0x18, 0x98, 0x68, 0x34, 0x1E, 0xCF,
  0x65, 0x02, 0x81, 0x61, 0x11, 0x8F, 0x00, 0x0E, 0x34, 0x64, 0x44, 0x0C,
  0x0C, 0x08, 0x08, 0x08, 0x08, 0x18, 0xFF, 0x0F, 0x18, 0xC8, 0x20, 0x10,
  0x08, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0x18, 0x1F, 0xF0, 0x0F, 0x18, 0xC8,
  0x20, 0x10, 0x10, 0x70, 0x44, 0x03, 0x01, 0xA0, 0xB0, 0xC7, 0x80, 0x01,
  0x81, 0xC1, 0xE1, 0xB0, 0x90, 0x88, 0xC4, 0xC2, 0x43, 0x7F, 0xC0, 0x80,
  0x40, 0x3F, 0x90, 0x08, 0x04, 0x06, 0x02, 0xF1, 0x8C, 0x06, 0x03, 0x41,
  0xB1, 0x8F, 0x80, 0x07, 0x08, 0x10, 0x20, 0x60, 0x5E, 0xE3, 0xC1, 0x81,
  0x83, 0x46, 0x7C, 0xFF, 0x83, 0x82, 0x06, 0x04, 0x0C, 0x18, 0x10, 0x30,
  0x20, 0x60, 0xC0, 0x1F, 0x10, 0x98, 0x68, 0x26, 0x30, 0xE1, 0x8D, 0x02,
  0x81, 0x41, 0xB1, 0x8F, 0x80, 0x1E, 0x10, 0x90, 0x48, 0x3C, 0x12, 0x38,
  0xEC, 0x04, 0x06, 0x06, 0x06, 0x0E, 0x00, 0x37, 0x00, 0x00, 0x0E, 0xE0,
  0x19, 0xC0, 0x00, 0x00, 0x06, 0x62, 0x30, 0x00, 0x81, 0x83, 0x87, 0x06,
  0x02, 0x02, 0xC0, 0x30, 0x06, 0x01, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0,
  0x40, 0x30, 0x18, 0x06, 0x03, 0x03, 0x0C, 0x30, 0xE0, 0x80, 0x3C, 0x8F,
  0x08, 0x10, 0x21, 0xCF, 0x18, 0x20, 0x01, 0x83, 0x80, 0x1E, 0x10, 0x98,
  0x69, 0xF5, 0x96, 0x8B, 0x45, 0x22, 0x93, 0x4F, 0xA0, 0x10, 0x04, 0x01,
  0xE0, 0x06, 0x03, 0x83, 0xC1, 0x61, 0x90, 0x88, 0xC4, 0x7E, 0x61, 0x20,
  0xD0, 0x78, 0x30, 0x3E, 0x21, 0x61, 0x61, 0x43, 0x7C, 0x43, 0x41, 0xC1,
  0xC3, 0x82, 0xFC, 0x0F, 0x18, 0xC8, 0x2C, 0x04, 0x02, 0x03, 0x01, 0x80,
  0xC0, 0x21, 0x90, 0x87, 0x80, 0x3E, 0x11, 0x88, 0x4C, 0x36, 0x1A, 0x0D,
  0x04, 0x82, 0x43, 0x61, 0x31, 0x9F, 0x00, 0x3F, 0x90, 0x18, 0x0C, 0x04,
  0x03, 0xF9, 0x00, 0x80, 0xC0, 0x60, 0x20, 0x1F, 0xC0, 0x3F, 0x90, 0x18,
  0x0C, 0x04, 0x03, 0xF9, 0x00, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x00, 0x1F,
  0x18, 0x98, 0x68, 0x04, 0x06, 0x03, 0x3D, 0x82, 0xC3, 0x61, 0x91, 0x8F,
  0x40, 0x20, 0xB0, 0xD8, 0x68, 0x24, 0x13, 0xF9, 0x05, 0x86, 0xC3, 0x41,
  0x20, 0x90, 0x40, 0x3F, 0xA6, 0x03, 0x01, 0x00, 0x80, 0x40, 0x20, 0x30,
  0x18, 0x08, 0x04, 0x1F, 0xC0, 0x1F, 0x21, 0x01, 0x03, 0x03, 0x02, 0x02,
  0x02, 0x02, 0x86, 0xC4, 0x78, 0x20, 0xD8, 0x46, 0x21, 0x90, 0x48, 0x16,
  0x06, 0xC3, 0x10, 0xC4, 0x31, 0x88, 0x22, 0x0C, 0x30, 0x20, 0x20, 0x20,
  0x20, 0x60, 0x60, 0x40, 0x40, 0x40, 0x40, 0xFF, 0x30, 0xCE, 0x32, 0x94,
  0xAF, 0x2A, 0xCB, 0x26, 0x49, 0x22, 0x40, 0x90, 0x64, 0x1B, 0x04, 0x30,
  0xB8, 0x5C, 0x6A, 0x25, 0x92, 0x49, 0x25, 0x92, 0xCF, 0x43, 0x21, 0x90,
  0xC0, 0x1E, 0x18, 0x98, 0x68, 0x34, 0x1E, 0x0F, 0x05, 0x02, 0x83, 0x61,
  0x11, 0x8F, 0x00, 0x3F, 0x10, 0xD8, 0x6C, 0x34, 0x1A, 0x09, 0xF8, 0x80,
  0xC0, 0x60, 0x20, 0x10, 0x00, 0x1E, 0x18, 0x98, 0x68, 0x34, 0x1E, 0x0F,
  0x05, 0x02, 0x83, 0x61, 0x11, 0x8F, 0x81, 0x90, 0x58, 0x18, 0x3F, 0x10,
  0xD8, 0x6C, 0x34, 0x1A, 0x09, 0xF8, 0x98, 0xC4, 0x62, 0x21, 0x90, 0x60,
  0x0F, 0x8C, 0x32, 0x08, 0x80, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00, 0x90,
  0x6E, 0x10, 0xF8, 0x7F, 0xE3, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x60, 0x18, 0x04, 0x01, 0x00, 0x40, 0x20, 0xB0, 0xD8, 0x68, 0x24, 0x12,
  0x09, 0x05, 0x86, 0xC3, 0x61, 0x11, 0x8F, 0x80, 0x81, 0xC0, 0xA0, 0xD8,
  0x4C, 0x62, 0x21, 0x30, 0x90, 0x48, 0x28, 0x14, 0x0E, 0x00, 0x40, 0xD0,
  0x24, 0x09, 0x32, 0xDD, 0xB5, 0x49, 0x52, 0x94, 0xA5, 0x29, 0xCC, 0x63,
  0x18, 0x30, 0x62, 0x18, 0x66, 0x04, 0x80, 0xA0, 0x0C, 0x03, 0x00, 0xD0,
  0x12, 0x04, 0x61, 0x84, 0x60, 0xC0, 0x81, 0xE1, 0x90, 0x88, 0xC6, 0xC1,
  0x40, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x04, 0x00, 0x3F, 0xC0, 0x30, 0x18,
  0x0C, 0x02, 0x01, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x04, 0x03, 0xFE, 0x3E,
  0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x40, 0x83, 0x04, 0x08, 0x10, 0x3E,
  0x00, 0x86, 0x10, 0x84, 0x20, 0x84, 0x21, 0x0C, 0x21, 0x08, 0x60, 0x1E,
  0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x08, 0x30, 0x40, 0x81, 0x3E,
  0x00, 0x0C, 0x07, 0x04, 0x86, 0x66, 0x12, 0x0A, 0x06, 0xFF, 0xB4, 0x3D,
  0x63, 0x43, 0xC3, 0x82, 0x82, 0x86, 0xCA, 0x73, 0x20, 0x20, 0x20, 0x60,
  0x6E, 0x53, 0x61, 0x41, 0x41, 0xC1, 0xC3, 0xC6, 0xBC, 0x1E, 0x23, 0x40,
  0x40, 0xC0, 0xC0, 0xC3, 0x46, 0x3C, 0x00, 0x80, 0xC0, 0x60, 0x23, 0xD3,
  0x19, 0x05, 0x86, 0x83, 0x41, 0x20, 0x99, 0xC7, 0xA0, 0x1E, 0x23, 0x41,
  0xC7, 0xFC, 0xC0, 0xC3, 0x46, 0x3C, 0x03, 0xE0, 0x40, 0x08, 0x03, 0x03,
  0xFC, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x30, 0x04, 0x08, 0x81,
  0x90, 0x1A, 0x01, 0x80, 0x3D, 0x63, 0x41, 0xC3, 0x83, 0x82, 0x82, 0xCE,
  0x7A, 0x06, 0x84, 0xF8, 0x20, 0x20, 0x20, 0x20, 0x6E, 0x73, 0x63, 0x43,
  0x43, 0x42, 0xC2, 0xC2, 0x82, 0x0C, 0x0C, 0x00, 0x00, 0xF8, 0x18, 0x18,
  0x10, 0x10, 0x11, 0x12, 0x34, 0x18, 0x03, 0x03, 0x00, 0x00, 0x3E, 0x06,
  0x06, 0x04, 0x04, 0x04, 0x04, 0x0C, 0x8C, 0x48, 0x28, 0x18, 0x20, 0x10,
  0x08, 0x04, 0x06, 0xE3, 0x99, 0x8C, 0x84, 0x44, 0x2C, 0x36, 0x79, 0x68,
  0xE0, 0xF0, 0x20, 0x41, 0x83, 0x04, 0x08, 0x10, 0x20, 0xC5, 0xB2, 0xC7,
  0x00, 0x2D, 0x9D, 0xB6, 0x4D, 0x12, 0x44, 0x93, 0x24, 0x8B, 0x22, 0xC9,
  0x80, 0x6E, 0x73, 0x63, 0x43, 0x43, 0x42, 0xC2, 0xC2, 0x82, 0x1E, 0x63,
  0x41, 0xC1, 0xC1, 0x83, 0xC2, 0x46, 0x3C, 0x37, 0x14, 0xCC, 0x24, 0x12,
  0x0B, 0x05, 0x86, 0xC6, 0x5E, 0x20, 0x10, 0x18, 0x00, 0x3D, 0x63, 0x41,
  0xC3, 0x83, 0x82, 0x82, 0xCE, 0x72, 0x06, 0x06, 0x04, 0xF7, 0x38, 0x30,
  0x20, 0x20, 0x20, 0x60, 0x60, 0x40, 0x3E, 0x61, 0x40, 0x60, 0x3E, 0x02,
  0x02, 0xC2, 0x7C, 0x08, 0x18, 0x10, 0xFF, 0x10, 0x10, 0x30, 0x30, 0x22,
  0x23, 0x2C, 0x38, 0x61, 0x41, 0x43, 0x43, 0x43, 0xC2, 0xC6, 0x4A, 0x76,
  0xE3, 0x21, 0x21, 0x21, 0x61, 0x63, 0x66, 0x4C, 0x78, 0x4D, 0x24, 0xF2,
  0x71, 0x38, 0x94, 0xCA, 0x45, 0x34, 0xEE, 0x00, 0x19, 0xDA, 0x94, 0xC4,
  0x30, 0x0C, 0x03, 0x09, 0x4A, 0x56, 0x66, 0x00, 0x30, 0x90, 0x48, 0x24,
  0x32, 0x11, 0x09, 0x8C, 0x4A, 0x3B, 0x01, 0x91, 0x9F, 0x80, 0x3D, 0xA3,
  0x90, 0x81, 0x81, 0x81, 0x91, 0x8D, 0xE2, 0x8F, 0x00, 0x0F, 0x10, 0x10,
  0x10, 0x18, 0x08, 0x08, 0xF0, 0x10, 0x18, 0x30, 0x20, 0x40, 0x40, 0x78,
  0x11, 0x13, 0x22, 0x22, 0x24, 0x44, 0x44, 0xC0, 0x3C, 0x04, 0x04, 0x04,
  0x08, 0x10, 0x10, 0x0F, 0x18, 0x30, 0x10, 0x18, 0x18, 0x10, 0xF0, 0x71,
  0xAC, 0xA2, 0x50, 0xC0,
};

const GFXglyph IBMPlexMono_Italic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 4, 12, 10, 3, -12 },
  { 7, 5, 5, 10, 4, -13 },
  { 11, 11, 12, 10, 0, -12 },
  { 28, 10, 16, 10, 0, -14 },
  { 48, 11, 12, 10, 0, -12 },
  { 65, 10, 12, 10, 0, -12 },
  { 80, 2, 5, 10, 5, -13 },
  { 82, 7, 15, 10, 3, -13 },
  { 96, 6, 15, 10, 1, -13 },
  { 108, 9, 8, 10, 1, -9 },
  { 117, 8, 9, 10, 1, -10 },
  { 126, 4, 4, 10, 2, -2 },
  { 128, 5, 1, 10, 3, -6 },
  { 129, 3, 2, 10, 3, -2 },
  { 130, 10, 15, 10, 0, -13 },
  { 149, 9, 12, 10, 1, -12 },
  { 163, 8, 12, 10, 1, -12 },
  { 175, 9, 12, 10, 0, -12 },
  { 189, 9, 12, 10, 0, -12 },
  { 203, 9, 12, 10, 0, -12 },
  { 217, 9, 12, 10, 1, -12 },
  { 231, 8, 12, 10, 1, -12 },
  { 243, 8, 12, 10, 2, -12 },
  { 255, 9, 12, 10, 1, -12 },
  { 269, 9, 12, 10, 1, -12 },
  { 283, 4, 9, 10, 3, -9 },
  { 288, 5, 11, 10, 2, -9 },
  { 295, 9, 10, 10, 1, -10 },
  { 307, 9, 4, 10, 1, -7 },
  { 312, 8, 10, 10, 1, -10 },
  { 322, 7, 12, 10, 2, -12 },
  { 333, 9, 14, 10, 1, -12 },
  { 349, 9, 12, 10, 0, -12 },
  { 363, 8, 12, 10, 1, -12 },
  { 375, 9, 12, 10, 1, -12 },
  { 389, 9, 12, 10, 1, -12 },
  { 403, 9, 12, 10, 1, -12 },
  { 417, 9, 12, 10, 1, -12 },
  { 431, 9, 12, 10, 1, -12 },
  { 445, 9, 12, 10, 1, -12 },
  { 459, 9, 12, 10, 1, -12 },
  { 473, 8, 12, 10, 1, -12 },
  { 485, 10, 12, 10, 1, -12 },
  { 500, 8, 12, 10, 1, -12 },
  { 512, 10, 12, 10, 0, -12 },
  { 527, 9, 12, 10, 1, -12 },
  { 541, 9, 12, 10, 1, -12 },
  { 555, 9, 12, 10, 1, -12 },
  { 569, 9, 15, 10, 1, -12 },
  { 586, 9, 12, 10, 1, -12 },
  { 600, 10, 12, 10, 0, -12 },
  { 615, 10, 12, 10, 1, -12 },
  { 630, 9, 12, 10, 1, -12 },
  { 644, 9, 12, 10, 2, -12 },
  { 658, 10, 12, 10, 1, -12 },
  { 673, 11, 12, 10, 0, -12 },
  { 690, 9, 12, 10, 2, -12 },
  { 704, 10, 12, 10, 0, -12 },
  { 719, 7, 15, 10, 3, -13 },
  { 733, 5, 15, 10, 3, -13 },
  { 743, 7, 15, 10, 0, -13 },
  { 757, 9, 7, 10, 1, -12 },
  { 765, 8, 1, 10, 0, 2 },
  { 766, 2, 3, 10, 4, -13 },
  { 767, 8, 9, 10, 1, -9 },
  { 776, 8, 13, 10, 1, -13 },
  { 789, 8, 9, 10, 1, -9 },
  { 798, 9, 13, 10, 1, -13 },
  { 813, 8, 9, 10, 1, -9 },
  { 822, 11, 16, 10, 0, -13 },
  { 844, 8, 12, 10, 1, -9 },
  { 856, 8, 13, 10, 1, -13 },
  { 869, 8, 13, 10, 1, -13 },
  { 882, 8, 16, 10, 1, -13 },
  { 898, 9, 13, 10, 1, -13 },
  { 913, 7, 13, 10, 2, -13 },
  { 925, 10, 9, 10, 0, -9 },
  { 937, 8, 9, 10, 1, -9 },
  { 946, 8, 9, 10, 1, -9 },
  { 955, 9, 12, 10, 0, -9 },
  { 969, 8, 12, 10, 1, -9 },
  { 981, 8, 9, 10, 2, -9 },
  { 990, 8, 9, 10, 1, -9 },
  { 999, 8, 12, 10, 1, -12 },
  { 1011, 8, 9, 10, 1, -9 },
  { 1020, 8, 9, 10, 1, -9 },
  { 1029, 9, 9, 10, 1, -9 },
  { 1040, 10, 9, 10, 0, -9 },
  { 1052, 9, 12, 10, 0, -9 },
  { 1066, 9, 9, 10, 1, -9 },
  { 1077, 8, 15, 10, 2, -13 },
  { 1092, 4, 15, 10, 3, -13 },
  { 1100, 8, 15, 10, 1, -13 },
  { 1115, 9, 4, 10, 1, -7 },
};

const GFXfont IBMPlexMono_Italic17pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic17pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic17pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _IBMPLEXMONO_ITALIC17PT7B_H_
