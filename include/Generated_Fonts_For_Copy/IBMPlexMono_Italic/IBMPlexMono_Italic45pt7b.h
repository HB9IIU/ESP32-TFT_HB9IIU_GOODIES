#ifndef _IBMPLEXMONO_ITALIC45PT7B_H_
#define _IBMPLEXMONO_ITALIC45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x0F,
  0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00,
  0x80, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0x80, 0x3C, 0x3C, 0xF0, 0xE3, 0x83, 0x8E, 0x0E, 0x38,
  0x38, 0xE1, 0xE7, 0x87, 0x9E, 0x1C, 0x70, 0x71, 0xC1, 0xC7, 0x07, 0x3C,
  0x3C, 0x00, 0x07, 0x07, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x38, 0x38, 0x00,
  0x0F, 0x07, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x0F, 0x07,
  0x00, 0x01, 0xC1, 0xE0, 0x00, 0x38, 0x38, 0x03, 0xFF, 0x07, 0xFC, 0x7F,
  0xC1, 0xFF, 0x8F, 0xF8, 0x3F, 0xE0, 0x0F, 0x07, 0x00, 0x01, 0xC1, 0xE0,
  0x00, 0x38, 0x38, 0x00, 0x0F, 0x07, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x38,
  0x38, 0x00, 0x07, 0x07, 0x00, 0x7F, 0xC1, 0xFF, 0x8F, 0xF8, 0x3F, 0xF1,
  0xFF, 0x07, 0xFC, 0x01, 0xC1, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x0F, 0x07,
  0x00, 0x01, 0xC1, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x0F, 0x07, 0x00, 0x01,
  0xC1, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x03,
  0xE3, 0x3F, 0x03, 0xE1, 0x87, 0xC3, 0xE1, 0xC1, 0xE1, 0xE0, 0xE0, 0x40,
  0xF0, 0x70, 0x00, 0x78, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x0C, 0x00,
  0x0F, 0x06, 0x00, 0x07, 0xC7, 0x00, 0x01, 0xF3, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x39,
  0xF8, 0x00, 0x1C, 0x3C, 0x00, 0x0E, 0x0F, 0x00, 0x07, 0x07, 0x80, 0x03,
  0x03, 0xC0, 0x01, 0x81, 0xE0, 0x01, 0xC0, 0xF0, 0x80, 0xE0, 0x78, 0xE0,
  0x70, 0x78, 0xF8, 0x38, 0x3C, 0x3E, 0x18, 0x3C, 0x1F, 0xCC, 0x7E, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x3C, 0x0F, 0xFE, 0x00,
  0xE0, 0x3C, 0x1C, 0x01, 0xC0, 0x70, 0x38, 0x07, 0x01, 0xE0, 0x30, 0x1C,
  0x03, 0x80, 0x70, 0x78, 0x07, 0x01, 0xC0, 0xE0, 0x0E, 0x03, 0x83, 0x80,
  0x1C, 0x07, 0x0F, 0x00, 0x38, 0x0E, 0x1C, 0x00, 0x70, 0x38, 0x70, 0x00,
  0xF0, 0xF1, 0xE0, 0x00, 0xFF, 0xC3, 0x80, 0x00, 0xFF, 0x0E, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xE3, 0xFE, 0x00, 0x03, 0x8F, 0xFE, 0x00, 0x0E, 0x1E, 0x1C, 0x00, 0x38,
  0x70, 0x38, 0x00, 0x70, 0xE0, 0x38, 0x01, 0xC3, 0x80, 0x70, 0x07, 0x07,
  0x01, 0xE0, 0x1E, 0x0E, 0x03, 0x80, 0x38, 0x1C, 0x07, 0x00, 0xE0, 0x38,
  0x0E, 0x03, 0xC0, 0x70, 0x3C, 0x07, 0x00, 0xF0, 0xF0, 0x1C, 0x00, 0xFF,
  0xC0, 0x78, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xC1, 0xF0, 0x01, 0xE0,
  0x3C, 0x00, 0x78, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x01,
  0xC0, 0x1C, 0x00, 0x70, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x07, 0x80, 0xF0,
  0x00, 0xE0, 0x38, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x1F, 0xEF,
  0x80, 0x0F, 0xFF, 0x80, 0x0F, 0x8F, 0x00, 0x03, 0x83, 0xC0, 0x01, 0xE0,
  0x78, 0x00, 0x70, 0x1E, 0x00, 0x3C, 0x03, 0xC0, 0x0F, 0x00, 0xF0, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0xBC, 0x01, 0xE0, 0x7F, 0x00, 0x5C,
  0x1F, 0xC0, 0x37, 0x0E, 0x78, 0x0D, 0xE7, 0x9F, 0x0E, 0x39, 0xC3, 0xFF,
  0x8F, 0xF0, 0x7F, 0xC1, 0xF8, 0x0F, 0xC0, 0x3C, 0x00, 0x3C, 0xF3, 0x8E,
  0x38, 0xE7, 0x9E, 0x71, 0xC7, 0x3C, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x18, 0x0E, 0x03, 0xFC, 0x38, 0x7F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0x01, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0xC0, 0x01, 0xE7, 0x80, 0x0F, 0x9E, 0x00, 0x3C, 0x3C, 0x01, 0xE0, 0x70,
  0x0F, 0x01, 0xE0, 0x78, 0x03, 0x80, 0x40, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xC3, 0xE0, 0xF8, 0x7C,
  0x1F, 0x07, 0x83, 0xE0, 0xF0, 0x38, 0x1E, 0x07, 0x03, 0xC0, 0x7F, 0xFF,
  0xFF, 0xEF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0x07, 0xC0, 0x78, 0x07, 0xC1, 0xE0, 0x07,
  0x87, 0x80, 0x07, 0x0F, 0x00, 0x0E, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x3C,
  0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xEF, 0x00, 0x03, 0xDC,
  0x0F, 0x07, 0x78, 0x3E, 0x0E, 0xF0, 0xFC, 0x3D, 0xE1, 0xF8, 0x7B, 0xC1,
  0xE0, 0xF7, 0x80, 0x01, 0xEE, 0x00, 0x03, 0x9C, 0x00, 0x0F, 0x38, 0x00,
  0x1E, 0x70, 0x00, 0x38, 0xE0, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x07,
  0x83, 0x80, 0x0E, 0x07, 0x80, 0x7C, 0x0F, 0x81, 0xF0, 0x0F, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xF7, 0x00, 0x3F, 0x78, 0x03, 0xE3, 0xC0, 0x3E, 0x1E,
  0x03, 0xE0, 0xF0, 0x3E, 0x07, 0x00, 0xE0, 0x38, 0x02, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xFC, 0x03, 0xF0, 0x7E, 0x07, 0xC0, 0x1E, 0x07, 0x80, 0x1E, 0x0F, 0x00,
  0x0F, 0x07, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xFC, 0x03, 0xF0, 0x7E, 0x07, 0xC0, 0x1E, 0x03, 0x80, 0x0F, 0x01, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x30, 0x00,
  0x78, 0xF0, 0x00, 0xF8, 0x78, 0x01, 0xF0, 0x7E, 0x07, 0xE0, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xDC, 0x00, 0x07,
  0xBC, 0x00, 0x07, 0x3C, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x3C,
  0x38, 0x00, 0x78, 0x38, 0x00, 0xF0, 0x78, 0x00, 0xE0, 0x78, 0x01, 0xE0,
  0x78, 0x03, 0xC0, 0x70, 0x07, 0x80, 0x70, 0x0F, 0x00, 0x70, 0x0E, 0x00,
  0xF0, 0x1E, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x78, 0x00, 0xE0, 0xF0, 0x00,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x3F, 0x80, 0x0E, 0x7F, 0xE0, 0x1F, 0xFF,
  0xF0, 0x1F, 0x81, 0xF8, 0x1E, 0x00, 0xF8, 0x0C, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x30, 0x00, 0x78, 0x70, 0x00,
  0xF0, 0xF8, 0x01, 0xE0, 0x7E, 0x07, 0xE0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC3, 0xF0, 0x1E, 0x7F, 0xE1, 0xEF, 0xFF, 0x8F, 0xE0, 0x7E, 0x7E, 0x00,
  0xF7, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xF7, 0x80, 0x07,
  0xBC, 0x00, 0x78, 0xF0, 0x07, 0xC7, 0xC0, 0xFC, 0x1F, 0xFF, 0x80, 0x7F,
  0xF8, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xDC, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x03, 0xCE, 0x00, 0x0F, 0x38,
  0x00, 0x78, 0xE0, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xFC, 0x03, 0xE0, 0x7E, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x1F,
  0x0F, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x1E, 0x00, 0x0E, 0x1E, 0x00, 0x0E,
  0x0E, 0x00, 0x1E, 0x0E, 0x00, 0x1C, 0x0F, 0x00, 0x38, 0x07, 0xC0, 0xF0,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0x81, 0xF0,
  0x3E, 0x00, 0x78, 0x38, 0x00, 0x38, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x3C,
  0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C,
  0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0x78, 0x01, 0xF0, 0x7E, 0x07, 0xE0,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x1F, 0xFE, 0x03, 0xFF, 0xF8, 0x3F, 0x03, 0xE3, 0xE0, 0x0F, 0x1E, 0x00,
  0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x07,
  0xEF, 0x00, 0x7E, 0x7E, 0x07, 0xF1, 0xFF, 0xF7, 0x87, 0xFE, 0x78, 0x0F,
  0xC3, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x8F, 0xC7,
  0xE3, 0xF1, 0xF8, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF0,
  0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xE0,
  0x3E, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x80, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x02, 0x00, 0x3F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0x08, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xFF,
  0xE0, 0x7F, 0xFE, 0x1F, 0x03, 0xE7, 0xC0, 0x3D, 0xF0, 0x03, 0xFC, 0x00,
  0x7B, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x07, 0xFC,
  0x00, 0xFE, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xF0, 0x3E, 0x0F,
  0x00, 0x38, 0x38, 0x00, 0xF1, 0xE0, 0x01, 0xC7, 0x00, 0x07, 0x3C, 0x00,
  0x1C, 0xE0, 0x3C, 0x73, 0x83, 0xFD, 0xDE, 0x0F, 0xF7, 0x70, 0x78, 0x5D,
  0xC3, 0xC0, 0xF7, 0x0E, 0x03, 0xDC, 0x38, 0x0E, 0xF1, 0xE0, 0x3B, 0xC7,
  0x80, 0xEE, 0x1C, 0x03, 0xB8, 0x70, 0x0E, 0xE1, 0xC0, 0x7B, 0x87, 0x01,
  0xCE, 0x1C, 0x07, 0x38, 0x70, 0x3C, 0xE1, 0xE1, 0x73, 0x87, 0xDD, 0xCE,
  0x0F, 0xEF, 0x38, 0x1F, 0x38, 0xE0, 0x10, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x0E, 0x70,
  0x00, 0x1E, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x3C, 0x78, 0x00, 0x38, 0x78,
  0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0xF0, 0x38, 0x00, 0xF0, 0x38,
  0x01, 0xE0, 0x38, 0x01, 0xE0, 0x3C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0x80, 0x3C, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC,
  0x0E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x1E,
  0x3C, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x0E, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0,
  0x38, 0x03, 0xE0, 0x70, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87,
  0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1C, 0x00, 0x3C, 0x38, 0x00, 0x78, 0xF0,
  0x01, 0xE1, 0xE0, 0x07, 0x83, 0xC0, 0x1E, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x78, 0x01, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x01,
  0xE3, 0xC0, 0x03, 0xC7, 0x00, 0x07, 0x9E, 0x00, 0x0F, 0x3C, 0x00, 0x1E,
  0x78, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x03, 0xC3, 0x80, 0x1F, 0x8F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xF8, 0x3E, 0x0F, 0x80, 0x78, 0x3C,
  0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x00, 0x04, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x43, 0xC0, 0x03, 0xCF, 0x00, 0x1E, 0x3C,
  0x00, 0x78, 0x78, 0x03, 0xC1, 0xF8, 0x3E, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x03, 0xC0, 0xE0, 0x03, 0xC1, 0xC0, 0x07,
  0x87, 0x80, 0x0F, 0x0F, 0x00, 0x0E, 0x1E, 0x00, 0x1C, 0x3C, 0x00, 0x38,
  0x70, 0x00, 0x70, 0xE0, 0x00, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8F,
  0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x38, 0x00, 0x3C, 0x70, 0x00, 0x79, 0xE0,
  0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x0E, 0x1C, 0x00,
  0x3C, 0x38, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x07, 0x83, 0xC0, 0x7E,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0x07, 0xC0,
  0x78, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0x80, 0x07, 0x8F, 0x00, 0x0C, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x3F, 0xF3, 0xC0, 0x7F, 0xE7, 0x80, 0xFF, 0xCF, 0x00, 0x07,
  0x9E, 0x00, 0x0E, 0x3C, 0x00, 0x1C, 0x78, 0x00, 0x38, 0xF0, 0x00, 0xF1,
  0xE0, 0x01, 0xE3, 0xC0, 0x07, 0xC3, 0xC0, 0x0F, 0x07, 0x80, 0x2E, 0x07,
  0xC1, 0xDC, 0x0F, 0xFF, 0x78, 0x0F, 0xFC, 0xF0, 0x07, 0xE0, 0x00, 0x07,
  0x80, 0x07, 0x83, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xC1, 0xE0, 0x01, 0xE0,
  0xF0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1C, 0x00, 0x1C,
  0x0E, 0x00, 0x0E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03,
  0xC1, 0xE0, 0x01, 0xE0, 0xE0, 0x00, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFC, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x00,
  0x07, 0x03, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0,
  0x00, 0xF0, 0x78, 0x00, 0x78, 0x38, 0x00, 0x38, 0x3C, 0x00, 0x3C, 0x1E,
  0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0x80,
  0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x20, 0x03, 0xC3, 0x80, 0x0F,
  0x0F, 0x00, 0x78, 0x3C, 0x03, 0xE0, 0x7C, 0x1F, 0x01, 0xFF, 0xF8, 0x01,
  0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x07, 0x80, 0x03, 0xE0, 0xF0, 0x00, 0xF8,
  0x1C, 0x00, 0x3C, 0x03, 0x80, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x03, 0xC0, 0x3C, 0x00, 0x78, 0x0F, 0x00, 0x0E, 0x03, 0xC0, 0x01,
  0xC0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x3C, 0xF8, 0x00, 0x07, 0x3F, 0x00, 0x00, 0xEF, 0xF0, 0x00, 0x3F,
  0xDE, 0x00, 0x07, 0xF1, 0xE0, 0x00, 0xFC, 0x3C, 0x00, 0x1F, 0x03, 0xC0,
  0x03, 0xC0, 0x78, 0x00, 0x70, 0x07, 0x00, 0x1E, 0x00, 0xF0, 0x03, 0xC0,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xC0, 0x03, 0xC0,
  0x38, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xF0, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x7E,
  0x00, 0xFC, 0x1F, 0x80, 0x7F, 0x07, 0xE0, 0x1F, 0x83, 0xF8, 0x0F, 0xE0,
  0xFF, 0x03, 0xB8, 0x3D, 0xC1, 0xCE, 0x0E, 0x70, 0xF7, 0x83, 0x9C, 0x39,
  0xE0, 0xE7, 0x9E, 0x70, 0x78, 0xEF, 0x1C, 0x1E, 0x3B, 0x87, 0x07, 0x8F,
  0xE1, 0xC1, 0xC3, 0xF0, 0xF0, 0x70, 0x7C, 0x3C, 0x1C, 0x1E, 0x0E, 0x0F,
  0x07, 0x03, 0x83, 0xC1, 0xC0, 0xE0, 0xE0, 0x20, 0x38, 0x38, 0x10, 0x1E,
  0x0E, 0x00, 0x07, 0x83, 0x80, 0x01, 0xC1, 0xE0, 0x00, 0x70, 0x78, 0x00,
  0x1C, 0x1C, 0x00, 0x0F, 0x07, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0xF0, 0x70,
  0x00, 0x38, 0x3C, 0x00, 0x0E, 0x0F, 0x00, 0x03, 0x80, 0x07, 0xC0, 0x07,
  0x83, 0xF0, 0x03, 0x81, 0xF8, 0x01, 0xC1, 0xFC, 0x00, 0xE0, 0xFE, 0x00,
  0xF0, 0x7F, 0x80, 0x78, 0x39, 0xC0, 0x3C, 0x1C, 0xE0, 0x1C, 0x0E, 0x70,
  0x0E, 0x0F, 0x3C, 0x07, 0x07, 0x9E, 0x07, 0x83, 0xC7, 0x03, 0xC1, 0xC3,
  0x81, 0xE0, 0xE1, 0xC0, 0xE0, 0x70, 0xF0, 0x70, 0x78, 0x38, 0x38, 0x3C,
  0x1C, 0x3C, 0x1C, 0x0E, 0x1E, 0x0E, 0x07, 0x8F, 0x07, 0x03, 0xC7, 0x03,
  0x80, 0xE3, 0x83, 0xC0, 0x71, 0xC1, 0xE0, 0x39, 0xE0, 0xE0, 0x1E, 0xF0,
  0x70, 0x07, 0x78, 0x38, 0x03, 0xB8, 0x3C, 0x01, 0xDC, 0x1E, 0x00, 0xFE,
  0x0F, 0x00, 0x7F, 0x07, 0x00, 0x1F, 0x83, 0x80, 0x0F, 0x80, 0x00, 0x3F,
  0x80, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0x07, 0xC0, 0x78, 0x07,
  0xC1, 0xE0, 0x07, 0x87, 0x80, 0x07, 0x0F, 0x00, 0x0E, 0x3C, 0x00, 0x1E,
  0x78, 0x00, 0x3C, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xEF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0,
  0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xEF, 0x00, 0x03, 0x9C, 0x00,
  0x0F, 0x38, 0x00, 0x1E, 0x70, 0x00, 0x3C, 0xF0, 0x00, 0xF1, 0xE0, 0x01,
  0xE3, 0xC0, 0x07, 0x83, 0x80, 0x1E, 0x07, 0x80, 0x7C, 0x0F, 0x81, 0xF0,
  0x0F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0x00, 0x1E, 0x07, 0x00, 0x0F,
  0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F,
  0x0E, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x1E,
  0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x7C, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x3F, 0x07, 0xC0, 0x78, 0x07, 0xC1, 0xE0, 0x07, 0x87,
  0x80, 0x07, 0x0F, 0x00, 0x0E, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x3D, 0xE0,
  0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xEF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x00,
  0xF7, 0x80, 0x01, 0xEF, 0x00, 0x07, 0x9C, 0x00, 0x0F, 0x38, 0x00, 0x1E,
  0x70, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x83,
  0xC0, 0x1E, 0x07, 0xC0, 0xF8, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x03,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x20, 0x01, 0xE0, 0xE0, 0x01,
  0xE3, 0xE0, 0x03, 0xCF, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0x80, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0x00,
  0x1E, 0x07, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00,
  0x0F, 0x0F, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x1E, 0x00,
  0x0F, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x7C, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x3C, 0x1E, 0x00, 0x3C, 0x0F,
  0x00, 0x3C, 0x0F, 0x00, 0x38, 0x07, 0x00, 0x38, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x78, 0x03, 0xC0, 0x78, 0x03, 0xC0, 0x78, 0x01, 0xE0, 0x70, 0x01,
  0xE0, 0x70, 0x00, 0xE0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7C, 0x07, 0xE0, 0x7C,
  0x00, 0xF8, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x08, 0x1E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x10, 0x00, 0x0F, 0x0C, 0x00, 0x0F, 0x1F, 0x00,
  0x07, 0x87, 0xC0, 0x07, 0x83, 0xF8, 0x0F, 0x80, 0x7F, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x0E, 0x00,
  0x0E, 0x1E, 0x00, 0x0E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00,
  0x1E, 0x1E, 0x00, 0x1E, 0x1C, 0x00, 0x1C, 0x3C, 0x00, 0x1C, 0x3C, 0x00,
  0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x38, 0x00,
  0x38, 0x78, 0x00, 0x38, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00,
  0x78, 0x78, 0x00, 0x78, 0x70, 0x00, 0x70, 0x70, 0x00, 0xF0, 0xF0, 0x00,
  0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xE0, 0xF0, 0x01,
  0xE0, 0x70, 0x01, 0xE0, 0x78, 0x03, 0xC0, 0x7C, 0x0F, 0x80, 0x3F, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x1E, 0xF0, 0x00, 0x1C, 0xF0, 0x00, 0x3C, 0x70, 0x00, 0x38, 0x70, 0x00,
  0x78, 0x70, 0x00, 0x78, 0x70, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x78, 0x01,
  0xE0, 0x78, 0x01, 0xE0, 0x78, 0x03, 0xC0, 0x38, 0x03, 0xC0, 0x38, 0x03,
  0x80, 0x38, 0x07, 0x80, 0x38, 0x07, 0x00, 0x3C, 0x0F, 0x00, 0x3C, 0x0E,
  0x00, 0x3C, 0x1E, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x3C, 0x00, 0x1C, 0x3C,
  0x00, 0x1C, 0x78, 0x00, 0x1C, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x1E, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x38, 0x70,
  0x00, 0x07, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x3C, 0x38, 0x1E, 0x07, 0x87, 0x03,
  0xE0, 0xE0, 0xE0, 0xFC, 0x1C, 0x1C, 0x1F, 0x83, 0x83, 0x87, 0x70, 0xF0,
  0x70, 0xEE, 0x1C, 0x0E, 0x1D, 0xC3, 0x83, 0xC7, 0x38, 0x70, 0x78, 0xE7,
  0x1E, 0x0E, 0x1C, 0xE3, 0x81, 0xC7, 0x1C, 0x70, 0x38, 0xE3, 0x8E, 0x07,
  0x38, 0x73, 0xC0, 0xE7, 0x0E, 0x70, 0x1C, 0xE1, 0xCE, 0x03, 0xB8, 0x39,
  0xC0, 0x77, 0x07, 0x78, 0x0E, 0xE0, 0xEE, 0x03, 0xF8, 0x1D, 0xC0, 0x7F,
  0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x07, 0x80, 0x03, 0xE0, 0x1E, 0x00, 0x0F,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00,
  0x07, 0x80, 0xF8, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x03, 0xBE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xC1, 0xC0, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0xF8, 0x0E, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x07, 0x80, 0x3E, 0x00,
  0x0F, 0x01, 0xF0, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0x07, 0xDE, 0x00, 0x03, 0xC7, 0x80, 0x01, 0xF1, 0xE0, 0x00, 0x78, 0x3C,
  0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x01, 0xE0, 0x0F, 0x80, 0x78, 0x03, 0xC0,
  0x0E, 0x01, 0xE0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x7C, 0x00, 0x1E, 0x1E,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x81, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xE0,
  0x06, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x30, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03,
  0x00, 0x38, 0x03, 0x80, 0x38, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x07, 0x01,
  0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x07, 0xFF, 0x80, 0x7F, 0xF8,
  0x0F, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xDC, 0x00, 0x07, 0x3C, 0x00, 0x1E, 0x38, 0x00, 0x78, 0x78, 0x00,
  0xE0, 0xF0, 0x03, 0xC0, 0xE0, 0x0F, 0x01, 0xE0, 0x3C, 0x01, 0xC0, 0x70,
  0x03, 0xC1, 0xE0, 0x07, 0x87, 0x80, 0x07, 0x1E, 0x00, 0x0F, 0x3C, 0x00,
  0x0E, 0xF0, 0x00, 0x1E, 0xC0, 0x00, 0x18, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x13, 0xC7, 0x1E, 0x38, 0xE1, 0x87, 0x18, 0x01,
  0xF8, 0x00, 0x3F, 0xF1, 0xC3, 0xFF, 0xDE, 0x3F, 0x06, 0xF3, 0xE0, 0x1F,
  0x9E, 0x00, 0x7D, 0xE0, 0x03, 0xCF, 0x00, 0x0E, 0x70, 0x00, 0xF7, 0x80,
  0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x0E, 0x70, 0x00, 0x73,
  0x80, 0x07, 0x9C, 0x00, 0x3C, 0xE0, 0x01, 0xE7, 0x00, 0x1F, 0x38, 0x00,
  0xF1, 0xE0, 0x0B, 0x8F, 0x00, 0xFC, 0x3E, 0x1D, 0xFD, 0xFF, 0xC7, 0xE7,
  0xFC, 0x1F, 0x0F, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x3F, 0x00, 0xF3, 0xFF, 0x03,
  0x9F, 0xFE, 0x0E, 0x70, 0xF8, 0x3B, 0x00, 0xF1, 0xF8, 0x03, 0xC7, 0xC0,
  0x07, 0x1E, 0x00, 0x1C, 0x78, 0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00, 0x07,
  0x3C, 0x00, 0x1C, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x38,
  0x00, 0x3C, 0xE0, 0x00, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0x78, 0x00,
  0xF1, 0xF0, 0x07, 0xC7, 0x70, 0x7E, 0x1C, 0xFF, 0xF0, 0xF1, 0xFF, 0x80,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0xE0, 0xF8,
  0x1F, 0x1F, 0x00, 0xF1, 0xE0, 0x07, 0x3C, 0x00, 0x43, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x47, 0x00, 0x0E,
  0x70, 0x00, 0xF7, 0x80, 0x1E, 0x78, 0x03, 0xC3, 0xE0, 0xF8, 0x1F, 0xFF,
  0x00, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x03, 0xF0, 0x78, 0x1F,
  0xF8, 0xF0, 0x7F, 0xF9, 0xC1, 0xF8, 0x3B, 0x87, 0xC0, 0x1F, 0x0F, 0x00,
  0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xE0, 0x00, 0xE3, 0xC0, 0x01,
  0xC7, 0x80, 0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x38, 0x00, 0x3C,
  0x70, 0x00, 0x70, 0xE0, 0x00, 0xE1, 0xC0, 0x03, 0xC3, 0x80, 0x07, 0x87,
  0x00, 0x1F, 0x0F, 0x00, 0x7E, 0x1E, 0x01, 0xB8, 0x1F, 0x0E, 0x70, 0x3F,
  0xFD, 0xE0, 0x3F, 0xF3, 0xC0, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x0F,
  0xFF, 0x00, 0xFF, 0xFC, 0x1F, 0x81, 0xE0, 0xF0, 0x07, 0x8E, 0x00, 0x3C,
  0xF0, 0x01, 0xE7, 0x00, 0x0F, 0x78, 0x00, 0xF3, 0xC0, 0x1F, 0x9C, 0x0F,
  0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0x7F, 0xF0, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x47, 0x80, 0x03, 0x1C, 0x00, 0x3C, 0xF0, 0x03,
  0xC7, 0xC0, 0x3C, 0x1F, 0x07, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xC0, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x78, 0x00, 0x0F, 0x81, 0xE0,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x78, 0x70, 0x00,
  0x00, 0xF1, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xFF, 0x8F, 0x03, 0xFF, 0xCE, 0x07, 0xE0, 0xEE, 0x0F, 0x80, 0x3E, 0x0F,
  0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1C, 0x00, 0x1C, 0x3C,
  0x00, 0x1C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x3C, 0x38,
  0x00, 0x3C, 0x38, 0x00, 0x38, 0x38, 0x00, 0x78, 0x38, 0x00, 0x78, 0x38,
  0x00, 0xF8, 0x3C, 0x01, 0xF8, 0x3C, 0x03, 0x78, 0x1F, 0x07, 0x70, 0x1F,
  0xFE, 0x70, 0x0F, 0xFC, 0x70, 0x03, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x30,
  0x03, 0xC0, 0x7C, 0x0F, 0x80, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE1, 0xF8, 0x1E, 0x3F, 0xC1, 0xE7, 0xFE, 0x1E, 0xE1, 0xF1, 0xD8,
  0x0F, 0x1D, 0x00, 0xF1, 0xE0, 0x07, 0x3E, 0x00, 0x73, 0xC0, 0x07, 0x3C,
  0x00, 0x73, 0x80, 0x0F, 0x38, 0x00, 0xF3, 0x80, 0x0F, 0x78, 0x00, 0xE7,
  0x80, 0x0E, 0x78, 0x00, 0xE7, 0x00, 0x1E, 0x70, 0x01, 0xE7, 0x00, 0x1E,
  0xF0, 0x01, 0xEF, 0x00, 0x1C, 0xF0, 0x01, 0xCE, 0x00, 0x3C, 0xE0, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x04, 0x03, 0x80, 0x70, 0x38, 0x0F, 0x07, 0x83, 0xE0, 0x78, 0x7C, 0x07,
  0x8F, 0x80, 0x71, 0xF0, 0x07, 0x3E, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x40, 0x1E, 0x03, 0x00, 0xE0, 0x3C, 0x07, 0x00, 0xF0, 0x38,
  0x03, 0xC3, 0xC0, 0x1F, 0x1E, 0x00, 0x7C, 0xF0, 0x01, 0xF7, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x3F, 0x00,
  0x78, 0xFF, 0x80, 0xF3, 0xFF, 0x01, 0xEE, 0x1F, 0x03, 0xB0, 0x1E, 0x07,
  0x40, 0x1C, 0x0F, 0x00, 0x38, 0x3E, 0x00, 0x70, 0x78, 0x01, 0xE0, 0xF0,
  0x03, 0x81, 0xC0, 0x0F, 0x03, 0x80, 0x7C, 0x07, 0x01, 0xE0, 0x1E, 0x1F,
  0x00, 0x3C, 0xF0, 0x00, 0x78, 0xE0, 0x00, 0xE1, 0xE0, 0x11, 0xC3, 0xC0,
  0x73, 0x83, 0xC1, 0xFF, 0x07, 0x87, 0x9E, 0x07, 0x9F, 0x3C, 0x0F, 0x7C,
  0x70, 0x0F, 0xF0, 0xE0, 0x1F, 0x80, 0x00, 0x1E, 0x00, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x04, 0x0E, 0x01, 0xC1, 0xC0, 0x7C, 0x78,
  0x1E, 0x0F, 0x0F, 0x81, 0xE3, 0xE0, 0x3C, 0xF8, 0x07, 0x3E, 0x00, 0xFF,
  0x00, 0x1F, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x3E, 0x0F, 0x7E, 0x3F,
  0x87, 0x7F, 0xBF, 0xC3, 0xA3, 0xD8, 0xE1, 0xE0, 0xF8, 0x78, 0xF0, 0x78,
  0x3C, 0xF0, 0x38, 0x1C, 0x78, 0x1C, 0x0E, 0x38, 0x0E, 0x07, 0x1C, 0x0F,
  0x03, 0x8E, 0x07, 0x01, 0xC7, 0x03, 0x81, 0xE7, 0x81, 0xC0, 0xE3, 0xC0,
  0xE0, 0x71, 0xC0, 0x70, 0x38, 0xE0, 0x78, 0x1C, 0x70, 0x38, 0x0E, 0x38,
  0x1C, 0x0F, 0x3C, 0x0E, 0x07, 0x1E, 0x07, 0x03, 0x8E, 0x03, 0x81, 0xC7,
  0x03, 0xC0, 0xE3, 0x81, 0xC0, 0x71, 0xC0, 0xE0, 0x78, 0x00, 0x1F, 0x81,
  0xE3, 0xFC, 0x1E, 0x7F, 0xE1, 0xEE, 0x1F, 0x1D, 0x80, 0xF1, 0xD0, 0x0F,
  0x1E, 0x00, 0x73, 0xE0, 0x07, 0x3C, 0x00, 0x73, 0xC0, 0x07, 0x38, 0x00,
  0xF3, 0x80, 0x0F, 0x38, 0x00, 0xF7, 0x80, 0x0E, 0x78, 0x00, 0xE7, 0x80,
  0x0E, 0x70, 0x01, 0xE7, 0x00, 0x1E, 0x70, 0x01, 0xEF, 0x00, 0x1E, 0xF0,
  0x01, 0xCF, 0x00, 0x1C, 0xE0, 0x03, 0xCE, 0x00, 0x3C, 0x00, 0x7E, 0x00,
  0x1F, 0xFC, 0x01, 0xFF, 0xF8, 0x1F, 0x03, 0xC1, 0xE0, 0x0F, 0x1E, 0x00,
  0x38, 0xF0, 0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0x3B, 0x80, 0x01, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFC, 0x00, 0x0E, 0xE0, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x78, 0xE0,
  0x03, 0xC7, 0x80, 0x3C, 0x1E, 0x07, 0xC0, 0xFF, 0xFC, 0x01, 0xFF, 0xC0,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0x3F, 0xF0, 0x1E, 0xFF, 0xF0,
  0x39, 0xC3, 0xE0, 0x76, 0x01, 0xE1, 0xF8, 0x03, 0xC3, 0xE0, 0x03, 0x87,
  0x80, 0x07, 0x0F, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0xF0,
  0x00, 0x71, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8E, 0x00,
  0x0F, 0x1C, 0x00, 0x1C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x03,
  0xC3, 0xE0, 0x0F, 0x87, 0x70, 0x7E, 0x0E, 0x7F, 0xF8, 0x3C, 0x7F, 0xE0,
  0x78, 0x7F, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xF8, 0xF0, 0xFF, 0xF3, 0x87, 0xE0,
  0xEE, 0x3E, 0x00, 0xF8, 0xF0, 0x01, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1E,
  0x70, 0x00, 0x73, 0xC0, 0x01, 0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xF0,
  0x00, 0xF3, 0x80, 0x03, 0xCE, 0x00, 0x0E, 0x38, 0x00, 0x38, 0xE0, 0x01,
  0xE3, 0x80, 0x07, 0x8E, 0x00, 0x3E, 0x3C, 0x01, 0xF8, 0xF0, 0x0D, 0xC1,
  0xF0, 0xE7, 0x07, 0xFF, 0x9C, 0x0F, 0xFC, 0xF0, 0x0F, 0xC3, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0xFF, 0xC1, 0xFF,
  0xFF, 0x1F, 0xEF, 0xFC, 0xFF, 0x80, 0xF7, 0x00, 0x03, 0xF0, 0x00, 0x0E,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xF0, 0x3F,
  0x0F, 0x00, 0x38, 0x38, 0x00, 0x41, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC2, 0x00, 0x07, 0x1C, 0x00, 0x3C, 0xF8, 0x00, 0xF1, 0xF8,
  0x0F, 0x83, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x40, 0xF0, 0x0E, 0x0F, 0x03,
  0xF0, 0xE0, 0x7C, 0x0E, 0x1F, 0x81, 0xE3, 0xE0, 0x1E, 0x7C, 0x01, 0xFF,
  0x80, 0x0F, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x73, 0xC0, 0x07, 0x38,
  0x00, 0xF3, 0x80, 0x0F, 0x38, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0xE7,
  0x80, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x1E, 0x70, 0x01, 0xEF, 0x00, 0x1E,
  0xF0, 0x01, 0xCF, 0x00, 0x1C, 0xE0, 0x03, 0xCE, 0x00, 0x3C, 0xE0, 0x07,
  0xCE, 0x00, 0x7C, 0xF0, 0x0F, 0x8F, 0x01, 0xB8, 0xF8, 0x37, 0x87, 0xFF,
  0x78, 0x3F, 0xE7, 0x81, 0xF8, 0x00, 0xFF, 0x80, 0x37, 0xFC, 0x07, 0xFF,
  0xC0, 0x1E, 0x0E, 0x00, 0xF0, 0x70, 0x03, 0x83, 0x80, 0x1C, 0x3C, 0x00,
  0xE1, 0xE0, 0x07, 0x0F, 0x00, 0x38, 0x70, 0x03, 0xC3, 0x80, 0x1E, 0x1C,
  0x00, 0xF1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x07, 0x83, 0x80, 0x3C,
  0x1C, 0x03, 0xC0, 0xE0, 0x3C, 0x07, 0x07, 0xC0, 0x78, 0xFC, 0x03, 0xFF,
  0xC0, 0x0F, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x1C, 0x0E, 0x06, 0x1C, 0x0E,
  0x1E, 0x3C, 0x0E, 0x0E, 0x38, 0x0E, 0x0E, 0x38, 0x1C, 0x0E, 0x38, 0x1C,
  0x0E, 0x38, 0x1C, 0x0F, 0x38, 0x1C, 0x0F, 0x78, 0x1C, 0x0E, 0x70, 0x3C,
  0x0E, 0x70, 0x38, 0x0E, 0x70, 0x38, 0x0E, 0x70, 0x38, 0x0E, 0x70, 0x38,
  0x1E, 0xF0, 0x38, 0x1C, 0xE0, 0x78, 0x1C, 0xE0, 0x78, 0x3C, 0xE0, 0x70,
  0x38, 0xE0, 0xB8, 0x78, 0xF1, 0xB8, 0xF0, 0xFF, 0x3F, 0xE0, 0x7F, 0x1F,
  0xC0, 0x3C, 0x0F, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x3F, 0x87, 0xF8, 0x0F,
  0xF1, 0xFF, 0x07, 0xEE, 0x38, 0xE1, 0xF1, 0xCE, 0x1E, 0x78, 0x1D, 0x83,
  0xC6, 0x03, 0xE0, 0x78, 0x00, 0x7C, 0x0F, 0x00, 0x0F, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x70, 0x1E,
  0x00, 0x1E, 0x07, 0xC0, 0x43, 0xC0, 0xF8, 0x0C, 0x78, 0x37, 0x07, 0xCF,
  0x0E, 0xF1, 0xF1, 0xE3, 0x8E, 0xF8, 0x1F, 0xF1, 0xFE, 0x03, 0xFC, 0x3F,
  0x80, 0x3E, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x0E, 0x0F, 0x00, 0x1C, 0x1C,
  0x00, 0x78, 0x38, 0x00, 0xF0, 0x70, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0,
  0x07, 0x07, 0x80, 0x0E, 0x0E, 0x00, 0x3C, 0x1C, 0x00, 0x78, 0x38, 0x00,
  0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0x83, 0xC0, 0x07, 0x07, 0x00, 0x1E,
  0x0E, 0x00, 0x3C, 0x1C, 0x00, 0xF8, 0x3C, 0x03, 0xF0, 0x78, 0x0D, 0xC0,
  0xF8, 0x3B, 0x80, 0xFF, 0xE7, 0x00, 0xFF, 0x9E, 0x00, 0xFC, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x03, 0x00, 0x7C, 0x0F, 0x01, 0xF0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xFC, 0x3C, 0x3F, 0xFC,
  0x78, 0xF0, 0x7E, 0xF1, 0xC0, 0x1F, 0xC3, 0x80, 0x0F, 0x07, 0x00, 0x3C,
  0x0C, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x1C, 0x01,
  0xE0, 0x38, 0x07, 0x80, 0x38, 0x3E, 0x00, 0x70, 0xF8, 0x00, 0xE3, 0xFF,
  0x01, 0xE7, 0xFF, 0xF1, 0xCE, 0x7F, 0xFF, 0x3C, 0x1F, 0xFE, 0x78, 0x07,
  0xF8, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0xC0,
  0x3F, 0xF8, 0x01, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x01, 0xC0,
  0xF0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x81, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0E, 0x03, 0x80,
  0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x80, 0x7C, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x03, 0xC0, 0x04,
  0x0F, 0xE0, 0x0F, 0x1F, 0xF0, 0x0E, 0x1C, 0x78, 0x0E, 0x38, 0x38, 0x1C,
  0x78, 0x3C, 0x3C, 0x70, 0x1E, 0x78, 0x70, 0x0F, 0xF0, 0xE0, 0x0F, 0xF0,
  0x60, 0x03, 0xC0,
};

const GFXglyph IBMPlexMono_Italic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 10, 31, 27, 9, -31 },
  { 40, 14, 12, 27, 9, -33 },
  { 61, 27, 31, 27, 1, -31 },
  { 166, 25, 43, 27, 1, -37 },
  { 301, 31, 33, 27, -1, -32 },
  { 429, 26, 33, 27, 0, -32 },
  { 537, 6, 12, 27, 13, -33 },
  { 546, 17, 40, 27, 9, -34 },
  { 631, 17, 40, 27, 2, -34 },
  { 716, 22, 22, 27, 3, -25 },
  { 777, 22, 21, 27, 3, -24 },
  { 835, 10, 12, 27, 6, -6 },
  { 850, 14, 3, 27, 7, -15 },
  { 856, 6, 6, 27, 9, -6 },
  { 861, 26, 40, 27, 1, -34 },
  { 991, 23, 33, 27, 3, -32 },
  { 1086, 21, 31, 27, 2, -31 },
  { 1168, 24, 32, 27, 1, -32 },
  { 1264, 24, 33, 27, 1, -32 },
  { 1363, 24, 31, 27, 1, -31 },
  { 1456, 24, 32, 27, 2, -31 },
  { 1552, 21, 32, 27, 3, -31 },
  { 1636, 22, 31, 27, 5, -31 },
  { 1722, 24, 33, 27, 2, -32 },
  { 1821, 21, 32, 27, 4, -32 },
  { 1905, 9, 24, 27, 9, -24 },
  { 1932, 12, 30, 27, 6, -24 },
  { 1977, 22, 26, 27, 4, -27 },
  { 2049, 23, 12, 27, 2, -20 },
  { 2084, 22, 26, 27, 2, -27 },
  { 2156, 19, 32, 27, 6, -32 },
  { 2232, 22, 37, 27, 3, -32 },
  { 2334, 24, 31, 27, 0, -31 },
  { 2427, 23, 31, 27, 2, -31 },
  { 2517, 22, 33, 27, 4, -32 },
  { 2608, 23, 31, 27, 2, -31 },
  { 2698, 25, 31, 27, 2, -31 },
  { 2795, 25, 31, 27, 2, -31 },
  { 2892, 23, 33, 27, 3, -32 },
  { 2987, 25, 31, 27, 2, -31 },
  { 3084, 25, 31, 27, 2, -31 },
  { 3181, 22, 32, 27, 3, -31 },
  { 3269, 27, 31, 27, 2, -31 },
  { 3374, 19, 31, 27, 4, -31 },
  { 3448, 26, 31, 27, 1, -31 },
  { 3549, 25, 31, 27, 2, -31 },
  { 3646, 23, 33, 27, 3, -32 },
  { 3741, 24, 31, 27, 2, -31 },
  { 3834, 23, 40, 27, 3, -32 },
  { 3949, 24, 31, 27, 2, -31 },
  { 4042, 25, 33, 27, 1, -32 },
  { 4146, 25, 31, 27, 4, -31 },
  { 4243, 24, 32, 27, 3, -31 },
  { 4339, 24, 31, 27, 5, -31 },
  { 4432, 27, 31, 27, 2, -31 },
  { 4537, 30, 31, 27, -1, -31 },
  { 4654, 26, 31, 27, 4, -31 },
  { 4755, 27, 31, 27, 0, -31 },
  { 4860, 19, 40, 27, 7, -34 },
  { 4955, 12, 40, 27, 8, -34 },
  { 5015, 20, 40, 27, 0, -34 },
  { 5115, 23, 18, 27, 3, -31 },
  { 5167, 22, 3, 27, 0, 4 },
  { 5176, 6, 9, 27, 10, -35 },
  { 5183, 21, 25, 27, 3, -24 },
  { 5249, 22, 34, 27, 2, -33 },
  { 5343, 20, 25, 27, 3, -24 },
  { 5406, 23, 34, 27, 3, -33 },
  { 5504, 21, 25, 27, 3, -24 },
  { 5570, 30, 43, 27, -1, -33 },
  { 5732, 24, 34, 27, 1, -24 },
  { 5834, 20, 33, 27, 3, -33 },
  { 5917, 20, 34, 27, 4, -33 },
  { 6002, 21, 43, 27, 3, -33 },
  { 6115, 23, 34, 27, 3, -33 },
  { 6213, 19, 34, 27, 5, -33 },
  { 6294, 25, 24, 27, 1, -24 },
  { 6369, 20, 24, 27, 3, -24 },
  { 6429, 21, 25, 27, 3, -24 },
  { 6495, 23, 33, 27, 1, -24 },
  { 6590, 22, 33, 27, 3, -24 },
  { 6681, 22, 23, 27, 5, -23 },
  { 6745, 22, 25, 27, 2, -24 },
  { 6814, 20, 32, 27, 4, -31 },
  { 6894, 20, 24, 27, 4, -23 },
  { 6954, 21, 23, 27, 3, -23 },
  { 7015, 24, 23, 27, 2, -23 },
  { 7084, 27, 25, 27, 0, -24 },
  { 7169, 23, 33, 27, 1, -23 },
  { 7264, 23, 24, 27, 2, -24 },
  { 7333, 21, 40, 27, 5, -34 },
  { 7438, 10, 40, 27, 9, -34 },
  { 7488, 21, 40, 27, 2, -34 },
  { 7593, 24, 10, 27, 2, -19 },
};

const GFXfont IBMPlexMono_Italic45pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic45pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic45pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _IBMPLEXMONO_ITALIC45PT7B_H_
