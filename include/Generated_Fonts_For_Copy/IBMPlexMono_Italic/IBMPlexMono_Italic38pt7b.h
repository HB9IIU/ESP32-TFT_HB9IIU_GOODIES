#ifndef _IBMPLEXMONO_ITALIC38PT7B_H_
#define _IBMPLEXMONO_ITALIC38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x3C, 0x1E, 0x0E, 0x07,
  0x03, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0xF8, 0xFC, 0x7E, 0x1E, 0x00, 0x38, 0xE6, 0x1D, 0xC3,
  0xB8, 0x77, 0x0C, 0xE3, 0x9C, 0x73, 0x0E, 0xE1, 0xDC, 0x3B, 0x86, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x70,
  0x00, 0x38, 0x70, 0x00, 0x38, 0x60, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0,
  0x1F, 0xF0, 0xFF, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x00, 0xE1, 0xC0,
  0x01, 0xC3, 0x80, 0x01, 0xC3, 0x80, 0x01, 0xC3, 0x80, 0x03, 0x87, 0x00,
  0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x0F, 0xF8, 0x87, 0x0E, 0x00,
  0x07, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00,
  0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x07, 0xF0, 0x01, 0xFF,
  0xE0, 0x1F, 0xFF, 0x81, 0xF3, 0xBE, 0x0E, 0x1C, 0x78, 0xF0, 0xC1, 0x87,
  0x06, 0x00, 0x38, 0x30, 0x01, 0xC1, 0x80, 0x0F, 0x1C, 0x00, 0x7C, 0xC0,
  0x01, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0xE7, 0xC0, 0x07, 0x1E, 0x00, 0x30, 0x70, 0x01, 0x83, 0x80, 0x0C, 0x1C,
  0x40, 0x60, 0xE7, 0x07, 0x0F, 0x3C, 0x30, 0xF0, 0xF9, 0x8F, 0x83, 0xFF,
  0xF8, 0x0F, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x00, 0xF0, 0x01, 0xC0, 0xFF, 0x00, 0xE0,
  0x7F, 0xC0, 0x70, 0x3C, 0x38, 0x1C, 0x0E, 0x0E, 0x0E, 0x03, 0x03, 0x87,
  0x01, 0xC0, 0xE1, 0x80, 0x70, 0x38, 0xE0, 0x1C, 0x1C, 0x70, 0x03, 0x8F,
  0x18, 0x00, 0xFF, 0x8E, 0x00, 0x1F, 0xC4, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xE7, 0xFC,
  0x00, 0x63, 0xC7, 0x00, 0x38, 0xE0, 0xE0, 0x1C, 0x70, 0x38, 0x06, 0x1C,
  0x0E, 0x03, 0x87, 0x03, 0x01, 0xC1, 0xC1, 0xC0, 0x60, 0x70, 0xF0, 0x38,
  0x0F, 0xF8, 0x1C, 0x03, 0xFC, 0x0E, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xF0, 0xF0, 0x03, 0x81, 0xE0, 0x0E,
  0x03, 0x80, 0x38, 0x0E, 0x00, 0xE0, 0x38, 0x03, 0x80, 0xE0, 0x0E, 0x07,
  0x00, 0x1C, 0x1C, 0x00, 0x70, 0xE0, 0x0F, 0xEF, 0x00, 0x7F, 0xF8, 0x03,
  0xCF, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x70, 0x03, 0x80, 0xE0, 0x0E, 0x03,
  0xC0, 0x38, 0x07, 0x02, 0xE0, 0x1E, 0x1F, 0x80, 0x78, 0x7F, 0x03, 0x73,
  0x9E, 0x1D, 0xCE, 0x7F, 0xE7, 0xF0, 0xFF, 0x0F, 0xC0, 0xF8, 0x1C, 0x00,
  0x39, 0xCC, 0xE7, 0x39, 0xCE, 0x67, 0x38, 0x00, 0x3C, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60,
  0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00,
  0x18, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x18, 0x1C, 0x1F,
  0xE3, 0x3F, 0x7F, 0xFF, 0xE1, 0xFF, 0xC0, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x0E, 0x70, 0x03, 0x87, 0x00, 0xE0, 0xE0, 0x38, 0x0E, 0x0F,
  0x01, 0xC0, 0x40, 0x20, 0x00, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0F, 0x8F, 0x87, 0x83, 0xC3, 0xC1, 0xE0, 0xE0, 0xE0, 0x70, 0x70, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x39, 0xFF, 0xFF, 0x78, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8,
  0x03, 0xFF, 0xC0, 0x78, 0x3E, 0x0F, 0x00, 0xE1, 0xE0, 0x0E, 0x1C, 0x00,
  0xE3, 0xC0, 0x07, 0x38, 0x00, 0x73, 0x80, 0x07, 0x78, 0x00, 0x77, 0x00,
  0x0F, 0x70, 0xF0, 0xE7, 0x0F, 0x0E, 0x70, 0xF0, 0xEF, 0x0F, 0x0E, 0xE0,
  0x01, 0xEE, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x3C, 0x70, 0x03, 0x87,
  0x00, 0x78, 0x70, 0x0F, 0x07, 0xC1, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x80,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0x70,
  0x07, 0x9C, 0x03, 0xC7, 0x03, 0xE1, 0xC0, 0xF0, 0xF0, 0x38, 0x38, 0x04,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0,
  0x7C, 0x3E, 0x0F, 0x00, 0xF0, 0xE0, 0x0F, 0x1C, 0x00, 0x70, 0x40, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7C, 0x1E, 0x0F, 0x00,
  0xF0, 0x60, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x20, 0x01, 0xC6, 0x00, 0x3C, 0xF0, 0x07, 0x87, 0xC1, 0xF0,
  0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0xEE, 0x00, 0x1F, 0xC0, 0x01, 0xDC, 0x00,
  0x39, 0xC0, 0x07, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x01, 0xC3, 0x80,
  0x38, 0x38, 0x07, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x38,
  0x38, 0x07, 0x07, 0x00, 0x70, 0xE0, 0x07, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0xFC, 0x01, 0x9F, 0xF0, 0x1B, 0xFF,
  0x83, 0xE0, 0x78, 0x38, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x20, 0x03, 0xC6, 0x00, 0x38, 0xF0,
  0x07, 0x87, 0x81, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC7,
  0xC0, 0xE7, 0xFC, 0x3B, 0xFF, 0x9D, 0x81, 0xF7, 0xC0, 0x3D, 0xE0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xDC,
  0x00, 0xE7, 0x00, 0x79, 0xF0, 0x7C, 0x3F, 0xFE, 0x07, 0xFF, 0x00, 0x7E,
  0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x30, 0x00, 0xEE, 0x00,
  0x39, 0xC0, 0x07, 0x38, 0x01, 0xC7, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x07,
  0xFF, 0xE0, 0xF8, 0x1E, 0x1E, 0x00, 0xF1, 0xC0, 0x0F, 0x1C, 0x00, 0xF1,
  0xC0, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x1C, 0x1E, 0x07, 0x80, 0x7F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x3E, 0x07, 0x87, 0x80, 0x3C, 0x70, 0x01,
  0xCE, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00,
  0x3C, 0xF0, 0x07, 0x8F, 0x81, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xC0, 0x0F,
  0xF0, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7C, 0x1E, 0x3C,
  0x03, 0xDE, 0x00, 0x77, 0x00, 0x1D, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0x70, 0x07, 0xDF, 0x07, 0xE3, 0xFF, 0xB8,
  0x7F, 0xDE, 0x0F, 0xC7, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xE0, 0x00, 0x0F, 0x0F, 0x87, 0xE3, 0xE1, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x7C, 0x7E, 0x3F,
  0x0F, 0x00, 0x03, 0xC0, 0xF8, 0x1F, 0x83, 0xE0, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x1F, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x70, 0x1C, 0x03, 0x80, 0xE0,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0x10, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0x20, 0x00, 0x00,
  0x03, 0xF0, 0x0F, 0xFC, 0x3F, 0xFE, 0x3C, 0x1E, 0x70, 0x0F, 0xF0, 0x07,
  0xE0, 0x07, 0x20, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x3C,
  0x00, 0xFC, 0x07, 0xF0, 0x07, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1F,
  0xFF, 0x07, 0xC1, 0xE0, 0xE0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x19, 0xC0,
  0x03, 0x38, 0x3C, 0x67, 0x0F, 0xCC, 0xC3, 0xFF, 0xB8, 0x70, 0xF7, 0x1C,
  0x0E, 0xE3, 0x81, 0xDC, 0x70, 0x33, 0x1C, 0x06, 0xE3, 0x81, 0xDC, 0x70,
  0x3B, 0x8E, 0x07, 0x71, 0xC1, 0xEE, 0x38, 0x59, 0xC3, 0xFB, 0x38, 0x7E,
  0xE7, 0x07, 0xDC, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xB8, 0x00, 0x3B, 0x80, 0x03, 0xB8, 0x00,
  0x73, 0x80, 0x07, 0x38, 0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x01, 0xC1, 0xC0,
  0x1C, 0x1C, 0x03, 0x81, 0xC0, 0x38, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xC0, 0x0E, 0x1C, 0x00,
  0xE3, 0x80, 0x0E, 0x38, 0x00, 0xE7, 0x80, 0x0F, 0x70, 0x00, 0xFF, 0x00,
  0x07, 0xE0, 0x00, 0x70, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07,
  0x00, 0xF1, 0xE0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x07, 0x1C,
  0x00, 0xE3, 0x80, 0x3C, 0xF0, 0x07, 0x1C, 0x03, 0xC3, 0xFF, 0xF0, 0x7F,
  0xF8, 0x0F, 0xFF, 0xC1, 0xC0, 0x3C, 0x78, 0x01, 0xCE, 0x00, 0x39, 0xC0,
  0x07, 0x38, 0x00, 0xE7, 0x00, 0x1C, 0xE0, 0x07, 0xBC, 0x00, 0xE7, 0x00,
  0x7C, 0xFF, 0xFF, 0x1F, 0xFF, 0xC3, 0xFF, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x3F, 0xE0, 0x1F, 0xFE, 0x07, 0xC1, 0xE1, 0xE0, 0x1E, 0x38, 0x01, 0xCF,
  0x00, 0x31, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x01, 0x8E, 0x00, 0x39, 0xE0,
  0x0E, 0x1C, 0x03, 0xC3, 0xE0, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0x03, 0xE0,
  0xE0, 0x1E, 0x1C, 0x01, 0xC7, 0x80, 0x38, 0xE0, 0x07, 0x1C, 0x00, 0xE3,
  0x80, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0x73, 0xC0, 0x0E, 0x70, 0x01, 0xCE,
  0x00, 0x39, 0xC0, 0x07, 0x38, 0x01, 0xE7, 0x00, 0x39, 0xE0, 0x07, 0x38,
  0x01, 0xE7, 0x00, 0x38, 0xE0, 0x0F, 0x1C, 0x03, 0xC3, 0x80, 0xF0, 0xFF,
  0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF,
  0x83, 0xFF, 0xFC, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xFF,
  0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3,
  0xFF, 0xFE, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE,
  0x07, 0xC3, 0xE1, 0xE0, 0x1C, 0x78, 0x03, 0x8E, 0x00, 0x3B, 0xC0, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0xFF, 0x38, 0x1F, 0xE7, 0x03, 0xFC, 0xE0, 0x03, 0x9C, 0x00, 0x73,
  0x80, 0x0E, 0x70, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x1E, 0x3C, 0x07, 0xC3,
  0xC1, 0xB8, 0x7F, 0xE7, 0x07, 0xFC, 0xC0, 0x3E, 0x38, 0x00, 0x07, 0x00,
  0x3C, 0x1C, 0x00, 0xE0, 0xF0, 0x03, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x38,
  0x38, 0x01, 0xE0, 0xE0, 0x07, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x70, 0x70,
  0x01, 0xC1, 0xC0, 0x07, 0x07, 0x00, 0x3C, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x81, 0xFF, 0xFE, 0x0F, 0x00, 0x38, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0x83,
  0x80, 0x1C, 0x0E, 0x00, 0x70, 0x38, 0x01, 0xC1, 0xE0, 0x07, 0x07, 0x00,
  0x1C, 0x1C, 0x00, 0x70, 0x70, 0x03, 0x81, 0xC0, 0x0E, 0x0F, 0x00, 0x38,
  0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x86, 0x00, 0xF1, 0xE0,
  0x1C, 0x1C, 0x07, 0x83, 0xC1, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x3F,
  0x80, 0x00, 0x0E, 0x00, 0x3E, 0x1C, 0x00, 0xF0, 0x38, 0x03, 0xC0, 0xF0,
  0x0F, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0xF0, 0x07, 0x03, 0xC0, 0x0E, 0x0F,
  0x00, 0x1C, 0x3C, 0x00, 0x78, 0xF0, 0x00, 0xE3, 0xC0, 0x01, 0xCF, 0x00,
  0x03, 0xBF, 0x00, 0x07, 0x7E, 0x00, 0x0F, 0xDE, 0x00, 0x1F, 0x1C, 0x00,
  0x7C, 0x38, 0x00, 0xF0, 0x38, 0x01, 0xC0, 0x70, 0x03, 0x80, 0xF0, 0x07,
  0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x3C, 0x01, 0xC0, 0x70, 0x03, 0xC0, 0xE0,
  0x03, 0x81, 0xC0, 0x07, 0x03, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0x00, 0x3C, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0,
  0x3E, 0x0F, 0x80, 0xF8, 0x36, 0x07, 0xE1, 0xDC, 0x3B, 0x87, 0x70, 0xEE,
  0x1C, 0xC7, 0x38, 0x73, 0x18, 0xC1, 0xCE, 0xE7, 0x06, 0x3B, 0x1C, 0x38,
  0x7C, 0x70, 0xE1, 0xE1, 0xC3, 0x87, 0x87, 0x0E, 0x1C, 0x18, 0x38, 0x70,
  0xE0, 0xC0, 0x83, 0x87, 0x04, 0x0E, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xE1,
  0xC0, 0x03, 0x07, 0x00, 0x1C, 0x18, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80,
  0x07, 0x0E, 0x00, 0x1C, 0x00, 0x07, 0xC0, 0x1C, 0x1F, 0x00, 0xE0, 0xFC,
  0x03, 0x83, 0xF0, 0x0E, 0x0E, 0xC0, 0x38, 0x3B, 0x80, 0xE0, 0xEE, 0x03,
  0x03, 0xB8, 0x1C, 0x0C, 0x60, 0x70, 0x71, 0xC1, 0xC1, 0xC7, 0x07, 0x07,
  0x1C, 0x1C, 0x1C, 0x70, 0x60, 0x70, 0xC3, 0x81, 0x83, 0x8E, 0x0E, 0x0E,
  0x38, 0x38, 0x38, 0xE0, 0xE0, 0xE3, 0x83, 0x81, 0x8C, 0x0E, 0x07, 0x70,
  0x30, 0x1D, 0xC1, 0xC0, 0x77, 0x07, 0x00, 0xDC, 0x1C, 0x03, 0xF0, 0x70,
  0x0F, 0x81, 0xC0, 0x3E, 0x0E, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x1F,
  0xF8, 0x03, 0xFF, 0xC0, 0x78, 0x3E, 0x0F, 0x00, 0xE1, 0xE0, 0x0E, 0x1C,
  0x00, 0xE3, 0xC0, 0x07, 0x38, 0x00, 0x73, 0x80, 0x07, 0x78, 0x00, 0xF7,
  0x00, 0x0F, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xEF, 0x00, 0x0E,
  0xF0, 0x01, 0xEE, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x3C, 0x70, 0x03,
  0x87, 0x00, 0x78, 0x70, 0x0F, 0x07, 0xC1, 0xE0, 0x3F, 0xFC, 0x01, 0xFF,
  0x80, 0x07, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0xE0, 0x0F, 0x1E, 0x00, 0x71, 0xE0, 0x07, 0x1C, 0x00, 0x71, 0xC0, 0x07,
  0x1C, 0x00, 0x71, 0xC0, 0x07, 0x3C, 0x00, 0xF3, 0xC0, 0x0E, 0x38, 0x03,
  0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x78, 0x3E, 0x0F, 0x00,
  0xE1, 0xE0, 0x0E, 0x1C, 0x00, 0xE3, 0xC0, 0x07, 0x38, 0x00, 0x73, 0x80,
  0x07, 0x78, 0x00, 0xF7, 0x00, 0x0F, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x70,
  0x00, 0xEF, 0x00, 0x0E, 0xF0, 0x01, 0xEE, 0x00, 0x1C, 0xE0, 0x01, 0xCE,
  0x00, 0x3C, 0xF0, 0x03, 0x87, 0x00, 0x78, 0x70, 0x0F, 0x07, 0xC1, 0xE0,
  0x3F, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0xC0, 0x0F, 0x1E, 0x00, 0x73, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x01,
  0xC0, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xE0, 0x0F, 0x1E,
  0x00, 0x71, 0xE0, 0x07, 0x1C, 0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00, 0x71,
  0xC0, 0x07, 0x3C, 0x00, 0xF3, 0xC0, 0x0E, 0x38, 0x03, 0xE3, 0xFF, 0xFC,
  0x3F, 0xFF, 0x83, 0xFF, 0xC0, 0x78, 0x70, 0x07, 0x83, 0x80, 0x70, 0x38,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xE0, 0x70, 0x0E, 0x0F, 0x00,
  0xF0, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x80, 0x00, 0x7F, 0x00,
  0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0x03, 0xE0, 0xF0, 0x07, 0x8F, 0x00,
  0x18, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC2, 0x00, 0x0E, 0x30, 0x00, 0xF3, 0xC0, 0x0F, 0x0F, 0x81, 0xF8,
  0x3F, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0xFD, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0xF1, 0xC0, 0x0E, 0x3C, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x00, 0xE3,
  0x80, 0x1E, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x78, 0x01, 0xC7, 0x00, 0x1C,
  0x70, 0x01, 0xC7, 0x00, 0x3C, 0x70, 0x03, 0x87, 0x00, 0x38, 0xF0, 0x03,
  0x8E, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x78, 0xE0, 0x07, 0x0E, 0x00,
  0x70, 0xE0, 0x07, 0x0E, 0x00, 0xF0, 0xE0, 0x1E, 0x0F, 0x83, 0xE0, 0x7F,
  0xFC, 0x03, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x0E,
  0xE0, 0x00, 0xE7, 0x00, 0x1E, 0x70, 0x01, 0xC7, 0x00, 0x3C, 0x70, 0x03,
  0x87, 0x00, 0x38, 0x70, 0x07, 0x07, 0x00, 0x70, 0x70, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x1C, 0x03, 0x81, 0xC0, 0x38, 0x3C, 0x03, 0x83, 0x80, 0x38,
  0x38, 0x03, 0x87, 0x00, 0x18, 0x70, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x01,
  0xDC, 0x00, 0x1D, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xCE,
  0x00, 0x06, 0x30, 0x00, 0x38, 0xC0, 0x00, 0xE7, 0x00, 0x03, 0x9C, 0x1E,
  0x0C, 0x70, 0x78, 0x71, 0xC3, 0xE1, 0xC7, 0x0F, 0x87, 0x1C, 0x76, 0x18,
  0x71, 0xD8, 0xE1, 0xC6, 0x63, 0x87, 0x39, 0x8E, 0x18, 0xC6, 0x30, 0x63,
  0x18, 0xC1, 0x9C, 0x67, 0x0E, 0x61, 0x9C, 0x39, 0x86, 0x70, 0xEE, 0x19,
  0x83, 0xB0, 0x6E, 0x0F, 0xC1, 0xB8, 0x3F, 0x06, 0xE0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0x80, 0x07, 0x81, 0xC0, 0x03,
  0x80, 0x70, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x07, 0x01,
  0xC0, 0x03, 0xC1, 0xC0, 0x00, 0xE1, 0xE0, 0x00, 0x79, 0xE0, 0x00, 0x1D,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x78, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x38, 0x1C, 0x00,
  0x38, 0x0F, 0x00, 0x3C, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x3C, 0x00, 0x70,
  0x1C, 0x00, 0x3C, 0x3C, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x3D, 0xC0, 0x01,
  0xE7, 0x80, 0x0F, 0x0E, 0x00, 0x38, 0x3C, 0x01, 0xE0, 0x70, 0x0F, 0x01,
  0xC0, 0x38, 0x07, 0x81, 0xC0, 0x0E, 0x0F, 0x00, 0x38, 0x78, 0x00, 0x71,
  0xC0, 0x01, 0xCE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0,
  0xC0, 0x38, 0x0E, 0x01, 0x80, 0x60, 0x1C, 0x07, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x80, 0xE0, 0x18, 0x06, 0x01, 0xC0, 0x70, 0x0C, 0x03, 0x00, 0xC0,
  0x38, 0x0E, 0x01, 0x80, 0x60, 0x1C, 0x07, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x80, 0xE0, 0x18, 0x06, 0x01, 0xC0, 0x70, 0x03, 0xFF, 0x81, 0xFF, 0x80,
  0xFF, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x0E, 0xE0, 0x01, 0xE7, 0x00, 0x1C, 0x70, 0x03,
  0x83, 0x80, 0x70, 0x38, 0x0F, 0x03, 0x80, 0xE0, 0x1C, 0x1C, 0x01, 0xC3,
  0xC0, 0x0E, 0x38, 0x00, 0xE7, 0x00, 0x0E, 0xE0, 0x00, 0x70, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x00, 0xEE, 0x67, 0x73, 0x30, 0x03, 0xF1,
  0xC1, 0xFE, 0x70, 0xFF, 0xDC, 0x78, 0x1F, 0x3C, 0x03, 0xCE, 0x00, 0xF7,
  0x00, 0x39, 0xC0, 0x0E, 0x70, 0x03, 0xBC, 0x00, 0xEE, 0x00, 0x3B, 0x80,
  0x0E, 0xE0, 0x07, 0x38, 0x01, 0xCE, 0x00, 0xF3, 0xC0, 0x5C, 0x78, 0x37,
  0x1F, 0xF9, 0xF3, 0xFC, 0x7C, 0x7E, 0x0F, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x1C, 0x3E, 0x03, 0x9F, 0xF0, 0x77, 0xFF, 0x0E, 0xC1, 0xE1,
  0xE0, 0x1C, 0x78, 0x03, 0xCF, 0x00, 0x39, 0xC0, 0x07, 0x38, 0x00, 0xE7,
  0x00, 0x3C, 0xE0, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x1C, 0xE0, 0x07, 0x9C,
  0x00, 0xE3, 0xC0, 0x3C, 0x6C, 0x1F, 0x1D, 0xFF, 0xC3, 0x9F, 0xF0, 0x70,
  0xF8, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x83, 0xC1, 0xE3, 0xC0,
  0x7B, 0xC0, 0x19, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x27, 0x00, 0x3B, 0x80, 0x3D, 0xE0, 0x3C,
  0x78, 0x3C, 0x3F, 0xFC, 0x0F, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x03, 0xF0, 0xE0, 0x7F, 0xCE, 0x0F, 0xFC,
  0xC1, 0xE0, 0x7C, 0x3C, 0x03, 0xC3, 0x80, 0x1C, 0x70, 0x01, 0xC7, 0x00,
  0x1C, 0x70, 0x03, 0x8F, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0xE0,
  0x03, 0x8E, 0x00, 0x78, 0xE0, 0x0F, 0x0F, 0x01, 0xF0, 0x78, 0x37, 0x07,
  0xFF, 0x70, 0x3F, 0xE7, 0x01, 0xF8, 0x70, 0x01, 0xFC, 0x03, 0xFF, 0x83,
  0xFF, 0xE3, 0xC0, 0xF3, 0x80, 0x3B, 0x80, 0x1D, 0xC0, 0x1F, 0xC0, 0x7E,
  0xFF, 0xFE, 0x7F, 0xFC, 0x3F, 0xE0, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x1B, 0x80, 0x1F, 0xE0, 0x1E, 0x78, 0x3E, 0x3F, 0xFE, 0x0F, 0xFE, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x04, 0x07, 0x00, 0x07, 0x03, 0x80, 0x07, 0xC3, 0xC0, 0x00,
  0xF1, 0xC0, 0x00, 0x3C, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF8, 0x70, 0x3F, 0xE7,
  0x07, 0xFE, 0xE0, 0xF8, 0x3E, 0x1E, 0x01, 0xE1, 0xC0, 0x0E, 0x38, 0x00,
  0xE3, 0x80, 0x0E, 0x38, 0x00, 0xC7, 0x80, 0x1C, 0x70, 0x01, 0xC7, 0x00,
  0x1C, 0x70, 0x01, 0xC7, 0x00, 0x3C, 0x78, 0x07, 0x87, 0x80, 0xF8, 0x3C,
  0x1B, 0x83, 0xFF, 0xB8, 0x1F, 0xF3, 0x80, 0x7C, 0x38, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x02, 0x00, 0xE0, 0x70, 0x3E, 0x0F, 0xFF, 0xC0,
  0x3F, 0xF8, 0x00, 0xFE, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E,
  0x3E, 0x07, 0x1F, 0xC1, 0xCF, 0xF8, 0x76, 0x1E, 0x1D, 0x03, 0xC7, 0x80,
  0x73, 0xC0, 0x1C, 0xF0, 0x07, 0x38, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x38,
  0xE0, 0x0E, 0x78, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0x71, 0xC0, 0x1C, 0x70,
  0x07, 0x1C, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x1C, 0x00, 0x70, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x70, 0x10, 0x38, 0x1C, 0x1C, 0x3E, 0x0E, 0x3E, 0x07,
  0x3E, 0x07, 0x3C, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F,
  0xFC, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x60, 0x38, 0x3C, 0x0E, 0x07, 0x87, 0x00, 0xF1, 0xC0, 0x1E, 0x70,
  0x03, 0xDC, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x3E, 0x01, 0xC7, 0xF8, 0x1C,
  0xFF, 0x81, 0xD8, 0x3C, 0x1F, 0x03, 0xC1, 0xE0, 0x1C, 0x3C, 0x03, 0x83,
  0xC0, 0x38, 0x38, 0x07, 0x03, 0x81, 0xE0, 0x38, 0xFC, 0x03, 0xBE, 0x00,
  0x79, 0xC0, 0x07, 0x0E, 0x06, 0x70, 0xE0, 0xE7, 0x07, 0x1F, 0x70, 0x73,
  0xC7, 0x07, 0xF8, 0xE0, 0x3F, 0x0E, 0x01, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x06,
  0x1C, 0x0F, 0x1C, 0x1E, 0x1C, 0x3C, 0x1C, 0xF8, 0x1D, 0xF0, 0x1F, 0xE0,
  0x1F, 0x80, 0x1F, 0x00, 0x0C, 0x70, 0xF0, 0x77, 0xE7, 0xE1, 0xDF, 0xBF,
  0x87, 0xCE, 0xCF, 0x1E, 0x1E, 0x1C, 0x70, 0x70, 0x61, 0xC1, 0xC1, 0x8E,
  0x06, 0x0E, 0x38, 0x38, 0x38, 0xE0, 0xE0, 0xE3, 0x83, 0x83, 0x8E, 0x0E,
  0x0C, 0x38, 0x30, 0x31, 0xC0, 0xC1, 0xC7, 0x07, 0x07, 0x1C, 0x1C, 0x1C,
  0x70, 0x70, 0x71, 0xC1, 0xC1, 0x86, 0x06, 0x06, 0x38, 0x38, 0x38, 0x1C,
  0x3E, 0x07, 0x1F, 0xC1, 0xCF, 0xF8, 0x76, 0x1E, 0x1D, 0x03, 0xC7, 0x80,
  0x73, 0xC0, 0x1C, 0xF0, 0x07, 0x38, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x38,
  0xE0, 0x0E, 0x78, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0x71, 0xC0, 0x1C, 0x70,
  0x07, 0x1C, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x1C, 0x00, 0xFC, 0x01, 0xFF,
  0xC0, 0xFF, 0xF8, 0x7C, 0x1E, 0x3C, 0x03, 0xCE, 0x00, 0x77, 0x80, 0x1D,
  0xC0, 0x07, 0x70, 0x01, 0xDC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0,
  0x03, 0xD8, 0x00, 0xE7, 0x00, 0x79, 0xC0, 0x1C, 0x7C, 0x1F, 0x0F, 0xFF,
  0x81, 0xFF, 0x80, 0x1F, 0x80, 0x0E, 0x1F, 0x00, 0xE7, 0xFC, 0x0E, 0xFF,
  0xE0, 0xEC, 0x1E, 0x0F, 0x00, 0xE1, 0xE0, 0x0F, 0x1E, 0x00, 0x71, 0xC0,
  0x07, 0x1C, 0x00, 0x71, 0xC0, 0x0F, 0x1C, 0x00, 0xE3, 0x80, 0x0E, 0x38,
  0x00, 0xE3, 0x80, 0x1E, 0x38, 0x01, 0xC3, 0xC0, 0x3C, 0x36, 0x0F, 0x87,
  0x7F, 0xF0, 0x73, 0xFE, 0x07, 0x0F, 0x80, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xF0, 0xE0, 0xFF, 0x9C, 0x3F, 0xF7, 0x0F, 0x03,
  0xE3, 0xC0, 0x3C, 0x70, 0x03, 0x9C, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x03,
  0x9E, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x01, 0xCE, 0x00, 0x39, 0xC0, 0x0F,
  0x38, 0x03, 0xC7, 0x80, 0xF8, 0x78, 0x37, 0x0F, 0xFC, 0xE0, 0xFF, 0x9C,
  0x0F, 0xC3, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xFF, 0x87,
  0xFF, 0xE7, 0xFF, 0xFB, 0xFC, 0x0D, 0xC0, 0x07, 0x40, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xE0,
  0xFF, 0xFC, 0x78, 0x0F, 0x1C, 0x00, 0x86, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0xFE, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x39, 0x80, 0x1E, 0xF8, 0x0F, 0x1F, 0xFF, 0x83,
  0xFF, 0xC0, 0x3F, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x41, 0xC0, 0x60, 0xE0,
  0xF8, 0x70, 0xF8, 0x71, 0xF8, 0x39, 0xF0, 0x1F, 0xF0, 0x0F, 0xE0, 0x03,
  0xC0, 0x00, 0x38, 0x01, 0xCE, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x38,
  0x03, 0x9C, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x01,
  0xC7, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x0F, 0x38, 0x03, 0x8E, 0x01, 0xE3,
  0xC0, 0xB8, 0xF8, 0x6E, 0x1F, 0xF3, 0x83, 0xF8, 0xE0, 0x7C, 0x70, 0xFE,
  0x01, 0xBF, 0x81, 0xEF, 0xE0, 0x38, 0x30, 0x0E, 0x1C, 0x03, 0xC7, 0x00,
  0xF1, 0xC0, 0x3C, 0x70, 0x0E, 0x1C, 0x03, 0x87, 0x00, 0xE1, 0x80, 0x78,
  0xE0, 0x1C, 0x38, 0x0F, 0x0E, 0x03, 0x83, 0x81, 0xE0, 0xE1, 0xF0, 0x31,
  0xF8, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0x7C, 0x00, 0x38, 0x38, 0x63, 0x83,
  0x0E, 0x30, 0x30, 0x63, 0x07, 0x06, 0x70, 0x70, 0x67, 0x07, 0x07, 0x70,
  0x60, 0x77, 0x06, 0x06, 0x60, 0xE0, 0x66, 0x0E, 0x06, 0xE0, 0xE0, 0xEE,
  0x0E, 0x0E, 0xE0, 0xC0, 0xEE, 0x1C, 0x1C, 0xC1, 0xC1, 0xCC, 0x1C, 0x3C,
  0xE3, 0xE7, 0x8F, 0xEF, 0xF0, 0xFC, 0xFE, 0x07, 0x87, 0xC0, 0x01, 0xE0,
  0xF8, 0x07, 0xE3, 0xF8, 0x1F, 0xCF, 0xF0, 0x7B, 0x98, 0xE3, 0xC3, 0x60,
  0xE7, 0x06, 0xC1, 0xC8, 0x0D, 0x03, 0x00, 0x1E, 0x06, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x0E, 0x07, 0x80, 0x1C,
  0x0F, 0x02, 0x38, 0x3E, 0x0E, 0x70, 0xFC, 0x78, 0xF3, 0x99, 0xE0, 0xFF,
  0x3F, 0x81, 0xFC, 0x7E, 0x01, 0xE0, 0x70, 0x00, 0x0E, 0x00, 0x70, 0xE0,
  0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x0E, 0x00, 0xE1, 0xC0, 0x0E, 0x1C,
  0x00, 0xE1, 0xC0, 0x1C, 0x1C, 0x01, 0xC1, 0xC0, 0x1C, 0x1C, 0x01, 0xC3,
  0x80, 0x1C, 0x38, 0x03, 0xC3, 0x80, 0x38, 0x38, 0x07, 0x83, 0xC0, 0xF8,
  0x1E, 0x1B, 0x81, 0xFF, 0x38, 0x0F, 0xE3, 0x80, 0x7C, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x0F, 0x06, 0x01, 0xE0, 0xF0, 0x3E, 0x0F, 0xFF,
  0xC0, 0x3F, 0xF8, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0xE1, 0xFF, 0x9C, 0x7F,
  0xFF, 0x9E, 0x1F, 0xF3, 0x80, 0x7C, 0x60, 0x0F, 0x0C, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x80, 0x70,
  0x38, 0x3C, 0x03, 0x0F, 0x00, 0x63, 0xF8, 0x0E, 0xFF, 0xF9, 0xDD, 0xFF,
  0xFB, 0x87, 0xFE, 0x70, 0x1F, 0x80, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x1E, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x07,
  0x07, 0x06, 0x06, 0x06, 0x0E, 0x0E, 0x0E, 0x0C, 0x0C, 0x0C, 0x1C, 0x1C,
  0x1C, 0x18, 0x18, 0x18, 0x38, 0x38, 0x38, 0x30, 0x30, 0x30, 0x70, 0x70,
  0x70, 0x60, 0x60, 0xE0, 0xE0, 0xE0, 0xE0, 0xC0, 0xC0, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0xFF, 0xC0,
  0xF0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x07, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0x0F, 0x00,
  0x61, 0xF8, 0x07, 0x3F, 0xC0, 0xE3, 0x9E, 0x0E, 0x70, 0xE1, 0xC6, 0x07,
  0x1C, 0xE0, 0x7F, 0x8E, 0x03, 0xF0, 0x40, 0x1E, 0x00,
};

const GFXglyph IBMPlexMono_Italic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 9, 27, 23, 7, -27 },
  { 32, 11, 11, 23, 8, -28 },
  { 48, 24, 27, 23, 0, -27 },
  { 129, 21, 35, 23, 1, -31 },
  { 221, 26, 27, 23, -1, -27 },
  { 309, 22, 27, 23, 0, -27 },
  { 384, 5, 11, 23, 11, -28 },
  { 391, 14, 34, 23, 8, -29 },
  { 451, 14, 34, 23, 2, -29 },
  { 511, 19, 19, 23, 2, -21 },
  { 557, 18, 19, 23, 3, -21 },
  { 600, 9, 10, 23, 5, -5 },
  { 612, 11, 3, 23, 6, -13 },
  { 617, 6, 5, 23, 7, -5 },
  { 621, 22, 34, 23, 1, -29 },
  { 715, 20, 27, 23, 2, -27 },
  { 783, 18, 27, 23, 2, -27 },
  { 844, 20, 27, 23, 1, -27 },
  { 912, 20, 27, 23, 1, -27 },
  { 980, 20, 27, 23, 1, -27 },
  { 1048, 20, 27, 23, 2, -27 },
  { 1116, 18, 27, 23, 2, -27 },
  { 1177, 19, 27, 23, 4, -27 },
  { 1242, 20, 27, 23, 2, -27 },
  { 1310, 18, 27, 23, 3, -27 },
  { 1371, 9, 20, 23, 7, -20 },
  { 1394, 11, 25, 23, 5, -20 },
  { 1429, 19, 22, 23, 3, -23 },
  { 1482, 20, 11, 23, 2, -17 },
  { 1510, 18, 22, 23, 2, -23 },
  { 1560, 16, 27, 23, 5, -27 },
  { 1614, 19, 31, 23, 2, -27 },
  { 1688, 20, 27, 23, 0, -27 },
  { 1756, 19, 27, 23, 2, -27 },
  { 1821, 19, 27, 23, 3, -27 },
  { 1886, 19, 27, 23, 2, -27 },
  { 1951, 21, 27, 23, 2, -27 },
  { 2022, 21, 27, 23, 2, -27 },
  { 2093, 19, 27, 23, 3, -27 },
  { 2158, 22, 27, 23, 1, -27 },
  { 2233, 20, 27, 23, 2, -27 },
  { 2301, 19, 27, 23, 2, -27 },
  { 2366, 23, 27, 23, 2, -27 },
  { 2444, 16, 27, 23, 3, -27 },
  { 2498, 22, 27, 23, 1, -27 },
  { 2573, 22, 27, 23, 1, -27 },
  { 2648, 20, 27, 23, 2, -27 },
  { 2716, 20, 27, 23, 2, -27 },
  { 2784, 20, 34, 23, 2, -27 },
  { 2869, 20, 27, 23, 2, -27 },
  { 2937, 21, 27, 23, 1, -27 },
  { 3008, 22, 27, 23, 3, -27 },
  { 3083, 20, 27, 23, 3, -27 },
  { 3151, 20, 27, 23, 4, -27 },
  { 3219, 22, 27, 23, 2, -27 },
  { 3294, 25, 27, 23, -1, -27 },
  { 3379, 22, 27, 23, 3, -27 },
  { 3454, 23, 27, 23, 0, -27 },
  { 3532, 16, 34, 23, 6, -29 },
  { 3600, 10, 34, 23, 7, -29 },
  { 3643, 17, 34, 23, 0, -29 },
  { 3716, 20, 15, 23, 2, -27 },
  { 3754, 19, 3, 23, 0, 3 },
  { 3762, 4, 7, 23, 9, -29 },
  { 3766, 18, 20, 23, 2, -20 },
  { 3811, 19, 28, 23, 2, -28 },
  { 3878, 17, 20, 23, 3, -20 },
  { 3921, 20, 28, 23, 2, -28 },
  { 3991, 17, 20, 23, 3, -20 },
  { 4034, 25, 36, 23, -1, -28 },
  { 4147, 20, 28, 23, 1, -20 },
  { 4217, 18, 28, 23, 2, -28 },
  { 4280, 17, 29, 23, 3, -29 },
  { 4342, 18, 37, 23, 2, -29 },
  { 4426, 20, 28, 23, 2, -28 },
  { 4496, 16, 28, 23, 4, -28 },
  { 4552, 22, 20, 23, 0, -20 },
  { 4607, 18, 20, 23, 2, -20 },
  { 4652, 18, 20, 23, 2, -20 },
  { 4697, 20, 28, 23, 1, -20 },
  { 4767, 19, 28, 23, 2, -20 },
  { 4834, 18, 20, 23, 4, -20 },
  { 4879, 18, 20, 23, 2, -20 },
  { 4924, 17, 27, 23, 3, -27 },
  { 4982, 18, 20, 23, 3, -20 },
  { 5027, 18, 20, 23, 3, -20 },
  { 5072, 20, 20, 23, 2, -20 },
  { 5122, 23, 20, 23, 0, -20 },
  { 5180, 20, 28, 23, 1, -20 },
  { 5250, 19, 20, 23, 2, -20 },
  { 5298, 18, 34, 23, 4, -29 },
  { 5375, 8, 34, 23, 8, -29 },
  { 5409, 17, 34, 23, 2, -29 },
  { 5482, 20, 9, 23, 2, -16 },
};

const GFXfont IBMPlexMono_Italic38pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic38pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic38pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _IBMPLEXMONO_ITALIC38PT7B_H_
