#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/IBMPlexMono_Italic
// Headers: 67

#include "IBMPlexMono_Italic6pt7b.h"
#include "IBMPlexMono_Italic7pt7b.h"
#include "IBMPlexMono_Italic8pt7b.h"
#include "IBMPlexMono_Italic9pt7b.h"
#include "IBMPlexMono_Italic10pt7b.h"
#include "IBMPlexMono_Italic11pt7b.h"
#include "IBMPlexMono_Italic12pt7b.h"
#include "IBMPlexMono_Italic13pt7b.h"
#include "IBMPlexMono_Italic14pt7b.h"
#include "IBMPlexMono_Italic15pt7b.h"
#include "IBMPlexMono_Italic16pt7b.h"
#include "IBMPlexMono_Italic17pt7b.h"
#include "IBMPlexMono_Italic18pt7b.h"
#include "IBMPlexMono_Italic19pt7b.h"
#include "IBMPlexMono_Italic20pt7b.h"
#include "IBMPlexMono_Italic21pt7b.h"
#include "IBMPlexMono_Italic22pt7b.h"
#include "IBMPlexMono_Italic23pt7b.h"
#include "IBMPlexMono_Italic24pt7b.h"
#include "IBMPlexMono_Italic25pt7b.h"
#include "IBMPlexMono_Italic26pt7b.h"
#include "IBMPlexMono_Italic27pt7b.h"
#include "IBMPlexMono_Italic28pt7b.h"
#include "IBMPlexMono_Italic29pt7b.h"
#include "IBMPlexMono_Italic30pt7b.h"
#include "IBMPlexMono_Italic31pt7b.h"
#include "IBMPlexMono_Italic32pt7b.h"
#include "IBMPlexMono_Italic33pt7b.h"
#include "IBMPlexMono_Italic34pt7b.h"
#include "IBMPlexMono_Italic35pt7b.h"
#include "IBMPlexMono_Italic36pt7b.h"
#include "IBMPlexMono_Italic37pt7b.h"
#include "IBMPlexMono_Italic38pt7b.h"
#include "IBMPlexMono_Italic39pt7b.h"
#include "IBMPlexMono_Italic40pt7b.h"
#include "IBMPlexMono_Italic41pt7b.h"
#include "IBMPlexMono_Italic42pt7b.h"
#include "IBMPlexMono_Italic43pt7b.h"
#include "IBMPlexMono_Italic44pt7b.h"
#include "IBMPlexMono_Italic45pt7b.h"
#include "IBMPlexMono_Italic46pt7b.h"
#include "IBMPlexMono_Italic47pt7b.h"
#include "IBMPlexMono_Italic48pt7b.h"
#include "IBMPlexMono_Italic49pt7b.h"
#include "IBMPlexMono_Italic50pt7b.h"
#include "IBMPlexMono_Italic51pt7b.h"
#include "IBMPlexMono_Italic52pt7b.h"
#include "IBMPlexMono_Italic53pt7b.h"
#include "IBMPlexMono_Italic54pt7b.h"
#include "IBMPlexMono_Italic55pt7b.h"
#include "IBMPlexMono_Italic56pt7b.h"
#include "IBMPlexMono_Italic57pt7b.h"
#include "IBMPlexMono_Italic58pt7b.h"
#include "IBMPlexMono_Italic59pt7b.h"
#include "IBMPlexMono_Italic60pt7b.h"
#include "IBMPlexMono_Italic61pt7b.h"
#include "IBMPlexMono_Italic62pt7b.h"
#include "IBMPlexMono_Italic63pt7b.h"
#include "IBMPlexMono_Italic64pt7b.h"
#include "IBMPlexMono_Italic65pt7b.h"
#include "IBMPlexMono_Italic66pt7b.h"
#include "IBMPlexMono_Italic67pt7b.h"
#include "IBMPlexMono_Italic68pt7b.h"
#include "IBMPlexMono_Italic69pt7b.h"
#include "IBMPlexMono_Italic70pt7b.h"
#include "IBMPlexMono_Italic71pt7b.h"
#include "IBMPlexMono_Italic72pt7b.h"
