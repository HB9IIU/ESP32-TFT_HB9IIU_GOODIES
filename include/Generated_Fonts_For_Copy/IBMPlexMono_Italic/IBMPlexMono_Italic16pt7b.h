#ifndef _IBMPLEXMONO_ITALIC16PT7B_H_
#define _IBMPLEXMONO_ITALIC16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x32, 0x22, 0x24, 0x40, 0x0C, 0xC0, 0x4A, 0x57, 0xA0, 0x04, 0x83,
  0x40, 0x91, 0xE7, 0x1A, 0x04, 0x81, 0x23, 0x9E, 0x24, 0x09, 0x04, 0x80,
  0x02, 0x01, 0x07, 0xC6, 0x92, 0x41, 0x20, 0xD0, 0x3C, 0x09, 0x04, 0xE2,
  0x49, 0x63, 0xE0, 0x80, 0x40, 0x38, 0x6C, 0x91, 0x12, 0x26, 0x83, 0xA0,
  0x00, 0x05, 0xE1, 0x24, 0x68, 0x89, 0x12, 0x1C, 0x00, 0x1E, 0x09, 0x8C,
  0x46, 0x21, 0x23, 0xE3, 0x21, 0x18, 0x84, 0xE7, 0x5C, 0xC0, 0xEA, 0x0C,
  0x43, 0x08, 0x41, 0x04, 0x30, 0x82, 0x04, 0x10, 0x60, 0xC0, 0x30, 0x60,
  0x82, 0x0C, 0x30, 0xC2, 0x08, 0x21, 0x0C, 0x63, 0x00, 0x08, 0x08, 0x89,
  0xFF, 0x18, 0x28, 0x6C, 0xC4, 0x08, 0x08, 0x08, 0xFF, 0x10, 0x10, 0x10,
  0x36, 0x4C, 0xF0, 0xF0, 0x00, 0xC0, 0x60, 0x10, 0x0C, 0x02, 0x01, 0x00,
  0x40, 0x20, 0x08, 0x04, 0x03, 0x00, 0x80, 0x40, 0x30, 0x00, 0x1E, 0x23,
  0x41, 0x41, 0xD9, 0xD9, 0x83, 0x82, 0x82, 0xC4, 0x78, 0x1C, 0x79, 0xB2,
  0x40, 0x81, 0x02, 0x0C, 0x18, 0x23, 0xF8, 0x1F, 0x18, 0xC8, 0x60, 0x30,
  0x10, 0x18, 0x18, 0x10, 0x30, 0x30, 0x3F, 0xC0, 0x1F, 0x18, 0xC0, 0x60,
  0x30, 0x30, 0xE0, 0x0C, 0x02, 0x81, 0x21, 0x0F, 0x00, 0x03, 0x81, 0x81,
  0x41, 0x21, 0x11, 0x99, 0x88, 0x84, 0xFF, 0x81, 0x01, 0x80, 0x3F, 0x20,
  0x60, 0x40, 0x5C, 0x62, 0x02, 0x02, 0x82, 0xC6, 0x78, 0x0E, 0x18, 0x30,
  0x60, 0x5C, 0xE2, 0xC3, 0x83, 0x82, 0xC6, 0x78, 0xFF, 0x82, 0x86, 0x04,
  0x08, 0x18, 0x10, 0x30, 0x20, 0x40, 0xC0, 0x1E, 0x23, 0x41, 0x41, 0x62,
  0x3C, 0x42, 0x83, 0x82, 0x86, 0x7C, 0x1E, 0x63, 0x41, 0xC1, 0xC3, 0x43,
  0x7E, 0x06, 0x0C, 0x18, 0x60, 0x76, 0x00, 0x00, 0xCC, 0x39, 0x80, 0x00,
  0x00, 0xCC, 0x46, 0x00, 0x01, 0x07, 0x1C, 0x70, 0x40, 0xE0, 0x18, 0x0C,
  0x02, 0xFF, 0x00, 0x00, 0xFF, 0x40, 0x60, 0x60, 0x30, 0x21, 0x8E, 0x70,
  0x80, 0x3C, 0x8E, 0x08, 0x30, 0x47, 0x88, 0x10, 0x00, 0xC1, 0x80, 0x1E,
  0x23, 0x41, 0x4D, 0xD3, 0x91, 0x93, 0xB2, 0x92, 0x9E, 0x80, 0xC0, 0x7C,
  0x06, 0x0E, 0x0A, 0x1A, 0x13, 0x33, 0x23, 0x3F, 0x41, 0x41, 0xC1, 0x3E,
  0x63, 0x41, 0x43, 0x42, 0x7C, 0x42, 0xC2, 0x83, 0x86, 0xFC, 0x1E, 0x31,
  0x61, 0x40, 0x40, 0xC0, 0xC0, 0xC0, 0xC3, 0x46, 0x3C, 0x3E, 0x63, 0x61,
  0x41, 0x41, 0x41, 0x43, 0xC3, 0xC2, 0x84, 0xF8, 0x3F, 0x60, 0x60, 0x40,
  0x40, 0x7E, 0x40, 0xC0, 0x80, 0x80, 0xFE, 0x3F, 0xB0, 0x18, 0x08, 0x04,
  0x03, 0xF1, 0x01, 0x80, 0x80, 0x40, 0x20, 0x00, 0x1E, 0x23, 0x41, 0x40,
  0xC0, 0xC0, 0x8F, 0x82, 0xC2, 0xC6, 0x7E, 0x61, 0x61, 0x41, 0x41, 0x43,
  0x7F, 0xC2, 0xC2, 0x82, 0x82, 0x86, 0x7F, 0x08, 0x08, 0x08, 0x08, 0x18,
  0x18, 0x10, 0x10, 0x10, 0xFE, 0x3F, 0x03, 0x02, 0x02, 0x02, 0x02, 0x06,
  0x06, 0x84, 0xCC, 0x78, 0x61, 0xB1, 0x91, 0x89, 0x85, 0x83, 0xC3, 0xA1,
  0x98, 0x84, 0x43, 0x20, 0x80, 0x20, 0x40, 0x81, 0x06, 0x0C, 0x10, 0x20,
  0x40, 0x83, 0xF8, 0x30, 0xCC, 0x63, 0x18, 0xAA, 0x2A, 0x9B, 0x24, 0xD9,
  0x24, 0x41, 0x10, 0x4C, 0x10, 0x71, 0x71, 0x51, 0x51, 0x53, 0x5B, 0xCA,
  0x8A, 0x8A, 0x8E, 0x86, 0x1E, 0x23, 0x41, 0x41, 0xC1, 0xC1, 0x83, 0x82,
  0x82, 0xC4, 0x78, 0x3E, 0x61, 0x41, 0x41, 0x43, 0x7E, 0x40, 0xC0, 0x80,
  0x80, 0x80, 0x1E, 0x23, 0x41, 0x41, 0xC1, 0xC1, 0x83, 0x82, 0x82, 0xC4,
  0x78, 0x10, 0x0B, 0x0C, 0x3E, 0x61, 0x41, 0x41, 0x43, 0x7E, 0x48, 0xCC,
  0x84, 0x84, 0x86, 0x1F, 0x18, 0xC8, 0x04, 0x03, 0x00, 0xF0, 0x04, 0x03,
  0x81, 0x21, 0x8F, 0x80, 0xFF, 0x84, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x60,
  0x20, 0x10, 0x08, 0x0C, 0x00, 0x61, 0x61, 0x41, 0x41, 0x43, 0x43, 0xC2,
  0xC2, 0x82, 0xC4, 0x7C, 0x81, 0x82, 0x82, 0x86, 0xC4, 0xCC, 0x48, 0x58,
  0x50, 0x70, 0x60, 0x40, 0xA0, 0x70, 0x7B, 0x29, 0x94, 0xCA, 0xAD, 0x54,
  0xAA, 0x67, 0x33, 0x80, 0x20, 0xC4, 0x21, 0x10, 0x28, 0x0E, 0x03, 0x01,
  0xC0, 0x48, 0x22, 0x10, 0xCC, 0x18, 0xC0, 0xD0, 0x42, 0x20, 0x98, 0x3C,
  0x06, 0x01, 0x00, 0x40, 0x10, 0x04, 0x03, 0x00, 0x3F, 0xC0, 0x20, 0x10,
  0x08, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x20, 0x10, 0x0F, 0xF0, 0x3C, 0x82,
  0x10, 0x41, 0x04, 0x10, 0x42, 0x08, 0x20, 0x83, 0xC0, 0x88, 0x84, 0x44,
  0x42, 0x22, 0x21, 0x11, 0x3E, 0x04, 0x18, 0x20, 0x40, 0x81, 0x02, 0x0C,
  0x10, 0x20, 0x40, 0x9F, 0x00, 0x0C, 0x1C, 0x12, 0x22, 0x43, 0xC1, 0xFF,
  0xA4, 0x3B, 0x46, 0xC2, 0x82, 0x82, 0x86, 0xCE, 0x77, 0x20, 0x20, 0x60,
  0x60, 0x5E, 0x62, 0x43, 0x43, 0xC3, 0xC2, 0xC6, 0xBC, 0x3C, 0xC5, 0x06,
  0x0C, 0x10, 0x51, 0x3C, 0x01, 0x01, 0x01, 0x01, 0x3F, 0x42, 0xC2, 0x82,
  0x82, 0x86, 0xCE, 0x74, 0x1E, 0x62, 0x43, 0xC6, 0xF8, 0x80, 0x46, 0x7C,
  0x03, 0xC0, 0x80, 0x60, 0x10, 0x3F, 0xC1, 0x00, 0x40, 0x30, 0x0C, 0x02,
  0x00, 0x82, 0x20, 0xC8, 0x1E, 0x03, 0x00, 0x1D, 0x99, 0x98, 0x48, 0x24,
  0x12, 0x19, 0x9C, 0x74, 0x02, 0x23, 0x3F, 0x00, 0x20, 0x40, 0x83, 0x05,
  0xEC, 0x50, 0xA1, 0x43, 0x86, 0x1C, 0x20, 0x0C, 0x08, 0x00, 0x00, 0xF8,
  0x10, 0x10, 0x10, 0x12, 0x33, 0x2C, 0x38, 0x02, 0x0C, 0x00, 0x03, 0xE0,
  0x81, 0x02, 0x04, 0x18, 0x24, 0x4C, 0x8D, 0x0C, 0x00, 0x20, 0x20, 0x20,
  0x60, 0x4E, 0x72, 0x42, 0x46, 0x58, 0xD1, 0x8A, 0x8C, 0xF0, 0x43, 0x08,
  0x20, 0x82, 0x18, 0x45, 0x35, 0x98, 0x79, 0xB3, 0x51, 0x29, 0x14, 0x9A,
  0x4B, 0x25, 0x12, 0x7E, 0xC5, 0x0A, 0x14, 0x38, 0x61, 0xC2, 0x3C, 0x62,
  0xC3, 0xC3, 0x82, 0x82, 0xC6, 0x78, 0x2F, 0x18, 0x88, 0x64, 0x36, 0x1B,
  0x09, 0x8C, 0xBC, 0x40, 0x20, 0x30, 0x00, 0x3F, 0x42, 0xC2, 0x82, 0x82,
  0x86, 0xCE, 0x74, 0x04, 0x04, 0x04, 0xEE, 0x60, 0x81, 0x06, 0x0C, 0x10,
  0x20, 0x3E, 0x63, 0x40, 0x70, 0x0E, 0x02, 0x86, 0x7C, 0x18, 0x20, 0x47,
  0xF1, 0x06, 0x08, 0x10, 0x22, 0x58, 0xC0, 0x63, 0x42, 0x42, 0x42, 0xC2,
  0xC6, 0xCE, 0x74, 0xE2, 0x23, 0x23, 0x63, 0x42, 0x46, 0x4C, 0x70, 0x49,
  0xC9, 0x89, 0x99, 0x91, 0x93, 0x92, 0xEC, 0x1B, 0xB5, 0x63, 0x21, 0x80,
  0x84, 0x4A, 0x77, 0xCC, 0x31, 0x90, 0x88, 0x44, 0x26, 0x13, 0x19, 0x9C,
  0x74, 0x02, 0x23, 0x3F, 0x00, 0x39, 0x47, 0x44, 0x08, 0x10, 0x62, 0xF2,
  0x9E, 0x1E, 0x20, 0x40, 0x80, 0x83, 0x38, 0x08, 0x10, 0x41, 0x82, 0x04,
  0x0F, 0x00, 0x12, 0x22, 0x22, 0x64, 0x44, 0x44, 0xC8, 0x3C, 0x08, 0x10,
  0x41, 0x02, 0x03, 0x98, 0x20, 0x20, 0x40, 0x81, 0x1E, 0x00, 0x71, 0xDB,
  0x8E,
};

const GFXglyph IBMPlexMono_Italic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 4, 11, 10, 3, -11 },
  { 7, 5, 4, 10, 3, -12 },
  { 10, 10, 11, 10, 0, -11 },
  { 24, 9, 15, 10, 0, -13 },
  { 41, 11, 11, 10, 0, -11 },
  { 57, 9, 11, 10, 0, -11 },
  { 70, 2, 4, 10, 5, -12 },
  { 71, 6, 14, 10, 3, -12 },
  { 82, 6, 14, 10, 1, -12 },
  { 93, 8, 8, 10, 1, -9 },
  { 101, 8, 7, 10, 1, -8 },
  { 108, 4, 4, 10, 2, -2 },
  { 110, 4, 1, 10, 3, -5 },
  { 111, 2, 2, 10, 3, -2 },
  { 112, 10, 14, 10, 0, -12 },
  { 130, 8, 11, 10, 1, -11 },
  { 141, 7, 11, 10, 1, -11 },
  { 151, 9, 11, 10, 0, -11 },
  { 164, 9, 11, 10, 0, -11 },
  { 177, 9, 11, 10, 0, -11 },
  { 190, 8, 11, 10, 1, -11 },
  { 201, 8, 11, 10, 1, -11 },
  { 212, 8, 11, 10, 2, -11 },
  { 223, 8, 11, 10, 1, -11 },
  { 234, 8, 11, 10, 1, -11 },
  { 245, 4, 8, 10, 3, -8 },
  { 249, 5, 10, 10, 2, -8 },
  { 256, 8, 9, 10, 1, -9 },
  { 265, 8, 4, 10, 1, -7 },
  { 269, 7, 9, 10, 1, -9 },
  { 277, 7, 11, 10, 2, -11 },
  { 287, 8, 13, 10, 1, -11 },
  { 300, 8, 11, 10, 0, -11 },
  { 311, 8, 11, 10, 1, -11 },
  { 322, 8, 11, 10, 1, -11 },
  { 333, 8, 11, 10, 1, -11 },
  { 344, 8, 11, 10, 1, -11 },
  { 355, 9, 11, 10, 1, -11 },
  { 368, 8, 11, 10, 1, -11 },
  { 379, 8, 11, 10, 1, -11 },
  { 390, 8, 11, 10, 1, -11 },
  { 401, 8, 11, 10, 1, -11 },
  { 412, 9, 11, 10, 1, -11 },
  { 425, 7, 11, 10, 1, -11 },
  { 435, 10, 11, 10, 0, -11 },
  { 449, 8, 11, 10, 1, -11 },
  { 460, 8, 11, 10, 1, -11 },
  { 471, 8, 11, 10, 1, -11 },
  { 482, 8, 14, 10, 1, -11 },
  { 496, 8, 11, 10, 1, -11 },
  { 507, 9, 11, 10, 0, -11 },
  { 520, 9, 11, 10, 1, -11 },
  { 533, 8, 11, 10, 1, -11 },
  { 544, 8, 11, 10, 2, -11 },
  { 555, 9, 11, 10, 1, -11 },
  { 568, 10, 11, 10, 0, -11 },
  { 582, 10, 11, 10, 1, -11 },
  { 596, 10, 11, 10, 0, -11 },
  { 610, 6, 14, 10, 3, -12 },
  { 621, 4, 14, 10, 3, -12 },
  { 628, 7, 14, 10, 0, -12 },
  { 641, 8, 6, 10, 1, -11 },
  { 647, 8, 1, 10, 0, 2 },
  { 648, 2, 3, 10, 4, -12 },
  { 649, 8, 8, 10, 1, -8 },
  { 657, 8, 12, 10, 1, -12 },
  { 669, 7, 8, 10, 1, -8 },
  { 676, 8, 12, 10, 1, -12 },
  { 688, 8, 8, 10, 1, -8 },
  { 696, 10, 15, 10, 0, -12 },
  { 715, 9, 11, 10, 0, -8 },
  { 728, 7, 12, 10, 1, -12 },
  { 739, 8, 12, 10, 1, -12 },
  { 751, 7, 15, 10, 1, -12 },
  { 765, 8, 12, 10, 1, -12 },
  { 777, 6, 12, 10, 2, -12 },
  { 786, 9, 8, 10, 0, -8 },
  { 795, 7, 8, 10, 1, -8 },
  { 802, 8, 8, 10, 1, -8 },
  { 810, 9, 11, 10, 0, -8 },
  { 823, 8, 11, 10, 1, -8 },
  { 834, 7, 8, 10, 2, -8 },
  { 841, 8, 8, 10, 1, -8 },
  { 849, 7, 11, 10, 1, -11 },
  { 859, 8, 8, 10, 1, -8 },
  { 867, 8, 8, 10, 1, -8 },
  { 875, 8, 8, 10, 1, -8 },
  { 883, 9, 8, 10, 0, -8 },
  { 892, 9, 11, 10, 0, -8 },
  { 905, 8, 8, 10, 1, -8 },
  { 913, 7, 14, 10, 2, -12 },
  { 926, 4, 14, 10, 3, -12 },
  { 933, 7, 14, 10, 1, -12 },
  { 946, 8, 3, 10, 1, -7 },
};

const GFXfont IBMPlexMono_Italic16pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic16pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic16pt7bGlyphs,
  0x20, 0x7E, 21
};

#endif // _IBMPLEXMONO_ITALIC16PT7B_H_
