#ifndef _IBMPLEXMONO_ITALIC61PT7B_H_
#define _IBMPLEXMONO_ITALIC61PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic61pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01,
  0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x3F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xF8, 0x3F, 0xC0, 0xF8,
  0x00, 0x1E, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x78, 0xF8, 0x1E, 0x3C, 0x07,
  0x8F, 0x03, 0xE3, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x1F, 0x03, 0xC7,
  0x80, 0xF1, 0xE0, 0x7C, 0x78, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xE3, 0xE0,
  0x78, 0xF0, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x78,
  0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x1F,
  0x01, 0xE0, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x00, 0x7C, 0x07, 0x80, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFE, 0x03,
  0xFF, 0xE1, 0xFF, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x00,
  0x78, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x00, 0xF8,
  0x1F, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xE1, 0xFF, 0xF0, 0x1F,
  0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0x07,
  0xC0, 0x78, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x00, 0x1F, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x0F, 0x01, 0xF0,
  0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFC, 0x7B, 0xFE, 0x00,
  0xFE, 0x0F, 0x0F, 0xE0, 0x1F, 0x81, 0xC0, 0xFE, 0x07, 0xE0, 0x38, 0x0F,
  0x80, 0xF8, 0x0F, 0x00, 0xC0, 0x1F, 0x01, 0xE0, 0x00, 0x07, 0xE0, 0x3C,
  0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x1F, 0x00, 0xE0, 0x00, 0x03, 0xE0,
  0x1C, 0x00, 0x00, 0x7E, 0x03, 0x80, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x00,
  0xFC, 0x1E, 0x00, 0x00, 0x1F, 0xC3, 0xC0, 0x00, 0x01, 0xFE, 0x70, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x39, 0xFF, 0x00, 0x00, 0x07, 0x07, 0xE0, 0x00, 0x01, 0xE0, 0x7E, 0x00,
  0x00, 0x3C, 0x07, 0xC0, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x00, 0xF0, 0x1F,
  0x80, 0x00, 0x1C, 0x03, 0xF0, 0x00, 0x03, 0x80, 0x7E, 0x00, 0x00, 0xF0,
  0x0F, 0x80, 0x00, 0x1E, 0x01, 0xF0, 0x18, 0x03, 0xC0, 0x3E, 0x07, 0x00,
  0x78, 0x0F, 0xC1, 0xF0, 0x0F, 0x01, 0xF0, 0x7F, 0x01, 0xC0, 0x7E, 0x03,
  0xF8, 0x38, 0x3F, 0x80, 0x7F, 0xCF, 0x1F, 0xE0, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x80, 0x1F, 0xFC,
  0x00, 0x07, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0x80, 0x1F, 0xFF, 0x80, 0x07,
  0xC0, 0x1F, 0x83, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x80, 0x78, 0x03, 0xE0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x07, 0xC0, 0x1E,
  0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x01, 0xE0, 0x07, 0x81, 0xF0,
  0x00, 0xF0, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x01, 0xE0, 0xF0, 0x00, 0x3C,
  0x01, 0xF0, 0xF8, 0x00, 0x1E, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x00, 0xF8,
  0x78, 0x00, 0x07, 0xC1, 0xF8, 0x7C, 0x00, 0x01, 0xFF, 0xF8, 0x7C, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x07, 0xC7, 0xFF, 0xF0, 0x00, 0x07, 0x83, 0xE0, 0xF8, 0x00, 0x07,
  0xC3, 0xE0, 0x3C, 0x00, 0x03, 0xC3, 0xE0, 0x0F, 0x00, 0x03, 0xC1, 0xE0,
  0x07, 0x80, 0x03, 0xE0, 0xF0, 0x03, 0xC0, 0x01, 0xE0, 0xF8, 0x01, 0xE0,
  0x01, 0xE0, 0x7C, 0x01, 0xF0, 0x01, 0xF0, 0x3C, 0x00, 0xF8, 0x01, 0xF0,
  0x1E, 0x00, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x1F, 0x00,
  0x78, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x00, 0x3F, 0xFF, 0x80, 0x3C, 0x00,
  0x0F, 0xFF, 0x80, 0x3C, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0x83, 0xF8,
  0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x1F, 0x80, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0xFF, 0x9F, 0xC0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xE7, 0xFC, 0x00, 0x01, 0xF8, 0x7C,
  0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x7C,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0xCF, 0x80, 0x03, 0xE0, 0x0F, 0xF8,
  0x00, 0x3F, 0x01, 0xEF, 0x80, 0x06, 0xF0, 0x3E, 0xFC, 0x00, 0x6F, 0x83,
  0xC7, 0xC0, 0x0E, 0xF8, 0x7C, 0x7E, 0x01, 0xC7, 0xC7, 0x83, 0xF0, 0x3C,
  0x7C, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xE0, 0x0F,
  0xFE, 0x01, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0x80, 0x1E, 0x3C, 0xF9, 0xF3,
  0xE7, 0xCF, 0x1E, 0x7C, 0xF9, 0xF3, 0xE7, 0x8F, 0x3E, 0x7C, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x40, 0x07, 0xC0, 0x04, 0xF0, 0x0F, 0x80, 0x7B, 0xFC,
  0x1F, 0x07, 0xF7, 0xFF, 0x3C, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xCF,
  0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x01, 0xF8, 0x3E,
  0x00, 0x07, 0xE0, 0x3E, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x1F,
  0x80, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E,
  0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFE, 0x3F, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFC, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0x7F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0xF0, 0xF8,
  0x00, 0x01, 0xF1, 0xF0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0x0F, 0x9F, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x3E, 0xF8, 0x00,
  0x00, 0x7D, 0xF0, 0x1F, 0x00, 0xFB, 0xE0, 0x7F, 0x03, 0xF7, 0xC0, 0xFE,
  0x07, 0xDF, 0x83, 0xFC, 0x0F, 0xBF, 0x07, 0xF8, 0x1F, 0x7C, 0x0F, 0xE0,
  0x3E, 0xF8, 0x0F, 0x80, 0x7D, 0xF0, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x3E,
  0x3E, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x03, 0xE0, 0x0F, 0x80, 0x0F, 0xC0, 0x1F,
  0xC0, 0x7F, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFB,
  0xE0, 0x00, 0x3F, 0x9F, 0x00, 0x03, 0xF8, 0xF8, 0x00, 0x3F, 0x87, 0xC0,
  0x03, 0xF8, 0x3E, 0x00, 0x3F, 0x83, 0xE0, 0x07, 0xF0, 0x1F, 0x00, 0x3F,
  0x00, 0xF8, 0x00, 0xF0, 0x07, 0xC0, 0x03, 0x00, 0x3E, 0x00, 0x10, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0xFF, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x7E, 0x03,
  0xE0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3F, 0x01,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x07, 0xE0, 0x00, 0xFC, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x60, 0x00, 0x1F,
  0x00, 0x20, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x20,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x02, 0x00, 0x00, 0x3E, 0x03,
  0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xF0, 0x00, 0x1F, 0x81,
  0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x1F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7D, 0xF0, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00,
  0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x0F, 0x80, 0x3E, 0x00,
  0x0F, 0xC0, 0x1F, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x01, 0xE0, 0x07, 0xE0, 0x00, 0xF0,
  0x03, 0xE0, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x83, 0xFC, 0x00, 0x07,
  0x8F, 0xFF, 0x00, 0x0F, 0x9F, 0xFF, 0xC0, 0x0F, 0xBF, 0xFF, 0xE0, 0x0F,
  0x70, 0x0F, 0xF0, 0x0F, 0xC0, 0x07, 0xF0, 0x0F, 0x80, 0x03, 0xF8, 0x11,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x10, 0x00, 0x01, 0xF0, 0x38, 0x00, 0x03, 0xF0, 0x7C,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0x3F,
  0xC0, 0x7F, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x1F, 0xC0,
  0x07, 0xC7, 0xFF, 0xC0, 0x7E, 0x7F, 0xFF, 0x03, 0xE7, 0xFF, 0xFC, 0x3F,
  0x78, 0x0F, 0xF1, 0xF7, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x7E, 0xFE, 0x00,
  0x01, 0xF7, 0xF0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xDF,
  0x00, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0xBE, 0x00,
  0x00, 0xF9, 0xF0, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0x1F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0xE3, 0xC0, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x1F, 0x1F, 0x00,
  0x00, 0x7E, 0x3E, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x03, 0xF0, 0xF0, 0x00,
  0x0F, 0xC1, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x01, 0xF8, 0x07,
  0xE0, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x1F, 0x81,
  0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xF0,
  0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x0F,
  0xE0, 0x07, 0xC0, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x7E, 0x07, 0xC0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x01, 0xF1, 0xF0, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x00, 0xFC, 0x7C, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3F, 0x0F, 0x80,
  0x00, 0x1F, 0x87, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F, 0xC0, 0xFC,
  0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x7F, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0x80, 0x7F, 0x80, 0xFE, 0x07, 0xE0, 0x01, 0xF8, 0x7E, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07,
  0xDF, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFE, 0xF8, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x0E, 0xF8, 0xFF, 0x01, 0xEF, 0x83,
  0xFF, 0xFE, 0x7C, 0x0F, 0xFF, 0xE7, 0xC0, 0x3F, 0xFE, 0x3E, 0x00, 0x7F,
  0x83, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x3F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xF8, 0x3F, 0xC0,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x03, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F,
  0x83, 0xFC, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0,
  0x01, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0x02, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xC0, 0x7F, 0x0F, 0xC0, 0x07, 0xE7,
  0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xF3, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x3F,
  0x00, 0x1F, 0x80, 0x7C, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x03, 0xC0,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x7C, 0x00,
  0x00, 0xF0, 0xF0, 0x03, 0xE1, 0xE1, 0xE0, 0x1F, 0xE3, 0xC7, 0xC0, 0x7F,
  0xE7, 0x8F, 0x01, 0xFF, 0xEF, 0x1E, 0x07, 0xE0, 0xFE, 0x3C, 0x0F, 0x80,
  0xFC, 0xF8, 0x3E, 0x00, 0xF1, 0xF0, 0x7C, 0x01, 0xE3, 0xE1, 0xF0, 0x03,
  0xC7, 0x83, 0xE0, 0x07, 0x8F, 0x07, 0xC0, 0x1F, 0x3E, 0x0F, 0x00, 0x3E,
  0x7C, 0x3E, 0x00, 0x78, 0xF8, 0x7C, 0x00, 0xF1, 0xF0, 0xF8, 0x01, 0xE3,
  0xC1, 0xF0, 0x07, 0xC7, 0x83, 0xE0, 0x0F, 0x8F, 0x07, 0xC0, 0x1F, 0x1E,
  0x0F, 0x80, 0x7C, 0x3C, 0x1F, 0x01, 0xF8, 0xF8, 0x1E, 0x06, 0xF1, 0xF0,
  0x3F, 0x1D, 0xE3, 0xE0, 0x7F, 0xF7, 0xC3, 0xC0, 0x7F, 0xCF, 0x87, 0x80,
  0x7F, 0x1E, 0x0F, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x00,
  0xF9, 0xE0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00,
  0x3C, 0x3E, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x0F, 0x80, 0xF0, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x1F, 0x00,
  0x03, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0xF0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x00,
  0xF8, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x0F, 0x83, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xE1, 0xF8, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x7E, 0x7C, 0x00,
  0x00, 0x1F, 0x3E, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x03, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3E, 0x00, 0x1F, 0xC0, 0x7C,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x03, 0xC0,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x0F, 0x81, 0xE0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x1F, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x03, 0xF0,
  0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF8, 0xF8,
  0x00, 0x03, 0xF1, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0xFC, 0x1F, 0x00, 0x07, 0xF0, 0x7F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0x7F, 0x80, 0x3F, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x80, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x01, 0x81, 0xF0, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F,
  0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x7F,
  0x80, 0x3E, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8,
  0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x87, 0xC0,
  0x00, 0x3F, 0x1F, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0xC3, 0xE0, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x07, 0xF0, 0x1F, 0x00, 0x3F, 0xC0,
  0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0x3F,
  0x80, 0x3F, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x80,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0xFE, 0x7E, 0x00,
  0xFF, 0xFC, 0xFC, 0x01, 0xFF, 0xF1, 0xF0, 0x03, 0xFF, 0xE3, 0xE0, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x1F, 0x1F, 0x00, 0x00,
  0x3E, 0x3E, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x3F,
  0x07, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0x78, 0x0F, 0xC0, 0x0F, 0xF0,
  0x1F, 0xE0, 0x7B, 0xE0, 0x1F, 0xFF, 0xE7, 0xC0, 0x1F, 0xFF, 0x8F, 0x80,
  0x1F, 0xFE, 0x1E, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x01, 0xF0,
  0x1F, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x03, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3E, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x07,
  0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00,
  0x7C, 0x07, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x03, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x40, 0x00, 0x7C, 0x0F, 0x80, 0x01,
  0xF0, 0x3E, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x3E, 0x03, 0xF0, 0x01, 0xF8,
  0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0xFE, 0x03, 0xE0, 0x00, 0x1F,
  0xC0, 0x3E, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x0F, 0xC0,
  0x00, 0x7C, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x7C, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x0F,
  0x83, 0xF0, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0x0F, 0x8F, 0xC0, 0x00,
  0x00, 0xF9, 0xFE, 0x00, 0x00, 0x1F, 0x3F, 0xE0, 0x00, 0x01, 0xF7, 0xFF,
  0x00, 0x00, 0x1F, 0xFD, 0xF0, 0x00, 0x01, 0xFF, 0x9F, 0x80, 0x00, 0x1F,
  0xF0, 0xF8, 0x00, 0x01, 0xFE, 0x0F, 0x80, 0x00, 0x3F, 0xC0, 0x7C, 0x00,
  0x03, 0xF8, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x81, 0xFE,
  0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x80,
  0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x07, 0xFE, 0x07, 0xDE, 0x00, 0xF7,
  0xC0, 0xFB, 0xC0, 0x3E, 0xF0, 0x1E, 0x78, 0x07, 0x9E, 0x03, 0xCF, 0x81,
  0xE7, 0xC0, 0x78, 0xF0, 0x3C, 0xF8, 0x1F, 0x1E, 0x0F, 0x1F, 0x03, 0xE3,
  0xC3, 0xE3, 0xE0, 0x7C, 0x78, 0x78, 0x78, 0x0F, 0x87, 0x9F, 0x0F, 0x01,
  0xE0, 0xF3, 0xC3, 0xE0, 0x3C, 0x1E, 0xF0, 0x7C, 0x0F, 0x83, 0xFE, 0x0F,
  0x81, 0xF0, 0x3F, 0x81, 0xF0, 0x3E, 0x07, 0xF0, 0x3C, 0x07, 0xC0, 0xFC,
  0x07, 0x80, 0xF0, 0x1F, 0x81, 0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x07, 0xC0,
  0x38, 0x07, 0xC0, 0xF8, 0x07, 0x00, 0xF8, 0x1F, 0x00, 0xC0, 0x1E, 0x03,
  0xE0, 0x18, 0x03, 0xC0, 0x78, 0x02, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0x0F, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x7C, 0x07, 0x80,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x3E,
  0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xC0, 0x7F,
  0x80, 0x01, 0xF0, 0x1F, 0xE0, 0x00, 0x7C, 0x07, 0xFC, 0x00, 0x1F, 0x01,
  0xFF, 0x00, 0x07, 0x80, 0x7F, 0xC0, 0x01, 0xE0, 0x3E, 0xF0, 0x00, 0xF8,
  0x0F, 0xBC, 0x00, 0x3E, 0x03, 0xEF, 0x80, 0x0F, 0x80, 0xFB, 0xE0, 0x03,
  0xE0, 0x3C, 0x78, 0x00, 0xF0, 0x0F, 0x1E, 0x00, 0x3C, 0x07, 0xC7, 0xC0,
  0x1F, 0x01, 0xF1, 0xF0, 0x07, 0xC0, 0x7C, 0x7C, 0x01, 0xF0, 0x1F, 0x0F,
  0x00, 0x7C, 0x07, 0x83, 0xC0, 0x1E, 0x01, 0xE0, 0xF8, 0x07, 0x80, 0xF8,
  0x3E, 0x03, 0xE0, 0x3E, 0x07, 0x80, 0xF8, 0x0F, 0x81, 0xE0, 0x3E, 0x03,
  0xE0, 0x78, 0x0F, 0x80, 0xF0, 0x1F, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0xF0,
  0x1F, 0x00, 0xF0, 0x7C, 0x07, 0xC0, 0x3C, 0x1F, 0x01, 0xF0, 0x0F, 0x87,
  0xC0, 0x7C, 0x03, 0xE1, 0xF0, 0x1E, 0x00, 0x78, 0x78, 0x07, 0x80, 0x1E,
  0x1E, 0x03, 0xE0, 0x07, 0x8F, 0x80, 0xF8, 0x01, 0xF3, 0xE0, 0x3E, 0x00,
  0x7C, 0xF8, 0x0F, 0x80, 0x0F, 0x3E, 0x03, 0xC0, 0x03, 0xCF, 0x00, 0xF0,
  0x00, 0xFB, 0xC0, 0x7C, 0x00, 0x3F, 0xF0, 0x1F, 0x00, 0x07, 0xFC, 0x07,
  0xC0, 0x01, 0xFF, 0x01, 0xF0, 0x00, 0x7F, 0xC0, 0x78, 0x00, 0x1F, 0xE0,
  0x1E, 0x00, 0x07, 0xF8, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3E,
  0x03, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x1F, 0x7E,
  0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x01, 0xFB, 0xE0,
  0x00, 0x03, 0xF7, 0xC0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x0F, 0xBF, 0x00,
  0x00, 0x1F, 0x7E, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0xFD, 0xF0, 0x00,
  0x01, 0xFB, 0xE0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0x0F, 0x9F, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00,
  0xF8, 0xF8, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x03, 0xF0,
  0x0F, 0x80, 0x0F, 0xC0, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3E, 0x00, 0x0F, 0xE0, 0x1F, 0x00, 0x01,
  0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x1F, 0x83, 0xE0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x07, 0xE0, 0xF8, 0x00,
  0x03, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x7F, 0x80, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x3E, 0x03, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x00,
  0xF8, 0x3E, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x1F,
  0x7E, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x01, 0xFB,
  0xE0, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x0F, 0xBF,
  0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0xFD, 0xF0,
  0x00, 0x01, 0xFB, 0xE0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0x0F, 0x9F, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x7C, 0x7C, 0x00,
  0x00, 0xF8, 0xF8, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x03,
  0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x0E, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3E, 0x00, 0x0F,
  0xE0, 0x1F, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x0F, 0xC1, 0xF0, 0x00,
  0x07, 0xE0, 0xF8, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3F, 0x01, 0xF0,
  0x00, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x03,
  0xE0, 0x07, 0xC0, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0xF8, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x1F, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0xF8,
  0x03, 0xE0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x00,
  0x7E, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F,
  0x07, 0xC0, 0x00, 0x06, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0x03, 0x00, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x03, 0xF0, 0xF8,
  0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0x7C, 0x1F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00,
  0x00, 0xF8, 0x3F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00,
  0x01, 0xF0, 0x7E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0x7C, 0x00,
  0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00,
  0x00, 0x7E, 0xF8, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0xFC, 0xF8, 0x00,
  0x00, 0xF8, 0x78, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x01, 0xF0, 0x78, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0xC0, 0x3C, 0x00,
  0x0F, 0x80, 0x3C, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x07,
  0xC0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x0F, 0x9F,
  0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF1, 0xF0,
  0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x00, 0x3E,
  0x1F, 0x00, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x07, 0xC1, 0xE0,
  0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x1F, 0x80, 0x78,
  0x3E, 0x03, 0xF8, 0x0F, 0x83, 0xE0, 0x3F, 0x80, 0xF8, 0x3E, 0x03, 0xF8,
  0x0F, 0x03, 0xE0, 0x7F, 0x80, 0xF0, 0x3C, 0x07, 0xF8, 0x1F, 0x03, 0xC0,
  0xF7, 0x81, 0xF0, 0x3C, 0x0F, 0x78, 0x1E, 0x03, 0xC0, 0xF7, 0x81, 0xE0,
  0x3C, 0x1E, 0x78, 0x3E, 0x03, 0xC1, 0xE7, 0x83, 0xE0, 0x3C, 0x1E, 0x78,
  0x3C, 0x07, 0xC3, 0xC7, 0x83, 0xC0, 0x7C, 0x3C, 0x78, 0x3C, 0x07, 0xC3,
  0xC7, 0x87, 0xC0, 0x7C, 0x78, 0x78, 0x78, 0x07, 0x87, 0x83, 0x87, 0x80,
  0x78, 0xF0, 0x38, 0x78, 0x07, 0x8F, 0x03, 0x8F, 0x80, 0x78, 0xF0, 0x3C,
  0xF0, 0x07, 0x9E, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x3C, 0xF0, 0x07, 0x9E,
  0x03, 0xDF, 0x00, 0x7B, 0xC0, 0x3D, 0xE0, 0x0F, 0xBC, 0x03, 0xDE, 0x00,
  0xFF, 0xC0, 0x3D, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x07,
  0xC0, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x00,
  0x01, 0xF3, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x00,
  0x0F, 0xC7, 0xC0, 0x00, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00,
  0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x07, 0xEF,
  0x80, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x0F,
  0x83, 0xF0, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0xF8, 0x07, 0xC0,
  0x00, 0x0F, 0x81, 0xF8, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0xFC, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0,
  0x1E, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x78, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xF0, 0x1F, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x03, 0xC7, 0xE0, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x0F, 0xB8, 0x00, 0x00, 0x1E,
  0x10, 0x00, 0x00, 0x20, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0x08, 0x78, 0xF8, 0x78, 0x7C,
  0x3C, 0x3C, 0x1E, 0x1E, 0x1E, 0x0F, 0x0C, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFF, 0xE1, 0xF0, 0x0F, 0xFF, 0xC7, 0xC0, 0xFF, 0xFF, 0x9E, 0x03, 0xF8,
  0x0E, 0xF8, 0x1F, 0x80, 0x1F, 0xE0, 0xFC, 0x00, 0x3F, 0x87, 0xE0, 0x00,
  0x7E, 0x1F, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x03, 0xE1, 0xF0,
  0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0xF8, 0xF8, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x1E, 0x00, 0x03,
  0xF0, 0x7C, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x7F, 0x07, 0xC0, 0x03, 0x7C,
  0x1F, 0x80, 0x19, 0xE0, 0x3F, 0x81, 0xE7, 0xFC, 0x7F, 0xFF, 0x1F, 0xE1,
  0xFF, 0xF8, 0x7F, 0x81, 0xFF, 0xC0, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x01, 0xFC, 0x00, 0x7C, 0x1F, 0xFC, 0x01, 0xF1, 0xFF, 0xF8, 0x07,
  0xCF, 0xFF, 0xF0, 0x1F, 0x7C, 0x0F, 0xE0, 0x79, 0xC0, 0x1F, 0x83, 0xEC,
  0x00, 0x3E, 0x0F, 0xE0, 0x00, 0x7C, 0x3F, 0x80, 0x01, 0xF0, 0xFC, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x01,
  0xF1, 0xF0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7C,
  0x7C, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3F, 0x3E,
  0x00, 0x00, 0xF8, 0xF8, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F, 0x8F, 0x80,
  0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0x3E, 0x1F, 0xC0, 0x01, 0xF0, 0x7F, 0x80, 0x1F, 0xC1, 0xF7, 0x81, 0xFE,
  0x07, 0x9F, 0xFF, 0xF0, 0x3E, 0x3F, 0xFF, 0x80, 0xF8, 0x7F, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0x01, 0xFC, 0x1F, 0x80, 0x0F,
  0x87, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x01, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x04, 0x3C, 0x00, 0x00, 0xE7, 0xC0, 0x00,
  0x3E, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0xFC, 0x3F,
  0x00, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x7F, 0x01, 0xE0, 0x01, 0xFF, 0xE1, 0xF0, 0x01, 0xFF,
  0xF8, 0xF8, 0x01, 0xFF, 0xFE, 0x7C, 0x01, 0xFC, 0x07, 0xBE, 0x01, 0xF8,
  0x00, 0xDF, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x7C, 0x0F,
  0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xFC,
  0x07, 0x80, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x7F,
  0x00, 0xFC, 0x00, 0x7F, 0x80, 0x7E, 0x00, 0x77, 0xC0, 0x1F, 0xC0, 0xF3,
  0xE0, 0x07, 0xFF, 0xF1, 0xF0, 0x03, 0xFF, 0xF0, 0xF0, 0x00, 0x7F, 0xF0,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x03, 0xFC, 0x07, 0xE0,
  0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x1F, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3F,
  0x7C, 0x00, 0x07, 0xE7, 0xC0, 0x03, 0xFE, 0x7C, 0x07, 0xFF, 0xC7, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x87, 0xC0, 0x00, 0x1C, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x7C, 0x3E, 0x00, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x1F, 0xC0, 0x7F, 0x00,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x80, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x10, 0x01, 0xF0, 0x00, 0x00, 0x78,
  0x01, 0xF0, 0x00, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x83, 0xE0, 0x00, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x00, 0x07, 0xE3,
  0xE0, 0x00, 0x00, 0x03, 0xF3, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x3C,
  0x01, 0xFF, 0xF8, 0xF8, 0x07, 0xFF, 0xF9, 0xF0, 0x1F, 0xC0, 0x7B, 0xE0,
  0x7E, 0x00, 0x37, 0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x03, 0xE3, 0xF0, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x1F, 0x07, 0x80, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0xFC, 0x1F, 0x00, 0x03,
  0xF8, 0x3E, 0x00, 0x0D, 0xE0, 0x7E, 0x00, 0x3B, 0xC0, 0x7E, 0x00, 0xEF,
  0x80, 0xFE, 0x07, 0x9F, 0x00, 0xFF, 0xFF, 0x3E, 0x01, 0xFF, 0xFC, 0x7C,
  0x00, 0xFF, 0xE0, 0xF0, 0x00, 0x7F, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x0C, 0x00, 0x0F, 0xC0, 0x3C,
  0x00, 0x3F, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x0F, 0xC0,
  0x07, 0xC3, 0xFF, 0x00, 0x78, 0xFF, 0xF8, 0x0F, 0x9F, 0xFF, 0xC0, 0xF9,
  0xE0, 0xFE, 0x0F, 0xB8, 0x07, 0xE0, 0xFF, 0x00, 0x3E, 0x0F, 0x60, 0x03,
  0xF0, 0xFC, 0x00, 0x1F, 0x1F, 0x80, 0x01, 0xF1, 0xF8, 0x00, 0x1F, 0x1F,
  0x00, 0x01, 0xF1, 0xF0, 0x00, 0x1E, 0x1F, 0x00, 0x03, 0xE1, 0xE0, 0x00,
  0x3E, 0x3E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x7C, 0x7C, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x78,
  0x78, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80,
  0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0xC0, 0x0F, 0x80, 0x1E,
  0x00, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x00, 0xF8, 0x1F, 0x80, 0x0F,
  0x03, 0xF0, 0x01, 0xF0, 0x7E, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF1, 0xF8,
  0x00, 0x1F, 0x3F, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x02, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x20, 0x01, 0xF0, 0x07, 0x00, 0x1F, 0x00, 0xF8,
  0x01, 0xE0, 0x0F, 0xC0, 0x1E, 0x00, 0x7E, 0x03, 0xE0, 0x03, 0xF0, 0x3E,
  0x00, 0x1F, 0x83, 0xE0, 0x00, 0xFC, 0x3E, 0x00, 0x07, 0xE3, 0xC0, 0x00,
  0x3F, 0x3C, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x1F, 0xC0, 0x01,
  0xF0, 0xFF, 0xE0, 0x03, 0xC3, 0xFF, 0xE0, 0x0F, 0x8F, 0xFF, 0xE0, 0x1F,
  0x3C, 0x1F, 0xC0, 0x3E, 0xE0, 0x0F, 0x80, 0x7F, 0x80, 0x1F, 0x80, 0xFE,
  0x00, 0x1F, 0x01, 0xF8, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x78, 0x0F, 0xC0,
  0x01, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x80, 0x7C, 0x00,
  0x1F, 0x00, 0xF0, 0x00, 0xFC, 0x03, 0xE0, 0x03, 0xF0, 0x07, 0xC0, 0x1F,
  0x80, 0x0F, 0x81, 0xFC, 0x00, 0x1F, 0x3F, 0xE0, 0x00, 0x3C, 0x3E, 0x00,
  0x00, 0x78, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x43, 0xE0, 0xF8, 0x00,
  0xC7, 0xC0, 0xF8, 0x03, 0xCF, 0x81, 0xF0, 0x0F, 0xDE, 0x01, 0xF0, 0x3E,
  0x7C, 0x03, 0xE0, 0xF8, 0xF8, 0x03, 0xE3, 0xE1, 0xF0, 0x07, 0xCF, 0x83,
  0xE0, 0x07, 0xFE, 0x07, 0xC0, 0x0F, 0xF8, 0x0F, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x04, 0x07, 0xC0, 0x07, 0x03,
  0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xC0, 0xF0, 0x0F, 0xC0, 0xF8, 0x0F, 0xC0,
  0x7C, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x1F, 0x0F, 0xC0, 0x0F, 0x8F, 0xC0,
  0x07, 0x9F, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x01, 0xE3, 0xF8, 0x3F,
  0xC0, 0x79, 0xFF, 0x1F, 0xF8, 0x1E, 0xFF, 0xCF, 0xFE, 0x0F, 0xB1, 0xF7,
  0x8F, 0xC3, 0xF8, 0x3D, 0x81, 0xF0, 0xFC, 0x0F, 0xC0, 0x7C, 0x3E, 0x03,
  0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x07, 0x83, 0xC0, 0x3E, 0x01, 0xE1, 0xF0,
  0x0F, 0x80, 0x78, 0x7C, 0x03, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0x0F, 0x87,
  0x80, 0x3C, 0x03, 0xE1, 0xE0, 0x1F, 0x00, 0xF8, 0x78, 0x07, 0xC0, 0x3C,
  0x3E, 0x01, 0xF0, 0x0F, 0x0F, 0x80, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x01,
  0xF0, 0xF0, 0x07, 0x80, 0x7C, 0x3C, 0x03, 0xE0, 0x1F, 0x1F, 0x00, 0xF8,
  0x07, 0x87, 0xC0, 0x3C, 0x01, 0xE1, 0xF0, 0x0F, 0x00, 0x78, 0x78, 0x03,
  0xC0, 0x3E, 0x1E, 0x00, 0xF0, 0x0F, 0x87, 0x80, 0x7C, 0x03, 0xC3, 0xE0,
  0x1F, 0x00, 0xF0, 0xF8, 0x07, 0x80, 0x3C, 0x3E, 0x01, 0xE0, 0x0F, 0x0F,
  0x00, 0x78, 0x07, 0xC3, 0xC0, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x7C, 0x3F, 0xF0, 0x07, 0x8F, 0xFF, 0x80, 0xF9, 0xFF, 0xFC, 0x0F, 0x9E,
  0x0F, 0xE0, 0xFB, 0x80, 0x7E, 0x0F, 0xF0, 0x03, 0xE0, 0xF6, 0x00, 0x3F,
  0x0F, 0xC0, 0x01, 0xF1, 0xF8, 0x00, 0x1F, 0x1F, 0x80, 0x01, 0xF1, 0xF0,
  0x00, 0x1F, 0x1F, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3E, 0x3E,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x7C, 0x3C, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0x7C, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0x87,
  0x80, 0x00, 0xF8, 0x78, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8, 0xF8, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0x81, 0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x3E, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07,
  0x8F, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0xBE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F, 0x9F,
  0x00, 0x00, 0xFC, 0x78, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7E, 0x1F, 0x00,
  0x07, 0xE0, 0x7C, 0x00, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x7F, 0xF0, 0x01, 0xF1, 0xFF, 0xF8,
  0x01, 0xF3, 0xFF, 0xFC, 0x01, 0xF7, 0xC0, 0xFE, 0x01, 0xE7, 0x00, 0x7E,
  0x01, 0xEC, 0x00, 0x3E, 0x03, 0xF8, 0x00, 0x1F, 0x03, 0xF8, 0x00, 0x1F,
  0x03, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F,
  0x03, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C,
  0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xF8, 0x1F, 0xC0, 0x01, 0xF0,
  0x1F, 0xE0, 0x03, 0xF0, 0x1F, 0x78, 0x1F, 0xE0, 0x1E, 0x7F, 0xFF, 0xC0,
  0x3E, 0x3F, 0xFF, 0x80, 0x3E, 0x1F, 0xFE, 0x00, 0x3E, 0x03, 0xF8, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFF, 0xE1, 0xF0, 0x0F, 0xFF, 0xC7, 0xC0, 0x7F, 0xFF, 0x9F, 0x03,
  0xF8, 0x0F, 0x7C, 0x1F, 0x80, 0x0D, 0xF0, 0xFC, 0x00, 0x1F, 0x83, 0xE0,
  0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x01, 0xF1,
  0xF0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0xF8, 0xF8,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7E, 0x1E, 0x00,
  0x01, 0xF8, 0x7C, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x7F, 0x07, 0xE0, 0x03,
  0xFC, 0x1F, 0x80, 0x1D, 0xF0, 0x3F, 0x81, 0xE7, 0xC0, 0x7F, 0xFF, 0x1F,
  0x01, 0xFF, 0xF8, 0x78, 0x01, 0xFF, 0xC3, 0xE0, 0x01, 0xFC, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFD, 0xFF, 0xF1, 0xFF, 0xE0, 0x0F, 0x9E, 0x00, 0x00,
  0x7D, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x7C, 0x00, 0x07,
  0x01, 0xE0, 0x00, 0x10, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x10, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0x7E, 0x3F, 0x80, 0x03, 0xF0, 0x7F, 0xC0, 0x3F, 0x80, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x04, 0x03, 0xE0, 0x03, 0xC0, 0x7C, 0x00, 0xFC, 0x0F, 0x80, 0x7F,
  0x01, 0xE0, 0x1F, 0xC0, 0x7C, 0x0F, 0xE0, 0x0F, 0x83, 0xF8, 0x01, 0xF1,
  0xFE, 0x00, 0x3E, 0x7F, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xF1, 0xF0,
  0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3E, 0x3E,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x7C, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF8, 0xF8, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x8F, 0x80, 0x01, 0xF8,
  0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x03, 0xF0, 0xF8, 0x00, 0x7F, 0x0F, 0xC0,
  0x0D, 0xF0, 0x7C, 0x01, 0xDF, 0x07, 0xF0, 0x79, 0xE0, 0x7F, 0xFF, 0x1E,
  0x03, 0xFF, 0xE3, 0xE0, 0x1F, 0xFC, 0x3E, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x63, 0xFF, 0x80, 0x1F, 0xBF, 0xFC, 0x00, 0x7D, 0xFF, 0xE0,
  0x03, 0xEF, 0xFF, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x03,
  0xE0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x3E, 0x07, 0x80, 0x01, 0xF0, 0x3C, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01,
  0xF0, 0x3C, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0xC0,
  0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x7E, 0x01, 0xF0,
  0x07, 0xE0, 0x0F, 0x00, 0x7E, 0x00, 0x78, 0x07, 0xE0, 0x07, 0xC0, 0xFE,
  0x00, 0x3E, 0x3F, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x1F,
  0x00, 0xF0, 0x3E, 0x1F, 0x00, 0xF0, 0x3E, 0x1E, 0x00, 0xF0, 0x1E, 0x1E,
  0x00, 0xF0, 0x1E, 0x1E, 0x01, 0xF0, 0x1E, 0x1E, 0x01, 0xE0, 0x1E, 0x3E,
  0x01, 0xE0, 0x1F, 0x3E, 0x01, 0xE0, 0x1F, 0x3C, 0x01, 0xE0, 0x1F, 0x3C,
  0x01, 0xE0, 0x1F, 0x3C, 0x03, 0xE0, 0x1F, 0x3C, 0x03, 0xC0, 0x1E, 0x7C,
  0x03, 0xC0, 0x1E, 0x7C, 0x03, 0xC0, 0x1E, 0x78, 0x03, 0xC0, 0x1E, 0x78,
  0x03, 0xC0, 0x1E, 0x78, 0x07, 0xC0, 0x3E, 0x78, 0x07, 0xC0, 0x3E, 0xF8,
  0x07, 0x80, 0x3C, 0xF8, 0x07, 0x80, 0x3C, 0xF8, 0x07, 0x80, 0x7C, 0xF0,
  0x0F, 0x80, 0x7C, 0xF0, 0x0F, 0x80, 0x78, 0xF0, 0x0F, 0x80, 0xF8, 0xF0,
  0x1F, 0x80, 0xF0, 0xF0, 0x1F, 0x81, 0xF0, 0xF0, 0x37, 0x83, 0xE0, 0xF8,
  0x77, 0xC7, 0xE0, 0xFF, 0xE7, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0x80, 0x7F,
  0x83, 0xFF, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0x80,
  0x03, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x1F, 0xFE, 0x1F,
  0xFF, 0x03, 0xF9, 0xE3, 0xE1, 0xF0, 0x7F, 0x1F, 0x3C, 0x1F, 0x1F, 0xC0,
  0xF3, 0x80, 0xF1, 0xF0, 0x0F, 0x70, 0x0F, 0x0E, 0x00, 0xF6, 0x00, 0xF0,
  0x80, 0x0F, 0x60, 0x0F, 0x00, 0x00, 0xFE, 0x00, 0xF0, 0x00, 0x0F, 0xC0,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x80, 0x3F, 0x80, 0x00, 0x78, 0x03,
  0x78, 0x00, 0x0F, 0x80, 0x37, 0x80, 0x30, 0xF8, 0x07, 0x78, 0x07, 0x8F,
  0x80, 0x67, 0x80, 0xFC, 0xF8, 0x0E, 0x78, 0x3F, 0x07, 0x81, 0xE7, 0x87,
  0xE0, 0x7C, 0x3C, 0x7D, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0x80, 0x7F, 0xF8,
  0x3F, 0xF0, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8,
  0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x0F,
  0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00,
  0x7E, 0x07, 0xC0, 0x01, 0xF8, 0x0F, 0x80, 0x07, 0xF0, 0x1F, 0x80, 0x1F,
  0xE0, 0x1F, 0x00, 0x77, 0xC0, 0x3F, 0x83, 0xCF, 0x80, 0x3F, 0xFF, 0x1F,
  0x00, 0x7F, 0xFE, 0x3C, 0x00, 0x7F, 0xF0, 0xF8, 0x00, 0x1F, 0x81, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x06,
  0x00, 0x07, 0xE0, 0x1E, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x7C, 0x0F,
  0xFF, 0xE0, 0xF8, 0x3F, 0xFF, 0xF1, 0xF0, 0xFC, 0x0F, 0xF3, 0xE1, 0xF0,
  0x03, 0xFF, 0x83, 0xC0, 0x01, 0xFE, 0x0F, 0x00, 0x01, 0xF8, 0x1E, 0x00,
  0x07, 0xE0, 0x3C, 0x00, 0x1F, 0x80, 0x78, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x03, 0x00, 0x0F, 0xC0, 0x1E,
  0x00, 0x3F, 0x00, 0x3C, 0x00, 0xFC, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x78,
  0x0F, 0xC0, 0x00, 0xF0, 0x3F, 0x00, 0x01, 0xF0, 0xFF, 0xE0, 0x03, 0xE3,
  0xFF, 0xFE, 0x03, 0xC7, 0x8F, 0xFF, 0xC7, 0x9F, 0x03, 0xFF, 0xFF, 0x3E,
  0x00, 0xFF, 0xFC, 0x7C, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3F, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7C, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x0C, 0x03, 0xFC, 0x00, 0x1F,
  0x07, 0xFE, 0x00, 0x1E, 0x0F, 0xFF, 0x00, 0x1E, 0x1F, 0x0F, 0x80, 0x3C,
  0x1E, 0x07, 0xC0, 0x3C, 0x3C, 0x07, 0xC0, 0x7C, 0x3C, 0x03, 0xE0, 0xF8,
  0x78, 0x01, 0xF1, 0xF0, 0x78, 0x01, 0xFF, 0xF0, 0xF0, 0x00, 0xFF, 0xE0,
  0xF0, 0x00, 0x7F, 0xC0, 0x30, 0x00, 0x1F, 0x00,
};

const GFXglyph IBMPlexMono_Italic61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 37, 0, -1 },
  { 1, 13, 44, 37, 12, -43 },
  { 73, 18, 17, 37, 13, -45 },
  { 112, 37, 43, 37, 1, -43 },
  { 311, 35, 56, 37, 1, -49 },
  { 556, 41, 44, 37, -1, -43 },
  { 782, 36, 44, 37, 0, -43 },
  { 980, 7, 17, 37, 18, -45 },
  { 995, 22, 54, 37, 13, -46 },
  { 1144, 23, 54, 37, 2, -46 },
  { 1300, 31, 30, 37, 3, -33 },
  { 1417, 29, 30, 37, 4, -34 },
  { 1526, 14, 17, 37, 8, -8 },
  { 1556, 18, 4, 37, 10, -20 },
  { 1565, 9, 8, 37, 12, -7 },
  { 1574, 34, 54, 37, 2, -46 },
  { 1804, 31, 44, 37, 4, -43 },
  { 1975, 29, 43, 37, 3, -43 },
  { 2131, 32, 43, 37, 2, -43 },
  { 2303, 33, 44, 37, 1, -43 },
  { 2485, 33, 43, 37, 1, -43 },
  { 2663, 32, 44, 37, 3, -43 },
  { 2839, 29, 44, 37, 4, -43 },
  { 2999, 31, 43, 37, 6, -43 },
  { 3166, 33, 44, 37, 2, -43 },
  { 3348, 29, 43, 37, 5, -43 },
  { 3504, 13, 32, 37, 12, -31 },
  { 3556, 17, 40, 37, 8, -31 },
  { 3641, 30, 35, 37, 5, -36 },
  { 3773, 32, 16, 37, 3, -27 },
  { 3837, 29, 35, 37, 3, -36 },
  { 3964, 26, 44, 37, 8, -43 },
  { 4107, 31, 50, 37, 3, -43 },
  { 4301, 33, 43, 37, -1, -43 },
  { 4479, 31, 43, 37, 3, -43 },
  { 4646, 31, 44, 37, 5, -43 },
  { 4817, 31, 43, 37, 3, -43 },
  { 4984, 33, 43, 37, 3, -43 },
  { 5162, 34, 43, 37, 3, -43 },
  { 5345, 31, 44, 37, 4, -43 },
  { 5516, 34, 43, 37, 2, -43 },
  { 5699, 34, 43, 37, 2, -43 },
  { 5882, 30, 44, 37, 4, -43 },
  { 6047, 36, 43, 37, 3, -43 },
  { 6241, 26, 43, 37, 5, -43 },
  { 6381, 35, 43, 37, 2, -43 },
  { 6570, 34, 43, 37, 2, -43 },
  { 6753, 31, 44, 37, 4, -43 },
  { 6924, 33, 43, 37, 3, -43 },
  { 7102, 31, 54, 37, 4, -43 },
  { 7312, 33, 43, 37, 3, -43 },
  { 7490, 34, 44, 37, 2, -43 },
  { 7677, 35, 43, 37, 5, -43 },
  { 7866, 32, 44, 37, 4, -43 },
  { 8042, 32, 43, 37, 7, -43 },
  { 8214, 36, 43, 37, 3, -43 },
  { 8408, 40, 43, 37, -1, -43 },
  { 8623, 35, 43, 37, 5, -43 },
  { 8812, 37, 43, 37, 0, -43 },
  { 9011, 26, 54, 37, 10, -46 },
  { 9187, 16, 54, 37, 11, -46 },
  { 9295, 26, 54, 37, 1, -46 },
  { 9471, 31, 25, 37, 4, -43 },
  { 9568, 30, 4, 37, 0, 6 },
  { 9583, 8, 12, 37, 14, -48 },
  { 9595, 30, 33, 37, 3, -32 },
  { 9719, 30, 46, 37, 3, -45 },
  { 9892, 27, 33, 37, 5, -32 },
  { 10004, 33, 46, 37, 3, -45 },
  { 10194, 28, 33, 37, 4, -32 },
  { 10310, 40, 58, 37, -1, -45 },
  { 10600, 31, 45, 37, 2, -32 },
  { 10775, 28, 45, 37, 4, -45 },
  { 10933, 28, 46, 37, 5, -45 },
  { 11094, 28, 58, 37, 4, -45 },
  { 11297, 31, 46, 37, 4, -45 },
  { 11476, 25, 46, 37, 7, -45 },
  { 11620, 34, 32, 37, 1, -32 },
  { 11756, 28, 32, 37, 4, -32 },
  { 11868, 29, 33, 37, 4, -32 },
  { 11988, 32, 44, 37, 1, -32 },
  { 12164, 30, 44, 37, 3, -32 },
  { 12329, 29, 31, 37, 7, -31 },
  { 12442, 30, 33, 37, 3, -32 },
  { 12566, 27, 44, 37, 5, -43 },
  { 12715, 28, 32, 37, 5, -31 },
  { 12827, 29, 32, 37, 4, -32 },
  { 12943, 32, 33, 37, 3, -32 },
  { 13075, 36, 33, 37, 0, -32 },
  { 13224, 31, 44, 37, 2, -31 },
  { 13395, 31, 33, 37, 3, -32 },
  { 13523, 28, 54, 37, 7, -46 },
  { 13712, 14, 54, 37, 12, -46 },
  { 13807, 28, 54, 37, 3, -46 },
  { 13996, 32, 13, 37, 3, -25 },
};

const GFXfont IBMPlexMono_Italic61pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic61pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic61pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _IBMPLEXMONO_ITALIC61PT7B_H_
