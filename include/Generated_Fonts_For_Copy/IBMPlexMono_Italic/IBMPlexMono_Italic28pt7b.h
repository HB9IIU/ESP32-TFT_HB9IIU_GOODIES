#ifndef _IBMPLEXMONO_ITALIC28PT7B_H_
#define _IBMPLEXMONO_ITALIC28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x18, 0x30, 0x61, 0xC3, 0x86, 0x0C, 0x18, 0x30, 0x40, 0x81,
  0x00, 0x00, 0x00, 0x70, 0xF3, 0xC3, 0x80, 0x63, 0x63, 0x63, 0x67, 0xE6,
  0xC6, 0xC6, 0xC6, 0x00, 0xE3, 0x00, 0x63, 0x00, 0x31, 0x80, 0x30, 0xC0,
  0x18, 0xC0, 0x0C, 0x60, 0xFC, 0x3E, 0x7E, 0x3F, 0x03, 0x18, 0x03, 0x0C,
  0x01, 0x8C, 0x00, 0xC6, 0x07, 0xC3, 0xE7, 0xE3, 0xF0, 0x31, 0x80, 0x30,
  0xC0, 0x18, 0xC0, 0x0C, 0x60, 0x0C, 0x30, 0x06, 0x30, 0x00, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x00, 0x1F, 0x80, 0xFF, 0xC3, 0x9B, 0xCE, 0x31, 0x98,
  0x62, 0x30, 0x80, 0x61, 0x00, 0xE6, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x4E, 0x01, 0x8E, 0x03, 0x0C, 0x06, 0x39, 0x0C, 0x77, 0x10, 0xCF,
  0x27, 0x8F, 0xFE, 0x07, 0xF0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x03,
  0xC0, 0x61, 0xFC, 0x18, 0x31, 0x83, 0x0C, 0x30, 0xC1, 0x86, 0x30, 0x30,
  0xC6, 0x06, 0x19, 0x80, 0xC6, 0x60, 0x1F, 0xD0, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x1F, 0x80, 0x37, 0x18, 0x0C, 0xC3, 0x03, 0x18, 0x60, 0xE6,
  0x0C, 0x18, 0xC3, 0x86, 0x0C, 0x61, 0x81, 0xF8, 0x70, 0x1E, 0x00, 0x01,
  0xF0, 0x07, 0xF8, 0x06, 0x1C, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0E,
  0x1C, 0x06, 0x18, 0x06, 0x38, 0x1F, 0xF0, 0x3B, 0x80, 0x61, 0x80, 0xE1,
  0x80, 0xC0, 0xC0, 0xC0, 0xC2, 0xC0, 0xE3, 0xE0, 0xE3, 0x61, 0x36, 0x7F,
  0x3E, 0x3E, 0x1C, 0x36, 0x66, 0x66, 0x6C, 0x01, 0xC0, 0xC0, 0x60, 0x30,
  0x18, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00,
  0xE0, 0x1C, 0x00, 0x0E, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0xE0, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x83, 0x07, 0xCD,
  0xF7, 0xFF, 0x03, 0xE0, 0x0F, 0x00, 0x76, 0x03, 0x98, 0x0C, 0x30, 0x60,
  0xE1, 0x02, 0x00, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x83, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x07, 0x00, 0x3C, 0xE3, 0x9C, 0x71, 0x8E, 0x30, 0x7F, 0xFF, 0xC0, 0x73,
  0xFC, 0xE0, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0,
  0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0x03, 0xE0, 0x3F, 0xC1, 0xC3, 0x8E, 0x07, 0x30,
  0x0D, 0xC0, 0x36, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x8E, 0x7C, 0x79, 0xF1,
  0xC6, 0xC0, 0x1B, 0x00, 0x6C, 0x03, 0x30, 0x0C, 0xE0, 0x61, 0x83, 0x87,
  0xFC, 0x07, 0xC0, 0x01, 0xE0, 0x0F, 0x80, 0x76, 0x03, 0xB8, 0x3C, 0xE0,
  0xE3, 0x03, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x0F, 0xFF,
  0xFF, 0xFE, 0x03, 0xF0, 0x3F, 0xE1, 0xE1, 0xC6, 0x03, 0x30, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x0F, 0xFF, 0xBF,
  0xFE, 0x03, 0xF0, 0x3F, 0xE1, 0xE1, 0xC6, 0x03, 0x10, 0x0C, 0x00, 0x30,
  0x01, 0xC0, 0x0E, 0x07, 0xE0, 0x1F, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x90, 0x0E, 0xC0, 0x33, 0xC3, 0xC7, 0xFE, 0x07, 0xE0,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x6C, 0x00, 0xEC, 0x01, 0xCC,
  0x01, 0x8C, 0x03, 0x1C, 0x06, 0x1C, 0x0E, 0x18, 0x1C, 0x18, 0x18, 0x18,
  0x30, 0x18, 0x60, 0x38, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x70, 0x0F, 0xFE, 0x1F, 0xFC, 0x30, 0x00, 0x60, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0D, 0xF0, 0x37, 0xF0, 0x70, 0x70, 0x40,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x20, 0x0C, 0x60, 0x39,
  0xE0, 0xE0, 0xFF, 0x80, 0x7C, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0xF8, 0x6F, 0xF3, 0xC3, 0xB8, 0x0F,
  0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x06, 0xC0, 0x77, 0x07, 0x1F,
  0xF0, 0x3E, 0x00, 0x7F, 0xFD, 0xFF, 0xFE, 0x01, 0xB0, 0x0E, 0xC0, 0x33,
  0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0,
  0x07, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00,
  0x1C, 0x00, 0x03, 0xF8, 0x1F, 0xF8, 0x78, 0x78, 0xC0, 0x73, 0x80, 0x67,
  0x01, 0xC6, 0x03, 0x0E, 0x0C, 0x0F, 0xF0, 0x1F, 0xE0, 0xE0, 0xE3, 0x80,
  0xE6, 0x00, 0xDC, 0x01, 0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x38, 0xE0, 0xF0,
  0xFF, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x7F, 0xC3, 0xC3, 0x8C, 0x06, 0x70,
  0x1D, 0x80, 0x76, 0x01, 0xF8, 0x07, 0xE0, 0x19, 0x80, 0xE7, 0x05, 0x8F,
  0xEC, 0x1F, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x1E, 0x00, 0x1C, 0xF3, 0xC7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x7B, 0xC7, 0x00, 0x0E, 0x3C, 0x78, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE3, 0x87, 0x1C, 0x38, 0x61, 0xC3, 0x00, 0x00, 0x04, 0x00, 0x70,
  0x07, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x1C, 0x00, 0x60, 0x03,
  0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x08,
  0x3F, 0xFE, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xBF,
  0xFF, 0x00, 0x10, 0x00, 0x60, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x06, 0x00, 0x20, 0x00, 0x1F, 0x83, 0xFC, 0x70, 0xEE, 0x06,
  0xC0, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0xF8, 0x1F, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x00, 0x00, 0x00, 0x38, 0x07, 0x80, 0x78, 0x07, 0x00,
  0x07, 0xE0, 0x3F, 0xC1, 0xC3, 0x8C, 0x06, 0x30, 0x0D, 0x80, 0x36, 0x1C,
  0xD8, 0xFA, 0xE7, 0x1B, 0x18, 0x6C, 0xE1, 0xB3, 0x06, 0xCC, 0x1B, 0x30,
  0xCC, 0xC3, 0x33, 0xFC, 0xC7, 0xB3, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x70,
  0x01, 0xFF, 0x01, 0xFC, 0x00, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0xC0, 0x19, 0x80, 0x73, 0x00, 0xC6, 0x01, 0x8C, 0x06, 0x18, 0x0C, 0x30,
  0x30, 0x60, 0x60, 0xE1, 0xFF, 0xC3, 0xFF, 0x8E, 0x03, 0x18, 0x06, 0x70,
  0x0C, 0xC0, 0x1B, 0x80, 0x3E, 0x00, 0x70, 0x1F, 0xF0, 0x3F, 0xF8, 0x60,
  0x70, 0xC0, 0x61, 0x80, 0xE3, 0x01, 0xCE, 0x03, 0x1C, 0x0E, 0x30, 0x18,
  0x7F, 0xE0, 0xFF, 0xC1, 0x81, 0xC7, 0x01, 0xCE, 0x03, 0x98, 0x07, 0x30,
  0x0E, 0x60, 0x18, 0xC0, 0x71, 0xFF, 0xC7, 0xFE, 0x00, 0x03, 0xE0, 0x3F,
  0xE1, 0xE1, 0xC6, 0x03, 0x38, 0x0C, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0E, 0x01, 0x38,
  0x0E, 0x60, 0x31, 0xC3, 0x83, 0xFC, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0xC3,
  0x83, 0x8E, 0x06, 0x30, 0x1C, 0xC0, 0x73, 0x00, 0xCC, 0x07, 0x70, 0x1D,
  0xC0, 0x76, 0x01, 0xD8, 0x06, 0x60, 0x19, 0x80, 0xEE, 0x03, 0xB8, 0x0C,
  0xC0, 0x73, 0x07, 0x8F, 0xFC, 0x3F, 0xC0, 0x1F, 0xFF, 0x1F, 0xFE, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x1F,
  0xFF, 0x1F, 0xFF, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x3F, 0xFC, 0x3F, 0xF8, 0x30, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0x03, 0xE0, 0x3F, 0xE1, 0xC3, 0x8E, 0x07, 0x30, 0x0D,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x1F, 0xB0, 0x7E,
  0xC0, 0x1B, 0x00, 0xCC, 0x03, 0x30, 0x0C, 0xE0, 0x71, 0xC2, 0xC7, 0xF3,
  0x07, 0x9C, 0x1C, 0x07, 0x18, 0x06, 0x18, 0x06, 0x18, 0x06, 0x18, 0x06,
  0x38, 0x0E, 0x38, 0x0E, 0x30, 0x0C, 0x30, 0x0C, 0x3F, 0xFC, 0x3F, 0xFC,
  0x70, 0x1C, 0x70, 0x1C, 0x60, 0x18, 0x60, 0x18, 0x60, 0x18, 0x60, 0x18,
  0xE0, 0x38, 0xE0, 0x38, 0xC0, 0x30, 0x1F, 0xFF, 0x1F, 0xFE, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0xFF, 0xF8, 0xFF, 0xF0, 0x0F, 0xF8,
  0x7F, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x98, 0x1C,
  0xC0, 0xE7, 0x0E, 0x1F, 0xE0, 0x7E, 0x00, 0x1C, 0x03, 0x8E, 0x03, 0x86,
  0x03, 0x83, 0x03, 0x81, 0x83, 0x80, 0xC3, 0x80, 0xE3, 0x80, 0x73, 0x80,
  0x33, 0x80, 0x1B, 0xC0, 0x0F, 0xF0, 0x07, 0x98, 0x07, 0x8C, 0x03, 0x87,
  0x01, 0x81, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x30, 0x1C, 0x38, 0x06, 0x1C,
  0x03, 0x80, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38,
  0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0x1C, 0x07, 0x1C, 0x0F,
  0x1C, 0x0F, 0x36, 0x1E, 0x36, 0x1E, 0x36, 0x36, 0x36, 0x66, 0x33, 0x66,
  0x33, 0xCE, 0x73, 0xCC, 0x63, 0x8C, 0x61, 0x8C, 0x61, 0x0C, 0x62, 0x0C,
  0x60, 0x1C, 0xE0, 0x18, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x18,
  0x1E, 0x07, 0x1E, 0x06, 0x1E, 0x06, 0x1E, 0x06, 0x1B, 0x06, 0x3B, 0x06,
  0x33, 0x0E, 0x33, 0x0C, 0x33, 0x8C, 0x31, 0x8C, 0x31, 0x8C, 0x71, 0x8C,
  0x61, 0x9C, 0x60, 0xD8, 0x60, 0xD8, 0x60, 0xD8, 0x60, 0xD8, 0xE0, 0xF8,
  0xC0, 0x78, 0xC0, 0x70, 0x03, 0xE0, 0x3F, 0xC1, 0xC3, 0x8E, 0x07, 0x30,
  0x0D, 0xC0, 0x36, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0,
  0x06, 0xC0, 0x1B, 0x00, 0xEC, 0x03, 0xB0, 0x0C, 0xE0, 0x61, 0x83, 0x87,
  0xFC, 0x07, 0xC0, 0x1F, 0xF8, 0x3F, 0xF8, 0x60, 0x38, 0xC0, 0x31, 0x80,
  0x63, 0x00, 0xC6, 0x01, 0x9C, 0x07, 0x30, 0x1C, 0x7F, 0xF0, 0xFF, 0xC1,
  0x80, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x07, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0xC1, 0xC3, 0x8E, 0x07,
  0x30, 0x0D, 0xC0, 0x36, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01,
  0xF0, 0x06, 0xC0, 0x1B, 0x00, 0xEC, 0x03, 0xB0, 0x0C, 0xE0, 0x73, 0x83,
  0x87, 0xFC, 0x0F, 0xC0, 0x06, 0x10, 0x1C, 0x60, 0x3B, 0x00, 0x78, 0x00,
  0xC0, 0x1F, 0xF8, 0x3F, 0xF8, 0x60, 0x38, 0xC0, 0x31, 0x80, 0x63, 0x00,
  0xC6, 0x01, 0x9C, 0x07, 0x30, 0x1C, 0x7F, 0xF0, 0xFF, 0xC1, 0x8E, 0x03,
  0x0C, 0x0E, 0x18, 0x18, 0x38, 0x30, 0x30, 0x60, 0x70, 0xC0, 0x61, 0x80,
  0xC7, 0x01, 0xC0, 0x03, 0xF0, 0x1F, 0xF8, 0x70, 0x79, 0xC0, 0x33, 0x00,
  0x46, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1F, 0xC0, 0x0F, 0xE0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x07, 0x20, 0x0E, 0xC0, 0x19, 0xE0,
  0xF1, 0xFF, 0xC0, 0xFE, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x81, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x38, 0x0E, 0x60,
  0x18, 0xC0, 0x31, 0x80, 0x63, 0x00, 0xCE, 0x03, 0x9C, 0x07, 0x30, 0x0C,
  0x60, 0x18, 0xC0, 0x31, 0x80, 0x67, 0x01, 0xCE, 0x03, 0x18, 0x06, 0x30,
  0x0C, 0x60, 0x38, 0xE0, 0x61, 0xC1, 0xC1, 0xFF, 0x00, 0xFC, 0x00, 0xC0,
  0x0F, 0x80, 0x1B, 0x80, 0x77, 0x00, 0xC6, 0x03, 0x8C, 0x06, 0x18, 0x0C,
  0x30, 0x30, 0x60, 0x60, 0xC1, 0xC1, 0xC3, 0x01, 0x8E, 0x03, 0x18, 0x06,
  0x70, 0x0C, 0xC0, 0x19, 0x80, 0x36, 0x00, 0x6C, 0x00, 0xF0, 0x00, 0xE0,
  0x00, 0x30, 0x01, 0x98, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x31,
  0x8E, 0x39, 0x87, 0x18, 0xC7, 0x8C, 0x63, 0xC6, 0x31, 0x63, 0x19, 0xB3,
  0x0C, 0xD9, 0x86, 0xCC, 0xC3, 0x66, 0x61, 0xB3, 0x60, 0xF0, 0xB0, 0x78,
  0x58, 0x6C, 0x2C, 0x3C, 0x1C, 0x1E, 0x0E, 0x00, 0x1C, 0x01, 0xC3, 0x00,
  0xE0, 0xE0, 0x70, 0x18, 0x18, 0x07, 0x0E, 0x00, 0xC7, 0x00, 0x3B, 0x80,
  0x06, 0xC0, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07,
  0x60, 0x01, 0x8C, 0x00, 0xC3, 0x00, 0x70, 0xE0, 0x38, 0x18, 0x0C, 0x07,
  0x06, 0x00, 0xC3, 0x80, 0x38, 0xC0, 0x0F, 0xC0, 0x1B, 0x80, 0x73, 0x01,
  0xC7, 0x03, 0x06, 0x0C, 0x0C, 0x38, 0x1C, 0xE0, 0x19, 0x80, 0x37, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC0,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00, 0x3F, 0xFF, 0x9F,
  0xFF, 0x80, 0x07, 0xF0, 0xFF, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x07, 0xF0, 0xFF, 0x00, 0xC1, 0x81, 0x03, 0x06, 0x0C, 0x08, 0x18, 0x30,
  0x60, 0xC0, 0x81, 0x83, 0x06, 0x04, 0x0C, 0x18, 0x30, 0x60, 0x40, 0xC1,
  0x83, 0x02, 0x0F, 0xF0, 0xFF, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03,
  0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x36, 0x01, 0x98, 0x0C,
  0x70, 0x70, 0xC1, 0x83, 0x0C, 0x06, 0x70, 0x1B, 0x80, 0x7C, 0x00, 0xC0,
  0xFF, 0xFF, 0xFF, 0xE0, 0xE6, 0x63, 0x30, 0x0F, 0x99, 0xFE, 0xDE, 0x16,
  0xC0, 0x6E, 0x03, 0x60, 0x1B, 0x00, 0xD8, 0x06, 0xC0, 0x76, 0x03, 0x30,
  0x39, 0xC2, 0xC7, 0xF7, 0x9E, 0x3C, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x7C, 0x1B, 0xF8, 0xF8, 0x73,
  0xC0, 0xCE, 0x03, 0x30, 0x0C, 0xC0, 0x33, 0x00, 0xDC, 0x07, 0x60, 0x19,
  0xC0, 0xE7, 0x87, 0x1B, 0xF8, 0xE7, 0xC0, 0x07, 0xC0, 0xFF, 0x0E, 0x1C,
  0xE0, 0x76, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x26, 0x01, 0xB8,
  0x1C, 0xE1, 0xC3, 0xFC, 0x0F, 0x80, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x83, 0xE6, 0x3F, 0xD9, 0xE1, 0x66,
  0x03, 0xB8, 0x0C, 0xC0, 0x33, 0x00, 0xCC, 0x03, 0x30, 0x0C, 0xC0, 0x73,
  0x03, 0xCE, 0x16, 0x1F, 0xD8, 0x3C, 0x60, 0x07, 0xE0, 0xFF, 0x8E, 0x0E,
  0xE0, 0x36, 0x03, 0xF0, 0x7B, 0xFF, 0x9F, 0xE0, 0xC0, 0x06, 0x01, 0x38,
  0x0C, 0xE1, 0xC7, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x3F, 0xFE,
  0x0F, 0xFF, 0x84, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x30, 0xE0, 0x0E, 0x30, 0x01, 0xCC, 0x00,
  0x3B, 0x00, 0x07, 0xC0, 0x00, 0xE0, 0x00, 0x07, 0xCC, 0x7F, 0xB3, 0xC2,
  0xCC, 0x07, 0x70, 0x1D, 0x80, 0x66, 0x01, 0x98, 0x06, 0x60, 0x19, 0x80,
  0xE6, 0x07, 0x9C, 0x3C, 0x3F, 0xB0, 0x7C, 0xC0, 0x03, 0x00, 0x1C, 0x80,
  0x63, 0x87, 0x8F, 0xFC, 0x0F, 0xC0, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x3C, 0x37, 0xF1, 0xA3, 0x9E, 0x0E,
  0xE0, 0x77, 0x03, 0x30, 0x19, 0x80, 0xCC, 0x06, 0xE0, 0x36, 0x03, 0xB0,
  0x19, 0x80, 0xCC, 0x06, 0x00, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x07, 0x00, 0x30, 0x61, 0x8E, 0x0C, 0xE0, 0x6E, 0x07, 0xE0,
  0x1C, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x61, 0x03, 0x0C, 0x18,
  0x71, 0xC1, 0xCC, 0x07, 0x60, 0x1F, 0x00, 0x70, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x78, 0x37,
  0xF0, 0xF0, 0xC7, 0x83, 0x9C, 0x0C, 0x60, 0x71, 0x83, 0x86, 0x78, 0x1B,
  0x80, 0xE6, 0x0B, 0x0C, 0x7C, 0x33, 0xB0, 0x7C, 0xC1, 0xC0, 0xFF, 0x0F,
  0xE0, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x23, 0x87, 0x30, 0xE3,
  0x38, 0x37, 0x03, 0xE0, 0x3C, 0x00, 0x1B, 0x8E, 0x3F, 0xDF, 0x38, 0xE3,
  0x38, 0xC3, 0x30, 0xC3, 0x30, 0xC3, 0x30, 0xC6, 0x71, 0x86, 0x61, 0x86,
  0x61, 0x86, 0x61, 0x86, 0x61, 0x8C, 0x63, 0x0C, 0xC3, 0x0C, 0x31, 0xE1,
  0xBF, 0x8D, 0x1C, 0xF0, 0x77, 0x03, 0xB8, 0x19, 0x80, 0xCC, 0x06, 0x60,
  0x37, 0x01, 0xB0, 0x1D, 0x80, 0xCC, 0x06, 0x60, 0x30, 0x07, 0xC0, 0xFF,
  0x8E, 0x1C, 0xE0, 0x76, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E,
  0x01, 0xB0, 0x1C, 0xC1, 0xC7, 0xFC, 0x0F, 0x80, 0x19, 0xF0, 0x6F, 0xE3,
  0xE1, 0xCF, 0x03, 0x38, 0x0C, 0xC0, 0x33, 0x00, 0xCC, 0x03, 0x70, 0x1D,
  0x80, 0x67, 0x03, 0x9E, 0x1C, 0x6F, 0xE1, 0x9F, 0x0E, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x0F, 0x99, 0xFE, 0xDE, 0x16,
  0xC0, 0x7E, 0x03, 0xE0, 0x1B, 0x00, 0xD8, 0x06, 0xC0, 0x36, 0x03, 0xB0,
  0x3D, 0xC3, 0xC7, 0xF6, 0x1E, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0xFE, 0x7F, 0xE7, 0xC3, 0x40, 0x1C, 0x00, 0xC0,
  0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03,
  0x00, 0x18, 0x00, 0x07, 0xF0, 0x3F, 0xE1, 0xC1, 0xCE, 0x00, 0x30, 0x00,
  0x70, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x38, 0x00, 0x64, 0x01, 0xBC, 0x1C,
  0x7F, 0xF0, 0x7F, 0x00, 0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x03, 0xFF, 0xFF, 0xFF, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x0E, 0x00, 0x60, 0x43, 0x0F, 0x18, 0xE0, 0xDE, 0x07, 0xC0, 0x3C,
  0x00, 0x30, 0x19, 0x80, 0xDC, 0x06, 0xE0, 0x76, 0x03, 0x30, 0x19, 0x80,
  0xCC, 0x06, 0xE0, 0x77, 0x03, 0xB8, 0x38, 0xC2, 0xC7, 0xF6, 0x1E, 0x30,
  0xF8, 0x37, 0xC0, 0xC6, 0x06, 0x30, 0x31, 0x81, 0x98, 0x0C, 0xC0, 0xE6,
  0x06, 0x30, 0x31, 0x83, 0x0C, 0x38, 0xE7, 0x87, 0xF0, 0x1F, 0x00, 0x30,
  0xCC, 0x61, 0x0C, 0xC6, 0x1B, 0x0C, 0x36, 0x18, 0x6C, 0x30, 0xD8, 0x61,
  0xB1, 0x87, 0x63, 0x0D, 0x86, 0x1B, 0x0C, 0x76, 0x39, 0xCF, 0x9F, 0x0F,
  0x3C, 0x00, 0x07, 0x0F, 0x07, 0xCF, 0x8F, 0x6C, 0xEE, 0x34, 0x74, 0x1C,
  0x38, 0x0E, 0x18, 0x07, 0x00, 0x03, 0x80, 0x41, 0x80, 0x61, 0x41, 0x30,
  0xB3, 0x9C, 0xDB, 0x87, 0xCF, 0x83, 0xC3, 0x80, 0x18, 0x0C, 0x60, 0x31,
  0x80, 0xCE, 0x07, 0x30, 0x18, 0xC0, 0x63, 0x01, 0x8C, 0x06, 0x70, 0x39,
  0xC0, 0xE7, 0x07, 0x0C, 0x2C, 0x3F, 0xB0, 0x78, 0xC0, 0x07, 0x00, 0x18,
  0x80, 0x63, 0x87, 0x8F, 0xFC, 0x0F, 0xC0, 0x0F, 0x8E, 0x3F, 0xD8, 0xC1,
  0xF1, 0x80, 0xC3, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x18,
  0x38, 0x30, 0xC0, 0x63, 0xFC, 0x66, 0xFF, 0xDC, 0x3F, 0x00, 0x01, 0xF8,
  0x1F, 0xC1, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01,
  0x80, 0x0C, 0x00, 0xC1, 0xFC, 0x0F, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07,
  0xF0, 0x1F, 0x80, 0x0C, 0x21, 0x86, 0x18, 0x61, 0x84, 0x30, 0xC3, 0x0C,
  0x30, 0x86, 0x18, 0x61, 0x86, 0x30, 0xC3, 0x0C, 0x30, 0xC0, 0x0F, 0xE0,
  0x7F, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x03, 0xF0, 0x3F, 0x83, 0x80, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x1F,
  0xE0, 0xFE, 0x00, 0x1E, 0x06, 0x7E, 0x0C, 0xCC, 0x33, 0x0C, 0xE6, 0x1F,
  0x98, 0x1E, 0x00,
};

const GFXglyph IBMPlexMono_Italic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 7, 20, 17, 5, -20 },
  { 19, 8, 8, 17, 6, -21 },
  { 27, 17, 20, 17, 0, -20 },
  { 70, 15, 26, 17, 1, -23 },
  { 119, 19, 20, 17, -1, -20 },
  { 167, 16, 20, 17, 0, -20 },
  { 207, 4, 8, 17, 8, -21 },
  { 211, 10, 25, 17, 6, -21 },
  { 243, 11, 25, 17, 1, -21 },
  { 278, 14, 14, 17, 2, -15 },
  { 303, 13, 14, 17, 2, -16 },
  { 326, 6, 8, 17, 4, -4 },
  { 332, 9, 2, 17, 4, -10 },
  { 335, 5, 4, 17, 5, -4 },
  { 338, 16, 25, 17, 1, -21 },
  { 388, 14, 20, 17, 2, -20 },
  { 423, 14, 20, 17, 1, -20 },
  { 458, 14, 20, 17, 1, -20 },
  { 493, 14, 20, 17, 1, -20 },
  { 528, 16, 20, 17, 0, -20 },
  { 568, 15, 20, 17, 1, -20 },
  { 606, 13, 20, 17, 2, -20 },
  { 639, 14, 20, 17, 3, -20 },
  { 674, 15, 20, 17, 1, -20 },
  { 712, 14, 20, 17, 2, -20 },
  { 747, 6, 15, 17, 5, -15 },
  { 759, 7, 19, 17, 4, -15 },
  { 776, 14, 16, 17, 2, -17 },
  { 804, 15, 7, 17, 1, -12 },
  { 818, 14, 16, 17, 1, -17 },
  { 846, 12, 20, 17, 4, -20 },
  { 876, 14, 23, 17, 2, -20 },
  { 917, 15, 20, 17, 0, -20 },
  { 955, 15, 20, 17, 1, -20 },
  { 993, 14, 20, 17, 2, -20 },
  { 1028, 14, 20, 17, 2, -20 },
  { 1063, 16, 20, 17, 1, -20 },
  { 1103, 16, 20, 17, 1, -20 },
  { 1143, 14, 20, 17, 2, -20 },
  { 1178, 16, 20, 17, 1, -20 },
  { 1218, 16, 20, 17, 1, -20 },
  { 1258, 13, 20, 17, 2, -20 },
  { 1291, 17, 20, 17, 1, -20 },
  { 1334, 12, 20, 17, 2, -20 },
  { 1364, 16, 20, 17, 1, -20 },
  { 1404, 16, 20, 17, 1, -20 },
  { 1444, 14, 20, 17, 2, -20 },
  { 1479, 15, 20, 17, 1, -20 },
  { 1517, 14, 25, 17, 2, -20 },
  { 1561, 15, 20, 17, 1, -20 },
  { 1599, 15, 20, 17, 1, -20 },
  { 1637, 16, 20, 17, 2, -20 },
  { 1677, 15, 20, 17, 2, -20 },
  { 1715, 15, 20, 17, 3, -20 },
  { 1753, 17, 20, 17, 1, -20 },
  { 1796, 18, 20, 17, 0, -20 },
  { 1841, 15, 20, 17, 3, -20 },
  { 1879, 17, 20, 17, 0, -20 },
  { 1922, 12, 25, 17, 4, -21 },
  { 1960, 7, 25, 17, 5, -21 },
  { 1982, 12, 25, 17, 0, -21 },
  { 2020, 14, 11, 17, 2, -20 },
  { 2040, 14, 2, 17, 0, 3 },
  { 2044, 4, 5, 17, 6, -21 },
  { 2047, 13, 14, 17, 2, -14 },
  { 2070, 14, 21, 17, 1, -21 },
  { 2107, 13, 14, 17, 2, -14 },
  { 2130, 14, 21, 17, 2, -21 },
  { 2167, 13, 14, 17, 2, -14 },
  { 2190, 18, 27, 17, 0, -21 },
  { 2251, 14, 20, 17, 1, -14 },
  { 2286, 13, 21, 17, 2, -21 },
  { 2321, 13, 20, 17, 2, -20 },
  { 2354, 13, 26, 17, 2, -20 },
  { 2397, 14, 21, 17, 2, -21 },
  { 2434, 12, 21, 17, 3, -21 },
  { 2466, 16, 14, 17, 0, -14 },
  { 2494, 13, 14, 17, 2, -14 },
  { 2517, 13, 14, 17, 2, -14 },
  { 2540, 14, 20, 17, 1, -14 },
  { 2575, 13, 20, 17, 2, -14 },
  { 2608, 13, 14, 17, 3, -14 },
  { 2631, 14, 14, 17, 1, -14 },
  { 2656, 13, 20, 17, 2, -20 },
  { 2689, 13, 14, 17, 2, -14 },
  { 2712, 13, 14, 17, 2, -14 },
  { 2735, 15, 14, 17, 1, -14 },
  { 2762, 17, 14, 17, 0, -14 },
  { 2792, 14, 20, 17, 1, -14 },
  { 2827, 15, 14, 17, 1, -14 },
  { 2854, 13, 25, 17, 3, -21 },
  { 2895, 6, 25, 17, 6, -21 },
  { 2914, 13, 25, 17, 1, -21 },
  { 2955, 15, 6, 17, 1, -12 },
};

const GFXfont IBMPlexMono_Italic28pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic28pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic28pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _IBMPLEXMONO_ITALIC28PT7B_H_
