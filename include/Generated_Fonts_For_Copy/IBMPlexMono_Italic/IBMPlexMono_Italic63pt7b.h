#ifndef _IBMPLEXMONO_ITALIC63PT7B_H_
#define _IBMPLEXMONO_ITALIC63PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic63pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x01, 0xFE, 0x07, 0xFC, 0x3F, 0xF0, 0xFF,
  0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xC0, 0x7E, 0x00, 0x1F, 0x03, 0xE3, 0xE0,
  0x7C, 0x78, 0x0F, 0x0F, 0x01, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81,
  0xF1, 0xF0, 0x3E, 0x3C, 0x07, 0x87, 0x80, 0xF1, 0xF0, 0x3E, 0x3E, 0x07,
  0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0xF8, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x00,
  0x3C, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x78,
  0x00, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x3C, 0x00, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x7F, 0xFC, 0x07, 0xFF,
  0xC1, 0xFF, 0xF0, 0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x3F, 0xFE,
  0x03, 0xFF, 0xE0, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x7C, 0x00,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x1F, 0x00, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x3F, 0xFF, 0x03,
  0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xFE, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0xF7, 0xFC,
  0x01, 0xFC, 0x0E, 0x0F, 0xE0, 0x1F, 0x81, 0xE0, 0x7F, 0x03, 0xF0, 0x1E,
  0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x1C, 0x03, 0xE0, 0x1E, 0x01, 0x00, 0x3E,
  0x01, 0xC0, 0x00, 0x07, 0xE0, 0x1C, 0x00, 0x00, 0x7E, 0x03, 0xC0, 0x00,
  0x07, 0xE0, 0x3C, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x03, 0xF0, 0x3C,
  0x00, 0x00, 0x3F, 0x83, 0x80, 0x00, 0x01, 0xFE, 0x38, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xF0, 0xFE, 0x00, 0x00,
  0x0F, 0x07, 0xF0, 0x00, 0x00, 0xF0, 0x3F, 0x00, 0x00, 0x0F, 0x01, 0xF0,
  0x00, 0x00, 0xE0, 0x1F, 0x80, 0x00, 0x1E, 0x01, 0xF8, 0x00, 0x01, 0xE0,
  0x1F, 0x80, 0x00, 0x1E, 0x01, 0xF8, 0x00, 0x01, 0xE0, 0x1F, 0x01, 0x80,
  0x1C, 0x01, 0xF0, 0x3C, 0x01, 0xC0, 0x3F, 0x07, 0xE0, 0x3C, 0x07, 0xE0,
  0xFF, 0x03, 0xC0, 0xFE, 0x03, 0xF8, 0x3C, 0x1F, 0xC0, 0x1F, 0xF3, 0xCF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7C, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0x00, 0x3F, 0xFF, 0x80, 0x03,
  0xE0, 0x0F, 0xC1, 0xF0, 0x00, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x1E, 0x00,
  0x7C, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x01, 0xE0,
  0x07, 0x80, 0x3C, 0x00, 0x7C, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x80, 0x1E,
  0x03, 0xE0, 0x01, 0xE0, 0x07, 0xC0, 0xF8, 0x00, 0x3C, 0x00, 0xF8, 0x1E,
  0x00, 0x07, 0x80, 0x1F, 0x07, 0xC0, 0x00, 0xF0, 0x03, 0xC1, 0xF0, 0x00,
  0x1E, 0x00, 0xF8, 0x3C, 0x00, 0x03, 0xE0, 0x3E, 0x0F, 0x80, 0x00, 0x3E,
  0x0F, 0xC3, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x78, 0x00, 0x00, 0x7F, 0xFC,
  0x1E, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xC1, 0xFF, 0xFC, 0x00, 0x00, 0xF8,
  0x7E, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0x83, 0xE0,
  0x0F, 0x00, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x3C,
  0x00, 0x1F, 0x03, 0xE0, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x01, 0xF0, 0x00,
  0xF8, 0x0F, 0x00, 0x3E, 0x00, 0x3E, 0x01, 0xE0, 0x07, 0x80, 0x07, 0x80,
  0x3C, 0x00, 0xF0, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x01, 0xF0, 0x03, 0xC0, 0x03, 0xF0, 0x7C,
  0x00, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1E, 0x00, 0x03, 0xFF, 0xC0, 0x07,
  0x80, 0x00, 0x3F, 0xF0, 0x01, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x0F,
  0x80, 0x3E, 0x00, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x3F, 0x00,
  0x00, 0x7F, 0xC7, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFC, 0xFF,
  0x80, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x1D, 0xF0, 0x00, 0x3E, 0x01, 0xFF, 0x80, 0x03,
  0xF8, 0x0F, 0x7E, 0x00, 0x1B, 0xC0, 0xF9, 0xF0, 0x01, 0xDF, 0x07, 0x8F,
  0x80, 0x0C, 0xF8, 0x7C, 0x7E, 0x00, 0xE3, 0xE3, 0xC1, 0xF8, 0x1E, 0x1F,
  0x3E, 0x0F, 0xFF, 0xF0, 0x7F, 0xE0, 0x3F, 0xFF, 0x03, 0xFE, 0x00, 0x7F,
  0xF0, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1E, 0x00, 0x1E, 0x7C, 0xF9, 0xF3,
  0xE7, 0x8F, 0x3E, 0x7C, 0xF9, 0xF3, 0xC7, 0x9F, 0x3E, 0x7C, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xC0, 0x0F, 0x00, 0x3F, 0xF0, 0x1E,
  0x03, 0xFF, 0xFC, 0x3C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xDF, 0x00,
  0x00, 0x1F, 0xBE, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x07, 0xE0, 0x7C, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x7E, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x03, 0xC0, 0x01, 0xC0, 0x03,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0x80,
  0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01,
  0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x1F, 0x1F, 0xE7,
  0xFF, 0xFF, 0xFF, 0xBF, 0xEF, 0xFB, 0xFC, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x03, 0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x0F,
  0xC0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x1F, 0x1F,
  0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x1F, 0x3E,
  0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x1F, 0x7E,
  0x00, 0x00, 0x3F, 0x7C, 0x03, 0xE0, 0x3F, 0x7C, 0x07, 0xF0, 0x3F, 0x7C,
  0x0F, 0xF0, 0x3E, 0xFC, 0x0F, 0xF0, 0x3E, 0xFC, 0x0F, 0xF0, 0x3E, 0xFC,
  0x0F, 0xE0, 0x7E, 0xF8, 0x07, 0xC0, 0x7E, 0xF8, 0x00, 0x00, 0x7C, 0xF8,
  0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0xFC, 0xF8,
  0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x01, 0xF8, 0xF8,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE0, 0x7C,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0x3F,
  0xC0, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xDF, 0x00, 0x00, 0xFE, 0x7C, 0x00, 0x07, 0xF1,
  0xF0, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF8, 0x3E, 0x00, 0x1F, 0xC0, 0xF8,
  0x00, 0xFE, 0x03, 0xE0, 0x07, 0xF0, 0x0F, 0x80, 0x0F, 0x80, 0x3E, 0x00,
  0x18, 0x01, 0xF8, 0x00, 0x40, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x07, 0xF0, 0x01,
  0xFC, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x1F, 0x03, 0xF0, 0x00,
  0x0F, 0xC1, 0xF0, 0x00, 0x07, 0xE0, 0x38, 0x00, 0x03, 0xF0, 0x08, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xF8, 0x0F, 0xF8, 0x07, 0xF0, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x70, 0x00, 0x0F, 0xC0, 0x10, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x02, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x1F, 0x87, 0xC0,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x1F, 0xC0, 0x7F,
  0xC0, 0x3F, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00,
  0x1F, 0x3E, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0xFC, 0x1F, 0x00,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x07, 0xC0, 0x1E, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0xF0, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x03, 0xC0, 0x07, 0xC0, 0x01, 0xF0, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x3E,
  0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0xC1, 0xFE, 0x00, 0x03, 0xE3, 0xFF, 0xC0, 0x01, 0xE7, 0xFF,
  0xF0, 0x00, 0xF7, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xC0,
  0x7F, 0xC0, 0x3F, 0x80, 0x0F, 0xE0, 0x1F, 0x00, 0x03, 0xF8, 0x03, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7C, 0x02, 0x00, 0x00, 0x3E, 0x07, 0x00, 0x00, 0x3F, 0x07,
  0xC0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x3F, 0x80,
  0x7F, 0x80, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x3E, 0x3F, 0xFE, 0x01, 0xF1, 0xFF, 0xFC,
  0x07, 0xCF, 0xFF, 0xF8, 0x3E, 0x7F, 0xFF, 0xF0, 0xFB, 0xE0, 0x3F, 0xC7,
  0xDC, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0xF9, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00,
  0x3E, 0xF8, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x1F,
  0x3E, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x87,
  0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0x00, 0x00,
  0x1F, 0x9E, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x01,
  0xF1, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x87, 0x80, 0x00, 0x3E,
  0x0F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xF8, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF0,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x01, 0xF8, 0x3E,
  0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x07,
  0xE0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x0F, 0xF0,
  0x07, 0xE0, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x0F,
  0x87, 0xE0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x01,
  0xF9, 0xF0, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00,
  0x3F, 0x3E, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x1F, 0x8F, 0x80, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x0F, 0xE1, 0xFE, 0x00,
  0x0F, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0,
  0x1F, 0xE0, 0xFE, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x3E, 0x1F, 0x80, 0x00,
  0xFC, 0xFC, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x1F,
  0x7C, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07, 0xDF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xF7, 0xC0,
  0x00, 0x0F, 0xDF, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x03, 0xF9, 0xF8, 0x00,
  0x1F, 0xE7, 0xF0, 0x00, 0xEF, 0x8F, 0xF0, 0x0F, 0x7C, 0x3F, 0xFF, 0xF9,
  0xF0, 0x7F, 0xFF, 0xCF, 0x80, 0xFF, 0xFE, 0x3E, 0x00, 0xFF, 0xF1, 0xF8,
  0x00, 0xFF, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0xE0, 0x7F, 0xC1, 0xFF, 0x0F,
  0xFC, 0x3F, 0xE0, 0xFF, 0x81, 0xFC, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x07, 0xF8, 0x1F, 0xF0, 0xFF, 0xC3, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0,
  0xFF, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x1F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x40, 0x1F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x3F, 0xC0, 0x7F, 0x8F,
  0xE0, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xEF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0x9C, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x3F,
  0x00, 0x1F, 0x80, 0xF8, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x00, 0xF1, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x0F, 0xC3, 0xC7, 0x80, 0x3F,
  0xC7, 0x9F, 0x01, 0xFF, 0xCF, 0x3E, 0x07, 0xFF, 0xDE, 0x78, 0x0F, 0xC1,
  0xFC, 0xF0, 0x3E, 0x01, 0xFB, 0xE0, 0x7C, 0x01, 0xE7, 0xC1, 0xF0, 0x03,
  0xCF, 0x83, 0xE0, 0x07, 0x9F, 0x07, 0xC0, 0x0F, 0x3C, 0x1F, 0x00, 0x3E,
  0x78, 0x3E, 0x00, 0x7D, 0xF0, 0x7C, 0x00, 0xF3, 0xE0, 0xF8, 0x01, 0xE7,
  0xC1, 0xF0, 0x03, 0xCF, 0x83, 0xC0, 0x07, 0x9E, 0x07, 0x80, 0x1F, 0x3C,
  0x0F, 0x00, 0x3E, 0x78, 0x1E, 0x00, 0xF8, 0xF0, 0x3C, 0x01, 0xF1, 0xE0,
  0x7C, 0x05, 0xE3, 0xC0, 0xF8, 0x1B, 0xC7, 0x81, 0xFC, 0xFF, 0x8F, 0x01,
  0xFF, 0xDF, 0x1E, 0x03, 0xFF, 0x3E, 0x3C, 0x03, 0xFC, 0x78, 0x78, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x07, 0xBE, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x00, 0x7C, 0xF8, 0x00, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x01,
  0xF0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x01, 0xF0, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x3E, 0x0F, 0xC0,
  0x00, 0x0F, 0x87, 0xE0, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x00, 0xF8, 0x7C,
  0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x01, 0xF7,
  0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0xFE, 0x03, 0xE0, 0x00, 0x3F,
  0x03, 0xE0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F,
  0x07, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3F,
  0x07, 0xC0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x03, 0xF0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x01, 0xF8,
  0x1F, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C,
  0x3F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C,
  0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xFC,
  0x7E, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x01, 0xF8,
  0x7C, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x1F, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0x10, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x80, 0xF8, 0x00, 0x00, 0xE0, 0xF8, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80,
  0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0x80, 0x1F, 0xE0, 0x07, 0xC0, 0x03,
  0xF8, 0x03, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x01, 0xF8, 0x1F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0x80,
  0x00, 0x3F, 0x07, 0xC0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x0F, 0xC1, 0xF0,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7E, 0x0F,
  0x80, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x03, 0xF0,
  0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC,
  0x1F, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x7E,
  0x03, 0xE0, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0xFF, 0x01, 0xF0, 0x01, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0xFF, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0x7E, 0x07, 0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x18, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0xFF, 0xFC, 0xFC, 0x00, 0xFF, 0xFC, 0xFC, 0x01,
  0xFF, 0xF8, 0xFC, 0x01, 0xFF, 0xF8, 0xFC, 0x01, 0xFF, 0xF8, 0xFC, 0x00,
  0x00, 0xF8, 0xFC, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0xF8, 0xF8, 0x00,
  0x00, 0xF0, 0xF8, 0x00, 0x00, 0xF0, 0xFC, 0x00, 0x01, 0xF0, 0xFC, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xF0, 0x7C, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x0F, 0xE0, 0x3F, 0x00,
  0x3B, 0xE0, 0x1F, 0xC0, 0xFB, 0xE0, 0x1F, 0xFF, 0xF3, 0xE0, 0x0F, 0xFF,
  0xE3, 0xC0, 0x03, 0xFF, 0x83, 0xC0, 0x00, 0xFE, 0x04, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x3E, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x3F, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x7C, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3F,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x30, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0xFC, 0x0F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x1F, 0x80, 0x1F,
  0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xFC, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x00, 0x3E, 0x0F,
  0xC0, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0x03, 0xE3, 0xF8, 0x00, 0x00,
  0x0F, 0x9F, 0xF0, 0x00, 0x00, 0x7E, 0xFF, 0xC0, 0x00, 0x01, 0xF7, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x3E, 0x00, 0x00, 0x1F, 0xF8, 0xFC, 0x00, 0x00,
  0x7F, 0xC1, 0xF0, 0x00, 0x01, 0xFE, 0x07, 0xC0, 0x00, 0x0F, 0xF0, 0x1F,
  0x80, 0x00, 0x3F, 0x80, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x0F,
  0xC0, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE0, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xE0,
  0x03, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x07, 0xFE, 0x03,
  0xDE, 0x00, 0x7B, 0xE0, 0x7D, 0xF0, 0x0F, 0xBE, 0x07, 0xDF, 0x00, 0xF3,
  0xC0, 0x7C, 0xF0, 0x1F, 0x7C, 0x07, 0xCF, 0x01, 0xE7, 0xC0, 0x78, 0xF0,
  0x3C, 0x7C, 0x07, 0x8F, 0x87, 0xC7, 0xC0, 0xF8, 0x78, 0x78, 0x7C, 0x0F,
  0x87, 0x8F, 0x87, 0x80, 0xF8, 0x78, 0xF0, 0xF8, 0x0F, 0x87, 0xDF, 0x0F,
  0x80, 0xF0, 0x3D, 0xE0, 0xF8, 0x0F, 0x03, 0xFC, 0x0F, 0x81, 0xF0, 0x3F,
  0xC0, 0xF8, 0x1F, 0x03, 0xF8, 0x0F, 0x01, 0xF0, 0x1F, 0x81, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1F,
  0x03, 0xE0, 0x0C, 0x01, 0xF0, 0x3E, 0x00, 0xC0, 0x1E, 0x03, 0xE0, 0x08,
  0x03, 0xE0, 0x3E, 0x00, 0x80, 0x3E, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x3C,
  0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x3C,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00,
  0x07, 0xC0, 0x78, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0xF8,
  0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x1F, 0xE0,
  0x00, 0x7C, 0x07, 0xFC, 0x00, 0x0F, 0x80, 0xFF, 0x80, 0x01, 0xF0, 0x1F,
  0xF0, 0x00, 0x3E, 0x03, 0xFF, 0x00, 0x07, 0x80, 0x7F, 0xE0, 0x01, 0xF0,
  0x0F, 0x7C, 0x00, 0x3E, 0x03, 0xE7, 0x80, 0x07, 0xC0, 0x7C, 0xF0, 0x00,
  0xF8, 0x0F, 0x9F, 0x00, 0x1F, 0x01, 0xF3, 0xE0, 0x03, 0xC0, 0x3E, 0x7C,
  0x00, 0xF8, 0x07, 0x87, 0x80, 0x1F, 0x01, 0xF0, 0xF8, 0x03, 0xE0, 0x3E,
  0x1F, 0x00, 0x7C, 0x07, 0xC3, 0xE0, 0x0F, 0x80, 0xF8, 0x3C, 0x01, 0xE0,
  0x1F, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x01,
  0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0xF0, 0x0F, 0x80, 0xF8, 0x3E, 0x01, 0xE0, 0x1F, 0x07, 0xC0, 0x7C,
  0x01, 0xE0, 0xF8, 0x0F, 0x80, 0x3C, 0x1F, 0x01, 0xF0, 0x07, 0xC3, 0xE0,
  0x3E, 0x00, 0xF8, 0x78, 0x07, 0xC0, 0x1F, 0x1F, 0x00, 0xF0, 0x01, 0xE3,
  0xE0, 0x3E, 0x00, 0x3E, 0x7C, 0x07, 0xC0, 0x07, 0xCF, 0x80, 0xF8, 0x00,
  0xF9, 0xF0, 0x1F, 0x00, 0x0F, 0x3C, 0x03, 0xE0, 0x01, 0xEF, 0x80, 0x78,
  0x00, 0x3F, 0xF0, 0x1F, 0x00, 0x07, 0xFE, 0x03, 0xE0, 0x00, 0xFF, 0xC0,
  0x7C, 0x00, 0x0F, 0xF8, 0x0F, 0x80, 0x01, 0xFE, 0x01, 0xF0, 0x00, 0x3F,
  0xC0, 0x7C, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0xC0,
  0x00, 0x3F, 0x0F, 0x80, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x1F, 0x1F, 0x00,
  0x00, 0x1F, 0x3F, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x1F, 0x3E, 0x00,
  0x00, 0x1F, 0x3E, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0x3F, 0x7C, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x3F, 0x7C, 0x00,
  0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00,
  0x00, 0x7E, 0xF8, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x7E, 0xF8, 0x00,
  0x00, 0x7C, 0xF8, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0xFC, 0xF8, 0x00,
  0x00, 0xF8, 0xF8, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x01, 0xF8, 0xF8, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE0, 0x7C, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x1F, 0xE0,
  0x3F, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0xF8, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x3F, 0x07, 0xC0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x03, 0xF0, 0x7C, 0x00,
  0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x07, 0xE0, 0xF8, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x01, 0xFC, 0x0F,
  0x80, 0x01, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0xC0, 0x00,
  0x3F, 0x0F, 0x80, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x1F, 0x1F, 0x00, 0x00,
  0x1F, 0x3F, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00,
  0x1F, 0x3E, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0x3F, 0x7C, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00,
  0x3E, 0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00,
  0x7E, 0xF8, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00,
  0x7C, 0xF8, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00,
  0xF8, 0xF8, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x10, 0x00, 0x1F, 0x80, 0x38, 0x00, 0x0F, 0xC0, 0x78, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x0F,
  0x80, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x03, 0xF0,
  0x3E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x0F,
  0xC1, 0xF0, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xF8, 0x00,
  0x03, 0xF0, 0x3E, 0x00, 0x01, 0xFC, 0x0F, 0x80, 0x01, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0x00,
  0x03, 0xF0, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x03, 0xF0, 0x07, 0xC0,
  0x00, 0x7C, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x7F, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x00, 0x60, 0x1F, 0x00, 0x00, 0x08,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x18, 0x00, 0x00,
  0x1F, 0x07, 0x80, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x80,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xE8, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3F,
  0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x3E,
  0x1F, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7E,
  0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x7C,
  0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xFC,
  0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0xF8,
  0x7C, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x01, 0xF8,
  0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x03, 0xF0,
  0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x1F, 0x80,
  0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F,
  0xBE, 0x00, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x03,
  0xE3, 0xC0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x01,
  0xF8, 0x7C, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0x7E, 0x03, 0xC0, 0x00, 0x3E, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x3E, 0x00,
  0x0F, 0x80, 0x1F, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xE0, 0x03, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0x7C,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00,
  0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x07, 0xC7, 0xE0, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x00, 0x79, 0xF0, 0x00,
  0x00, 0x3E, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x78,
  0x00, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x01,
  0xE1, 0xF0, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0xF0, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x3C, 0x03, 0xF0,
  0x07, 0x81, 0xE0, 0x1F, 0x80, 0x7C, 0x0F, 0x00, 0xFE, 0x03, 0xE0, 0xF8,
  0x0F, 0xF0, 0x1F, 0x07, 0xC0, 0x7F, 0x80, 0xF0, 0x3E, 0x07, 0xFC, 0x0F,
  0x81, 0xF0, 0x3D, 0xE0, 0x7C, 0x0F, 0x81, 0xEF, 0x03, 0xE0, 0x7C, 0x1E,
  0x78, 0x1E, 0x03, 0xC0, 0xF3, 0xC0, 0xF0, 0x1E, 0x07, 0x9E, 0x0F, 0x80,
  0xF0, 0x78, 0xF0, 0x7C, 0x07, 0x83, 0xC7, 0x83, 0xC0, 0x3C, 0x3E, 0x3C,
  0x1E, 0x03, 0xE1, 0xE1, 0xE1, 0xF0, 0x1F, 0x0F, 0x0F, 0x0F, 0x80, 0xF8,
  0xF0, 0x78, 0x78, 0x07, 0xC7, 0x83, 0xC3, 0xC0, 0x3E, 0x3C, 0x1E, 0x3E,
  0x01, 0xE3, 0xC0, 0xF1, 0xF0, 0x0F, 0x1E, 0x07, 0x8F, 0x00, 0x78, 0xF0,
  0x3C, 0x78, 0x03, 0xCF, 0x01, 0xE7, 0xC0, 0x1E, 0x78, 0x0F, 0xBE, 0x00,
  0xF7, 0xC0, 0x7D, 0xE0, 0x07, 0xBC, 0x03, 0xEF, 0x00, 0x7D, 0xE0, 0x0F,
  0x78, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0x03, 0xE0,
  0x3F, 0x00, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x00, 0x0F, 0xC3,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x1F, 0x00,
  0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x00, 0x7F, 0x3F, 0x00,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x01, 0xF8,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x01, 0xF8,
  0x07, 0xE0, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00,
  0x3E, 0x0F, 0xC0, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x00, 0xF8, 0xFC, 0x00,
  0x00, 0x0F, 0x9F, 0x00, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0x0F, 0xCF, 0x80, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0xF0,
  0x03, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x3E,
  0x7E, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0x38, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x10, 0x7F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x18, 0xFC, 0x7C, 0x7C, 0x3E, 0x3E, 0x1E, 0x1E,
  0x0F, 0x0F, 0x0F, 0x04, 0x00, 0x1F, 0xC0, 0x7C, 0x03, 0xFF, 0xC1, 0xF0,
  0x1F, 0xFF, 0xC7, 0xC0, 0xFF, 0xFF, 0xBE, 0x07, 0xF8, 0x1E, 0xF8, 0x3F,
  0x00, 0x1F, 0xE1, 0xF8, 0x00, 0x3F, 0x87, 0xC0, 0x00, 0x7E, 0x3F, 0x00,
  0x01, 0xF8, 0xF8, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00,
  0x7C, 0x7C, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x1F,
  0x3E, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x1F, 0x8F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xF0, 0xF8, 0x00,
  0x0F, 0xC3, 0xE0, 0x00, 0x7F, 0x0F, 0x80, 0x03, 0x7C, 0x3F, 0x00, 0x1D,
  0xF0, 0x7E, 0x00, 0xEF, 0x81, 0xFC, 0x0F, 0x3F, 0xF3, 0xFF, 0xFC, 0x7F,
  0x87, 0xFF, 0xE1, 0xFE, 0x0F, 0xFE, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x1F, 0xE0, 0x01, 0xF0,
  0xFF, 0xF0, 0x07, 0xC3, 0xFF, 0xF0, 0x0F, 0x8F, 0xFF, 0xF0, 0x1F, 0x3C,
  0x0F, 0xF0, 0x3E, 0xE0, 0x07, 0xE0, 0x7D, 0x80, 0x07, 0xC0, 0xFE, 0x00,
  0x0F, 0xC3, 0xF8, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x1F, 0x0F, 0xC0, 0x00,
  0x3E, 0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01,
  0xF1, 0xF0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x0F,
  0x8F, 0x80, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0xFC,
  0xF8, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x7E,
  0x00, 0x03, 0xF0, 0xFE, 0x00, 0x0F, 0xC1, 0xF6, 0x00, 0x3F, 0x83, 0xEF,
  0x01, 0xFE, 0x07, 0xCF, 0xFF, 0xF8, 0x0F, 0x8F, 0xFF, 0xE0, 0x3E, 0x0F,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xF8, 0x1F, 0xE0,
  0x7E, 0x00, 0x7E, 0x0F, 0x80, 0x03, 0xE1, 0xF8, 0x00, 0x1F, 0x1F, 0x00,
  0x01, 0x83, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0x0F, 0x80, 0x00, 0x3C, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x7C, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF8, 0x3E, 0x00, 0x7F, 0x03,
  0xF8, 0x0F, 0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x7F, 0x80, 0xF0, 0x00, 0xFF, 0xF0, 0xF8, 0x01,
  0xFF, 0xFC, 0x7C, 0x01, 0xFF, 0xFF, 0x3E, 0x01, 0xFE, 0x03, 0xDF, 0x01,
  0xFC, 0x00, 0x6F, 0x81, 0xF8, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x3E,
  0x0F, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0x7E, 0x07, 0xC0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3F, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0xF8, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x1B, 0xE0, 0x1F, 0x80,
  0x3D, 0xF0, 0x0F, 0xE0, 0x7C, 0xF8, 0x03, 0xFF, 0xFC, 0x78, 0x00, 0xFF,
  0xFC, 0x7C, 0x00, 0x3F, 0xFC, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x0F, 0xCF,
  0x80, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3F, 0x7E, 0x00,
  0x07, 0xF3, 0xE0, 0x01, 0xFF, 0x1F, 0x01, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x10, 0xF8, 0x00, 0x01, 0xC7, 0xC0, 0x00, 0x1F, 0x3F, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x1F, 0xC0, 0x7F, 0x80,
  0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xC0,
  0x03, 0xE0, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0xFC, 0x01, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x00,
  0x03, 0xF0, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x00, 0x3F,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x00, 0x03, 0xF7, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x1F, 0x00, 0x1F, 0xFE, 0x1F, 0x00, 0x7F, 0xFF, 0x1F, 0x00,
  0xFF, 0xFF, 0x9F, 0x01, 0xFE, 0x03, 0xDF, 0x03, 0xF8, 0x00, 0xDF, 0x07,
  0xE0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3E, 0x1F,
  0x00, 0x00, 0x3C, 0x3F, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x7C, 0x3E,
  0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x3E,
  0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x3E,
  0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x03, 0xF8, 0x3E,
  0x00, 0x03, 0xF0, 0x3E, 0x00, 0x06, 0xF0, 0x3F, 0x00, 0x0D, 0xF0, 0x1F,
  0x80, 0x1D, 0xF0, 0x1F, 0xE0, 0x79, 0xF0, 0x0F, 0xFF, 0xF1, 0xF0, 0x07,
  0xFF, 0xE1, 0xE0, 0x03, 0xFF, 0xC3, 0xE0, 0x00, 0xFE, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x30,
  0x00, 0x1F, 0x80, 0x78, 0x00, 0x3F, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0xF8, 0x3F,
  0xF0, 0x07, 0xC7, 0xFF, 0xC0, 0x3E, 0x7F, 0xFF, 0x03, 0xF3, 0xFF, 0xFC,
  0x1F, 0x3C, 0x0F, 0xE0, 0xFB, 0xC0, 0x3F, 0x07, 0xD8, 0x00, 0xFC, 0x3F,
  0x80, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x1F, 0xC0, 0x00, 0xF8, 0xFC, 0x00,
  0x07, 0xC7, 0xE0, 0x00, 0x3C, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0xF8, 0xFC, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3E, 0x3E,
  0x00, 0x01, 0xE1, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F,
  0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x3E,
  0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x78, 0x7C, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x03, 0x00, 0x1F, 0x00,
  0x3C, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x03, 0xF0,
  0x03, 0xE0, 0x3F, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0xF8, 0x7F, 0x00, 0x0F,
  0xC7, 0xF0, 0x00, 0x7C, 0x7E, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x10, 0x00, 0x7C, 0x01, 0xC0,
  0x03, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xF0, 0x0F,
  0x80, 0x0F, 0xC0, 0x7C, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0xFC, 0x1E, 0x00,
  0x03, 0xF1, 0xF0, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x3F, 0x7C, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x7F, 0x00, 0x07, 0xC1, 0xFF, 0xC0, 0x07, 0xC7, 0xFF, 0xE0, 0x07, 0xCF,
  0xFF, 0xF0, 0x0F, 0x9E, 0x07, 0xF0, 0x0F, 0x9C, 0x03, 0xF0, 0x0F, 0xB0,
  0x01, 0xF8, 0x0F, 0xE0, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0xF8, 0x0F, 0xC0,
  0x00, 0xF8, 0x1F, 0x80, 0x01, 0xF0, 0x1F, 0x80, 0x01, 0xF0, 0x1F, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x07, 0xC0, 0x1F, 0x00,
  0x1F, 0x80, 0x3E, 0x00, 0x7F, 0x00, 0x3E, 0x01, 0xFC, 0x00, 0x3E, 0x0F,
  0xF0, 0x00, 0x3E, 0x3F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3E, 0x1F,
  0x00, 0x00, 0x7C, 0x0F, 0x80, 0x08, 0x7C, 0x0F, 0x80, 0x0E, 0x7C, 0x0F,
  0xC0, 0x1F, 0x7C, 0x07, 0xC0, 0x3E, 0x7C, 0x07, 0xE0, 0x7C, 0x7C, 0x03,
  0xE0, 0xF8, 0xF8, 0x03, 0xE3, 0xF0, 0xF8, 0x01, 0xF7, 0xE0, 0xF8, 0x01,
  0xFF, 0xC0, 0xF8, 0x00, 0xFF, 0x80, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0xC0, 0x7E, 0x00, 0x78, 0x1F, 0x00, 0x3F, 0x07,
  0xC0, 0x1F, 0x81, 0xF0, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x1F, 0x03, 0xF0,
  0x0F, 0x83, 0xF0, 0x03, 0xE1, 0xF8, 0x00, 0xF8, 0xFC, 0x00, 0x3E, 0x7E,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC3, 0xE0, 0x1F, 0x00, 0xF9, 0xFE, 0x0F, 0xF0, 0x1E,
  0x7F, 0xC3, 0xFF, 0x03, 0xCF, 0xFC, 0xFF, 0xE0, 0xFB, 0x0F, 0x98, 0x7E,
  0x1F, 0xC0, 0xF6, 0x07, 0xC3, 0xF0, 0x1E, 0x80, 0xF8, 0x7C, 0x03, 0xF0,
  0x1F, 0x0F, 0x80, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x80, 0x7C, 0x7C, 0x01,
  0xE0, 0x0F, 0x0F, 0x80, 0x3C, 0x01, 0xE1, 0xF0, 0x0F, 0x80, 0x7C, 0x3E,
  0x01, 0xF0, 0x0F, 0x87, 0x80, 0x3E, 0x01, 0xF0, 0xF0, 0x07, 0x80, 0x3E,
  0x3E, 0x00, 0xF0, 0x07, 0x87, 0xC0, 0x1E, 0x00, 0xF0, 0xF8, 0x07, 0xC0,
  0x3E, 0x1F, 0x00, 0xF8, 0x07, 0xC3, 0xC0, 0x1F, 0x00, 0xF8, 0x78, 0x03,
  0xC0, 0x1F, 0x1F, 0x00, 0x78, 0x03, 0xC3, 0xE0, 0x0F, 0x00, 0x78, 0x7C,
  0x03, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x03, 0xE1, 0xE0, 0x0F, 0x80, 0x7C,
  0x3C, 0x01, 0xE0, 0x0F, 0x8F, 0x80, 0x3C, 0x01, 0xE1, 0xF0, 0x0F, 0x80,
  0x3C, 0x3E, 0x01, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x01, 0xF0, 0xF0, 0x07,
  0xC0, 0x3E, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x3E, 0x0F, 0xFC, 0x01, 0xF1,
  0xFF, 0xF0, 0x0F, 0x9F, 0xFF, 0xC0, 0xF8, 0xE0, 0x7F, 0x07, 0xCE, 0x01,
  0xF8, 0x3E, 0xC0, 0x07, 0xC1, 0xF4, 0x00, 0x3F, 0x0F, 0xE0, 0x01, 0xF8,
  0x7E, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x01, 0xF1, 0xF0,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x3E, 0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x78,
  0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF1, 0xF0,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xC3, 0xE0, 0x00,
  0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C,
  0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1E, 0x1F, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x80,
  0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0xF8, 0xFC, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x1F,
  0x7C, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x07, 0xEF, 0x80, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x1F, 0x80, 0x03, 0xF0,
  0x3F, 0x00, 0x1F, 0x80, 0x7F, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xF8, 0x1F, 0xE0, 0x00, 0xF8, 0x3F, 0xFC, 0x00, 0x7C, 0x3F, 0xFF, 0x00,
  0x3E, 0x3F, 0xFF, 0xC0, 0x1F, 0x3C, 0x0F, 0xF0, 0x0F, 0xB8, 0x01, 0xF8,
  0x07, 0xD8, 0x00, 0x7C, 0x03, 0xF8, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x0F,
  0x81, 0xF8, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x03, 0xF0, 0xF8, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00,
  0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xE0,
  0x00, 0x3F, 0x03, 0xF8, 0x00, 0x3F, 0x01, 0xF6, 0x00, 0x3F, 0x80, 0xFB,
  0xC0, 0x7F, 0x80, 0x7C, 0xFF, 0xFF, 0x80, 0x3E, 0x3F, 0xFF, 0x80, 0x3E,
  0x0F, 0xFF, 0x00, 0x1F, 0x01, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x7C, 0x01, 0xFF, 0xE1, 0xF0, 0x1F, 0xFF, 0xC7, 0xC0, 0xFF, 0xFF, 0x9F,
  0x07, 0xF8, 0x0F, 0x7C, 0x3F, 0x80, 0x0D, 0xF1, 0xF8, 0x00, 0x1F, 0x87,
  0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x03, 0xE7, 0xE0,
  0x00, 0x0F, 0x9F, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0xF1, 0xF0, 0x00,
  0x07, 0xCF, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0xF8,
  0xF8, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7E, 0x3E,
  0x00, 0x01, 0xF8, 0xF8, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x3F, 0x0F, 0x80,
  0x01, 0xFC, 0x3F, 0x00, 0x0D, 0xF0, 0x7E, 0x00, 0xF7, 0xC1, 0xFC, 0x0F,
  0x9F, 0x03, 0xFF, 0xFC, 0x78, 0x07, 0xFF, 0xE3, 0xE0, 0x0F, 0xFF, 0x0F,
  0x80, 0x0F, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0x00, 0x7C, 0xFF, 0xF8, 0x01, 0xF7, 0xC0,
  0x00, 0x07, 0xDC, 0x00, 0x00, 0x3E, 0xC0, 0x00, 0x00, 0xFB, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x7E, 0x00, 0x1F, 0xC1, 0xF0, 0x00, 0x0E, 0x03, 0xE0, 0x00,
  0x08, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x20, 0x00, 0x03, 0xE0, 0xE0,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x0F, 0xF0, 0x00, 0x7E, 0x0F, 0xF8,
  0x03, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x04, 0x03, 0xE0,
  0x00, 0xE0, 0x3E, 0x00, 0x3F, 0x03, 0xE0, 0x07, 0xF0, 0x3E, 0x01, 0xFC,
  0x03, 0xE0, 0x3F, 0x80, 0x3E, 0x07, 0xF0, 0x07, 0xE1, 0xFC, 0x00, 0x7C,
  0x3F, 0x80, 0x07, 0xEF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF1, 0xF0,
  0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x3E, 0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C,
  0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF0,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x7C,
  0x7C, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x3F, 0x1F, 0x00, 0x03, 0xF0, 0xF8,
  0x00, 0x1F, 0x87, 0xC0, 0x01, 0xFC, 0x3F, 0x00, 0x1B, 0xE0, 0xF8, 0x01,
  0xDF, 0x07, 0xE0, 0x1C, 0xF8, 0x3F, 0x81, 0xCF, 0x80, 0xFF, 0xFE, 0x7C,
  0x03, 0xFF, 0xE3, 0xE0, 0x0F, 0xFC, 0x1F, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x31, 0xFF, 0xC0, 0x07, 0xEF, 0xFF, 0x00, 0x0F, 0xBF,
  0xFC, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0xFC, 0x07, 0xC0, 0x01, 0xF0, 0x1F,
  0x00, 0x07, 0xC0, 0x78, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80,
  0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x3C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xF0, 0x1E, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x7E, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x80, 0x0F, 0x80, 0x3E, 0x00,
  0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x3F, 0x80, 0x0F, 0x03, 0xFC,
  0x00, 0x3C, 0x3F, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x06,
  0x07, 0x80, 0x3C, 0x0F, 0x87, 0xC0, 0x3E, 0x07, 0xC3, 0xE0, 0x1F, 0x01,
  0xE1, 0xF0, 0x0F, 0x00, 0xF0, 0xF0, 0x07, 0x80, 0x78, 0x78, 0x03, 0xC0,
  0x3E, 0x3C, 0x01, 0xE0, 0x1F, 0x3E, 0x01, 0xF0, 0x0F, 0x9F, 0x00, 0xF8,
  0x07, 0xCF, 0x80, 0x78, 0x03, 0xE7, 0x80, 0x3C, 0x01, 0xF3, 0xC0, 0x1E,
  0x00, 0xF9, 0xE0, 0x0F, 0x00, 0x7D, 0xF0, 0x0F, 0x80, 0x3C, 0xF8, 0x07,
  0xC0, 0x1E, 0x7C, 0x03, 0xE0, 0x0F, 0x3C, 0x01, 0xE0, 0x07, 0x9E, 0x00,
  0xF0, 0x07, 0xCF, 0x00, 0x78, 0x03, 0xEF, 0x80, 0x7C, 0x01, 0xE7, 0xC0,
  0x3E, 0x00, 0xF3, 0xE0, 0x1F, 0x00, 0xF9, 0xF0, 0x0F, 0x00, 0x7C, 0xF0,
  0x0F, 0x80, 0x3C, 0x78, 0x07, 0xC0, 0x3E, 0x3C, 0x03, 0xE0, 0x1E, 0x1E,
  0x03, 0x70, 0x1F, 0x0F, 0x83, 0xBC, 0x1F, 0x07, 0xC3, 0x9E, 0x1F, 0x83,
  0xFF, 0x8F, 0xFF, 0x80, 0xFF, 0xC7, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x00,
  0x0F, 0x80, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x00, 0xFF,
  0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0xE1, 0xFF, 0xF0,
  0x3F, 0xCF, 0x1F, 0x1F, 0x83, 0xF8, 0x78, 0xE0, 0x7C, 0x3F, 0x83, 0xCF,
  0x01, 0xE3, 0xF0, 0x1E, 0x70, 0x0F, 0x0E, 0x00, 0xF3, 0x00, 0x78, 0x60,
  0x07, 0xB8, 0x03, 0xC0, 0x00, 0x1D, 0x80, 0x1E, 0x00, 0x00, 0xFC, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xE0,
  0x07, 0xE0, 0x00, 0x0F, 0x00, 0x7F, 0x00, 0x10, 0xF8, 0x03, 0x78, 0x01,
  0x87, 0xC0, 0x3B, 0xC0, 0x1E, 0x3E, 0x01, 0xDF, 0x03, 0xF9, 0xF0, 0x1C,
  0xF8, 0x3F, 0x07, 0xC1, 0xE3, 0xC7, 0xF0, 0x3E, 0x1F, 0x1E, 0x7F, 0x01,
  0xFF, 0xF0, 0xFF, 0xF0, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x1F,
  0xE0, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x0F,
  0x80, 0x00, 0x78, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF8, 0x1F,
  0x00, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xF0, 0x1F,
  0x80, 0x05, 0xF0, 0x0F, 0x80, 0x0D, 0xF0, 0x0F, 0xC0, 0x39, 0xF0, 0x0F,
  0xE0, 0x79, 0xE0, 0x07, 0xFF, 0xF3, 0xE0, 0x03, 0xFF, 0xE3, 0xE0, 0x01,
  0xFF, 0xC3, 0xE0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x30, 0x00, 0x1F, 0x00, 0x78,
  0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x1F, 0x00, 0xFF, 0xF8, 0x1F, 0x03, 0xFF, 0xFE, 0x1F, 0x07,
  0xFF, 0xFF, 0x9F, 0x07, 0xC0, 0xFF, 0xFF, 0x0F, 0x80, 0x1F, 0xFE, 0x0F,
  0x00, 0x07, 0xFC, 0x0F, 0x00, 0x01, 0xF8, 0x0F, 0x00, 0x03, 0xF0, 0x1F,
  0x00, 0x07, 0xE0, 0x1F, 0x00, 0x0F, 0xC0, 0x1E, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x20, 0x00, 0x7E, 0x00, 0xF0, 0x00,
  0xFC, 0x00, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0xF8, 0x07,
  0xE0, 0x00, 0x78, 0x0F, 0xC0, 0x00, 0x7C, 0x1F, 0xC0, 0x00, 0x7C, 0x3F,
  0xFC, 0x00, 0x7C, 0x7F, 0xFF, 0xE0, 0x3C, 0x7C, 0x7F, 0xFE, 0x3C, 0x7C,
  0x0F, 0xFF, 0xFC, 0xF8, 0x01, 0xFF, 0xF8, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01,
  0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x06, 0x01, 0xFF,
  0x00, 0x07, 0xC1, 0xFF, 0xC0, 0x03, 0xC1, 0xFF, 0xF0, 0x01, 0xE1, 0xF8,
  0xFC, 0x01, 0xF0, 0xF8, 0x3E, 0x00, 0xF0, 0xF8, 0x0F, 0x80, 0xF8, 0x78,
  0x03, 0xE0, 0xF8, 0x7C, 0x01, 0xF8, 0xF8, 0x3C, 0x00, 0x7F, 0xFC, 0x3E,
  0x00, 0x1F, 0xFC, 0x1E, 0x00, 0x07, 0xFC, 0x03, 0x00, 0x01, 0xF8, 0x00,
};

const GFXglyph IBMPlexMono_Italic63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 14, 45, 38, 12, -44 },
  { 80, 19, 17, 38, 13, -47 },
  { 121, 38, 44, 38, 1, -44 },
  { 330, 36, 58, 38, 1, -51 },
  { 591, 43, 46, 38, -2, -45 },
  { 839, 37, 46, 38, 0, -45 },
  { 1052, 7, 17, 38, 19, -47 },
  { 1067, 23, 57, 38, 13, -48 },
  { 1231, 23, 57, 38, 3, -48 },
  { 1395, 31, 31, 38, 4, -35 },
  { 1516, 31, 30, 38, 4, -34 },
  { 1633, 14, 18, 38, 9, -9 },
  { 1665, 19, 5, 38, 10, -22 },
  { 1677, 10, 9, 38, 12, -8 },
  { 1689, 35, 57, 38, 2, -48 },
  { 1939, 32, 46, 38, 4, -45 },
  { 2123, 30, 44, 38, 3, -44 },
  { 2288, 33, 45, 38, 2, -45 },
  { 2474, 33, 46, 38, 2, -45 },
  { 2664, 34, 44, 38, 1, -44 },
  { 2851, 33, 45, 38, 3, -44 },
  { 3037, 30, 45, 38, 4, -44 },
  { 3206, 31, 44, 38, 7, -44 },
  { 3377, 33, 46, 38, 3, -45 },
  { 3567, 30, 45, 38, 5, -45 },
  { 3736, 14, 34, 38, 12, -33 },
  { 3796, 17, 42, 38, 9, -33 },
  { 3886, 30, 36, 38, 6, -37 },
  { 4021, 33, 17, 38, 3, -28 },
  { 4092, 30, 36, 38, 3, -37 },
  { 4227, 27, 46, 38, 8, -45 },
  { 4383, 31, 52, 38, 4, -45 },
  { 4585, 34, 44, 38, -1, -44 },
  { 4772, 32, 44, 38, 3, -44 },
  { 4948, 32, 46, 38, 5, -45 },
  { 5132, 33, 44, 38, 3, -44 },
  { 5314, 34, 44, 38, 3, -44 },
  { 5501, 35, 44, 38, 3, -44 },
  { 5694, 32, 46, 38, 4, -45 },
  { 5878, 35, 44, 38, 2, -44 },
  { 6071, 34, 44, 38, 3, -44 },
  { 6258, 31, 45, 38, 4, -44 },
  { 6433, 38, 44, 38, 3, -44 },
  { 6642, 27, 44, 38, 5, -44 },
  { 6791, 36, 44, 38, 2, -44 },
  { 6989, 35, 44, 38, 2, -44 },
  { 7182, 32, 46, 38, 4, -45 },
  { 7366, 34, 44, 38, 3, -44 },
  { 7553, 32, 57, 38, 4, -45 },
  { 7781, 34, 44, 38, 3, -44 },
  { 7968, 35, 46, 38, 2, -45 },
  { 8170, 36, 44, 38, 5, -44 },
  { 8368, 32, 45, 38, 5, -44 },
  { 8548, 33, 44, 38, 7, -44 },
  { 8730, 37, 44, 38, 3, -44 },
  { 8934, 42, 44, 38, -1, -44 },
  { 9165, 35, 44, 38, 6, -44 },
  { 9358, 38, 44, 38, 0, -44 },
  { 9567, 27, 57, 38, 10, -48 },
  { 9760, 17, 57, 38, 11, -48 },
  { 9882, 26, 57, 38, 1, -48 },
  { 10068, 32, 26, 38, 4, -44 },
  { 10172, 31, 5, 38, 0, 6 },
  { 10192, 8, 12, 38, 14, -49 },
  { 10204, 30, 34, 38, 4, -33 },
  { 10332, 31, 48, 38, 3, -47 },
  { 10518, 28, 34, 38, 5, -33 },
  { 10637, 33, 48, 38, 4, -47 },
  { 10835, 29, 34, 38, 5, -33 },
  { 10959, 41, 60, 38, -1, -47 },
  { 11267, 32, 46, 38, 2, -33 },
  { 11451, 29, 47, 38, 4, -47 },
  { 11622, 29, 48, 38, 5, -47 },
  { 11796, 29, 60, 38, 4, -47 },
  { 12014, 32, 48, 38, 4, -47 },
  { 12206, 26, 48, 38, 7, -47 },
  { 12362, 35, 33, 38, 1, -33 },
  { 12507, 29, 33, 38, 4, -33 },
  { 12627, 30, 34, 38, 4, -33 },
  { 12755, 33, 46, 38, 1, -33 },
  { 12945, 30, 46, 38, 4, -33 },
  { 13118, 30, 33, 38, 7, -33 },
  { 13242, 31, 34, 38, 3, -33 },
  { 13374, 28, 45, 38, 5, -44 },
  { 13532, 29, 34, 38, 5, -33 },
  { 13656, 30, 34, 38, 4, -33 },
  { 13784, 33, 34, 38, 3, -33 },
  { 13925, 37, 34, 38, 0, -33 },
  { 14083, 32, 46, 38, 2, -33 },
  { 14267, 32, 34, 38, 3, -33 },
  { 14403, 29, 57, 38, 7, -48 },
  { 14610, 13, 57, 38, 13, -48 },
  { 14703, 29, 57, 38, 3, -48 },
  { 14910, 33, 13, 38, 3, -26 },
};

const GFXfont IBMPlexMono_Italic63pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic63pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic63pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _IBMPLEXMONO_ITALIC63PT7B_H_
