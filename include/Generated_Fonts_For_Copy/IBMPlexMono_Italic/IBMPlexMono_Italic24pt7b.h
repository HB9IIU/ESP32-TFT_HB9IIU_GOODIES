#ifndef _IBMPLEXMONO_ITALIC24PT7B_H_
#define _IBMPLEXMONO_ITALIC24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xCE, 0x63, 0x18, 0xC4, 0x21, 0x08, 0x00, 0x03, 0x9C, 0xE0,
  0x66, 0xCD, 0x9A, 0x3C, 0x59, 0xB3, 0x00, 0x01, 0x8C, 0x03, 0x30, 0x0C,
  0x60, 0x18, 0x80, 0x33, 0x07, 0xC7, 0xCF, 0x8F, 0x83, 0x30, 0x0C, 0x60,
  0x18, 0x83, 0xF3, 0xE7, 0xC7, 0xC1, 0x88, 0x03, 0x30, 0x0C, 0x60, 0x18,
  0x80, 0x33, 0x00, 0x00, 0x80, 0x0C, 0x01, 0xF0, 0x3F, 0xE3, 0x93, 0x98,
  0x89, 0x8C, 0x0E, 0x60, 0x33, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x67,
  0x03, 0x18, 0x18, 0xD8, 0x8C, 0xE4, 0xE3, 0xFE, 0x07, 0xC0, 0x18, 0x00,
  0x80, 0x00, 0x07, 0x81, 0x87, 0xC1, 0x86, 0x31, 0x82, 0x18, 0x81, 0x0C,
  0xC0, 0x8C, 0xC0, 0x7E, 0xC0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x01,
  0xBF, 0x01, 0x98, 0xC0, 0x98, 0x60, 0xCC, 0x30, 0xC6, 0x30, 0xC1, 0xF8,
  0xE0, 0x70, 0x00, 0x03, 0xC0, 0x3F, 0x80, 0xC7, 0x03, 0x0C, 0x08, 0x30,
  0x30, 0xC0, 0xC6, 0x03, 0xB8, 0x3F, 0x81, 0x98, 0x0C, 0x30, 0x30, 0x60,
  0xC1, 0x8B, 0x07, 0x3E, 0x2D, 0x9F, 0x9E, 0x3C, 0x70, 0x6D, 0xAD, 0xB0,
  0x03, 0x83, 0x03, 0x03, 0x01, 0x01, 0x81, 0x80, 0xC0, 0x40, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x40, 0x30, 0x18, 0x06, 0x01, 0x80,
  0x0C, 0x03, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x06, 0x06, 0x0E, 0x00,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x72, 0x3F, 0xFF, 0x0F, 0x00, 0xF0,
  0x19, 0x03, 0x98, 0x70, 0xC2, 0x08, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x41, 0xFF, 0xFF, 0xF8, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x00, 0x3C,
  0xE3, 0x1C, 0x63, 0x00, 0xFF, 0xFC, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x80,
  0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x00, 0x18,
  0x00, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01,
  0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x07, 0xC0, 0x7F, 0x87, 0x0C,
  0x70, 0x63, 0x01, 0xB0, 0x0D, 0x80, 0x6C, 0xE3, 0x67, 0x33, 0x39, 0xB0,
  0x0D, 0x80, 0x64, 0x06, 0x30, 0x31, 0x87, 0x07, 0xF0, 0x1F, 0x00, 0x03,
  0xC0, 0x78, 0x0F, 0x83, 0xD8, 0x79, 0x82, 0x18, 0x41, 0x80, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x0F, 0xFF, 0xFF,
  0xE0, 0x07, 0xC0, 0xFE, 0x18, 0x73, 0x03, 0x30, 0x30, 0x03, 0x00, 0x30,
  0x06, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0F,
  0xFE, 0xFF, 0xE0, 0x07, 0xC0, 0xFE, 0x18, 0x73, 0x03, 0x00, 0x30, 0x03,
  0x00, 0xE0, 0xFC, 0x0F, 0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x6C, 0x0E,
  0xE1, 0xC7, 0xF8, 0x3F, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x3C, 0x03, 0x60,
  0x13, 0x01, 0x98, 0x18, 0xC1, 0x86, 0x18, 0x60, 0x83, 0x0C, 0x18, 0xC0,
  0xC7, 0xFF, 0xFF, 0xFC, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x1F, 0xF8, 0xFF,
  0x86, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xDE, 0x07, 0xFC, 0x30, 0x60,
  0x03, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x20, 0x33, 0x83, 0x0F, 0xF8, 0x1F,
  0x00, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x37, 0xC6,
  0xFE, 0x70, 0x76, 0x03, 0x60, 0x3C, 0x03, 0xC0, 0x76, 0x06, 0x60, 0xC3,
  0xFC, 0x1F, 0x00, 0x7F, 0xF7, 0xFF, 0x60, 0x36, 0x06, 0x40, 0x68, 0x0C,
  0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0x80,
  0x18, 0x03, 0x00, 0x70, 0x00, 0x07, 0xE0, 0xFF, 0x86, 0x0E, 0x60, 0x33,
  0x01, 0x98, 0x18, 0xE1, 0xC3, 0xF8, 0x1F, 0xC3, 0x83, 0x18, 0x0D, 0x80,
  0x6C, 0x03, 0x60, 0x3B, 0x83, 0x8F, 0xF8, 0x3F, 0x00, 0x0F, 0x87, 0xF9,
  0xC3, 0xB0, 0x3C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xE1, 0xEF, 0xF8, 0xF3,
  0x00, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x00, 0x3B, 0xDC, 0x00,
  0x00, 0x00, 0x00, 0x39, 0xCE, 0x00, 0x0E, 0x3C, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF1, 0xC3, 0x0E, 0x18, 0x60, 0x00, 0x10, 0x06, 0x01,
  0xE0, 0x78, 0x1E, 0x07, 0x80, 0xE0, 0x0C, 0x00, 0x70, 0x03, 0xC0, 0x0E,
  0x00, 0x38, 0x01, 0xC0, 0x08, 0x7F, 0xFB, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x20, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03,
  0x80, 0x0E, 0x00, 0x70, 0x06, 0x01, 0xC0, 0x78, 0x1E, 0x07, 0x80, 0xE0,
  0x08, 0x00, 0x1F, 0x0F, 0xE7, 0x1F, 0x83, 0x40, 0xC0, 0x30, 0x0C, 0x0E,
  0x1F, 0x06, 0x01, 0x80, 0x60, 0x00, 0x00, 0x03, 0x81, 0xE0, 0x70, 0x00,
  0x07, 0xC0, 0xFE, 0x1C, 0x33, 0x03, 0x30, 0x12, 0x1D, 0x63, 0xD6, 0x63,
  0x66, 0x36, 0xC3, 0x4C, 0x3C, 0xC2, 0xCC, 0x6C, 0xFE, 0xC7, 0x64, 0x00,
  0x60, 0x07, 0x00, 0x3F, 0x81, 0xF8, 0x01, 0xC0, 0x0F, 0x00, 0x58, 0x06,
  0xC0, 0x26, 0x03, 0x30, 0x11, 0x81, 0x8C, 0x0C, 0x30, 0xC1, 0x87, 0xFC,
  0x7F, 0xE3, 0x03, 0x30, 0x19, 0x80, 0xDC, 0x06, 0xC0, 0x18, 0x1F, 0xE1,
  0xFF, 0x30, 0x33, 0x03, 0x30, 0x33, 0x03, 0x30, 0x63, 0xFC, 0x7F, 0xC6,
  0x06, 0x60, 0x36, 0x03, 0x60, 0x36, 0x06, 0x40, 0xEF, 0xFC, 0xFF, 0x80,
  0x07, 0xC1, 0xFE, 0x38, 0x63, 0x03, 0x60, 0x26, 0x00, 0xE0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x6C, 0x0C, 0xE1, 0xC7, 0xF8,
  0x3E, 0x00, 0x1F, 0xC0, 0xFF, 0x06, 0x1C, 0x30, 0x63, 0x03, 0x18, 0x0C,
  0xC0, 0x66, 0x06, 0x30, 0x31, 0x81, 0x98, 0x0C, 0xC0, 0x66, 0x06, 0x30,
  0x31, 0x87, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0xC6, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0xFE, 0x3F, 0xE3, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x1F, 0xF8,
  0xFF, 0xC6, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0xFE, 0x3F,
  0xE3, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00,
  0xC0, 0x00, 0x07, 0x81, 0xFC, 0x38, 0x67, 0x07, 0x60, 0x4E, 0x00, 0xC0,
  0x0C, 0x00, 0xC7, 0xEC, 0x7E, 0xC0, 0x6C, 0x0C, 0xC0, 0xCC, 0x0C, 0xE3,
  0xC7, 0xEC, 0x3C, 0xC0, 0x18, 0x19, 0x80, 0xCC, 0x06, 0x60, 0x33, 0x03,
  0x18, 0x18, 0xC0, 0xCF, 0xFE, 0x7F, 0xF3, 0x01, 0x98, 0x18, 0xC0, 0xC6,
  0x06, 0x60, 0x33, 0x01, 0x98, 0x0C, 0xC0, 0xE0, 0x1F, 0xF8, 0xFF, 0xC0,
  0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x1F, 0xFC, 0xFF, 0xC0,
  0x0F, 0xF0, 0xFF, 0x00, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x40, 0xCE, 0x0C, 0x61, 0xC7, 0xF8,
  0x1F, 0x00, 0x18, 0x1C, 0x60, 0xE3, 0x07, 0x0C, 0x18, 0x30, 0xC0, 0xC6,
  0x03, 0x30, 0x0D, 0x80, 0x6F, 0x01, 0xEC, 0x07, 0x18, 0x18, 0x60, 0x60,
  0xC1, 0x83, 0x0C, 0x0E, 0x30, 0x18, 0xC0, 0x70, 0x18, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x30, 0x0C, 0x03, 0xFF, 0xFF, 0xC0, 0x38, 0x1C, 0xE0, 0xE3, 0x83, 0x8F,
  0x1E, 0x2C, 0x58, 0xB3, 0x66, 0x59, 0x19, 0xEC, 0x67, 0x31, 0x98, 0xC4,
  0x23, 0x11, 0x0C, 0xC0, 0x23, 0x01, 0x8C, 0x06, 0x30, 0x18, 0xC0, 0x60,
  0x1C, 0x19, 0xE0, 0xCF, 0x06, 0x68, 0x33, 0x61, 0x1B, 0x18, 0xD8, 0xCC,
  0xC6, 0x62, 0x33, 0x19, 0x98, 0xC8, 0xC6, 0xC6, 0x16, 0x60, 0xF3, 0x07,
  0x98, 0x3C, 0xC1, 0xE0, 0x07, 0xC0, 0x7F, 0x87, 0x0C, 0x70, 0x63, 0x01,
  0xB0, 0x0D, 0x80, 0x6C, 0x07, 0x60, 0x33, 0x01, 0xB8, 0x0D, 0x80, 0x64,
  0x06, 0x30, 0x31, 0xC7, 0x07, 0xF0, 0x1F, 0x00, 0x1F, 0xE0, 0xFF, 0x86,
  0x0E, 0x60, 0x33, 0x01, 0x98, 0x0C, 0xC0, 0xE6, 0x06, 0x3F, 0xF3, 0xFE,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x00,
  0x07, 0xC0, 0x7F, 0x87, 0x0C, 0x70, 0x63, 0x01, 0xB0, 0x0D, 0x80, 0x6C,
  0x07, 0x60, 0x33, 0x01, 0xB8, 0x0D, 0x80, 0x64, 0x06, 0x30, 0x31, 0xC7,
  0x07, 0xF0, 0x1F, 0x00, 0x30, 0x01, 0x8C, 0x06, 0xE0, 0x3E, 0x00, 0xE0,
  0x1F, 0xE0, 0xFF, 0x86, 0x0E, 0x60, 0x33, 0x01, 0x98, 0x0C, 0xC0, 0xE6,
  0x06, 0x3F, 0xE3, 0xFE, 0x18, 0xC0, 0xC3, 0x06, 0x18, 0x30, 0xE1, 0x83,
  0x18, 0x18, 0xC0, 0x60, 0x07, 0xC0, 0xFF, 0x8E, 0x0E, 0x60, 0x27, 0x00,
  0x18, 0x00, 0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60,
  0x03, 0x60, 0x33, 0x83, 0x8F, 0xF8, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0x30, 0x36, 0x03, 0x60, 0x36, 0x03, 0x60, 0x66, 0x06, 0x60,
  0x6C, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0xCC, 0x0C, 0xC0, 0xCC, 0x0C, 0xC1,
  0x8F, 0xF8, 0x3E, 0x00, 0xC0, 0x3C, 0x07, 0xC0, 0x6C, 0x06, 0xC0, 0xCC,
  0x0C, 0xC1, 0x84, 0x18, 0x63, 0x06, 0x30, 0x62, 0x06, 0x60, 0x66, 0x06,
  0xC0, 0x2C, 0x03, 0x80, 0x38, 0x00, 0x20, 0x0D, 0x80, 0x36, 0x00, 0xD8,
  0x02, 0x63, 0x19, 0x9C, 0x66, 0x71, 0x99, 0x44, 0x6D, 0x31, 0x36, 0xC4,
  0x9B, 0x16, 0x6C, 0xD9, 0xA3, 0x47, 0x8F, 0x1E, 0x3C, 0x78, 0xE1, 0xC0,
  0x18, 0x06, 0x38, 0x18, 0x30, 0x60, 0x61, 0xC0, 0x63, 0x00, 0xCC, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1B, 0x00, 0x66, 0x01, 0x86,
  0x07, 0x0C, 0x0C, 0x0C, 0x30, 0x18, 0xC0, 0x38, 0xC0, 0x1D, 0x80, 0xE6,
  0x03, 0x0C, 0x18, 0x30, 0xC0, 0xC7, 0x01, 0x98, 0x06, 0xC0, 0x0E, 0x00,
  0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0x1F, 0xFE, 0x3F, 0xF8, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x1F, 0xC7,
  0xF1, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x03, 0xF8, 0xFE,
  0x00, 0xC0, 0x81, 0x03, 0x06, 0x04, 0x08, 0x18, 0x30, 0x20, 0x40, 0x81,
  0x83, 0x02, 0x04, 0x0C, 0x18, 0x10, 0x20, 0x60, 0x0F, 0xC3, 0xF0, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x01, 0x80, 0x60, 0x18, 0x04, 0x01,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x23, 0xF8, 0xFE, 0x00, 0x03,
  0x00, 0x78, 0x0D, 0x81, 0x8C, 0x18, 0xC3, 0x0C, 0x60, 0x66, 0x06, 0xC0,
  0x38, 0x02, 0xFF, 0xFF, 0xFF, 0x4E, 0x62, 0x30, 0x0F, 0x33, 0xFB, 0x30,
  0x76, 0x06, 0x60, 0x66, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0xC6, 0x1C, 0x7E,
  0xF3, 0xC7, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x33,
  0xC3, 0x7E, 0x3C, 0x73, 0x03, 0x70, 0x36, 0x03, 0x60, 0x36, 0x03, 0x60,
  0x65, 0x0E, 0xDF, 0xCC, 0xF8, 0x0F, 0x07, 0xF9, 0xC3, 0x30, 0x3C, 0x01,
  0x80, 0x30, 0x06, 0x06, 0xC0, 0xDC, 0x71, 0xFC, 0x1F, 0x00, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x3C, 0xC3, 0xF6, 0x30,
  0x73, 0x01, 0x18, 0x08, 0xC0, 0xCC, 0x06, 0x60, 0x33, 0x03, 0x8C, 0x28,
  0x7F, 0xC1, 0xE6, 0x00, 0x0F, 0x87, 0xF9, 0xC3, 0xA0, 0x3C, 0x1D, 0xFF,
  0x3F, 0x86, 0x00, 0xC0, 0xDC, 0x39, 0xFE, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0xFC, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x07, 0xFF, 0x8F, 0xFE,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x01, 0x06, 0x03, 0x18, 0x07, 0x30, 0x07, 0x60,
  0x07, 0xC0, 0x07, 0x00, 0x00, 0x0F, 0x31, 0xFB, 0x38, 0x76, 0x03, 0x60,
  0x26, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0xE6, 0x16, 0x7F, 0xC3, 0xCC, 0x00,
  0xC0, 0x1C, 0xC3, 0x8F, 0xF0, 0x7E, 0x00, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x70, 0x0C, 0xF1, 0xBF, 0x34, 0x67, 0x0C, 0xC1, 0xB8, 0x36,
  0x06, 0xC0, 0xD8, 0x1B, 0x03, 0x60, 0xD8, 0x18, 0x07, 0x00, 0xE0, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x87, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x04,
  0x01, 0x84, 0x31, 0xC6, 0x70, 0xDC, 0x1F, 0x03, 0x80, 0x00, 0x60, 0x07,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x84, 0x30,
  0x63, 0x0F, 0x30, 0x3B, 0x01, 0xF0, 0x0E, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xCF, 0x06, 0xFC, 0x3C, 0x61, 0xC1,
  0x0C, 0x18, 0xE3, 0x86, 0xF8, 0x33, 0x09, 0x98, 0xCC, 0x6F, 0x63, 0xE6,
  0x0E, 0x00, 0xFC, 0x3F, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x8C, 0x76, 0x71, 0xB8, 0x7C, 0x0E,
  0x00, 0x37, 0x38, 0xFD, 0xF3, 0x94, 0xCC, 0x63, 0x21, 0x09, 0x84, 0x66,
  0x31, 0x98, 0xC6, 0x63, 0x19, 0x8C, 0x44, 0x21, 0x31, 0x8C, 0x33, 0xC6,
  0xFC, 0xD1, 0x9C, 0x33, 0x06, 0x60, 0xD8, 0x1B, 0x03, 0x60, 0x6C, 0x0D,
  0x83, 0x60, 0x60, 0x1F, 0x07, 0xF9, 0xC3, 0x70, 0x3C, 0x07, 0x80, 0xF0,
  0x1C, 0x06, 0xC0, 0xD8, 0x31, 0xFE, 0x1F, 0x00, 0x19, 0xE0, 0xDF, 0x87,
  0x8E, 0x30, 0x31, 0x81, 0x98, 0x0C, 0xC0, 0x66, 0x03, 0x30, 0x31, 0x43,
  0x8B, 0xF8, 0xCF, 0x86, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x00,
  0x0F, 0x31, 0xFB, 0x30, 0x76, 0x03, 0x60, 0x26, 0x06, 0xC0, 0x6C, 0x06,
  0xC0, 0xE6, 0x16, 0x7E, 0xC3, 0xCC, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x01, 0x80, 0xF9, 0xFF, 0x7C, 0x78, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0x80, 0x30, 0x00, 0x0F, 0xC1, 0xFE, 0x30, 0x33,
  0x00, 0x30, 0x03, 0xF8, 0x0F, 0xE0, 0x06, 0x00, 0x6E, 0x0E, 0x7F, 0xC1,
  0xF0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC1, 0xFF, 0xFF, 0xF8, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x08, 0x03, 0x0C, 0x63, 0xCD, 0xE1, 0xF0, 0x3C,
  0x00, 0x60, 0x6C, 0x0D, 0x81, 0xB0, 0x64, 0x0D, 0x81, 0xB0, 0x36, 0x06,
  0xC3, 0xDC, 0x73, 0xF6, 0x3C, 0xC0, 0xF0, 0xDE, 0x0C, 0xC1, 0x98, 0x33,
  0x06, 0x40, 0xD8, 0x33, 0x06, 0x61, 0x8C, 0xE1, 0xF8, 0x3C, 0x00, 0x63,
  0x33, 0x18, 0x98, 0xC6, 0xC6, 0x34, 0x21, 0xA3, 0x0B, 0x18, 0xD8, 0xC6,
  0xC6, 0x36, 0x73, 0x3F, 0xF8, 0xE7, 0x00, 0x0E, 0x38, 0x7D, 0xF3, 0xBC,
  0xD8, 0xE3, 0x03, 0x8C, 0x0C, 0x00, 0x30, 0x30, 0xC4, 0xC5, 0x1B, 0x34,
  0xCF, 0x9E, 0x1C, 0x70, 0x30, 0x33, 0x03, 0x30, 0x33, 0x02, 0x20, 0x66,
  0x06, 0x60, 0x66, 0x06, 0x61, 0xE7, 0x1C, 0x7E, 0xC3, 0xCC, 0x00, 0xC0,
  0x1C, 0xC3, 0x8F, 0xF0, 0x7E, 0x00, 0x1F, 0x33, 0xFF, 0x31, 0xF6, 0x0E,
  0x01, 0x80, 0x30, 0x0E, 0x01, 0x86, 0x30, 0x2F, 0xE3, 0xDF, 0xFC, 0x3E,
  0x07, 0xE1, 0xFC, 0x30, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x30, 0x06,
  0x1F, 0x83, 0xE0, 0x06, 0x00, 0x40, 0x18, 0x06, 0x01, 0x80, 0x20, 0x04,
  0x01, 0x80, 0x3F, 0x03, 0xE0, 0x18, 0xC6, 0x21, 0x18, 0xC6, 0x31, 0x08,
  0xC6, 0x31, 0x88, 0x46, 0x31, 0x8C, 0x00, 0x0F, 0x83, 0xF0, 0x02, 0x00,
  0x40, 0x18, 0x02, 0x01, 0x80, 0x20, 0x06, 0x00, 0x7C, 0x1F, 0x86, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x7E, 0x0F, 0xC0,
  0x1C, 0x19, 0xF0, 0x99, 0x8C, 0xC6, 0x6C, 0x3E, 0x60, 0xE0,
};

const GFXglyph IBMPlexMono_Italic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 5, 17, 14, 5, -17 },
  { 12, 7, 7, 14, 5, -18 },
  { 19, 15, 17, 14, 0, -17 },
  { 51, 13, 21, 14, 1, -19 },
  { 86, 17, 17, 14, -1, -17 },
  { 123, 14, 17, 14, 0, -17 },
  { 153, 3, 7, 14, 7, -18 },
  { 156, 9, 21, 14, 5, -18 },
  { 180, 9, 21, 14, 1, -18 },
  { 204, 12, 12, 14, 1, -13 },
  { 222, 11, 12, 14, 2, -13 },
  { 239, 6, 6, 14, 3, -3 },
  { 244, 7, 2, 14, 4, -8 },
  { 246, 3, 3, 14, 5, -3 },
  { 248, 13, 21, 14, 1, -18 },
  { 283, 13, 17, 14, 1, -17 },
  { 311, 12, 17, 14, 1, -17 },
  { 337, 12, 17, 14, 1, -17 },
  { 363, 12, 17, 14, 1, -17 },
  { 389, 13, 17, 14, 0, -17 },
  { 417, 13, 17, 14, 1, -17 },
  { 445, 12, 17, 14, 1, -17 },
  { 471, 12, 17, 14, 2, -17 },
  { 497, 13, 17, 14, 1, -17 },
  { 525, 11, 17, 14, 2, -17 },
  { 549, 5, 13, 14, 5, -13 },
  { 558, 7, 16, 14, 3, -13 },
  { 572, 12, 14, 14, 2, -14 },
  { 593, 13, 7, 14, 1, -11 },
  { 605, 12, 14, 14, 1, -14 },
  { 626, 10, 17, 14, 3, -17 },
  { 648, 12, 20, 14, 1, -17 },
  { 678, 13, 17, 14, 0, -17 },
  { 706, 12, 17, 14, 1, -17 },
  { 732, 12, 17, 14, 2, -17 },
  { 758, 13, 17, 14, 1, -17 },
  { 786, 13, 17, 14, 1, -17 },
  { 814, 13, 17, 14, 1, -17 },
  { 842, 12, 17, 14, 2, -17 },
  { 868, 13, 17, 14, 1, -17 },
  { 896, 13, 17, 14, 1, -17 },
  { 924, 12, 17, 14, 1, -17 },
  { 950, 14, 17, 14, 1, -17 },
  { 980, 10, 17, 14, 2, -17 },
  { 1002, 14, 17, 14, 1, -17 },
  { 1032, 13, 17, 14, 1, -17 },
  { 1060, 13, 17, 14, 1, -17 },
  { 1088, 13, 17, 14, 1, -17 },
  { 1116, 13, 22, 14, 1, -17 },
  { 1152, 13, 17, 14, 1, -17 },
  { 1180, 13, 17, 14, 1, -17 },
  { 1208, 14, 17, 14, 2, -17 },
  { 1238, 12, 17, 14, 2, -17 },
  { 1264, 12, 17, 14, 3, -17 },
  { 1290, 14, 17, 14, 1, -17 },
  { 1320, 15, 17, 14, 0, -17 },
  { 1352, 14, 17, 14, 2, -17 },
  { 1382, 15, 17, 14, 0, -17 },
  { 1414, 10, 21, 14, 4, -18 },
  { 1441, 7, 21, 14, 4, -18 },
  { 1460, 10, 21, 14, 0, -18 },
  { 1487, 12, 10, 14, 2, -17 },
  { 1502, 12, 2, 14, 0, 2 },
  { 1505, 4, 5, 14, 5, -19 },
  { 1508, 12, 12, 14, 1, -12 },
  { 1526, 12, 18, 14, 1, -18 },
  { 1553, 11, 12, 14, 2, -12 },
  { 1570, 13, 18, 14, 1, -18 },
  { 1600, 11, 12, 14, 2, -12 },
  { 1617, 15, 23, 14, 0, -18 },
  { 1661, 12, 17, 14, 1, -12 },
  { 1687, 11, 18, 14, 1, -18 },
  { 1712, 11, 18, 14, 2, -18 },
  { 1737, 12, 23, 14, 1, -18 },
  { 1772, 13, 18, 14, 1, -18 },
  { 1802, 10, 18, 14, 3, -18 },
  { 1825, 14, 12, 14, 0, -12 },
  { 1846, 11, 12, 14, 1, -12 },
  { 1863, 11, 12, 14, 2, -12 },
  { 1880, 13, 17, 14, 0, -12 },
  { 1908, 12, 17, 14, 1, -12 },
  { 1934, 11, 12, 14, 3, -12 },
  { 1951, 12, 12, 14, 1, -12 },
  { 1969, 11, 17, 14, 2, -17 },
  { 1993, 11, 12, 14, 2, -12 },
  { 2010, 11, 12, 14, 2, -12 },
  { 2027, 13, 12, 14, 1, -12 },
  { 2047, 14, 12, 14, 0, -12 },
  { 2068, 12, 17, 14, 1, -12 },
  { 2094, 12, 12, 14, 1, -12 },
  { 2112, 11, 21, 14, 3, -18 },
  { 2141, 5, 21, 14, 5, -18 },
  { 2155, 11, 21, 14, 1, -18 },
  { 2184, 13, 6, 14, 1, -10 },
};

const GFXfont IBMPlexMono_Italic24pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic24pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic24pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _IBMPLEXMONO_ITALIC24PT7B_H_
