#ifndef _IBMPLEXMONO_ITALIC46PT7B_H_
#define _IBMPLEXMONO_ITALIC46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x70, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x00,
  0xC0, 0x30, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC3, 0xF8,
  0xFE, 0x3F, 0x8F, 0xC1, 0xE0, 0x38, 0x39, 0xC1, 0xDE, 0x1E, 0xF0, 0xF7,
  0x87, 0xB8, 0x39, 0xC1, 0xCE, 0x0E, 0xF0, 0xF7, 0x87, 0xB8, 0x39, 0xC1,
  0xCE, 0x0E, 0x00, 0x00, 0x07, 0x07, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x3C,
  0x1C, 0x00, 0x07, 0x07, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x3C, 0x1C, 0x00,
  0x07, 0x07, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x07, 0x07,
  0x80, 0x7F, 0xE0, 0xFF, 0x8F, 0xFC, 0x1F, 0xF1, 0xFF, 0x07, 0xFE, 0x01,
  0xE0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x07, 0x80, 0x01, 0xE0, 0xE0,
  0x00, 0x38, 0x1C, 0x00, 0x07, 0x07, 0x80, 0x7F, 0xE0, 0xFF, 0x8F, 0xF8,
  0x1F, 0xF1, 0xFF, 0x07, 0xFE, 0x01, 0xE0, 0xE0, 0x00, 0x38, 0x3C, 0x00,
  0x07, 0x07, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0x38, 0x3C, 0x00, 0x07, 0x07,
  0x00, 0x01, 0xE0, 0xE0, 0x00, 0x38, 0x3C, 0x00, 0x07, 0x07, 0x00, 0x01,
  0xE0, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x03, 0xF3, 0x9F, 0x81, 0xF0, 0xE1, 0xF0,
  0x78, 0x38, 0x38, 0x3C, 0x0C, 0x04, 0x0F, 0x03, 0x00, 0x03, 0xC1, 0xC0,
  0x00, 0xF0, 0x70, 0x00, 0x3C, 0x1C, 0x00, 0x0F, 0x07, 0x00, 0x03, 0xC1,
  0x80, 0x00, 0x7C, 0x60, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x37, 0xF0, 0x00, 0x0C, 0x7C,
  0x00, 0x07, 0x07, 0x80, 0x01, 0xC1, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x1C,
  0x0F, 0x00, 0x07, 0x03, 0xC0, 0x01, 0x80, 0xE0, 0x80, 0xE0, 0x78, 0x70,
  0x38, 0x1E, 0x3E, 0x0E, 0x0F, 0x07, 0xC3, 0x87, 0xC1, 0xFC, 0xE7, 0xE0,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x3C, 0x0F, 0xFE,
  0x00, 0x70, 0x1E, 0x1C, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0xC0, 0x70, 0x38, 0x07, 0x00, 0xE0, 0xF0, 0x0E, 0x03, 0xC1,
  0xC0, 0x1C, 0x07, 0x87, 0x00, 0x38, 0x0E, 0x1E, 0x00, 0x70, 0x3C, 0x38,
  0x00, 0xF0, 0xF0, 0xE0, 0x00, 0xFF, 0xC3, 0x80, 0x00, 0xFF, 0x0F, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xC3, 0xFC, 0x00, 0x07, 0x0F, 0xFC, 0x00,
  0x1C, 0x3C, 0x3C, 0x00, 0x78, 0xF0, 0x38, 0x01, 0xE1, 0xC0, 0x70, 0x03,
  0x83, 0x80, 0xE0, 0x0E, 0x0F, 0x01, 0xC0, 0x3C, 0x1C, 0x03, 0x80, 0x70,
  0x38, 0x07, 0x01, 0xC0, 0x70, 0x1E, 0x07, 0x80, 0xE0, 0x38, 0x0E, 0x00,
  0xE1, 0xE0, 0x38, 0x01, 0xFF, 0xC0, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x7C, 0x3E, 0x00, 0x0E, 0x03, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x78,
  0x07, 0x80, 0x0E, 0x00, 0xF0, 0x01, 0xC0, 0x1E, 0x00, 0x38, 0x03, 0xC0,
  0x07, 0x80, 0x78, 0x00, 0xF0, 0x0E, 0x00, 0x0E, 0x03, 0xC0, 0x01, 0xE0,
  0x70, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0xCF, 0x80, 0x0F, 0xFF, 0xC0, 0x03,
  0xE7, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0xE0, 0x1E, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0x80, 0x3C, 0x00, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0x70, 0x1B, 0xC0, 0x1F, 0x03, 0xF8, 0x03, 0xE0,
  0xEF, 0x00, 0x5E, 0x3C, 0xF0, 0x19, 0xC7, 0x1F, 0x07, 0x3D, 0xE1, 0xFF,
  0xC3, 0xF8, 0x1F, 0xF0, 0x7E, 0x00, 0xF8, 0x07, 0x80, 0x39, 0xDE, 0xF7,
  0x39, 0xCE, 0xF7, 0xB9, 0xCE, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x30, 0x1C, 0x03, 0xF8, 0x38, 0x3F, 0xFE, 0x77, 0xFC,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x01, 0xEF, 0x00, 0x07, 0x8E, 0x00, 0x1E, 0x1E, 0x00, 0x78,
  0x1C, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0x3C, 0x07, 0x00, 0x70, 0x04, 0x00,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xE1, 0xF8, 0x3E, 0x07, 0xC1,
  0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xC0, 0x78, 0x00, 0x7F,
  0xFD, 0xFF, 0xFF, 0xFF, 0x80, 0x7D, 0xFF, 0xFF, 0xFF, 0xCF, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0x07,
  0xC0, 0x78, 0x03, 0xC1, 0xE0, 0x03, 0x83, 0x80, 0x07, 0x8F, 0x00, 0x0F,
  0x1C, 0x00, 0x1E, 0x78, 0x00, 0x1C, 0xF0, 0x00, 0x3B, 0xC0, 0x00, 0x77,
  0x80, 0x01, 0xEF, 0x00, 0x03, 0xDE, 0x00, 0x07, 0xF8, 0x1E, 0x0F, 0xF0,
  0x7E, 0x1F, 0xE0, 0xF8, 0x3F, 0xC1, 0xF0, 0x7F, 0x83, 0xC1, 0xEF, 0x00,
  0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x70, 0x00, 0x3C, 0xE0, 0x00,
  0x79, 0xE0, 0x00, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x07, 0x00, 0x1E,
  0x0F, 0x00, 0x78, 0x0F, 0x83, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x3E, 0xF0, 0x01, 0xF3, 0xC0, 0x0F, 0x8E, 0x00, 0xFC, 0x78, 0x07, 0xE1,
  0xE0, 0x3E, 0x07, 0x80, 0x70, 0x1E, 0x00, 0x80, 0x78, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xF0, 0x7E, 0x07, 0xC0, 0x1F, 0x07, 0x80,
  0x0F, 0x0F, 0x00, 0x0F, 0x07, 0x00, 0x0F, 0x02, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x03, 0xF0, 0x3E, 0x07, 0xC0,
  0x1F, 0x03, 0x80, 0x0F, 0x01, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x30, 0x00, 0x78, 0xF0, 0x00,
  0x78, 0x78, 0x00, 0xF0, 0x7E, 0x03, 0xE0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xDE, 0x00, 0x07,
  0x9C, 0x00, 0x0F, 0x1C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x3C,
  0x3C, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x38, 0x01, 0xE0, 0x38, 0x01, 0xE0,
  0x78, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x00, 0x78, 0x1E, 0x00,
  0x70, 0x1E, 0x00, 0x70, 0x3C, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0xF0, 0x00,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x1F, 0x80, 0x0E, 0x7F,
  0xE0, 0x1E, 0xFF, 0xF0, 0x1F, 0x81, 0xF8, 0x1E, 0x00, 0x7C, 0x0C, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x30, 0x00,
  0x78, 0x78, 0x00, 0xF8, 0xF8, 0x01, 0xF0, 0x7E, 0x07, 0xE0, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x3F, 0x00, 0xF3, 0xFF, 0x03, 0x9F, 0xFF,
  0x1E, 0xE0, 0x7C, 0x7E, 0x00, 0xF9, 0xF0, 0x01, 0xEF, 0x80, 0x07, 0xBE,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xBC, 0x00,
  0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x0F, 0x3C, 0x00, 0x7C,
  0x78, 0x03, 0xE1, 0xF8, 0x1F, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0x80,
  0x01, 0xE7, 0x00, 0x07, 0x9E, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0x70, 0x00,
  0xF8, 0xE0, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xF0, 0x3E, 0x07, 0xC0,
  0x1F, 0x07, 0x80, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0E, 0x00,
  0x0F, 0x0E, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x0E, 0x00, 0x1E, 0x0F, 0x00,
  0x1E, 0x0F, 0x00, 0x3C, 0x07, 0xC0, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFF, 0xE0, 0x0F, 0x81, 0xF8, 0x1E, 0x00, 0x78, 0x3C, 0x00,
  0x3C, 0x78, 0x00, 0x1C, 0x70, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00,
  0x1E, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00,
  0x78, 0x78, 0x00, 0xF8, 0x7E, 0x03, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFE,
  0x03, 0xE0, 0x7C, 0x1E, 0x00, 0x78, 0xF0, 0x01, 0xE7, 0x80, 0x03, 0x9E,
  0x00, 0x0F, 0x70, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xBE, 0x00, 0x3E,
  0x78, 0x01, 0x79, 0xF8, 0x1F, 0xC3, 0xFF, 0xEF, 0x07, 0xFE, 0x78, 0x07,
  0xE1, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0x87, 0xF1, 0xFC, 0x7F, 0x1F, 0x83, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC3, 0xF8,
  0xFE, 0x3F, 0x8F, 0xC1, 0xE0, 0x01, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F,
  0x00, 0xF0, 0x07, 0x00, 0x78, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70,
  0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x00, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x08, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x1F,
  0xFF, 0x83, 0xF0, 0x7C, 0x7C, 0x03, 0xE7, 0x80, 0x1E, 0xF0, 0x01, 0xE7,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x03, 0xFF,
  0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x3E, 0x03, 0xC0, 0x78, 0x03, 0xC1, 0xE0, 0x03, 0x87, 0x80,
  0x07, 0x8E, 0x00, 0x0F, 0x1C, 0x00, 0x0E, 0x78, 0x1F, 0x1C, 0xE0, 0x7F,
  0x39, 0xC1, 0xFF, 0xF7, 0x87, 0xC7, 0xCF, 0x0E, 0x07, 0x9C, 0x3C, 0x07,
  0x38, 0x70, 0x0E, 0x70, 0xE0, 0x1D, 0xE3, 0xC0, 0x7B, 0xC7, 0x80, 0xF7,
  0x8F, 0x01, 0xCE, 0x1C, 0x03, 0x9C, 0x38, 0x07, 0x38, 0x70, 0x1E, 0x70,
  0xE0, 0x3C, 0xE1, 0xC0, 0xF9, 0xC3, 0xC3, 0xE3, 0x83, 0xFD, 0xC7, 0x07,
  0xFB, 0x8E, 0x07, 0xE7, 0x1C, 0x02, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x70, 0x00, 0x0F,
  0x78, 0x00, 0x0E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1C, 0x78, 0x00, 0x3C,
  0x38, 0x00, 0x3C, 0x38, 0x00, 0x78, 0x38, 0x00, 0x78, 0x3C, 0x00, 0xF0,
  0x3C, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x3C, 0x03, 0xC0,
  0x1C, 0x03, 0xC0, 0x1C, 0x03, 0xC0, 0x1E, 0x07, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00,
  0x0E, 0x3C, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x07, 0xFF, 0xE0, 0x07, 0xFF,
  0xF8, 0x07, 0xFF, 0xFC, 0x07, 0x80, 0x3E, 0x07, 0x00, 0x1E, 0x07, 0x00,
  0x0E, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x1F, 0x0F, 0x00,
  0x1E, 0x0E, 0x00, 0x1E, 0x0E, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x1E, 0x00,
  0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x1C, 0x00,
  0xF8, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x1C, 0x3C, 0x00,
  0x1C, 0x38, 0x00, 0x3C, 0x38, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00,
  0x3C, 0x78, 0x00, 0x78, 0x78, 0x00, 0xF8, 0x70, 0x01, 0xF0, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0x07, 0xC0, 0x78, 0x03, 0xC1, 0xE0, 0x07,
  0x87, 0x80, 0x07, 0x8F, 0x00, 0x0C, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0xC3, 0xC0, 0x03,
  0xC7, 0x80, 0x07, 0x87, 0x80, 0x1E, 0x0F, 0x00, 0x7C, 0x0F, 0x83, 0xF0,
  0x1F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x78, 0x0F, 0xC0, 0xF0, 0x07, 0xC1,
  0xE0, 0x07, 0x83, 0xC0, 0x07, 0x07, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x3C,
  0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0x80,
  0x03, 0xCF, 0x00, 0x07, 0x9E, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x78, 0x00,
  0x78, 0xF0, 0x00, 0xF1, 0xC0, 0x01, 0xE7, 0x80, 0x03, 0xCF, 0x00, 0x07,
  0x9E, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0xF0, 0xE0, 0x01, 0xE3,
  0xC0, 0x07, 0x87, 0x80, 0x1E, 0x0F, 0x00, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xE0, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0xE0, 0x1F, 0x03, 0xE0, 0x7C, 0x03, 0xC1, 0xF0, 0x03, 0xC3, 0xC0,
  0x07, 0x8F, 0x00, 0x06, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x3F, 0xFB, 0xC0, 0x7F, 0xE7,
  0x80, 0xFF, 0xCF, 0x00, 0x03, 0x9E, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x78,
  0x00, 0x3C, 0xF0, 0x00, 0x71, 0xE0, 0x00, 0xE3, 0xC0, 0x03, 0xC3, 0xC0,
  0x07, 0x87, 0x80, 0x1F, 0x0F, 0x80, 0x7E, 0x0F, 0x83, 0xBC, 0x1F, 0xFE,
  0x70, 0x1F, 0xF8, 0xE0, 0x0F, 0xC0, 0x00, 0x07, 0x80, 0x07, 0x83, 0xC0,
  0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x70, 0x78,
  0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07,
  0x00, 0x07, 0x87, 0x80, 0x03, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0,
  0xF0, 0x00, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC,
  0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0x80, 0x03,
  0xC1, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00,
  0x78, 0x3C, 0x00, 0x3C, 0x1C, 0x00, 0x1E, 0x0E, 0x00, 0x0F, 0x0F, 0x00,
  0x07, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0x07,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x00, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x80, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC1,
  0x80, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x01, 0xF0, 0xF8, 0x07, 0x81, 0xF0,
  0x7C, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x80,
  0x03, 0xF0, 0x78, 0x00, 0x7C, 0x07, 0x80, 0x0F, 0x80, 0x78, 0x01, 0xF0,
  0x07, 0x00, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0xF8, 0x00, 0xF0,
  0x1F, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0xF0, 0x7C, 0x00, 0x0E, 0x0F, 0x80,
  0x01, 0xE1, 0xF0, 0x00, 0x1E, 0x3E, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x1E,
  0x7C, 0x00, 0x01, 0xEF, 0xE0, 0x00, 0x1D, 0xFE, 0x00, 0x03, 0xFC, 0xF0,
  0x00, 0x3F, 0x8F, 0x00, 0x03, 0xF0, 0x78, 0x00, 0x3E, 0x07, 0x80, 0x03,
  0xC0, 0x3C, 0x00, 0x38, 0x03, 0xC0, 0x07, 0x80, 0x3E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x07, 0x80, 0x0F, 0x00,
  0x70, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3C, 0x0F, 0x00,
  0x03, 0xC0, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x03, 0xE0, 0xFC, 0x00,
  0xFC, 0x1F, 0x80, 0x1F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x01, 0xFC, 0x0F,
  0xE0, 0x3F, 0x83, 0xDC, 0x0F, 0xF0, 0x7B, 0x81, 0xDE, 0x0F, 0x70, 0x73,
  0x81, 0xCE, 0x1E, 0x70, 0x38, 0xE3, 0x8E, 0x07, 0x1C, 0xF3, 0xC1, 0xE3,
  0x9C, 0x78, 0x3C, 0x77, 0x8F, 0x07, 0x87, 0xE1, 0xC0, 0xE0, 0xF8, 0x38,
  0x1C, 0x1F, 0x07, 0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x38, 0x3C, 0x1E, 0x06,
  0x07, 0x83, 0xC0, 0x80, 0xE0, 0x70, 0x10, 0x1C, 0x0E, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x70, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x78, 0x3C,
  0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0x07, 0xE0, 0x03, 0x83, 0xF0, 0x03,
  0xC1, 0xF8, 0x01, 0xE0, 0xFC, 0x00, 0xF0, 0xFF, 0x00, 0x70, 0x7B, 0x80,
  0x38, 0x3D, 0xC0, 0x1C, 0x1C, 0xE0, 0x1E, 0x0E, 0x78, 0x0F, 0x07, 0x3C,
  0x07, 0x87, 0x8E, 0x03, 0x83, 0xC7, 0x01, 0xC1, 0xE3, 0x80, 0xE0, 0xE1,
  0xE0, 0xF0, 0x70, 0xF0, 0x78, 0x38, 0x38, 0x3C, 0x3C, 0x1C, 0x1C, 0x1E,
  0x0F, 0x0E, 0x0F, 0x07, 0x87, 0x07, 0x01, 0xC7, 0x83, 0x80, 0xE3, 0xC1,
  0xC0, 0x71, 0xE1, 0xE0, 0x3C, 0xE0, 0xF0, 0x1E, 0x70, 0x78, 0x07, 0x38,
  0x38, 0x03, 0xBC, 0x1C, 0x01, 0xFE, 0x0E, 0x00, 0xFF, 0x0F, 0x00, 0x3F,
  0x07, 0x80, 0x1F, 0x83, 0xC0, 0x0F, 0xC1, 0xC0, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0x07, 0xC0, 0x78, 0x03,
  0xC1, 0xE0, 0x03, 0x83, 0xC0, 0x07, 0x8F, 0x00, 0x0F, 0x1C, 0x00, 0x1E,
  0x78, 0x00, 0x3C, 0xF0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xEF,
  0x00, 0x03, 0xDE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xEF, 0x00, 0x03, 0xDE, 0x00,
  0x07, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0, 0x00,
  0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x87, 0x80, 0x1E, 0x0F, 0x00, 0x78,
  0x0F, 0x83, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xF0, 0x03,
  0xE0, 0x78, 0x00, 0xF0, 0x38, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x00,
  0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xC0,
  0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0x78, 0x01, 0xF8, 0x3F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x1F, 0x07, 0xE0, 0x78, 0x03, 0xC1, 0xE0, 0x03, 0x87, 0x80, 0x07,
  0x8F, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x7B,
  0xC0, 0x00, 0xF7, 0x80, 0x01, 0xEF, 0x00, 0x03, 0xDE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xF7, 0x80,
  0x01, 0xEF, 0x00, 0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0x78, 0x00,
  0x3C, 0xF0, 0x00, 0x79, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC3, 0x80, 0x0F,
  0x07, 0x80, 0x3C, 0x0F, 0xC1, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x60, 0x03, 0xC1, 0xE0,
  0x03, 0xC7, 0x80, 0x03, 0xDE, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0x80, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0xF0, 0x03, 0xE0, 0x78, 0x00, 0xF0, 0x38, 0x00, 0x3C, 0x3C, 0x00, 0x1E,
  0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01,
  0xE1, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0x78, 0x01,
  0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0x03,
  0x80, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x3C, 0x00, 0xF0,
  0x1E, 0x00, 0x70, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E,
  0x00, 0x78, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x03, 0x80, 0x07, 0x83,
  0xC0, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xC0, 0xFE, 0x07, 0xC0, 0x07, 0x81, 0xE0,
  0x00, 0xF0, 0xF0, 0x00, 0x10, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x82, 0x00, 0x01, 0xE0, 0xC0, 0x00,
  0x78, 0xF8, 0x00, 0x3C, 0x1F, 0x00, 0x1F, 0x03, 0xF0, 0x1F, 0x80, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x70, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0E,
  0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x0E, 0x1E,
  0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C,
  0x00, 0x1E, 0x3C, 0x00, 0x1C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C,
  0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x38, 0x78,
  0x00, 0x78, 0x78, 0x00, 0x78, 0x70, 0x00, 0x78, 0x70, 0x00, 0x78, 0xF0,
  0x00, 0x70, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0,
  0x00, 0xE0, 0x70, 0x01, 0xE0, 0x78, 0x03, 0xC0, 0x7C, 0x0F, 0xC0, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0x70, 0x00, 0x3C, 0x70,
  0x00, 0x3C, 0x70, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0xF0, 0x78,
  0x00, 0xF0, 0x78, 0x01, 0xE0, 0x38, 0x01, 0xE0, 0x38, 0x01, 0xC0, 0x38,
  0x03, 0xC0, 0x38, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x3C, 0x07, 0x80, 0x3C,
  0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x1C, 0x1E, 0x00, 0x1C, 0x1E, 0x00, 0x1C,
  0x1C, 0x00, 0x1C, 0x3C, 0x00, 0x1E, 0x38, 0x00, 0x1E, 0x78, 0x00, 0x1E,
  0x70, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x3C, 0x70, 0x00, 0x07, 0x8E, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x1C, 0x78, 0x00, 0x03, 0x8F, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1C, 0x38,
  0x1F, 0x03, 0x87, 0x03, 0xE0, 0x70, 0xE0, 0x7C, 0x1E, 0x1C, 0x1F, 0x83,
  0x83, 0x83, 0xF0, 0x70, 0x70, 0xEE, 0x0E, 0x0E, 0x1D, 0xC3, 0xC1, 0xC3,
  0xB8, 0x78, 0x78, 0xE7, 0x0E, 0x0F, 0x1C, 0xE1, 0xC1, 0xE3, 0x9C, 0x78,
  0x38, 0xE3, 0x8F, 0x07, 0x1C, 0x71, 0xC0, 0xE7, 0x86, 0x38, 0x1C, 0xE0,
  0xCF, 0x03, 0x9C, 0x1D, 0xE0, 0x77, 0x03, 0xB8, 0x0E, 0xE0, 0x77, 0x01,
  0xDC, 0x0E, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x07,
  0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x3E,
  0x03, 0xC0, 0x00, 0xF0, 0x07, 0x80, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x1E, 0x07, 0xC0, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xF7,
  0x80, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0x38,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0xF0,
  0x07, 0xC0, 0x01, 0xE0, 0x1F, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x03, 0xE0,
  0xF0, 0x00, 0x07, 0xDE, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF0, 0xF0, 0x00,
  0x7C, 0x3C, 0x00, 0x3E, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x07, 0x80, 0x78,
  0x03, 0xE0, 0x0E, 0x00, 0xF0, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x3C, 0x00,
  0x1E, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x00, 0xE3, 0xC0, 0x00, 0x3D, 0xF0,
  0x00, 0x0F, 0x78, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1C, 0x00, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x7F,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x03, 0x00, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x30, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x01, 0xFF, 0xF0,
  0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x7F, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0x9C, 0x00, 0x1E, 0x3C, 0x00, 0x38, 0x78,
  0x00, 0xF0, 0x70, 0x03, 0xC0, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0,
  0x78, 0x03, 0xC1, 0xE0, 0x03, 0x83, 0x80, 0x07, 0x8F, 0x00, 0x07, 0x3C,
  0x00, 0x0F, 0xF0, 0x00, 0x1E, 0xC0, 0x00, 0x1C, 0x80, 0x00, 0x20, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF0, 0x27, 0x3C, 0xE7, 0x3C,
  0xE7, 0x10, 0x01, 0xFC, 0x3C, 0x1F, 0xF8, 0xF0, 0xFF, 0xF3, 0x87, 0xE0,
  0xEE, 0x1E, 0x00, 0xB8, 0xF0, 0x01, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1E,
  0x70, 0x00, 0x73, 0xC0, 0x01, 0xCF, 0x00, 0x07, 0x3C, 0x00, 0x3C, 0xF0,
  0x00, 0xF3, 0x80, 0x03, 0xCE, 0x00, 0x0E, 0x38, 0x00, 0x38, 0xE0, 0x01,
  0xE3, 0x80, 0x07, 0x8E, 0x00, 0x3E, 0x3C, 0x01, 0xF8, 0xF0, 0x0D, 0xC1,
  0xF0, 0xE7, 0xF7, 0xFF, 0x9F, 0x8F, 0xFC, 0x3E, 0x0F, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x3C, 0x1F, 0x80, 0x78, 0xFF, 0x80, 0xF3, 0xFF,
  0x81, 0xEE, 0x0F, 0x83, 0xB0, 0x0F, 0x07, 0xC0, 0x0F, 0x1F, 0x00, 0x1E,
  0x3E, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xC0, 0x01, 0xE3,
  0x80, 0x03, 0xCF, 0x00, 0x07, 0x9E, 0x00, 0x0F, 0x3C, 0x00, 0x1C, 0x78,
  0x00, 0x78, 0xE0, 0x00, 0xF1, 0xC0, 0x01, 0xE7, 0x80, 0x07, 0x8F, 0x80,
  0x1F, 0x1F, 0x00, 0x7C, 0x3F, 0x81, 0xF0, 0x73, 0xFF, 0xC0, 0xE3, 0xFF,
  0x02, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8,
  0x1F, 0x83, 0xE0, 0xF0, 0x07, 0x8F, 0x00, 0x3C, 0xF0, 0x00, 0x87, 0x80,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0x43, 0x80, 0x03, 0x9C, 0x00, 0x3C, 0xF0, 0x03, 0xC3, 0xC0, 0x3C, 0x1F,
  0x07, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0xFC, 0x1C, 0x03, 0xFF, 0x3C, 0x0F, 0xFF,
  0xBC, 0x1F, 0x81, 0xBC, 0x1E, 0x00, 0xF8, 0x3C, 0x00, 0x78, 0x78, 0x00,
  0x78, 0x78, 0x00, 0x78, 0x70, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00,
  0x70, 0xF0, 0x00, 0x70, 0xF0, 0x00, 0x70, 0xE0, 0x00, 0xF0, 0xE0, 0x00,
  0xF0, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0xE0, 0xE0, 0x01, 0xE0, 0xF0, 0x03,
  0xE0, 0xF0, 0x03, 0xE0, 0xF8, 0x07, 0xE0, 0x7C, 0x1D, 0xE0, 0x7F, 0xF9,
  0xC0, 0x3F, 0xF1, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFF,
  0x00, 0xFF, 0xFC, 0x0F, 0x81, 0xF0, 0xF0, 0x07, 0x8F, 0x00, 0x1C, 0xF0,
  0x00, 0xE7, 0x00, 0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x0F, 0x9E, 0x07, 0xFC,
  0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0x7F, 0xF0, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x43, 0x80, 0x03, 0x9E, 0x00, 0x1E, 0xF0, 0x01, 0xE7,
  0xC0, 0x1E, 0x1F, 0x03, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x80, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x3E, 0x07, 0x80, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3F,
  0x0F, 0x00, 0xFF, 0xCF, 0x03, 0xFF, 0xEF, 0x07, 0xE0, 0x6F, 0x07, 0x80,
  0x3E, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1C, 0x00,
  0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1C, 0x3C, 0x00, 0x1C, 0x3C, 0x00,
  0x1C, 0x38, 0x00, 0x3C, 0x38, 0x00, 0x3C, 0x38, 0x00, 0x3C, 0x38, 0x00,
  0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0xB8, 0x3E, 0x01, 0xF8, 0x1F, 0x07,
  0x78, 0x1F, 0xFE, 0x78, 0x0F, 0xFC, 0x70, 0x03, 0xF0, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xE0, 0x30, 0x03, 0xC0, 0x7C, 0x0F, 0xC0, 0xFF, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x83, 0xE0, 0x3C, 0x7F, 0xC1,
  0xE7, 0xFF, 0x0F, 0x70, 0xF8, 0x7E, 0x03, 0xE3, 0xA0, 0x0F, 0x1E, 0x00,
  0x79, 0xF0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0x1C,
  0x00, 0x38, 0xE0, 0x01, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x07,
  0x9E, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x78, 0x00, 0xF3, 0xC0,
  0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x01, 0xC7, 0x00, 0x0E, 0x00, 0x00, 0x3C,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x20, 0x1E, 0x03, 0xC0, 0xE0, 0x3C, 0x07, 0x03, 0xC0,
  0x78, 0x7C, 0x03, 0xC7, 0xC0, 0x1E, 0x7C, 0x00, 0xF7, 0xC0, 0x07, 0xFC,
  0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0x00, 0xF0, 0x38,
  0x07, 0x81, 0xE0, 0x3C, 0x07, 0x81, 0xC0, 0x1E, 0x0E, 0x00, 0x78, 0x70,
  0x01, 0xE7, 0x80, 0x07, 0xBC, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x3E, 0x00, 0xF1, 0xFF,
  0x01, 0xE7, 0xFF, 0x03, 0xDC, 0x1E, 0x07, 0xE0, 0x1E, 0x0E, 0x80, 0x3C,
  0x1F, 0x00, 0x78, 0x7C, 0x00, 0xF0, 0xF0, 0x01, 0xC1, 0xE0, 0x07, 0x83,
  0xC0, 0x1E, 0x07, 0x00, 0x78, 0x0E, 0x03, 0xE0, 0x3C, 0x3F, 0x00, 0x79,
  0xE0, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x23, 0x83, 0xC0, 0x67, 0x07,
  0x81, 0xFE, 0x07, 0x07, 0xBC, 0x0F, 0x1E, 0x78, 0x0E, 0x78, 0xF0, 0x1F,
  0xE1, 0xC0, 0x1F, 0x80, 0x00, 0x1C, 0x00, 0xFF, 0xF8, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0xC1, 0xE0, 0x3C, 0x3C, 0x0F, 0x07,
  0x03, 0xC1, 0xE0, 0xF0, 0x3C, 0x3C, 0x07, 0x9F, 0x00, 0xF7, 0xC0, 0x1F,
  0xF0, 0x03, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x38, 0x1E, 0x0F, 0x7E,
  0x3F, 0x87, 0xBF, 0x9F, 0xE3, 0xB3, 0xD8, 0xF1, 0xE0, 0xE8, 0x38, 0xF0,
  0x78, 0x1C, 0xF0, 0x3C, 0x0E, 0x78, 0x1C, 0x07, 0x3C, 0x0E, 0x07, 0x9C,
  0x07, 0x03, 0xCE, 0x07, 0x81, 0xC7, 0x03, 0xC0, 0xE7, 0x81, 0xC0, 0x73,
  0xC0, 0xE0, 0x39, 0xC0, 0x70, 0x3C, 0xE0, 0x38, 0x1E, 0x70, 0x3C, 0x0E,
  0x38, 0x1E, 0x07, 0x3C, 0x0E, 0x03, 0x9E, 0x07, 0x03, 0xCE, 0x03, 0x81,
  0xE7, 0x01, 0xC0, 0xE3, 0x81, 0xE0, 0x71, 0xC0, 0xF0, 0x38, 0x0E, 0x0F,
  0x80, 0xF1, 0xFF, 0x07, 0x9F, 0xFC, 0x3D, 0xC3, 0xE1, 0xF8, 0x0F, 0x8E,
  0x80, 0x3C, 0x78, 0x01, 0xE7, 0xC0, 0x0F, 0x3C, 0x00, 0x79, 0xE0, 0x03,
  0xCF, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x07, 0x3C, 0x00, 0x79, 0xE0,
  0x03, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x39,
  0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0x1C, 0x00,
  0x38, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xE0, 0x7C,
  0x1F, 0x00, 0xF0, 0xF0, 0x01, 0xE3, 0xC0, 0x03, 0x9E, 0x00, 0x0E, 0x78,
  0x00, 0x3D, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7B,
  0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x1C, 0x00, 0x78, 0x78, 0x03, 0xC0, 0xF8,
  0x3F, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x07, 0x83,
  0xF0, 0x07, 0x8F, 0xF8, 0x07, 0x9F, 0xFC, 0x07, 0x38, 0x3E, 0x07, 0x60,
  0x1E, 0x0F, 0xC0, 0x0F, 0x0F, 0x80, 0x0F, 0x0F, 0x80, 0x0F, 0x0F, 0x00,
  0x0F, 0x0F, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00,
  0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x0E, 0x1E, 0x00, 0x1E, 0x1C, 0x00,
  0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x3E, 0x00,
  0xF8, 0x3F, 0x81, 0xF0, 0x39, 0xFF, 0xE0, 0x78, 0xFF, 0xC0, 0x78, 0x3F,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x3C, 0x0F, 0xFC, 0xF0, 0xFF, 0xFB, 0xC7, 0xE0, 0x6F,
  0x1E, 0x00, 0xF8, 0xF0, 0x01, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0x70,
  0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0x3C, 0x00, 0x1C, 0xF0, 0x00,
  0x73, 0x80, 0x03, 0xCE, 0x00, 0x0F, 0x38, 0x00, 0x3C, 0xE0, 0x00, 0xE3,
  0x80, 0x07, 0x8F, 0x00, 0x3E, 0x3C, 0x00, 0xF8, 0xF8, 0x05, 0xE1, 0xF0,
  0x77, 0x87, 0xFF, 0x9C, 0x0F, 0xFC, 0x70, 0x0F, 0xC1, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xFF, 0xE1, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFC, 0xFF, 0xC0, 0x77, 0x00, 0x03, 0xD8, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3E,
  0x03, 0xE0, 0xF0, 0x01, 0xE1, 0xC0, 0x02, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x80, 0x01, 0xE3, 0x80, 0x03, 0xCF,
  0x80, 0x0F, 0x0F, 0xC0, 0x7C, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x03,
  0xFE, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x06, 0x0F, 0x00, 0xF0, 0xF0, 0x1F, 0x0F, 0x07, 0xC0, 0xE0, 0xF8,
  0x0E, 0x3E, 0x00, 0xE7, 0xC0, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0xE3,
  0x80, 0x07, 0x1C, 0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x00,
  0xF3, 0xC0, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0xCF, 0x00, 0x1E, 0x78,
  0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x38, 0xF0, 0x03, 0xC7, 0x80, 0x1E,
  0x3C, 0x01, 0xF1, 0xE0, 0x1F, 0x8F, 0x01, 0xBC, 0x7C, 0x19, 0xC1, 0xFF,
  0xCE, 0x07, 0xFC, 0x70, 0x1F, 0x84, 0x00, 0xFF, 0x80, 0x1B, 0xFE, 0x01,
  0xEF, 0xF8, 0x03, 0x81, 0xE0, 0x0F, 0x07, 0x00, 0x3C, 0x1C, 0x00, 0xF0,
  0x70, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF0,
  0x03, 0x83, 0x80, 0x1E, 0x0E, 0x00, 0x78, 0x38, 0x01, 0xE1, 0xE0, 0x0F,
  0x07, 0x80, 0x3C, 0x1E, 0x01, 0xE0, 0x70, 0x0F, 0x01, 0xC0, 0x78, 0x07,
  0x07, 0xE0, 0x1C, 0x7F, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x03, 0xF0,
  0x00, 0x1C, 0x0F, 0x06, 0x1C, 0x0E, 0x0E, 0x1C, 0x0E, 0x0F, 0x3C, 0x0E,
  0x07, 0x38, 0x0E, 0x07, 0x38, 0x0E, 0x07, 0x38, 0x1E, 0x07, 0x38, 0x1C,
  0x07, 0x38, 0x1C, 0x07, 0x78, 0x1C, 0x07, 0x70, 0x1C, 0x07, 0x70, 0x3C,
  0x0F, 0x70, 0x3C, 0x0F, 0x70, 0x38, 0x0E, 0x70, 0x38, 0x0E, 0xF0, 0x38,
  0x1E, 0xE0, 0x78, 0x1E, 0xE0, 0x78, 0x1C, 0xE0, 0x78, 0x3C, 0xE0, 0xF8,
  0x78, 0xF1, 0xB8, 0xF8, 0xFF, 0xBF, 0xF0, 0x7F, 0x1F, 0xE0, 0x3C, 0x0F,
  0x80, 0x00, 0x78, 0x0F, 0x80, 0x3F, 0x83, 0xF8, 0x0F, 0xF0, 0xFF, 0x87,
  0xEF, 0x38, 0xF1, 0xF0, 0xEE, 0x0E, 0x7C, 0x1D, 0x81, 0xC6, 0x03, 0xB0,
  0x38, 0x00, 0x7C, 0x07, 0x00, 0x0F, 0x80, 0xE0, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x70, 0x1F, 0x00, 0x1E, 0x06,
  0xE0, 0x23, 0xC0, 0xDC, 0x0E, 0x78, 0x3B, 0x83, 0xCF, 0x06, 0x71, 0xF0,
  0xE3, 0xCE, 0x7C, 0x1F, 0xF1, 0xFF, 0x03, 0xFC, 0x1F, 0x80, 0x1F, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x07,
  0x80, 0x0E, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F,
  0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x0E,
  0x00, 0x1C, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1E,
  0x00, 0x78, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0xF8, 0x1E, 0x01, 0xF8, 0x1E,
  0x03, 0x78, 0x0F, 0x06, 0x78, 0x0F, 0xFE, 0x70, 0x07, 0xFC, 0x70, 0x01,
  0xF0, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x30, 0x03, 0xC0, 0x7C, 0x0F, 0x80, 0xFF,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x0F, 0x07,
  0xFF, 0x8F, 0x0F, 0xFF, 0xCE, 0x1E, 0x07, 0xFE, 0x1C, 0x01, 0xFE, 0x1C,
  0x00, 0x78, 0x1C, 0x00, 0xF0, 0x1C, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x30, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x38, 0x0F,
  0x00, 0x3C, 0x3E, 0x00, 0x3C, 0x7F, 0xF0, 0x1C, 0x7F, 0xFF, 0x1C, 0x71,
  0xFF, 0xFC, 0x70, 0x3F, 0xF8, 0xF0, 0x07, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x01, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x81, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xF0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x03, 0xC0, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0x80, 0x1F, 0xFC, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x06, 0x0F, 0xE0, 0x07, 0x1F,
  0xF0, 0x0F, 0x1C, 0x78, 0x0E, 0x38, 0x3C, 0x0E, 0x38, 0x1C, 0x1C, 0x70,
  0x1E, 0x3C, 0x70, 0x0F, 0xF8, 0xE0, 0x07, 0xF0, 0x60, 0x03, 0xC0,
};

const GFXglyph IBMPlexMono_Italic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 10, 32, 28, 9, -32 },
  { 41, 13, 13, 28, 10, -34 },
  { 63, 27, 32, 28, 1, -32 },
  { 171, 26, 44, 28, 1, -38 },
  { 314, 31, 34, 28, -1, -33 },
  { 446, 27, 34, 28, 0, -33 },
  { 561, 5, 13, 28, 14, -34 },
  { 570, 18, 41, 28, 9, -35 },
  { 663, 17, 41, 28, 2, -35 },
  { 751, 23, 23, 28, 3, -25 },
  { 818, 22, 23, 28, 3, -26 },
  { 882, 11, 12, 28, 6, -6 },
  { 899, 14, 3, 28, 7, -15 },
  { 905, 7, 6, 28, 9, -6 },
  { 911, 26, 41, 28, 1, -35 },
  { 1045, 23, 34, 28, 3, -33 },
  { 1143, 22, 32, 28, 2, -32 },
  { 1231, 24, 33, 28, 1, -33 },
  { 1330, 24, 34, 28, 1, -33 },
  { 1432, 24, 32, 28, 1, -32 },
  { 1528, 24, 33, 28, 2, -32 },
  { 1627, 22, 33, 28, 3, -32 },
  { 1718, 23, 32, 28, 5, -32 },
  { 1810, 24, 34, 28, 2, -33 },
  { 1912, 22, 33, 28, 4, -33 },
  { 2003, 10, 24, 28, 9, -24 },
  { 2033, 13, 30, 28, 6, -24 },
  { 2082, 22, 26, 28, 4, -27 },
  { 2154, 24, 12, 28, 2, -20 },
  { 2190, 22, 26, 28, 2, -27 },
  { 2262, 20, 33, 28, 6, -33 },
  { 2345, 23, 38, 28, 3, -33 },
  { 2455, 24, 32, 28, 0, -32 },
  { 2551, 24, 32, 28, 2, -32 },
  { 2647, 23, 34, 28, 4, -33 },
  { 2745, 23, 32, 28, 3, -32 },
  { 2837, 25, 32, 28, 2, -32 },
  { 2937, 26, 32, 28, 2, -32 },
  { 3041, 23, 34, 28, 3, -33 },
  { 3139, 25, 32, 28, 2, -32 },
  { 3239, 25, 32, 28, 2, -32 },
  { 3339, 22, 33, 28, 3, -32 },
  { 3430, 28, 32, 28, 2, -32 },
  { 3542, 19, 32, 28, 4, -32 },
  { 3618, 27, 32, 28, 1, -32 },
  { 3726, 25, 32, 28, 2, -32 },
  { 3826, 23, 34, 28, 3, -33 },
  { 3924, 25, 32, 28, 2, -32 },
  { 4024, 23, 41, 28, 3, -33 },
  { 4142, 25, 32, 28, 2, -32 },
  { 4242, 26, 34, 28, 1, -33 },
  { 4353, 26, 32, 28, 4, -32 },
  { 4457, 24, 33, 28, 3, -32 },
  { 4556, 24, 32, 28, 5, -32 },
  { 4652, 27, 32, 28, 2, -32 },
  { 4760, 31, 32, 28, -1, -32 },
  { 4884, 26, 32, 28, 4, -32 },
  { 4988, 28, 32, 28, 0, -32 },
  { 5100, 20, 41, 28, 7, -35 },
  { 5203, 12, 41, 28, 8, -35 },
  { 5265, 20, 41, 28, 0, -35 },
  { 5368, 23, 19, 28, 3, -32 },
  { 5423, 23, 3, 28, 0, 5 },
  { 5432, 5, 9, 28, 11, -36 },
  { 5438, 22, 25, 28, 3, -24 },
  { 5507, 23, 35, 28, 2, -34 },
  { 5608, 21, 25, 28, 3, -24 },
  { 5674, 24, 35, 28, 3, -34 },
  { 5779, 21, 25, 28, 3, -24 },
  { 5845, 30, 44, 28, -1, -34 },
  { 6010, 24, 34, 28, 1, -24 },
  { 6112, 21, 34, 28, 3, -34 },
  { 6202, 21, 35, 28, 4, -34 },
  { 6294, 21, 44, 28, 3, -34 },
  { 6410, 23, 35, 28, 3, -34 },
  { 6511, 19, 35, 28, 5, -34 },
  { 6595, 25, 24, 28, 1, -24 },
  { 6670, 21, 24, 28, 3, -24 },
  { 6733, 22, 25, 28, 3, -24 },
  { 6802, 24, 33, 28, 1, -24 },
  { 6901, 22, 33, 28, 3, -24 },
  { 6992, 22, 24, 28, 5, -24 },
  { 7058, 23, 25, 28, 2, -24 },
  { 7130, 20, 33, 28, 4, -32 },
  { 7213, 21, 25, 28, 4, -24 },
  { 7279, 22, 24, 28, 3, -24 },
  { 7345, 24, 24, 28, 2, -24 },
  { 7417, 27, 25, 28, 0, -24 },
  { 7502, 24, 34, 28, 1, -24 },
  { 7604, 24, 24, 28, 2, -24 },
  { 7676, 22, 41, 28, 5, -35 },
  { 7789, 10, 41, 28, 9, -35 },
  { 7841, 21, 41, 28, 2, -35 },
  { 7949, 24, 10, 28, 2, -19 },
};

const GFXfont IBMPlexMono_Italic46pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic46pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic46pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _IBMPLEXMONO_ITALIC46PT7B_H_
