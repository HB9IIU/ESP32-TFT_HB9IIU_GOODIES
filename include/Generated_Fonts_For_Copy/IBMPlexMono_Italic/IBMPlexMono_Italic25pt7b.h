#ifndef _IBMPLEXMONO_ITALIC25PT7B_H_
#define _IBMPLEXMONO_ITALIC25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xC6, 0x33, 0x98, 0xC6, 0x31, 0x08, 0x00, 0x03, 0x9E, 0xE0,
  0x63, 0x62, 0x66, 0x66, 0x66, 0xC6, 0xC6, 0x01, 0x8C, 0x03, 0x18, 0x06,
  0x60, 0x18, 0xC0, 0x31, 0x07, 0xE7, 0xCF, 0x8F, 0x83, 0x10, 0x06, 0x60,
  0x18, 0xC1, 0xF1, 0xF7, 0xC7, 0xE1, 0x8C, 0x03, 0x10, 0x04, 0x60, 0x18,
  0xC0, 0x33, 0x00, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x01, 0xF8, 0x1F, 0xF0,
  0xE6, 0xE3, 0x10, 0xCC, 0x40, 0x31, 0x00, 0xEC, 0x03, 0xF0, 0x03, 0xF8,
  0x03, 0xF0, 0x08, 0xC0, 0x23, 0x21, 0x8C, 0xC6, 0x33, 0x93, 0x87, 0xFE,
  0x07, 0xE0, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x07, 0x81, 0x87, 0xE0,
  0x86, 0x30, 0xC3, 0x18, 0xC1, 0x0C, 0xC0, 0x86, 0x60, 0x7E, 0x60, 0x1E,
  0x60, 0x00, 0x00, 0x01, 0x1E, 0x01, 0x9F, 0x81, 0x98, 0xC0, 0x8C, 0x20,
  0xC4, 0x30, 0xC2, 0x18, 0xC1, 0xF8, 0xE0, 0x78, 0x00, 0x03, 0xE0, 0x0F,
  0xE0, 0x30, 0xC0, 0x61, 0x80, 0xC3, 0x01, 0x86, 0x03, 0x0C, 0x07, 0x70,
  0x3F, 0xC0, 0xC6, 0x03, 0x0C, 0x06, 0x0C, 0x0C, 0x18, 0x58, 0x39, 0xF8,
  0xFB, 0x3F, 0x3C, 0x3C, 0x30, 0x6D, 0xB6, 0xF0, 0x01, 0x83, 0x03, 0x01,
  0x81, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0x40, 0x30, 0x18, 0x06, 0x03, 0x00, 0xE0, 0x0C, 0x03, 0x00,
  0xC0, 0x60, 0x18, 0x0C, 0x06, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x08, 0x0C, 0x06, 0x06, 0x03, 0x03, 0x03, 0x03, 0x07, 0x00, 0x01, 0x80,
  0x08, 0x00, 0xC0, 0x06, 0x06, 0x31, 0xFF, 0xFC, 0x3F, 0x00, 0xE0, 0x0D,
  0x80, 0xCC, 0x0C, 0x30, 0xC1, 0x80, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x0F, 0xFF, 0xFF, 0xE0, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x1C, 0xE3, 0x8C, 0x71, 0x8C, 0x00, 0xFF, 0xFC, 0xEF, 0xE0, 0x00, 0x0C,
  0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30,
  0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00,
  0x00, 0x07, 0xC1, 0xFE, 0x38, 0x77, 0x03, 0x60, 0x36, 0x03, 0xC0, 0x3C,
  0x63, 0xCF, 0x3C, 0xE3, 0xC0, 0x7C, 0x06, 0xC0, 0x6C, 0x0C, 0xE1, 0xC7,
  0xF8, 0x3E, 0x00, 0x03, 0xC0, 0x7C, 0x0E, 0xC1, 0xD8, 0x79, 0x83, 0x18,
  0x21, 0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x07, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x7F, 0x87, 0x0C, 0x60, 0x73,
  0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E,
  0x01, 0xC0, 0x1C, 0x01, 0x80, 0x1F, 0xFE, 0xFF, 0xE0, 0x07, 0xE0, 0x7F,
  0x87, 0x0E, 0x60, 0x30, 0x03, 0x80, 0x18, 0x01, 0x81, 0xF8, 0x0F, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x60, 0x07, 0x60, 0x33, 0x83, 0x8F, 0xF8, 0x3F,
  0x00, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x80, 0x36, 0x01, 0x98, 0x0C, 0xC0,
  0x63, 0x03, 0x0C, 0x0C, 0x30, 0x60, 0xC3, 0x02, 0x18, 0x18, 0x7F, 0xFF,
  0xFF, 0xF0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x0F, 0xF8, 0xFF, 0xC6, 0x00,
  0x30, 0x01, 0x80, 0x18, 0x00, 0xDF, 0x07, 0xFC, 0x38, 0x70, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x20, 0x3B, 0xC3, 0x87, 0xF8, 0x1F, 0x00, 0x01,
  0xE0, 0x60, 0x38, 0x0E, 0x03, 0x80, 0x60, 0x19, 0xE3, 0xFE, 0xF0, 0xF8,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xF8, 0x73, 0xFC, 0x3E, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x6C, 0x06, 0xC0, 0xC0, 0x1C, 0x01, 0x80, 0x30, 0x03,
  0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x06, 0x00, 0xE0,
  0x00, 0x07, 0xE0, 0x7F, 0xC7, 0x0E, 0x60, 0x33, 0x01, 0x98, 0x0C, 0xE1,
  0xC3, 0xFC, 0x1F, 0xC1, 0x83, 0x98, 0x0D, 0x80, 0x6C, 0x03, 0x60, 0x1B,
  0x83, 0x8F, 0xFC, 0x1F, 0x80, 0x0F, 0xC1, 0xFE, 0x38, 0x76, 0x03, 0xE0,
  0x3C, 0x03, 0xC0, 0x3E, 0x07, 0x60, 0xE7, 0xF6, 0x3E, 0xC0, 0x1C, 0x01,
  0x80, 0x30, 0x06, 0x01, 0xC0, 0x78, 0x00, 0x3B, 0xCE, 0x00, 0x00, 0x00,
  0x00, 0x39, 0xEE, 0x00, 0x0E, 0x3C, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x71, 0xC3, 0x86, 0x1C, 0x30, 0xC0, 0x00, 0x10, 0x07, 0x01, 0xE0,
  0x78, 0x0E, 0x03, 0x80, 0xE0, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00,
  0x38, 0x01, 0xC0, 0x04, 0x7F, 0xFB, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFB, 0xFF, 0xC0, 0x20, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0,
  0x0E, 0x00, 0x30, 0x07, 0x01, 0xE0, 0x78, 0x1E, 0x07, 0x80, 0xE0, 0x08,
  0x00, 0x0F, 0x87, 0xF9, 0xC3, 0xB0, 0x3C, 0x06, 0x00, 0xC0, 0x30, 0x0E,
  0x1F, 0x03, 0x80, 0x60, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x03, 0xC0, 0x38,
  0x00, 0x07, 0xE0, 0x7F, 0x87, 0x0E, 0x70, 0x33, 0x01, 0x98, 0xED, 0x8F,
  0xEC, 0xE7, 0x66, 0x1B, 0x30, 0x9B, 0x0C, 0x98, 0x6C, 0xC7, 0x63, 0xFB,
  0x1E, 0x88, 0x00, 0x60, 0x03, 0x80, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0xE0,
  0x0F, 0x00, 0x78, 0x06, 0xC0, 0x36, 0x03, 0x18, 0x18, 0xC1, 0x86, 0x0C,
  0x30, 0xC1, 0x87, 0xFC, 0x7F, 0xE3, 0x03, 0xB8, 0x0D, 0x80, 0x6C, 0x03,
  0xC0, 0x18, 0x1F, 0xE0, 0xFF, 0x86, 0x0E, 0x70, 0x33, 0x01, 0x98, 0x1C,
  0xC0, 0xC7, 0xFC, 0x3F, 0xE3, 0x03, 0x98, 0x0C, 0xC0, 0x66, 0x03, 0x30,
  0x19, 0x81, 0x9F, 0xFC, 0xFF, 0x80, 0x07, 0xC0, 0xFF, 0x06, 0x1C, 0x60,
  0x67, 0x02, 0xB0, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x06, 0x60, 0x71, 0x87, 0x0F, 0xF0, 0x1F, 0x00, 0x1F, 0xC0,
  0xFF, 0x86, 0x0C, 0x30, 0x31, 0x81, 0x98, 0x0C, 0xC0, 0x66, 0x03, 0x30,
  0x19, 0x80, 0xDC, 0x0E, 0xC0, 0x66, 0x03, 0x30, 0x31, 0x83, 0x8F, 0xF8,
  0xFF, 0x00, 0x1F, 0xFC, 0x7F, 0xF1, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0F, 0xFC, 0x3F, 0xF1, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x1F, 0xFC, 0x7F, 0xF1,
  0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0F, 0xFC, 0x3F, 0xF1,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00,
  0xC0, 0x00, 0x07, 0xC1, 0xFE, 0x38, 0x73, 0x03, 0x60, 0x26, 0x00, 0xC0,
  0x0C, 0x00, 0xC3, 0xEC, 0x3E, 0xC0, 0x6C, 0x06, 0xC0, 0x6C, 0x0E, 0xE1,
  0xC7, 0xEC, 0x3C, 0xC0, 0x18, 0x0C, 0x60, 0x73, 0x81, 0x8C, 0x06, 0x30,
  0x18, 0xC0, 0x63, 0x01, 0x8F, 0xFE, 0x7F, 0xF1, 0x80, 0xC6, 0x03, 0x18,
  0x0C, 0x60, 0x31, 0x81, 0x8C, 0x06, 0x30, 0x18, 0xC0, 0x60, 0x1F, 0xFC,
  0x7F, 0xF0, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x3F, 0xF8, 0xFF, 0xE0, 0x0F, 0xF8, 0x7F, 0xC0, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC4,
  0x06, 0x70, 0x61, 0x87, 0x07, 0xF0, 0x1F, 0x00, 0x18, 0x0E, 0x30, 0x38,
  0x60, 0xE1, 0x83, 0x83, 0x0C, 0x06, 0x30, 0x0C, 0xC0, 0x1B, 0x80, 0x3F,
  0x00, 0xF3, 0x01, 0xC6, 0x03, 0x0E, 0x06, 0x0C, 0x0C, 0x1C, 0x18, 0x18,
  0x60, 0x38, 0xC0, 0x30, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x30,
  0x07, 0xFF, 0xFF, 0xC0, 0x38, 0x1C, 0xE0, 0x73, 0xC3, 0xCF, 0x1B, 0x3C,
  0x78, 0xD3, 0x66, 0x6D, 0x99, 0xE6, 0x67, 0x19, 0x8C, 0x46, 0x23, 0x10,
  0x8C, 0xC0, 0x33, 0x00, 0xCC, 0x03, 0x30, 0x08, 0xC0, 0x60, 0x1C, 0x0C,
  0x70, 0x33, 0x41, 0x8D, 0x86, 0x36, 0x18, 0xD8, 0x63, 0x21, 0x8C, 0xC6,
  0x63, 0x31, 0x8C, 0xC6, 0x33, 0x18, 0x6C, 0x61, 0xB1, 0x06, 0x8C, 0x1E,
  0x30, 0x38, 0xC0, 0xE0, 0x07, 0xC1, 0xFE, 0x38, 0x77, 0x03, 0x60, 0x3E,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x06, 0xC0, 0x6C,
  0x0C, 0xE1, 0xC7, 0xF8, 0x3E, 0x00, 0x1F, 0xF0, 0x7F, 0xE1, 0x81, 0x8E,
  0x07, 0x30, 0x1C, 0xC0, 0x63, 0x01, 0x8C, 0x0E, 0x3F, 0xF1, 0xFF, 0x86,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0x07, 0xC1, 0xFE, 0x38, 0x77, 0x03, 0x60, 0x36, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x06, 0xC0, 0x6C, 0x0C, 0xE1, 0xC7, 0xF8,
  0x3E, 0x00, 0xC0, 0x06, 0x20, 0x67, 0x03, 0xC0, 0x18, 0x1F, 0xF0, 0x7F,
  0xE1, 0x81, 0x8E, 0x07, 0x30, 0x1C, 0xC0, 0x63, 0x01, 0x8C, 0x0E, 0x3F,
  0xF1, 0xFF, 0x06, 0x18, 0x18, 0x60, 0x61, 0xC1, 0x83, 0x06, 0x0C, 0x30,
  0x18, 0xC0, 0x70, 0x07, 0xE0, 0x7F, 0xC3, 0x83, 0x8C, 0x07, 0x30, 0x00,
  0xC0, 0x03, 0x80, 0x07, 0xC0, 0x0F, 0xE0, 0x03, 0xC0, 0x03, 0x00, 0x0C,
  0x80, 0x33, 0x00, 0xCE, 0x0E, 0x1F, 0xF8, 0x1F, 0x80, 0xFF, 0xFF, 0xFF,
  0xF0, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x1C, 0x00, 0x30, 0x19, 0x81, 0xD8, 0x0C, 0xC0, 0x66, 0x03, 0x30,
  0x19, 0x80, 0xCC, 0x0C, 0xC0, 0x66, 0x03, 0x30, 0x19, 0x80, 0xCC, 0x0E,
  0x60, 0x63, 0x87, 0x0F, 0xF0, 0x3F, 0x00, 0xC0, 0x3E, 0x01, 0xB0, 0x0D,
  0x80, 0xCC, 0x06, 0x60, 0x61, 0x83, 0x0C, 0x30, 0x61, 0x83, 0x18, 0x18,
  0xC0, 0xCC, 0x06, 0x60, 0x17, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x00, 0x30,
  0x06, 0x40, 0x0D, 0x80, 0x33, 0x00, 0x66, 0x38, 0xCC, 0x71, 0x99, 0xE6,
  0x33, 0xCC, 0x65, 0x98, 0xDB, 0x31, 0x36, 0xC2, 0x4D, 0x85, 0x9B, 0x1A,
  0x16, 0x3C, 0x28, 0x78, 0x70, 0xE0, 0xE0, 0x18, 0x07, 0x0C, 0x0E, 0x0C,
  0x0C, 0x06, 0x18, 0x06, 0x30, 0x03, 0x70, 0x03, 0xE0, 0x01, 0xC0, 0x01,
  0x80, 0x03, 0xC0, 0x06, 0xC0, 0x0C, 0x60, 0x1C, 0x60, 0x38, 0x70, 0x30,
  0x30, 0x60, 0x38, 0xC0, 0x18, 0xE0, 0x0D, 0x80, 0x66, 0x03, 0x0C, 0x1C,
  0x30, 0xE0, 0x63, 0x01, 0x98, 0x07, 0xE0, 0x0F, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x1F,
  0xFE, 0x3F, 0xFC, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x7F, 0xFC, 0xFF, 0xF8, 0x0F, 0xE3, 0xF8, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x0F, 0xE1,
  0xFC, 0x00, 0x82, 0x0C, 0x30, 0x41, 0x06, 0x18, 0x60, 0x82, 0x0C, 0x30,
  0x41, 0x06, 0x18, 0x60, 0x83, 0x0C, 0x30, 0x0F, 0xE1, 0xFC, 0x01, 0x80,
  0x20, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x8F, 0xE1,
  0xFC, 0x00, 0x03, 0x80, 0x78, 0x06, 0xC0, 0xCC, 0x18, 0xC3, 0x06, 0x30,
  0x66, 0x03, 0xC0, 0x3C, 0x03, 0xFF, 0xFF, 0xFF, 0x5B, 0x36, 0x0F, 0x31,
  0xFB, 0x38, 0x77, 0x03, 0x60, 0x36, 0x03, 0x60, 0x6C, 0x06, 0xC0, 0x6E,
  0x0E, 0x61, 0x67, 0xF7, 0x3C, 0x70, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0xCF, 0x86, 0xFE, 0x34, 0x31, 0xC1, 0x8C, 0x06,
  0x60, 0x36, 0x03, 0x30, 0x19, 0x80, 0xCC, 0x0E, 0x70, 0xE3, 0xFE, 0x33,
  0xE0, 0x0F, 0x87, 0xF9, 0xC3, 0xB0, 0x3E, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x58, 0x1F, 0x86, 0x3F, 0x83, 0xE0, 0x00, 0x0C, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0xF9, 0x87, 0xF4, 0x38, 0x71, 0xC0,
  0xC6, 0x03, 0x18, 0x0C, 0x60, 0x33, 0x01, 0x8C, 0x06, 0x38, 0x38, 0x61,
  0xE1, 0xFD, 0x83, 0xE6, 0x00, 0x0F, 0xC3, 0xFC, 0xC1, 0xB0, 0x3C, 0x1F,
  0xFF, 0xBF, 0x86, 0x00, 0xC0, 0x58, 0x1F, 0x87, 0x3F, 0xC3, 0xE0, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x1F,
  0xFE, 0x1F, 0xFE, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x83,
  0x00, 0xC3, 0x00, 0x66, 0x00, 0x76, 0x00, 0x3E, 0x00, 0x0C, 0x00, 0x0F,
  0x98, 0xFF, 0x8E, 0x1C, 0xE0, 0x66, 0x03, 0x30, 0x19, 0x80, 0xD8, 0x0C,
  0xC0, 0x63, 0x07, 0x18, 0x78, 0xFE, 0xC3, 0xE6, 0x00, 0x60, 0x03, 0x18,
  0x38, 0xFF, 0x81, 0xF0, 0x00, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x39, 0xC3, 0x3E, 0x34, 0x73, 0x83, 0x30, 0x33, 0x03, 0x30,
  0x36, 0x02, 0x60, 0x66, 0x06, 0x60, 0x66, 0x06, 0xE0, 0x60, 0x07, 0x00,
  0xE0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x04, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x10, 0x46, 0x38, 0xCE, 0x1B, 0x83, 0xE0, 0x70,
  0x00, 0x00, 0x70, 0x07, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE1,
  0xFE, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x41, 0x8E, 0x18, 0x73, 0x03, 0xB0, 0x1F, 0x00,
  0xE0, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE7,
  0x86, 0xFE, 0x34, 0x71, 0xC1, 0x8C, 0x0C, 0x60, 0xC3, 0x3C, 0x33, 0x81,
  0x98, 0x4C, 0x63, 0x63, 0x73, 0x0F, 0x38, 0x70, 0xFE, 0x3F, 0x00, 0xC0,
  0x30, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x30,
  0x0C, 0x33, 0x1C, 0xCE, 0x6E, 0x1F, 0x03, 0x80, 0x37, 0x3C, 0xDE, 0xF3,
  0x9C, 0xCC, 0x63, 0x31, 0x8C, 0x86, 0x36, 0x10, 0xD8, 0xC2, 0x63, 0x09,
  0x8C, 0x66, 0x31, 0x90, 0xC6, 0xC2, 0x18, 0x19, 0xC3, 0x3E, 0x34, 0x73,
  0x83, 0x30, 0x33, 0x03, 0x30, 0x36, 0x02, 0x60, 0x66, 0x06, 0x60, 0x66,
  0x06, 0xE0, 0x60, 0x0F, 0x87, 0xF9, 0xC3, 0xB0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x1B, 0x87, 0x3F, 0xC3, 0xE0, 0x19, 0xF0, 0x6F,
  0xE1, 0xA1, 0x87, 0x06, 0x18, 0x0C, 0x60, 0x33, 0x01, 0x8C, 0x06, 0x30,
  0x18, 0xC0, 0xE3, 0x87, 0x0B, 0xF8, 0x67, 0xC1, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x80, 0x00, 0x0F, 0x98, 0xFF, 0x8E, 0x1C, 0xE0, 0x66,
  0x03, 0x30, 0x19, 0x80, 0xD8, 0x0C, 0xC0, 0x67, 0x07, 0x18, 0x58, 0xFE,
  0xC3, 0xE6, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0xFC,
  0xFF, 0xBE, 0x1A, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x00, 0x07, 0xC1, 0xFF, 0x38, 0x33,
  0x00, 0x30, 0x03, 0xF0, 0x1F, 0xC0, 0x1E, 0x00, 0x64, 0x06, 0xE0, 0xE7,
  0xFC, 0x1F, 0x80, 0x06, 0x00, 0x80, 0x30, 0x06, 0x0F, 0xFF, 0xFF, 0xC3,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x21, 0x0E, 0x63, 0x8D, 0xE1,
  0xF0, 0x1C, 0x00, 0x60, 0x36, 0x06, 0x60, 0x66, 0x06, 0x60, 0x66, 0x06,
  0xC0, 0xEC, 0x0C, 0xC0, 0xCC, 0x1C, 0xE2, 0xC7, 0xEC, 0x39, 0xC0, 0xF8,
  0x6F, 0x06, 0x30, 0x63, 0x03, 0x30, 0x73, 0x06, 0x30, 0x62, 0x0E, 0x60,
  0xC6, 0x1C, 0x67, 0x87, 0xE0, 0x7C, 0x00, 0x21, 0x9B, 0x08, 0xD8, 0xC6,
  0xC6, 0x36, 0x31, 0xB1, 0x8D, 0x08, 0x78, 0x43, 0xC6, 0x16, 0x31, 0xB2,
  0x9D, 0xF7, 0xC7, 0x3C, 0x00, 0x06, 0x3C, 0x3E, 0xFC, 0xED, 0x9B, 0x0E,
  0x30, 0x18, 0x60, 0x70, 0x00, 0xE0, 0x01, 0x80, 0xC3, 0x09, 0x8A, 0x3B,
  0x36, 0xE7, 0xEF, 0x87, 0x8C, 0x00, 0x30, 0x19, 0x81, 0x8C, 0x0C, 0x60,
  0x63, 0x03, 0x18, 0x19, 0x80, 0xCC, 0x0C, 0x60, 0x63, 0x07, 0x1C, 0x58,
  0x7E, 0xC1, 0xCC, 0x00, 0x60, 0x03, 0x18, 0x30, 0xFF, 0x83, 0xF0, 0x00,
  0x1F, 0x19, 0xFE, 0xCC, 0x3E, 0x40, 0xC2, 0x0C, 0x00, 0xC0, 0x1C, 0x01,
  0xC4, 0x18, 0x21, 0x81, 0x9F, 0xCD, 0xBF, 0xEC, 0x3E, 0x00, 0x07, 0xE0,
  0xFC, 0x10, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x02, 0x00, 0xC3,
  0xF0, 0x7E, 0x00, 0xC0, 0x0C, 0x01, 0x00, 0x40, 0x10, 0x06, 0x00, 0x80,
  0x10, 0x03, 0xF0, 0x7E, 0x00, 0x08, 0xC6, 0x31, 0x8C, 0x46, 0x31, 0x8C,
  0x62, 0x31, 0x8C, 0x62, 0x11, 0x8C, 0x60, 0x0F, 0xC0, 0xFC, 0x00, 0xC0,
  0x0C, 0x00, 0x80, 0x18, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0xF0,
  0x7F, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0xFE, 0x0F, 0xC0, 0x1C, 0x09, 0xF0, 0xD9, 0x86, 0xC6, 0x6C, 0x1E,
  0x60, 0xF0,
};

const GFXglyph IBMPlexMono_Italic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 5, 17, 15, 5, -17 },
  { 12, 8, 7, 15, 5, -19 },
  { 19, 15, 17, 15, 0, -17 },
  { 51, 14, 23, 15, 1, -20 },
  { 92, 17, 17, 15, -1, -17 },
  { 129, 15, 17, 15, 0, -17 },
  { 161, 3, 7, 15, 7, -19 },
  { 164, 9, 22, 15, 5, -19 },
  { 189, 9, 22, 15, 1, -19 },
  { 214, 13, 12, 15, 1, -14 },
  { 234, 12, 12, 15, 2, -14 },
  { 252, 6, 7, 15, 3, -3 },
  { 258, 7, 2, 15, 4, -9 },
  { 260, 4, 3, 15, 5, -3 },
  { 262, 14, 22, 15, 1, -19 },
  { 301, 12, 17, 15, 2, -17 },
  { 327, 12, 17, 15, 1, -17 },
  { 353, 13, 17, 15, 1, -17 },
  { 381, 13, 17, 15, 1, -17 },
  { 409, 14, 17, 15, 0, -17 },
  { 439, 13, 17, 15, 1, -17 },
  { 467, 11, 17, 15, 2, -17 },
  { 491, 12, 17, 15, 3, -17 },
  { 517, 13, 17, 15, 1, -17 },
  { 545, 12, 17, 15, 2, -17 },
  { 571, 5, 13, 15, 5, -13 },
  { 580, 7, 17, 15, 3, -13 },
  { 595, 12, 14, 15, 2, -15 },
  { 616, 13, 7, 15, 1, -11 },
  { 628, 12, 14, 15, 1, -15 },
  { 649, 11, 17, 15, 3, -17 },
  { 673, 13, 20, 15, 1, -17 },
  { 706, 13, 17, 15, 0, -17 },
  { 734, 13, 17, 15, 1, -17 },
  { 762, 13, 17, 15, 2, -17 },
  { 790, 13, 17, 15, 1, -17 },
  { 818, 14, 17, 15, 1, -17 },
  { 848, 14, 17, 15, 1, -17 },
  { 878, 12, 17, 15, 2, -17 },
  { 904, 14, 17, 15, 1, -17 },
  { 934, 14, 17, 15, 1, -17 },
  { 964, 13, 17, 15, 1, -17 },
  { 992, 15, 17, 15, 1, -17 },
  { 1024, 11, 17, 15, 2, -17 },
  { 1048, 14, 17, 15, 1, -17 },
  { 1078, 14, 17, 15, 1, -17 },
  { 1108, 12, 17, 15, 2, -17 },
  { 1134, 14, 17, 15, 1, -17 },
  { 1164, 12, 22, 15, 2, -17 },
  { 1197, 14, 17, 15, 1, -17 },
  { 1227, 14, 17, 15, 1, -17 },
  { 1257, 14, 17, 15, 2, -17 },
  { 1287, 13, 17, 15, 2, -17 },
  { 1315, 13, 17, 15, 3, -17 },
  { 1343, 15, 17, 15, 1, -17 },
  { 1375, 16, 17, 15, 0, -17 },
  { 1409, 14, 17, 15, 2, -17 },
  { 1439, 15, 17, 15, 0, -17 },
  { 1471, 11, 22, 15, 4, -19 },
  { 1502, 6, 22, 15, 5, -19 },
  { 1519, 11, 22, 15, 0, -19 },
  { 1550, 12, 10, 15, 2, -17 },
  { 1565, 12, 2, 15, 0, 2 },
  { 1568, 3, 5, 15, 6, -20 },
  { 1570, 12, 13, 15, 1, -13 },
  { 1590, 13, 19, 15, 1, -19 },
  { 1621, 11, 13, 15, 2, -13 },
  { 1639, 14, 19, 15, 1, -19 },
  { 1673, 11, 13, 15, 2, -13 },
  { 1691, 16, 24, 15, 0, -19 },
  { 1739, 13, 18, 15, 1, -13 },
  { 1769, 12, 19, 15, 1, -19 },
  { 1798, 11, 19, 15, 2, -19 },
  { 1825, 12, 24, 15, 1, -19 },
  { 1861, 13, 19, 15, 1, -19 },
  { 1892, 10, 19, 15, 3, -19 },
  { 1916, 14, 13, 15, 0, -13 },
  { 1939, 12, 13, 15, 1, -13 },
  { 1959, 11, 13, 15, 2, -13 },
  { 1977, 14, 18, 15, 0, -13 },
  { 2009, 13, 18, 15, 1, -13 },
  { 2039, 12, 13, 15, 3, -13 },
  { 2059, 12, 13, 15, 1, -13 },
  { 2079, 11, 17, 15, 2, -17 },
  { 2103, 12, 13, 15, 2, -13 },
  { 2123, 12, 13, 15, 2, -13 },
  { 2143, 13, 13, 15, 1, -13 },
  { 2165, 15, 13, 15, 0, -13 },
  { 2190, 13, 18, 15, 1, -13 },
  { 2220, 13, 13, 15, 1, -13 },
  { 2242, 11, 22, 15, 3, -19 },
  { 2273, 5, 22, 15, 5, -19 },
  { 2287, 12, 22, 15, 1, -19 },
  { 2320, 13, 6, 15, 1, -10 },
};

const GFXfont IBMPlexMono_Italic25pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic25pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic25pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _IBMPLEXMONO_ITALIC25PT7B_H_
