#ifndef _IBMPLEXMONO_ITALIC72PT7B_H_
#define _IBMPLEXMONO_ITALIC72PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic72pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0x3F, 0x00, 0x1F, 0x80, 0xF8, 0xFC, 0x07,
  0xC7, 0xC0, 0x3E, 0x3E, 0x03, 0xF1, 0xF0, 0x1F, 0x8F, 0x80, 0xF8, 0xFC,
  0x07, 0xC7, 0xE0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x1F, 0x8F, 0x80, 0xFC,
  0x7C, 0x07, 0xC7, 0xE0, 0x3E, 0x3F, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80,
  0xFC, 0x7C, 0x07, 0xE3, 0xE0, 0x3E, 0x3F, 0x01, 0xF1, 0xF8, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x3F,
  0xFF, 0x80, 0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF,
  0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00,
  0xFF, 0xFE, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x7F, 0xFF, 0x00,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xFC,
  0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xE3, 0xCF, 0xFC, 0x00, 0xFF, 0x03, 0xC3, 0xFE, 0x01, 0xFE, 0x07,
  0xC0, 0xFF, 0x01, 0xFC, 0x07, 0xC0, 0x7F, 0x03, 0xF8, 0x07, 0x80, 0x3C,
  0x03, 0xF0, 0x07, 0x80, 0x18, 0x03, 0xF0, 0x07, 0x80, 0x00, 0x03, 0xF0,
  0x07, 0x80, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x0F, 0x80,
  0x00, 0x07, 0xE0, 0x0F, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0x00, 0x00, 0x03,
  0xF0, 0x0F, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0x00, 0x00, 0x03, 0xF8, 0x1F,
  0x00, 0x00, 0x01, 0xFE, 0x1F, 0x00, 0x00, 0x01, 0xFF, 0x9E, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x00, 0x3C, 0x3F, 0xE0, 0x00, 0x00, 0x3C, 0x1F, 0xE0, 0x00, 0x00, 0x7C,
  0x07, 0xF0, 0x00, 0x00, 0x7C, 0x07, 0xF0, 0x00, 0x00, 0x78, 0x03, 0xF0,
  0x00, 0x00, 0x78, 0x03, 0xF0, 0x00, 0x00, 0x78, 0x03, 0xF0, 0x00, 0x00,
  0x78, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x03,
  0xF0, 0x00, 0x00, 0xF0, 0x03, 0xF0, 0x18, 0x00, 0xF0, 0x03, 0xF0, 0x38,
  0x00, 0xF0, 0x07, 0xE0, 0x7C, 0x00, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xF0,
  0x0F, 0xE0, 0xFF, 0x81, 0xF0, 0x3F, 0xC0, 0x7F, 0xC1, 0xE0, 0x7F, 0x80,
  0x3F, 0xF9, 0xE3, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xC0,
  0x03, 0xFF, 0xFC, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xE0,
  0x03, 0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x01, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3C, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x0F, 0x80, 0xFC, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x7C,
  0x00, 0x03, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x01, 0xE0, 0x03, 0xE0, 0x7C,
  0x00, 0x00, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x3E,
  0x00, 0x00, 0x3E, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x3F,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x1F, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x1F,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xC1, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xC1,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xC1, 0xFC, 0x1F, 0x80, 0x00, 0x07, 0xC0,
  0xF8, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0xF8, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x3E, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x1F, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0xF8,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0xF8,
  0x01, 0xF0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x3E,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x10, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x00, 0x7F, 0xC3, 0xF8, 0x00, 0x00, 0xFF, 0xF3, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xDF, 0xFC, 0x00, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x33, 0xF0, 0x00, 0x1F, 0xC0, 0x1F, 0xFC, 0x00, 0x07, 0xF0, 0x07, 0xFF,
  0x00, 0x01, 0xFE, 0x03, 0xEF, 0xC0, 0x00, 0xEF, 0x81, 0xF9, 0xF8, 0x00,
  0x33, 0xF0, 0x7C, 0x7E, 0x00, 0x1C, 0xFC, 0x3F, 0x1F, 0xC0, 0x0F, 0x1F,
  0x8F, 0x83, 0xFC, 0x0F, 0x87, 0xE7, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x0F, 0x8F, 0xC7,
  0xE3, 0xE1, 0xF0, 0xF8, 0x7C, 0x7E, 0x3F, 0x1F, 0x0F, 0x87, 0xC3, 0xE3,
  0xF1, 0xF8, 0xF8, 0x7C, 0x3E, 0x1F, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x03, 0x00, 0x07, 0xC0, 0x03, 0x7E, 0x00,
  0xFC, 0x01, 0xF7, 0xFC, 0x0F, 0x80, 0xFF, 0xFF, 0xF8, 0xF8, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x03, 0xFB, 0xE0, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x07, 0xE1, 0xF0,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x03, 0xF8,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x07,
  0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x1F, 0x8F, 0xF9,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xF7, 0xFE, 0xFF, 0x87, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xF0, 0x1F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0xFC, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x7C,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x1F, 0x83, 0xE0, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0x00, 0xFC, 0xFC, 0x01, 0xF0, 0x07, 0xEF, 0xE0, 0x3F, 0xC0, 0x3F,
  0x7F, 0x01, 0xFE, 0x03, 0xFB, 0xF0, 0x1F, 0xF0, 0x1F, 0x9F, 0x80, 0xFF,
  0x80, 0xFC, 0xFC, 0x07, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0xC0, 0x3F, 0x3F,
  0x00, 0xFC, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x1F, 0xCF, 0x80, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x00, 0xFC,
  0x3E, 0x00, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x7E, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xF7, 0xE0,
  0x00, 0x03, 0xFC, 0xFC, 0x00, 0x01, 0xFE, 0x1F, 0x80, 0x00, 0x7F, 0x83,
  0xE0, 0x00, 0x1F, 0xE0, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0x80, 0x01, 0xFE,
  0x03, 0xF0, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x01,
  0xF0, 0x03, 0xF0, 0x00, 0x1C, 0x00, 0x7E, 0x00, 0x02, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F,
  0x80, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x01,
  0xE0, 0x00, 0x07, 0xE0, 0x03, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x08, 0x00, 0x00, 0x1F, 0xC0, 0x60, 0x00, 0x00, 0x7E, 0x07,
  0xC0, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x00,
  0xFD, 0xF8, 0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x01,
  0xF8, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x0F,
  0xF0, 0x00, 0x03, 0xE1, 0xFF, 0xF8, 0x00, 0x0F, 0x8F, 0xFF, 0xF0, 0x00,
  0x3E, 0x7F, 0xFF, 0xF0, 0x01, 0xFB, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x01, 0x00, 0x00, 0x07,
  0xF0, 0x0C, 0x00, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0xE0, 0x00, 0xFE, 0x1F,
  0xFF, 0x00, 0x1F, 0x8F, 0xFF, 0xF8, 0x07, 0xE3, 0xFF, 0xFF, 0x80, 0xFC,
  0xFF, 0xFF, 0xF8, 0x1F, 0xBE, 0x01, 0xFF, 0x87, 0xEF, 0x00, 0x0F, 0xF0,
  0xFF, 0x80, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x00,
  0xFC, 0xFE, 0x00, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x00, 0x7F, 0x7E, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFB, 0xF8,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0xFD,
  0xF8, 0x00, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF3, 0xE0, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0x0F, 0xE3, 0xE0, 0x00,
  0x00, 0xFC, 0x7E, 0x00, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x01, 0xF8, 0x7C,
  0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x07, 0xF0, 0x7C, 0x00, 0x00, 0x7E,
  0x07, 0xC0, 0x00, 0x0F, 0xE0, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x00,
  0xFF, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0xF8,
  0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0xC0,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x00, 0x1F, 0x8F,
  0xC0, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00,
  0x0F, 0xE3, 0xF0, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x01, 0xFC, 0x3F,
  0x80, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x03,
  0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0x80, 0x07, 0xF0,
  0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x03,
  0xF3, 0xF8, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00,
  0x07, 0xDF, 0x80, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x0F, 0xF7, 0xE0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x01, 0xFE,
  0x7F, 0x00, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0xF7, 0xE3, 0xFF, 0x00, 0xFB,
  0xF0, 0x7F, 0xFF, 0xFC, 0xFC, 0x0F, 0xFF, 0xFE, 0x7E, 0x01, 0xFF, 0xFF,
  0x1F, 0x80, 0x3F, 0xFF, 0x0F, 0xC0, 0x01, 0xFF, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x07, 0xFC, 0x1F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFE, 0x07, 0xFC,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x3F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF,
  0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x02, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x1F, 0xC0,
  0x00, 0xFE, 0x3F, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x01, 0xFD, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xF1, 0xC0, 0x00, 0x07, 0xE1, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x1F, 0xC0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xC1,
  0xF0, 0xF8, 0x01, 0xFF, 0x1F, 0x0F, 0x80, 0x7F, 0xF9, 0xF1, 0xF8, 0x0F,
  0xFF, 0x9F, 0x1F, 0x00, 0xFF, 0xFD, 0xF1, 0xF0, 0x1F, 0xC0, 0xDF, 0x1F,
  0x03, 0xF8, 0x07, 0xF3, 0xF0, 0x3F, 0x00, 0x3E, 0x3F, 0x07, 0xE0, 0x03,
  0xE3, 0xE0, 0x7E, 0x00, 0x3E, 0x3E, 0x07, 0xC0, 0x03, 0xE3, 0xE0, 0xFC,
  0x00, 0x3E, 0x7E, 0x0F, 0xC0, 0x03, 0xE7, 0xE0, 0xFC, 0x00, 0x7C, 0x7C,
  0x0F, 0xC0, 0x07, 0xC7, 0xC0, 0xF8, 0x00, 0x7C, 0x7C, 0x0F, 0x80, 0x07,
  0xC7, 0xC0, 0xF8, 0x00, 0x7C, 0x7C, 0x1F, 0x80, 0x0F, 0xCF, 0xC1, 0xF8,
  0x00, 0xF8, 0xF8, 0x1F, 0x80, 0x0F, 0x8F, 0x80, 0xF8, 0x01, 0xF8, 0xF8,
  0x0F, 0x80, 0x1F, 0x8F, 0x80, 0xF8, 0x02, 0xF8, 0xF8, 0x0F, 0xC0, 0x7F,
  0x8F, 0x80, 0xFE, 0x1D, 0xF0, 0xF8, 0x07, 0xFF, 0xDF, 0x0F, 0x80, 0x7F,
  0xF9, 0xF0, 0xF8, 0x03, 0xFF, 0x9F, 0x0F, 0x80, 0x1F, 0xE1, 0xF0, 0xF8,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00,
  0x0F, 0xCF, 0x80, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00,
  0x07, 0xC1, 0xF8, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0xFE, 0x00, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0x0F, 0xC7, 0xF0,
  0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7E,
  0x00, 0x0F, 0xF8, 0x03, 0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00,
  0x7F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0xF8,
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x01, 0xFC,
  0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x0F, 0xC1, 0xF0, 0x00,
  0x00, 0x7E, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x3F, 0x87,
  0xE0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00,
  0xFE, 0x0F, 0x80, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x00, 0xFE, 0x07, 0xE0,
  0x00, 0x3F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x1F,
  0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00,
  0x03, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0x80, 0xFC, 0x00, 0x00, 0x1C, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x03,
  0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x1F, 0xF0, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x7F,
  0xC0, 0x07, 0xE0, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x83, 0xF0,
  0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x00, 0x7F, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x1F,
  0x80, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x07, 0xE0, 0x03, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFC, 0x07, 0xFC,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0xFE, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x01, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0xCF, 0xE0,
  0x07, 0xFF, 0xF8, 0xFC, 0x00, 0x7F, 0xFF, 0x8F, 0xC0, 0x07, 0xFF, 0xF8,
  0xFC, 0x00, 0x7F, 0xFF, 0x8F, 0xC0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00,
  0x1F, 0x8F, 0xC0, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00, 0x1F, 0x0F, 0xC0,
  0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00,
  0x7E, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x03, 0xFE, 0x03, 0xF8, 0x00, 0xF7, 0xC0,
  0x3F, 0xE0, 0x3E, 0x7C, 0x01, 0xFF, 0xFF, 0xC7, 0xC0, 0x0F, 0xFF, 0xFC,
  0xFC, 0x00, 0x7F, 0xFF, 0x0F, 0xC0, 0x03, 0xFF, 0xE0, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x07, 0xC0, 0x00, 0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00,
  0x1F, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x04, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x7E, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x1F, 0x80, 0x00, 0x07, 0xF8, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x00, 0x1F, 0xE0, 0x01, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x7E, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xE0, 0x07, 0xF8, 0x00, 0x00, 0xFC,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x7F, 0x80, 0x00, 0x03, 0xF0, 0x1F,
  0xE0, 0x00, 0x00, 0x7C, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0x81, 0xFE, 0x00,
  0x00, 0x03, 0xF0, 0x7F, 0x80, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xC3, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0xFF, 0x80, 0x00, 0x00, 0x3E,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xCF, 0xFF, 0x00, 0x00, 0x01, 0xFB, 0xF7,
  0xE0, 0x00, 0x00, 0x3F, 0xFC, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x0F, 0xC0,
  0x00, 0x00, 0xFF, 0xC1, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x1F, 0x80, 0x00,
  0x07, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x7D, 0xF0, 0x01, 0xF7,
  0xC0, 0x1F, 0x7C, 0x00, 0xFB, 0xF0, 0x0F, 0xDF, 0x00, 0x7E, 0xFC, 0x03,
  0xF7, 0xC0, 0x1F, 0x3E, 0x00, 0xF8, 0xF8, 0x0F, 0xCF, 0x80, 0x3E, 0x3E,
  0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x81, 0xF0, 0xF8, 0x07, 0xE3, 0xE0, 0x7C,
  0x7E, 0x01, 0xF8, 0x7C, 0x3E, 0x1F, 0x80, 0x7E, 0x1F, 0x1F, 0x87, 0xC0,
  0x1F, 0x07, 0xC7, 0xC1, 0xF0, 0x07, 0xC1, 0xF3, 0xE0, 0x7C, 0x01, 0xF0,
  0x3E, 0xF8, 0x1F, 0x00, 0xFC, 0x0F, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xFF,
  0x03, 0xF0, 0x0F, 0xC0, 0xFF, 0x80, 0xF8, 0x03, 0xE0, 0x1F, 0xE0, 0x3E,
  0x00, 0xF8, 0x07, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x03, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x00, 0x7E, 0x01, 0xF8, 0x03,
  0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x30, 0x01,
  0xF0, 0x07, 0xC0, 0x04, 0x00, 0x7C, 0x03, 0xF0, 0x02, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x07, 0xE0, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0x00, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0xFF,
  0xC0, 0x00, 0x3E, 0x01, 0xFF, 0xC0, 0x00, 0x7E, 0x01, 0xFF, 0xC0, 0x00,
  0x7E, 0x01, 0xFF, 0xC0, 0x00, 0x7E, 0x01, 0xF7, 0xC0, 0x00, 0x7C, 0x01,
  0xF7, 0xE0, 0x00, 0x7C, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0x03, 0xF3, 0xE0,
  0x00, 0xFC, 0x03, 0xF3, 0xE0, 0x00, 0xFC, 0x03, 0xF3, 0xF0, 0x00, 0xFC,
  0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x03, 0xE1,
  0xF0, 0x00, 0xF8, 0x07, 0xE1, 0xF0, 0x01, 0xF8, 0x07, 0xE1, 0xF8, 0x01,
  0xF8, 0x07, 0xE0, 0xF8, 0x01, 0xF8, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x07,
  0xC0, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0xFC, 0x01, 0xF0, 0x0F, 0xC0, 0x7C,
  0x03, 0xF0, 0x0F, 0xC0, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x7C, 0x03, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x07,
  0xE0, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x1F,
  0x00, 0x1F, 0x07, 0xC0, 0x1F, 0x00, 0x1F, 0x0F, 0xC0, 0x3F, 0x00, 0x1F,
  0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x3F, 0x00, 0x0F, 0x8F, 0x80,
  0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x3E, 0x00,
  0x0F, 0xDF, 0x80, 0x7E, 0x00, 0x07, 0xDF, 0x80, 0x7E, 0x00, 0x07, 0xDF,
  0x80, 0x7E, 0x00, 0x07, 0xDF, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0x00, 0x7C,
  0x00, 0x07, 0xFF, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0x00, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x03,
  0xFB, 0xF8, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x03, 0xF9,
  0xF8, 0x00, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x03, 0xF9, 0xF8,
  0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0x0F,
  0xC1, 0xF0, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x7E, 0x00,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0xFF, 0x80,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x3E, 0x00,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x03, 0xF0,
  0x00, 0x0F, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xF0,
  0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0xFC, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00,
  0xFC, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x1F, 0x87, 0xF0,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0x3F,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0x00, 0x7E, 0x7F, 0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x1F, 0x9F,
  0x80, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x3F,
  0x3F, 0x00, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x00, 0x1F, 0xCF, 0xC0, 0x00,
  0x00, 0xFC, 0x7C, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x00,
  0xFC, 0x3E, 0x00, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF8,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x01, 0xF8, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xC0, 0x00, 0x0F, 0xE0, 0x0F,
  0x00, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0xFC, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0xFF, 0x80,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x3E, 0x00,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x03, 0xF0,
  0x00, 0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00, 0x3C,
  0x03, 0xF0, 0x00, 0x00, 0x18, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x18, 0x00, 0x00, 0x07, 0xF0, 0x3C,
  0x00, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x00, 0x7F, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00,
  0xFC, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x3F, 0x01,
  0xF0, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00,
  0x07, 0xF1, 0xF0, 0x00, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x00, 0x7E, 0x1F,
  0x00, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x01, 0xF0, 0x7E, 0x00, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x81, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0x00,
  0x7F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0x80, 0xFC, 0x03, 0xFC,
  0x01, 0xF0, 0x1F, 0x00, 0x7F, 0x80, 0x3E, 0x03, 0xE0, 0x1F, 0xF0, 0x0F,
  0xC0, 0x7C, 0x03, 0xFE, 0x01, 0xF0, 0x0F, 0x80, 0x7F, 0xC0, 0x3E, 0x01,
  0xF0, 0x1F, 0x78, 0x07, 0xC0, 0x3E, 0x03, 0xEF, 0x01, 0xF8, 0x07, 0xC0,
  0xF9, 0xE0, 0x3E, 0x00, 0xF8, 0x1F, 0x3C, 0x07, 0xC0, 0x1F, 0x03, 0xC7,
  0x80, 0xF8, 0x07, 0xE0, 0xF8, 0xF0, 0x3F, 0x00, 0xF8, 0x1F, 0x1F, 0x07,
  0xC0, 0x1F, 0x03, 0xC3, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x7C, 0x1F, 0x00,
  0x7C, 0x1F, 0x0F, 0x87, 0xE0, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x01, 0xF0,
  0xF8, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x07, 0xC3, 0xE0, 0x07, 0xC7, 0xC0,
  0xF8, 0xFC, 0x00, 0xF8, 0xF8, 0x1F, 0x1F, 0x00, 0x1F, 0x1E, 0x03, 0xE3,
  0xE0, 0x07, 0xE7, 0xC0, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x0F, 0x8F, 0x80,
  0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x00, 0x7C,
  0xF8, 0x03, 0xCF, 0x80, 0x0F, 0xBE, 0x00, 0x79, 0xF0, 0x01, 0xF7, 0xC0,
  0x0F, 0x7C, 0x00, 0x3E, 0xF0, 0x01, 0xEF, 0x80, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7E,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xDF, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00,
  0x00, 0x3F, 0x87, 0xE0, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0x81, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0x03, 0xE7, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xF7,
  0x80, 0x00, 0x00, 0x1E, 0x10, 0x00, 0x00, 0x01, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x04, 0x0F, 0x0F, 0xE1, 0xF8,
  0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x1E, 0x07, 0xC0,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0xFC, 0x01, 0xFF,
  0xFE, 0x1F, 0x80, 0x7F, 0xFF, 0xE3, 0xE0, 0x1F, 0xFF, 0xFE, 0x7C, 0x07,
  0xFC, 0x07, 0xDF, 0x81, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x01, 0xFE,
  0x0F, 0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00,
  0x7E, 0x1F, 0x80, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x00, 0x3F, 0x1F, 0x80, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0xF8, 0x7E,
  0x00, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0xFC,
  0x7E, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00,
  0x7C, 0x3F, 0x00, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x00, 0x7E, 0x1F, 0x80, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF8, 0x7E,
  0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x07, 0xF8,
  0x1F, 0x80, 0x01, 0xFF, 0x03, 0xF8, 0x00, 0x77, 0xE0, 0x7F, 0x00, 0x1C,
  0xFC, 0x07, 0xF8, 0x0F, 0x9F, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0x0F, 0xFF,
  0xF8, 0x7F, 0xE0, 0xFF, 0xFE, 0x07, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0x80,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x7F, 0x00, 0x03, 0xF0, 0x7F, 0xFC, 0x00, 0x7C, 0x1F, 0xFF, 0xC0, 0x0F,
  0x87, 0xFF, 0xFC, 0x03, 0xF1, 0xFF, 0xFF, 0xC0, 0x7E, 0x7C, 0x07, 0xF8,
  0x0F, 0xDE, 0x00, 0x3F, 0x81, 0xFB, 0x80, 0x03, 0xF0, 0x3E, 0xE0, 0x00,
  0x7F, 0x07, 0xF8, 0x00, 0x07, 0xE1, 0xFE, 0x00, 0x00, 0xFC, 0x3F, 0x80,
  0x00, 0x1F, 0x87, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x7E, 0x1F,
  0x80, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x3F,
  0x1F, 0x80, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00,
  0x1F, 0x8F, 0x80, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x00, 0xFC, 0x7E, 0x00,
  0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x7E, 0x3F,
  0x00, 0x00, 0x1F, 0xC7, 0xC0, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x00, 0x7E,
  0x3F, 0x00, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00,
  0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0x83, 0xEE, 0x00, 0x1F, 0xE0, 0x7C, 0xF0,
  0x0F, 0xF8, 0x1F, 0x9F, 0xFF, 0xFE, 0x03, 0xF1, 0xFF, 0xFF, 0x80, 0x7E,
  0x1F, 0xFF, 0xE0, 0x0F, 0xC1, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7E, 0x0F, 0xE0,
  0x00, 0x1F, 0x07, 0xE0, 0x00, 0x0F, 0x47, 0xE0, 0x00, 0x02, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0C,
  0x1F, 0x00, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07,
  0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0x1F,
  0xFF, 0x03, 0xE0, 0x01, 0xFF, 0xFE, 0x0F, 0x80, 0x0F, 0xFF, 0xFC, 0x7E,
  0x00, 0x7F, 0xFF, 0xF9, 0xF8, 0x03, 0xFE, 0x01, 0xF7, 0xE0, 0x1F, 0xE0,
  0x01, 0xDF, 0x80, 0xFF, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x3F, 0x03, 0xF8, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x0F, 0x81,
  0xF8, 0x00, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x7C, 0x0F,
  0xC0, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x7F, 0x80, 0xFC,
  0x00, 0x01, 0xFE, 0x01, 0xF8, 0x00, 0x0D, 0xF0, 0x07, 0xF0, 0x00, 0x67,
  0xC0, 0x1F, 0xE0, 0x07, 0xBF, 0x00, 0x3F, 0xC0, 0x7C, 0xFC, 0x00, 0xFF,
  0xFF, 0xE3, 0xF0, 0x01, 0xFF, 0xFF, 0x0F, 0xC0, 0x03, 0xFF, 0xF8, 0x3E,
  0x00, 0x07, 0xFF, 0xC0, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x07, 0xF8,
  0x0F, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x01,
  0xFC, 0xFC, 0x00, 0x03, 0xFC, 0x7E, 0x00, 0x0F, 0xFC, 0x3F, 0x01, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0x0F, 0xC0, 0x00, 0x03, 0xC7, 0xE0, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x03, 0xF1, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF8, 0x3F,
  0xC0, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x1F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x7E,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x81, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x07, 0xC0, 0x07, 0xFF, 0xF8, 0x3E, 0x00, 0x7F,
  0xFF, 0xE3, 0xF0, 0x07, 0xFF, 0xFF, 0x9F, 0x80, 0x7F, 0xE0, 0x3E, 0xFC,
  0x07, 0xF8, 0x00, 0x77, 0xC0, 0x3F, 0x80, 0x01, 0xFE, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x3F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0xFC, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x7E, 0x00, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x01, 0xF0,
  0x7E, 0x00, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x0F,
  0xE0, 0x7E, 0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xC0,
  0x00, 0x6F, 0xC0, 0x7F, 0x00, 0x07, 0x7C, 0x03, 0xFC, 0x00, 0xF3, 0xE0,
  0x0F, 0xF8, 0x1F, 0x9F, 0x00, 0x7F, 0xFF, 0xF9, 0xF8, 0x01, 0xFF, 0xFF,
  0x8F, 0xC0, 0x07, 0xFF, 0xF8, 0x7E, 0x00, 0x1F, 0xFF, 0x03, 0xE0, 0x00,
  0x1F, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x01, 0x00, 0x00, 0x1F, 0x80,
  0x0C, 0x00, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0xC0, 0x03, 0xF0, 0x7F, 0xF8,
  0x01, 0xF8, 0x7F, 0xFE, 0x00, 0xFC, 0x7F, 0xFF, 0x80, 0x7E, 0x7F, 0xFF,
  0xE0, 0x3E, 0x7C, 0x0F, 0xF0, 0x1F, 0x38, 0x01, 0xFC, 0x1F, 0xB8, 0x00,
  0xFE, 0x0F, 0xD8, 0x00, 0x3F, 0x07, 0xF8, 0x00, 0x1F, 0x83, 0xF8, 0x00,
  0x0F, 0xC1, 0xFC, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x01, 0xF0, 0xFE, 0x00,
  0x00, 0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0x3F, 0x0F, 0x80, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x0F, 0x87, 0xE0,
  0x00, 0x07, 0xC3, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0xF8,
  0x00, 0x01, 0xF8, 0x7C, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0x7C, 0x3F,
  0x00, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x87,
  0xC0, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x03, 0xE1,
  0xF8, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFC,
  0x3E, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x1F,
  0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x20, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x7F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x1F,
  0x80, 0x7F, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x07, 0xC0, 0xFF, 0x00, 0x03,
  0xE0, 0xFF, 0x00, 0x03, 0xF0, 0xFF, 0x00, 0x01, 0xF8, 0xFF, 0x00, 0x00,
  0xFC, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x40, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x3E, 0x00, 0x07, 0xF0, 0x0F, 0x80, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x1F,
  0xC1, 0xF8, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0x7F, 0x1F, 0x00, 0x00,
  0x0F, 0xE7, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E,
  0x01, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0xF8, 0x00, 0x1F, 0x87, 0xFF, 0xF0,
  0x00, 0xFC, 0x7F, 0xFF, 0xC0, 0x07, 0xE7, 0xFF, 0xFE, 0x00, 0x3E, 0x7C,
  0x0F, 0xF8, 0x01, 0xF3, 0x80, 0x1F, 0xC0, 0x1F, 0xB8, 0x00, 0x7E, 0x00,
  0xFD, 0x80, 0x03, 0xF0, 0x07, 0xF8, 0x00, 0x0F, 0x80, 0x3F, 0x80, 0x00,
  0x7C, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x01, 0xF8,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0x80, 0x01, 0xFC, 0x00, 0x7C, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x07, 0xF8, 0x00, 0x3F, 0x01, 0xFF, 0x00, 0x01,
  0xF8, 0x7F, 0xE0, 0x00, 0x0F, 0x87, 0xF8, 0x00, 0x00, 0x7C, 0x1F, 0x80,
  0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x41, 0xF8,
  0x1F, 0x80, 0x03, 0x0F, 0xC0, 0x7C, 0x00, 0x7C, 0x7C, 0x03, 0xF0, 0x07,
  0xF3, 0xE0, 0x1F, 0x80, 0x7F, 0x3F, 0x00, 0x7E, 0x07, 0xF1, 0xF8, 0x03,
  0xF0, 0x7F, 0x0F, 0xC0, 0x0F, 0xC7, 0xF0, 0x7E, 0x00, 0x7E, 0x7F, 0x03,
  0xE0, 0x01, 0xFF, 0xF0, 0x1F, 0x00, 0x0F, 0xFF, 0x01, 0xF8, 0x00, 0x3F,
  0xF0, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xC0, 0x3F, 0x00,
  0x0F, 0x80, 0xFC, 0x00, 0x7F, 0x03, 0xF0, 0x03, 0xF8, 0x0F, 0x80, 0x1F,
  0xC0, 0x3E, 0x00, 0xFE, 0x01, 0xF8, 0x0F, 0xF0, 0x07, 0xE0, 0x7F, 0x80,
  0x1F, 0x83, 0xFC, 0x00, 0x7C, 0x1F, 0xC0, 0x01, 0xF0, 0xFE, 0x00, 0x07,
  0xCF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE3, 0xFE, 0x07, 0xFC, 0x03, 0xE7, 0xFE, 0x0F,
  0xFE, 0x03, 0xE7, 0xFF, 0x1F, 0xFE, 0x07, 0xEF, 0xFF, 0x3F, 0xFF, 0x07,
  0xFC, 0x3F, 0x38, 0x7F, 0x07, 0xD8, 0x1F, 0x70, 0x3F, 0x07, 0xF0, 0x1F,
  0x60, 0x3F, 0x07, 0xE0, 0x1F, 0xC0, 0x1F, 0x07, 0xE0, 0x1F, 0xC0, 0x1F,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x0F, 0xC0,
  0x1F, 0x80, 0x3E, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x3F, 0x00, 0x3E, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x7E, 0x00, 0x7C, 0x01, 0xF8, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x01, 0xF8, 0x3F, 0xFC, 0x00, 0xFC, 0x3F, 0xFF, 0x00, 0x7E, 0x3F, 0xFF,
  0xC0, 0x3F, 0x3F, 0xFF, 0xF0, 0x1F, 0x3E, 0x07, 0xF8, 0x1F, 0x9C, 0x00,
  0xFE, 0x0F, 0xDC, 0x00, 0x7F, 0x07, 0xEC, 0x00, 0x1F, 0x83, 0xFC, 0x00,
  0x0F, 0xC1, 0xFC, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x01, 0xF0, 0xFE, 0x00,
  0x00, 0xF8, 0x7F, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x07, 0xC3, 0xF0, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x01, 0xF8, 0x7C, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0x7E, 0x3F,
  0x00, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x1F,
  0x8F, 0xC0, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F,
  0x80, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x07,
  0xE0, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x3E,
  0x3F, 0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x00,
  0xFD, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x01, 0xFB, 0xE0,
  0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x0F, 0xCF,
  0x80, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x7E,
  0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x0F,
  0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xF8, 0x3F, 0xFE, 0x00, 0x07, 0xC1, 0xFF, 0xFC, 0x00, 0x1F, 0x0F,
  0xFF, 0xF8, 0x00, 0xFC, 0x7F, 0xFF, 0xF0, 0x03, 0xF3, 0xE0, 0x3F, 0xC0,
  0x0F, 0xDE, 0x00, 0x3F, 0x80, 0x3F, 0x70, 0x00, 0x7E, 0x00, 0xFB, 0x80,
  0x01, 0xFC, 0x03, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0xE0, 0x00, 0x0F, 0xC0,
  0x7F, 0x00, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x0F,
  0x80, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x7C,
  0x00, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0xFC, 0x03, 0xFC,
  0x00, 0x07, 0xF0, 0x0F, 0xB8, 0x00, 0x7F, 0x80, 0x7E, 0x78, 0x07, 0xFC,
  0x01, 0xF9, 0xFF, 0xFF, 0xE0, 0x07, 0xE3, 0xFF, 0xFF, 0x00, 0x1F, 0x87,
  0xFF, 0xF8, 0x00, 0x7E, 0x0F, 0xFF, 0x80, 0x01, 0xF0, 0x07, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x7C, 0x01,
  0xFF, 0xFE, 0x1F, 0x80, 0x7F, 0xFF, 0xE3, 0xF0, 0x1F, 0xFF, 0xFE, 0x7E,
  0x07, 0xFC, 0x03, 0xEF, 0xC1, 0xFE, 0x00, 0x1D, 0xF0, 0x7F, 0x80, 0x01,
  0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0xF8, 0x7E,
  0x00, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x00, 0xFC,
  0x7E, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00,
  0x7C, 0x7E, 0x00, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x01, 0xF1, 0xF8, 0x00,
  0x00, 0x7E, 0x3F, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x1F, 0xE1, 0xF8, 0x00, 0x03,
  0xFC, 0x1F, 0x80, 0x00, 0xDF, 0x03, 0xF8, 0x00, 0x3B, 0xE0, 0x7F, 0x80,
  0x1E, 0xFC, 0x07, 0xF8, 0x0F, 0x9F, 0x80, 0xFF, 0xFF, 0xE3, 0xF0, 0x0F,
  0xFF, 0xF8, 0x7E, 0x00, 0xFF, 0xFE, 0x0F, 0x80, 0x0F, 0xFF, 0x81, 0xF0,
  0x00, 0x3F, 0x80, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xC0,
  0x0F, 0xCF, 0x80, 0x00, 0x03, 0xF7, 0x80, 0x00, 0x00, 0xFB, 0x80, 0x00,
  0x00, 0x3E, 0xC0, 0x00, 0x00, 0x1F, 0xA0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0x00, 0x03, 0xF8, 0x1F,
  0xC0, 0x00, 0x1C, 0x03, 0xF0, 0x00, 0x01, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x30,
  0x00, 0x00, 0x3F, 0x0F, 0x00, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x03, 0xF8,
  0xFF, 0x80, 0x00, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x08, 0x01, 0xF8, 0x00, 0x1C, 0x01,
  0xF8, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0xFE, 0x01, 0xF0, 0x01, 0xFF, 0x01,
  0xF0, 0x07, 0xFC, 0x03, 0xF0, 0x0F, 0xF0, 0x03, 0xF0, 0x3F, 0xE0, 0x03,
  0xF0, 0x7F, 0xC0, 0x03, 0xF1, 0xFF, 0x00, 0x03, 0xF3, 0xFE, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x1F,
  0x8F, 0xC0, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x3E, 0x1F, 0x80, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x0F, 0xC3, 0xE0, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0xFE, 0x1F, 0x80,
  0x00, 0xFF, 0x0F, 0xC0, 0x00, 0xDF, 0x07, 0xE0, 0x00, 0xFF, 0x83, 0xF8,
  0x00, 0xEF, 0xC0, 0xFE, 0x00, 0xF7, 0xE0, 0x7F, 0x81, 0xF3, 0xF0, 0x3F,
  0xFF, 0xF1, 0xF8, 0x0F, 0xFF, 0xF0, 0xF8, 0x03, 0xFF, 0xF0, 0x7C, 0x00,
  0xFF, 0xF0, 0x7E, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x3F, 0xFF, 0x00, 0x0F, 0xCF, 0xFF, 0xC0, 0x01, 0xFB, 0xFF, 0xF0, 0x00,
  0x7E, 0xFF, 0xF8, 0x00, 0x1F, 0xBF, 0xFE, 0x00, 0x03, 0xE0, 0x0F, 0x80,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x3F, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07,
  0xE0, 0x3E, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0x80,
  0x01, 0xF8, 0x07, 0xC0, 0x00, 0xFE, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x7C,
  0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x07, 0xF0, 0x03,
  0xF0, 0x03, 0xFC, 0x00, 0xF8, 0x01, 0xFE, 0x00, 0x3E, 0x01, 0xFF, 0x00,
  0x0F, 0x80, 0xFF, 0x80, 0x03, 0xE1, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x1F,
  0x00, 0x3E, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x0F, 0x83, 0xE0, 0x07, 0xC0,
  0x3E, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0xF8,
  0x01, 0xF0, 0x0F, 0xC3, 0xE0, 0x07, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x00,
  0x7C, 0x7C, 0x00, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE0, 0x07, 0xC7, 0xC0,
  0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x7C, 0x01, 0xF8, 0x01,
  0xF1, 0xF0, 0x07, 0xC0, 0x07, 0xCF, 0x80, 0x1F, 0x00, 0x1F, 0x3E, 0x00,
  0x7C, 0x00, 0xFC, 0xF8, 0x01, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC0, 0x0F,
  0x8F, 0x80, 0x3F, 0x00, 0x3E, 0x3E, 0x00, 0xF8, 0x00, 0xF9, 0xF0, 0x03,
  0xE0, 0x03, 0xE7, 0xC0, 0x0F, 0x80, 0x1F, 0x9F, 0x00, 0x3E, 0x00, 0x7C,
  0x7C, 0x00, 0xF8, 0x01, 0xF1, 0xF0, 0x07, 0xE0, 0x0F, 0xC7, 0xC0, 0x1F,
  0x00, 0x3F, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF0, 0x07, 0xE3,
  0xE0, 0x0F, 0xC0, 0x1F, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x3F, 0x01, 0xBC,
  0x07, 0xE0, 0xFC, 0x0E, 0xF8, 0x1F, 0x83, 0xF8, 0x7B, 0xE1, 0xFC, 0x0F,
  0xFF, 0xCF, 0xFF, 0xE0, 0x1F, 0xFE, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x7F,
  0xF8, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xF0, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0xE0, 0x07, 0xFF,
  0xE1, 0xFF, 0xFC, 0x03, 0xFE, 0x7C, 0x7E, 0x1F, 0x80, 0xFF, 0x0F, 0x8F,
  0x01, 0xF8, 0x3F, 0xC1, 0xF3, 0xC0, 0x3F, 0x1F, 0xE0, 0x1E, 0x78, 0x07,
  0xE1, 0xF0, 0x03, 0xCE, 0x00, 0xFC, 0x3C, 0x00, 0x7B, 0xC0, 0x1F, 0x82,
  0x00, 0x0F, 0x70, 0x03, 0xF0, 0x00, 0x01, 0xEE, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x80, 0x0F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0x80, 0x0F, 0xE0, 0x00, 0x01, 0xF0, 0x01, 0xBC, 0x00,
  0x20, 0x3E, 0x00, 0x77, 0x80, 0x06, 0x07, 0xC0, 0x0E, 0xF0, 0x03, 0xE1,
  0xF8, 0x03, 0x9F, 0x00, 0xFC, 0x3F, 0x00, 0xF3, 0xE0, 0x3F, 0xC3, 0xE0,
  0x1E, 0x7C, 0x1F, 0xE0, 0x7C, 0x07, 0x8F, 0x87, 0xF8, 0x0F, 0xC3, 0xF1,
  0xFB, 0xFC, 0x01, 0xFF, 0xFC, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x07, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x3F, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x3F, 0x00, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x7C, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00,
  0x3F, 0x80, 0x7E, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x1F,
  0x80, 0x01, 0xBE, 0x00, 0xFC, 0x00, 0x1D, 0xF0, 0x07, 0xF0, 0x01, 0xCF,
  0x80, 0x1F, 0xC0, 0x1E, 0xFC, 0x00, 0xFF, 0x03, 0xE7, 0xE0, 0x03, 0xFF,
  0xFE, 0x3F, 0x00, 0x1F, 0xFF, 0xF1, 0xF0, 0x00, 0x7F, 0xFE, 0x0F, 0x80,
  0x01, 0xFF, 0xE0, 0x7C, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x20, 0x00, 0x07, 0xF0, 0x03, 0x80, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x07, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x3F, 0x01, 0xFF, 0xFF, 0x03, 0xF0, 0x3F, 0xFF, 0xFC,
  0x3F, 0x07, 0xFF, 0xFF, 0xE3, 0xF0, 0x7F, 0x03, 0xFF, 0xBF, 0x0F, 0xC0,
  0x07, 0xFF, 0xE0, 0xF8, 0x00, 0x1F, 0xFC, 0x0F, 0x80, 0x00, 0x7F, 0x80,
  0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0xFE, 0x01, 0xF0, 0x00, 0x1F,
  0xC0, 0x1F, 0x00, 0x03, 0xF8, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x02, 0x00, 0x03, 0xF8, 0x01, 0xE0, 0x00, 0x7F, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x07, 0xE0, 0x00, 0x0F, 0x81, 0xFC, 0x00, 0x00, 0xF8, 0x3F, 0xF8,
  0x00, 0x0F, 0x87, 0xFF, 0xF8, 0x00, 0xFC, 0xFF, 0xFF, 0xFC, 0x07, 0xCF,
  0xCF, 0xFF, 0xFC, 0x7C, 0xFC, 0x1F, 0xFF, 0xFF, 0x8F, 0xC0, 0x3F, 0xFF,
  0xF8, 0xFC, 0x00, 0x7F, 0xFF, 0x0F, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x60, 0x03, 0xFE, 0x00, 0x01,
  0xF0, 0x1F, 0xFC, 0x00, 0x07, 0xC0, 0xFF, 0xF8, 0x00, 0x3E, 0x07, 0xFF,
  0xF0, 0x00, 0xF8, 0x3F, 0x0F, 0xC0, 0x07, 0xC0, 0xF8, 0x1F, 0x80, 0x1F,
  0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0xF8, 0x01,
  0xF8, 0x1F, 0x83, 0xE0, 0x03, 0xF0, 0xFC, 0x1F, 0x00, 0x0F, 0xFF, 0xE0,
  0x7C, 0x00, 0x1F, 0xFF, 0x81, 0xF0, 0x00, 0x3F, 0xFC, 0x0F, 0x80, 0x00,
  0x7F, 0xC0, 0x06, 0x00, 0x00, 0x7E, 0x00,
};

const GFXglyph IBMPlexMono_Italic72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 43, 0, -1 },
  { 1, 16, 51, 43, 14, -50 },
  { 103, 21, 20, 43, 15, -53 },
  { 156, 44, 50, 43, 1, -50 },
  { 431, 40, 66, 43, 2, -58 },
  { 761, 49, 52, 43, -2, -51 },
  { 1080, 42, 52, 43, 0, -51 },
  { 1353, 9, 20, 43, 21, -53 },
  { 1376, 27, 65, 43, 15, -55 },
  { 1596, 27, 65, 43, 3, -55 },
  { 1816, 36, 36, 43, 4, -39 },
  { 1978, 34, 35, 43, 5, -39 },
  { 2127, 16, 20, 43, 10, -10 },
  { 2167, 22, 5, 43, 11, -24 },
  { 2181, 11, 10, 43, 14, -9 },
  { 2195, 41, 65, 43, 2, -55 },
  { 2529, 37, 52, 43, 4, -51 },
  { 2770, 35, 50, 43, 3, -50 },
  { 2989, 38, 51, 43, 2, -51 },
  { 3232, 38, 52, 43, 2, -51 },
  { 3479, 39, 50, 43, 1, -50 },
  { 3723, 38, 51, 43, 3, -50 },
  { 3966, 35, 51, 43, 4, -50 },
  { 4190, 36, 50, 43, 7, -50 },
  { 4415, 38, 52, 43, 3, -51 },
  { 4662, 34, 51, 43, 6, -51 },
  { 4879, 15, 39, 43, 14, -38 },
  { 4953, 19, 48, 43, 10, -38 },
  { 5067, 35, 41, 43, 6, -43 },
  { 5247, 37, 20, 43, 4, -32 },
  { 5340, 34, 41, 43, 4, -43 },
  { 5515, 31, 52, 43, 9, -51 },
  { 5717, 36, 59, 43, 4, -51 },
  { 5983, 39, 50, 43, -1, -50 },
  { 6227, 37, 50, 43, 3, -50 },
  { 6459, 36, 52, 43, 6, -51 },
  { 6693, 37, 50, 43, 4, -50 },
  { 6925, 40, 50, 43, 3, -50 },
  { 7175, 40, 50, 43, 3, -50 },
  { 7425, 36, 52, 43, 5, -51 },
  { 7659, 40, 50, 43, 3, -50 },
  { 7909, 39, 50, 43, 3, -50 },
  { 8153, 36, 51, 43, 4, -50 },
  { 8383, 43, 50, 43, 3, -50 },
  { 8652, 30, 50, 43, 6, -50 },
  { 8840, 42, 50, 43, 2, -50 },
  { 9103, 40, 50, 43, 3, -50 },
  { 9353, 37, 52, 43, 4, -51 },
  { 9594, 39, 50, 43, 3, -50 },
  { 9838, 37, 64, 43, 4, -51 },
  { 10134, 39, 50, 43, 3, -50 },
  { 10378, 40, 52, 43, 2, -51 },
  { 10638, 41, 50, 43, 6, -50 },
  { 10895, 38, 51, 43, 5, -50 },
  { 11138, 38, 50, 43, 8, -50 },
  { 11376, 43, 50, 43, 3, -50 },
  { 11645, 47, 50, 43, -1, -50 },
  { 11939, 41, 50, 43, 6, -50 },
  { 12196, 44, 50, 43, 0, -50 },
  { 12471, 30, 65, 43, 12, -55 },
  { 12715, 19, 65, 43, 13, -55 },
  { 12870, 30, 65, 43, 1, -55 },
  { 13114, 36, 29, 43, 5, -50 },
  { 13245, 35, 5, 43, 0, 7 },
  { 13267, 10, 14, 43, 16, -56 },
  { 13285, 35, 39, 43, 4, -38 },
  { 13456, 35, 54, 43, 4, -53 },
  { 13693, 33, 39, 43, 5, -38 },
  { 13854, 38, 54, 43, 4, -53 },
  { 14111, 33, 39, 43, 5, -38 },
  { 14272, 47, 68, 43, -1, -53 },
  { 14672, 37, 53, 43, 2, -38 },
  { 14918, 33, 53, 43, 4, -53 },
  { 15137, 33, 54, 43, 6, -53 },
  { 15360, 34, 68, 43, 4, -53 },
  { 15649, 37, 54, 43, 4, -53 },
  { 15899, 30, 54, 43, 8, -53 },
  { 16102, 40, 38, 43, 1, -38 },
  { 16292, 33, 38, 43, 4, -38 },
  { 16449, 34, 39, 43, 5, -38 },
  { 16615, 38, 52, 43, 1, -38 },
  { 16862, 35, 52, 43, 4, -38 },
  { 17090, 34, 37, 43, 8, -37 },
  { 17248, 35, 39, 43, 3, -38 },
  { 17419, 32, 51, 43, 6, -50 },
  { 17623, 33, 38, 43, 6, -37 },
  { 17780, 34, 39, 43, 5, -38 },
  { 17946, 38, 39, 43, 3, -38 },
  { 18132, 43, 39, 43, 0, -38 },
  { 18342, 37, 52, 43, 2, -37 },
  { 18583, 36, 39, 43, 4, -38 },
  { 18759, 34, 65, 43, 8, -55 },
  { 19036, 16, 65, 43, 14, -55 },
  { 19166, 34, 65, 43, 3, -55 },
  { 19443, 38, 16, 43, 3, -30 },
};

const GFXfont IBMPlexMono_Italic72pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic72pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic72pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _IBMPLEXMONO_ITALIC72PT7B_H_
