#ifndef _IBMPLEXMONO_ITALIC51PT7B_H_
#define _IBMPLEXMONO_ITALIC51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x1F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3,
  0xF8, 0x3E, 0x00, 0x3C, 0x1E, 0x78, 0x3C, 0xE0, 0x71, 0xC1, 0xE7, 0x83,
  0xCF, 0x07, 0x9E, 0x0F, 0x3C, 0x1E, 0x70, 0x39, 0xE0, 0xF3, 0xC1, 0xE7,
  0x83, 0xCF, 0x07, 0x9E, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x0E, 0x00, 0x3F, 0xF8, 0x3F,
  0xF8, 0xFF, 0xE0, 0x7F, 0xE1, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0x83, 0xFF,
  0x80, 0x0E, 0x07, 0x80, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x0E, 0x07, 0x80, 0x1F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0x7F,
  0xE0, 0x7F, 0xF0, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0x83, 0xC0, 0x00, 0x0E,
  0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xE0,
  0x78, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x0E, 0x07,
  0x80, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0xC7, 0x3F, 0x80, 0xF8, 0x38, 0x7C, 0x0F, 0x83, 0x81, 0xF0, 0x78, 0x1C,
  0x06, 0x07, 0xC0, 0xE0, 0x20, 0x3E, 0x07, 0x00, 0x01, 0xE0, 0x38, 0x00,
  0x0F, 0x81, 0xC0, 0x00, 0x7C, 0x1C, 0x00, 0x01, 0xF0, 0xE0, 0x00, 0x0F,
  0xC7, 0x00, 0x00, 0x7F, 0xB8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xC7, 0xE0, 0x00, 0x0E, 0x0F, 0x80, 0x00, 0x70, 0x7C, 0x00,
  0x07, 0x01, 0xE0, 0x00, 0x38, 0x0F, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x0E,
  0x03, 0xC1, 0x80, 0x70, 0x3E, 0x1E, 0x03, 0x81, 0xF1, 0xF8, 0x38, 0x1F,
  0x07, 0xE1, 0xC1, 0xF8, 0x1F, 0xCE, 0x3F, 0x80, 0x7F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xC0, 0x3F, 0xF0,
  0x00, 0xE0, 0x1F, 0xFC, 0x00, 0x78, 0x0F, 0x87, 0x80, 0x3C, 0x03, 0xC0,
  0xE0, 0x0E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x70, 0x0F, 0x03, 0xC0, 0x1C,
  0x03, 0xC0, 0xE0, 0x0F, 0x00, 0xF0, 0x78, 0x03, 0xC0, 0x3C, 0x3C, 0x00,
  0xF0, 0x0E, 0x1E, 0x00, 0x3C, 0x07, 0x87, 0x00, 0x0F, 0x01, 0xE3, 0xC0,
  0x01, 0xC0, 0xF1, 0xE0, 0x00, 0x78, 0x7C, 0x70, 0x00, 0x1F, 0xFE, 0x20,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0x0F, 0xFE, 0x00, 0x07, 0x87, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0xF0, 0x00,
  0xE0, 0xE0, 0x1C, 0x00, 0x78, 0x78, 0x07, 0x00, 0x3C, 0x1C, 0x01, 0xC0,
  0x0E, 0x07, 0x00, 0xF0, 0x07, 0x81, 0xC0, 0x3C, 0x03, 0xC0, 0x70, 0x0F,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x07, 0x01, 0xE0, 0x3C, 0x01, 0xC0,
  0x78, 0x0E, 0x00, 0x78, 0x7C, 0x07, 0x80, 0x0F, 0xFE, 0x03, 0xC0, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7C,
  0x1F, 0x80, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x3C, 0x01,
  0xE0, 0x01, 0xF0, 0x07, 0x80, 0x03, 0x80, 0x1E, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x3C, 0x01, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0x03, 0xC0, 0x3E, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x3E, 0x1F,
  0x00, 0x01, 0xF0, 0x3C, 0x00, 0x07, 0x80, 0x78, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0xF8, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x02,
  0x3C, 0x00, 0x78, 0x06, 0xF0, 0x01, 0xF0, 0x3F, 0xC0, 0x07, 0xC1, 0xEF,
  0x80, 0x37, 0x87, 0x9E, 0x01, 0xDF, 0x3C, 0x7E, 0x0E, 0x7D, 0xF0, 0xFF,
  0xF8, 0xFF, 0x83, 0xFF, 0xC1, 0xFE, 0x07, 0xFE, 0x07, 0xF0, 0x07, 0xE0,
  0x07, 0x80, 0x3C, 0xF3, 0xCF, 0x3C, 0xE7, 0x9E, 0x79, 0xE7, 0x9C, 0xF3,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x70, 0x1E, 0x01, 0x9F, 0x87,
  0x83, 0xEF, 0xFD, 0xEF, 0xFC, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x03,
  0xE0, 0x07, 0xC0, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0xF0, 0x03, 0x80, 0x08,
  0x00, 0x40, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x0F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0xF0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF0, 0x1F, 0x03,
  0xE0, 0x3E, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFC, 0x03, 0xF8, 0x1F, 0x81, 0xF8, 0x03, 0xE0, 0x7C, 0x00, 0x78, 0x3E,
  0x00, 0x1F, 0x0F, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x3C,
  0xF8, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF7, 0xC0, 0x00,
  0x3D, 0xF0, 0x00, 0x0F, 0x78, 0x1F, 0x03, 0xDE, 0x0F, 0xC1, 0xF7, 0x83,
  0xF0, 0x7F, 0xE0, 0xFC, 0x1E, 0xF8, 0x3F, 0x07, 0xBE, 0x07, 0x81, 0xEF,
  0x00, 0x00, 0xFB, 0xC0, 0x00, 0x3E, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x03,
  0xCF, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x78, 0xF8, 0x00, 0x3E, 0x1E, 0x00,
  0x0F, 0x07, 0x80, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x0F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xEF, 0x00, 0x07, 0xE7, 0x80, 0x0F, 0xC7, 0x80, 0x0F,
  0xC3, 0xC0, 0x0F, 0xC1, 0xE0, 0x0F, 0xC0, 0xF0, 0x03, 0x80, 0x78, 0x01,
  0x80, 0x7C, 0x00, 0x80, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xC1, 0xFC, 0x07,
  0xE0, 0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0x80, 0x01,
  0xE1, 0x20, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xC0,
  0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0xF0, 0x00, 0xF8, 0x0C, 0x00, 0x0F, 0x00,
  0x80, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC1, 0x00, 0x00, 0xF0, 0x60, 0x00,
  0x3E, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x03, 0xF0, 0x3F, 0x01, 0xFC, 0x07,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x1F, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF0, 0xF0, 0x00,
  0x3C, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xE0, 0xF0, 0x00, 0x78, 0x1E,
  0x00, 0x1E, 0x03, 0xC0, 0x07, 0x80, 0x78, 0x01, 0xE0, 0x1E, 0x00, 0x78,
  0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0xF0, 0x01, 0xE0,
  0x3C, 0x00, 0x7C, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x01, 0xE0, 0x78, 0x00,
  0x3C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E,
  0x1F, 0xC0, 0x01, 0xCF, 0xFE, 0x00, 0x7B, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE,
  0x01, 0xFC, 0x0F, 0xE0, 0x3E, 0x00, 0x7C, 0x0F, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0x81, 0x00, 0x01, 0xF0, 0x70, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x87,
  0xF0, 0x03, 0xE0, 0x3F, 0x01, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x0F, 0xC0, 0x1E, 0x3F, 0xF0, 0x1E, 0xFF, 0xFC, 0x3D, 0xFF, 0xFE, 0x3F,
  0xC0, 0xFE, 0x7B, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0x78,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1E, 0xF8,
  0x00, 0x3E, 0x78, 0x00, 0x7C, 0x7C, 0x00, 0xFC, 0x3F, 0x03, 0xF8, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE,
  0x78, 0x00, 0x0F, 0x9E, 0x00, 0x03, 0xC7, 0x80, 0x01, 0xE1, 0xE0, 0x00,
  0x78, 0x70, 0x00, 0x3C, 0x1C, 0x00, 0x1F, 0x0F, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0x80,
  0xFC, 0x0F, 0xC0, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x0F,
  0x80, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x87, 0x80, 0x01,
  0xE0, 0xF8, 0x00, 0x7C, 0x0F, 0x00, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x1F, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x9F, 0x00, 0x00, 0xF3,
  0xE0, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xCF, 0x80, 0x00, 0xF9, 0xF0, 0x00,
  0x1F, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0x7F, 0x01, 0xFE, 0x07,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0xFE, 0x07, 0xE0, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0x3C, 0x78,
  0x00, 0x1E, 0x7C, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0xDE, 0x00, 0x03, 0xEF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7B, 0xE0, 0x00, 0x7C,
  0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x3F, 0x3E, 0x00, 0x3F, 0x1F, 0xC0, 0x77,
  0x87, 0xFF, 0xF7, 0xC1, 0xFF, 0xF3, 0xC0, 0x7F, 0xF3, 0xE0, 0x0F, 0xE1,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xC1, 0xFC, 0x7F, 0x8F, 0xF1,
  0xFC, 0x3F, 0x83, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC1, 0xF0, 0x00, 0x00, 0xF8, 0x07, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0xFC,
  0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x00, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xC0, 0x04, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x3F,
  0xFE, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xE3, 0xF0, 0x3F, 0x3E, 0x00, 0x7F,
  0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x79, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xF0, 0x1F, 0x01,
  0xF0, 0x03, 0xE0, 0xF8, 0x00, 0x78, 0x3C, 0x00, 0x0E, 0x0F, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0xF1, 0xE0, 0x3E, 0x3C, 0xF0, 0x3F, 0xCF, 0x3C, 0x1F,
  0xFB, 0x8F, 0x07, 0xFE, 0xE3, 0x83, 0xE0, 0xB9, 0xE0, 0xF0, 0x1E, 0x78,
  0x78, 0x07, 0x9E, 0x1E, 0x01, 0xE7, 0x87, 0x80, 0x71, 0xE3, 0xC0, 0x1C,
  0x70, 0xF0, 0x0F, 0x3C, 0x3C, 0x03, 0xCF, 0x0F, 0x00, 0xF3, 0xC3, 0xC0,
  0x3C, 0xF0, 0xF0, 0x1E, 0x3C, 0x3C, 0x07, 0x8F, 0x0F, 0x03, 0xE3, 0xC3,
  0xF7, 0xF8, 0xE0, 0x7F, 0xDE, 0x38, 0x1F, 0xE7, 0x8F, 0x03, 0xF9, 0xC3,
  0xC0, 0x18, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x78,
  0x78, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x1E, 0x00,
  0x0F, 0x03, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x1E, 0x01,
  0xE0, 0x03, 0xC0, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x07,
  0xC0, 0x0F, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF0, 0x3C, 0x00, 0x1F, 0x07, 0x80, 0x03, 0xE1, 0xF0,
  0x00, 0x3C, 0x3C, 0x00, 0x07, 0x8F, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x1E,
  0x7C, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x03, 0xC0, 0x0F, 0xC1, 0xF0, 0x01, 0xF0, 0x78, 0x00,
  0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x78,
  0x00, 0x3C, 0x3C, 0x00, 0x1F, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x03, 0xE0,
  0xF0, 0x03, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x78, 0x00, 0xFC, 0x1E, 0x00, 0x0F, 0x07, 0x80,
  0x03, 0xE1, 0xE0, 0x00, 0x78, 0xF8, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x8F,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0xF8, 0xF0, 0x00, 0x3E, 0x3C, 0x00, 0x0F,
  0x1F, 0x00, 0x07, 0xC7, 0x80, 0x03, 0xE1, 0xE0, 0x03, 0xF8, 0x7F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x03, 0xF8, 0x3F, 0x01, 0xF8, 0x03, 0xE0, 0xF8, 0x00, 0x78, 0x3E, 0x00,
  0x1E, 0x1F, 0x00, 0x03, 0xC7, 0x80, 0x01, 0x03, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x01, 0x83, 0xC0, 0x00, 0x78, 0xF8, 0x00, 0x3E, 0x1E, 0x00, 0x0F,
  0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x07, 0x80, 0x7F, 0x01, 0xE0, 0x07, 0xC0, 0x78, 0x00, 0xF8, 0x1E,
  0x00, 0x1E, 0x0F, 0x80, 0x07, 0x83, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x3C,
  0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF1, 0xF0, 0x00,
  0x7C, 0x78, 0x00, 0x1F, 0x1E, 0x00, 0x07, 0xC7, 0x80, 0x01, 0xF1, 0xE0,
  0x00, 0x78, 0x78, 0x00, 0x1E, 0x3E, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xE3,
  0xC0, 0x00, 0xF8, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x07,
  0xC7, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF8, 0x78, 0x00, 0x3C, 0x1E, 0x00,
  0x1F, 0x07, 0x80, 0x1F, 0x81, 0xE0, 0x1F, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFE, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x07, 0xFF, 0xFC, 0x03, 0xF8, 0x1F, 0x80, 0xF8, 0x03, 0xE0, 0x7C, 0x00,
  0x7C, 0x3E, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x81, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x7F, 0xF1, 0xE0, 0x1F, 0xFC, 0x78, 0x07, 0xFF, 0x3E, 0x01,
  0xFF, 0xCF, 0x80, 0x80, 0xF3, 0xE0, 0x00, 0x3C, 0xF8, 0x00, 0x0E, 0x3E,
  0x00, 0x07, 0x8F, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x3E,
  0x1E, 0x00, 0x0F, 0x87, 0xC0, 0x07, 0xC1, 0xF8, 0x03, 0xF0, 0x3F, 0x03,
  0xBC, 0x0F, 0xFF, 0xCF, 0x01, 0xFF, 0xF3, 0xC0, 0x3F, 0xF0, 0xF0, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E,
  0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0xF8,
  0x00, 0x3E, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x7C, 0x1F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF8, 0x1E, 0x00, 0x07, 0x83, 0xE0, 0x00, 0xF8, 0x3C, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00,
  0x0F, 0x07, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0,
  0x78, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x0F, 0x80,
  0x03, 0xE0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0, 0x03, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x04,
  0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x10, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x87, 0x80, 0x07,
  0x83, 0xE0, 0x07, 0xC0, 0xF8, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x1F, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x7E, 0x07, 0x80, 0x01, 0xF0, 0x0F, 0x00, 0x07, 0xC0, 0x1E,
  0x00, 0x1F, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0,
  0x07, 0xC0, 0x03, 0xC0, 0x1F, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x0F, 0x01,
  0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x78, 0x1F, 0x00, 0x00, 0xF0, 0x7C,
  0x00, 0x01, 0xE1, 0xF0, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x07, 0x9F, 0x80,
  0x00, 0x1F, 0x7F, 0x00, 0x00, 0x3C, 0xFF, 0x00, 0x00, 0x7B, 0xDE, 0x00,
  0x00, 0xFF, 0x3E, 0x00, 0x01, 0xFC, 0x3C, 0x00, 0x03, 0xF0, 0x7C, 0x00,
  0x0F, 0xC0, 0x78, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xF0, 0x00,
  0x78, 0x01, 0xE0, 0x00, 0xF0, 0x03, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x0F, 0x80, 0x3C,
  0x00, 0x1F, 0x00, 0x78, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x03, 0xF0,
  0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x7E, 0x03, 0xF0, 0x03, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F,
  0x81, 0xEE, 0x03, 0xDE, 0x07, 0xB8, 0x0E, 0x70, 0x1C, 0xF0, 0x7B, 0xC0,
  0x73, 0xC1, 0xCF, 0x03, 0xC7, 0x0F, 0x3C, 0x0F, 0x1C, 0x78, 0xF0, 0x3C,
  0x79, 0xE3, 0xC0, 0xF1, 0xEF, 0x0E, 0x03, 0xC3, 0xB8, 0x78, 0x0E, 0x0F,
  0xE1, 0xE0, 0x78, 0x3F, 0x07, 0x81, 0xE0, 0xFC, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xC0, 0x78, 0x1C, 0x0F, 0x01, 0xC0, 0x60, 0x3C,
  0x0F, 0x00, 0x80, 0xF0, 0x3C, 0x04, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x38, 0x0F, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x07, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03,
  0xC0, 0x03, 0xF0, 0x00, 0xF0, 0x3F, 0x00, 0x0F, 0x03, 0xF8, 0x00, 0xF0,
  0x7F, 0x80, 0x0F, 0x07, 0xF8, 0x00, 0xE0, 0x7B, 0x80, 0x1E, 0x07, 0xB8,
  0x01, 0xE0, 0x7B, 0xC0, 0x1E, 0x07, 0x3C, 0x01, 0xE0, 0xF3, 0xC0, 0x1E,
  0x0F, 0x1C, 0x01, 0xC0, 0xF1, 0xE0, 0x3C, 0x0F, 0x1E, 0x03, 0xC0, 0xF1,
  0xE0, 0x3C, 0x0E, 0x1E, 0x03, 0xC1, 0xE0, 0xE0, 0x3C, 0x1E, 0x0F, 0x03,
  0x81, 0xE0, 0xF0, 0x78, 0x1E, 0x0F, 0x07, 0x81, 0xE0, 0x70, 0x78, 0x1C,
  0x07, 0x87, 0x83, 0xC0, 0x78, 0x78, 0x3C, 0x07, 0x87, 0x03, 0xC0, 0x78,
  0xF0, 0x3C, 0x03, 0x8F, 0x03, 0xC0, 0x3C, 0xF0, 0x38, 0x03, 0xCF, 0x07,
  0x80, 0x3C, 0xF0, 0x78, 0x01, 0xCE, 0x07, 0x80, 0x1D, 0xE0, 0x78, 0x01,
  0xFE, 0x07, 0x80, 0x1F, 0xE0, 0x70, 0x01, 0xFE, 0x0F, 0x00, 0x0F, 0xE0,
  0xF0, 0x00, 0xFC, 0x0F, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xF8, 0x1F, 0x81,
  0xF8, 0x03, 0xE0, 0x7C, 0x00, 0x78, 0x3E, 0x00, 0x1F, 0x0F, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x3C, 0xF8, 0x00, 0x0F, 0x3C, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x3D, 0xF0, 0x00, 0x0F, 0x78,
  0x00, 0x07, 0xDE, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1E,
  0xF8, 0x00, 0x07, 0xBE, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xFB, 0xC0, 0x00,
  0x3E, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xF3, 0xC0,
  0x00, 0x78, 0xF8, 0x00, 0x3E, 0x1E, 0x00, 0x1F, 0x07, 0x80, 0x07, 0xC1,
  0xF0, 0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xC0,
  0x07, 0xE0, 0x7C, 0x00, 0x1E, 0x07, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x1F,
  0x07, 0x80, 0x01, 0xF0, 0x78, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xF0, 0xF8,
  0x00, 0x1F, 0x0F, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x03,
  0xE0, 0xF0, 0x00, 0x7C, 0x0F, 0x00, 0x0F, 0xC1, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFC, 0x03, 0xF8, 0x1F, 0x01, 0xF8, 0x03, 0xE0, 0x7C, 0x00,
  0x78, 0x3E, 0x00, 0x1F, 0x0F, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF1, 0xE0,
  0x00, 0x3C, 0xF8, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF7,
  0xC0, 0x00, 0x3D, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xDE, 0x00, 0x01,
  0xF7, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x07, 0xBE, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x3E, 0xF0, 0x00, 0x0F, 0x3C,
  0x00, 0x03, 0xCF, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x78, 0xF8, 0x00, 0x3E,
  0x1E, 0x00, 0x1F, 0x07, 0x80, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0x3F, 0x03,
  0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x80, 0x03, 0xC0, 0x70, 0x00, 0xF8, 0x3C,
  0x00, 0x1F, 0x1F, 0x80, 0x03, 0xEF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xC0,
  0x07, 0xE0, 0x7C, 0x00, 0x1E, 0x07, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x1F,
  0x07, 0x80, 0x01, 0xF0, 0x78, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xF0, 0xF8,
  0x00, 0x1F, 0x0F, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x03,
  0xE0, 0xF0, 0x00, 0x7C, 0x0F, 0x00, 0x1F, 0xC1, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xE0, 0x78,
  0x00, 0x1E, 0x03, 0xC0, 0x03, 0xE0, 0x3C, 0x00, 0x3E, 0x03, 0xE0, 0x03,
  0xC0, 0x1E, 0x00, 0x3C, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x7C, 0x00, 0x78, 0x07, 0x80, 0x07, 0xC0,
  0x78, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x3E, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xF0, 0x00, 0xF8,
  0x1F, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x0C, 0x0F, 0x80, 0x00, 0x40, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x81, 0x00, 0x00, 0x7C, 0x3C,
  0x00, 0x03, 0xC3, 0xF0, 0x00, 0x3E, 0x0F, 0xC0, 0x03, 0xE0, 0x3F, 0x80,
  0x7F, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF1, 0xF0,
  0x00, 0x3C, 0x78, 0x00, 0x1F, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE1,
  0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x3E, 0x00, 0x07, 0x8F, 0x00, 0x03,
  0xE3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00,
  0x03, 0xC7, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x7C, 0x78, 0x00, 0x1F, 0x1E,
  0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0xF8, 0x00, 0x1E,
  0x3C, 0x00, 0x0F, 0x8F, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0xF0, 0xF0, 0x00,
  0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0xC3, 0xC0, 0x01, 0xE0, 0xF0,
  0x00, 0x78, 0x3C, 0x00, 0x3E, 0x0F, 0x00, 0x0F, 0x03, 0xE0, 0x07, 0xC0,
  0x7E, 0x07, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x3E, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x03,
  0xCF, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x3E, 0x1E, 0x00,
  0x0F, 0x07, 0x80, 0x07, 0xC1, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0xF8, 0x1E,
  0x00, 0x3C, 0x07, 0x80, 0x0F, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x1F, 0x00, 0x3C, 0x07,
  0x80, 0x0F, 0x03, 0xE0, 0x03, 0xC0, 0xF0, 0x00, 0x70, 0x3C, 0x00, 0x1E,
  0x1E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0x78, 0xF0, 0x00,
  0x1E, 0x78, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x38, 0x78, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x70,
  0x70, 0x1F, 0x03, 0xC1, 0xC0, 0xFC, 0x0F, 0x0F, 0x03, 0xF0, 0x3C, 0x3C,
  0x0F, 0xC0, 0xE0, 0xF0, 0x7F, 0x07, 0x83, 0xC1, 0xDC, 0x1E, 0x0F, 0x07,
  0x70, 0x78, 0x3C, 0x39, 0xC1, 0xC0, 0xF0, 0xE7, 0x07, 0x03, 0x87, 0x9C,
  0x3C, 0x0E, 0x1C, 0x70, 0xF0, 0x38, 0x71, 0xC3, 0xC0, 0xE3, 0xC7, 0x0E,
  0x07, 0x8E, 0x1C, 0x78, 0x1E, 0x38, 0x71, 0xE0, 0x79, 0xE1, 0xC7, 0x81,
  0xE7, 0x07, 0x9C, 0x07, 0x9C, 0x1E, 0xF0, 0x1E, 0xF0, 0x7B, 0xC0, 0x7B,
  0x81, 0xEF, 0x01, 0xDE, 0x07, 0xB8, 0x07, 0x70, 0x1E, 0xE0, 0x1D, 0xC0,
  0x7F, 0x80, 0x7F, 0x01, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x3C, 0x00,
  0x03, 0xE0, 0x0F, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x0F, 0x80, 0x00,
  0xF8, 0x07, 0xC0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x00, 0xF0, 0x7C, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x07, 0x9F, 0x00,
  0x00, 0x01, 0xEF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00,
  0x7C, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x3C, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x0F, 0x80, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3E, 0x78, 0x00, 0x03,
  0xE7, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0xF0, 0x3E,
  0x00, 0x1F, 0x01, 0xE0, 0x03, 0xE0, 0x1E, 0x00, 0x3C, 0x01, 0xF0, 0x07,
  0xC0, 0x0F, 0x00, 0xF8, 0x00, 0xF0, 0x1F, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x78, 0x3E, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0xF0,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x3F, 0xFF,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1E,
  0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0xC7, 0x80, 0x01, 0xE0, 0xE0, 0x00,
  0xF0, 0x3C, 0x00, 0x78, 0x0F, 0x00, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x07, 0x80, 0x0E, 0x03, 0xC0, 0x03, 0xC1, 0xF0, 0x00, 0xF0, 0x78, 0x00,
  0x1E, 0x3C, 0x00, 0x07, 0x9F, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0x20, 0x00, 0x02, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x33, 0xCF, 0x1C, 0x79, 0xE3,
  0x8F, 0x1C, 0x60, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0x8F, 0x07, 0xFF, 0xCF,
  0x0F, 0xFF, 0xEF, 0x0F, 0xC0, 0xEF, 0x1F, 0x00, 0x3F, 0x3E, 0x00, 0x1F,
  0x3C, 0x00, 0x1E, 0x7C, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E,
  0x78, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C,
  0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x7C,
  0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x03, 0x78,
  0x7E, 0x0E, 0x7F, 0x7F, 0xFE, 0x7F, 0x3F, 0xFC, 0x7F, 0x1F, 0xF8, 0x3F,
  0x07, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0xFE, 0x00, 0xF1, 0xFF, 0xC0, 0x79, 0xFF, 0xF0, 0x3D,
  0xFF, 0xF8, 0x3E, 0xE0, 0x7E, 0x1E, 0xC0, 0x1F, 0x0F, 0x40, 0x07, 0x87,
  0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xE0, 0x00, 0x79, 0xF0, 0x00, 0x3C,
  0xF0, 0x00, 0x1E, 0x78, 0x00, 0x1F, 0x3C, 0x00, 0x0F, 0x9E, 0x00, 0x07,
  0x8F, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF3, 0xC0, 0x00,
  0xF1, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7A, 0x00,
  0x7E, 0x3D, 0xC0, 0xFE, 0x1E, 0x7F, 0xFE, 0x0F, 0x3F, 0xFE, 0x07, 0x8F,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFC, 0x0F, 0xC3, 0xE0, 0x07, 0x8F, 0x80,
  0x0F, 0x1E, 0x00, 0x0D, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0xE7,
  0x80, 0x01, 0xEF, 0x00, 0x07, 0x8F, 0x00, 0x1E, 0x1F, 0x00, 0x7C, 0x3F,
  0x03, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x3F, 0x03, 0xC0, 0x1F, 0xF8, 0x78, 0x0F, 0xFF,
  0x8F, 0x03, 0xFF, 0xFB, 0xC0, 0x7E, 0x07, 0xF8, 0x1F, 0x00, 0x3F, 0x07,
  0xC0, 0x03, 0xE0, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0x87, 0x80, 0x01,
  0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x87, 0xC0, 0x00, 0xF0, 0xF0,
  0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1E,
  0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0xF8, 0x3C, 0x00, 0x1F, 0x07, 0x80,
  0x07, 0xE0, 0xF8, 0x01, 0xF8, 0x1F, 0x00, 0x7F, 0x01, 0xF8, 0x3D, 0xE0,
  0x3F, 0xFF, 0x3C, 0x03, 0xFF, 0xC7, 0x80, 0x3F, 0xF0, 0xF0, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0xFC, 0x07, 0xE3, 0xE0, 0x07, 0xCF, 0x80, 0x07, 0x9E, 0x00,
  0x0F, 0x7C, 0x00, 0x1E, 0xF0, 0x00, 0x7D, 0xE0, 0x01, 0xF7, 0x80, 0x0F,
  0xEF, 0x01, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0x7F, 0xF0, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x47, 0x80, 0x00, 0xCF,
  0x00, 0x03, 0xDF, 0x00, 0x0F, 0x1F, 0x00, 0x3E, 0x3F, 0x01, 0xF8, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x0C, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x03, 0xE0, 0x1E, 0x00,
  0x00, 0x7C, 0x0F, 0x00, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x01, 0xF0, 0xF0,
  0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xF0, 0xF0, 0x1F,
  0xFE, 0x3C, 0x1F, 0xFF, 0xDE, 0x07, 0xE0, 0x7F, 0x83, 0xE0, 0x07, 0xE1,
  0xF0, 0x00, 0xF8, 0x78, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0x8F, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x7C, 0x00, 0x0F, 0x1E, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x1E,
  0x00, 0x07, 0x87, 0x80, 0x03, 0xE1, 0xE0, 0x01, 0xF8, 0x7C, 0x00, 0xDE,
  0x1F, 0x00, 0x7F, 0x03, 0xF0, 0x7B, 0xC0, 0xFF, 0xFC, 0xF0, 0x1F, 0xFE,
  0x3C, 0x03, 0xFF, 0x0F, 0x00, 0x3F, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x80, 0x07, 0xC0,
  0x70, 0x03, 0xF0, 0x3F, 0x03, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0xF0, 0xFF, 0x81, 0xE3, 0xFF,
  0x83, 0xCF, 0xFF, 0x87, 0xB8, 0x3F, 0x0F, 0x60, 0x3E, 0x3F, 0x80, 0x3C,
  0x7A, 0x00, 0x78, 0xF8, 0x00, 0xF1, 0xF0, 0x01, 0xE3, 0xC0, 0x03, 0xC7,
  0x80, 0x07, 0x9E, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF0,
  0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xCF, 0x00, 0x07, 0x9E, 0x00,
  0x0F, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x01,
  0xE7, 0x80, 0x03, 0xCF, 0x00, 0x07, 0x9E, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0x20, 0x0F, 0x00, 0x60, 0x1E, 0x01, 0xE0, 0x3C, 0x07,
  0xC0, 0x78, 0x3F, 0x00, 0xE0, 0xFC, 0x03, 0xC3, 0xF0, 0x07, 0x8F, 0xC0,
  0x0F, 0x3F, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF8,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x30, 0x07, 0x80, 0x70, 0x07, 0x80,
  0xF8, 0x07, 0x80, 0x7C, 0x0F, 0x00, 0x3E, 0x0F, 0x00, 0x1F, 0x0F, 0x00,
  0x0F, 0x8F, 0x00, 0x07, 0xCF, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x0F, 0xC0, 0x0F, 0x0F, 0xF8,
  0x03, 0xC7, 0xFF, 0x00, 0xF3, 0xFF, 0xE0, 0x3D, 0xC0, 0xF8, 0x0F, 0xE0,
  0x1E, 0x07, 0xF0, 0x07, 0x81, 0xF8, 0x01, 0xE0, 0x7C, 0x00, 0x78, 0x1F,
  0x00, 0x1E, 0x07, 0x80, 0x0F, 0x81, 0xE0, 0x07, 0xC0, 0xF0, 0x03, 0xE0,
  0x3C, 0x03, 0xF0, 0x0F, 0x07, 0xF0, 0x03, 0xCF, 0xF0, 0x00, 0xF1, 0xE0,
  0x00, 0x3C, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x47, 0x83, 0xC0, 0x39, 0xE0,
  0x78, 0x1F, 0x78, 0x1E, 0x0F, 0x9E, 0x07, 0xC7, 0xC7, 0x80, 0xF3, 0xE3,
  0xC0, 0x3F, 0xF0, 0xF0, 0x07, 0xF8, 0x3C, 0x01, 0xFC, 0x00, 0x00, 0x3C,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0x80, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x01, 0x01, 0xE0, 0x0E, 0x07, 0x80, 0x7C, 0x1E, 0x07, 0xE0,
  0x78, 0x3F, 0x03, 0xC1, 0xF8, 0x0F, 0x0F, 0xC0, 0x3C, 0x7E, 0x00, 0xF3,
  0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1E, 0x07, 0xC0, 0xF7, 0xF0, 0xFE, 0x0E, 0x7F, 0x9F, 0xF0,
  0xEF, 0xFB, 0xFF, 0x1F, 0xC7, 0xB1, 0xF1, 0xF0, 0x7E, 0x0F, 0x1F, 0x03,
  0xC0, 0xF1, 0xE0, 0x7C, 0x0F, 0x1E, 0x07, 0x80, 0xF1, 0xC0, 0x78, 0x0E,
  0x3C, 0x07, 0x80, 0xE3, 0xC0, 0x78, 0x0E, 0x3C, 0x07, 0x01, 0xE3, 0xC0,
  0x70, 0x1E, 0x38, 0x0F, 0x01, 0xE3, 0x80, 0xF0, 0x1C, 0x78, 0x0F, 0x01,
  0xC7, 0x80, 0xF0, 0x1C, 0x78, 0x0E, 0x03, 0xC7, 0x80, 0xE0, 0x3C, 0x70,
  0x1E, 0x03, 0xC7, 0x01, 0xE0, 0x38, 0xF0, 0x1E, 0x03, 0x8F, 0x01, 0xE0,
  0x78, 0xF0, 0x1C, 0x07, 0x8F, 0x01, 0xC0, 0x78, 0xE0, 0x3C, 0x07, 0x80,
  0x00, 0x03, 0xE0, 0x1E, 0x1F, 0xF0, 0x3C, 0x7F, 0xF0, 0x79, 0xFF, 0xF0,
  0xF7, 0x07, 0xE1, 0xEC, 0x07, 0xC7, 0xF0, 0x07, 0x8F, 0x40, 0x0F, 0x1F,
  0x00, 0x1E, 0x3E, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF3, 0xC0,
  0x01, 0xE7, 0x80, 0x03, 0xCF, 0x00, 0x07, 0x9E, 0x00, 0x1E, 0x3C, 0x00,
  0x3C, 0x78, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xE7, 0x80, 0x03,
  0xCF, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0x79,
  0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xE0, 0x7E, 0x1F, 0x80, 0x1E,
  0x1F, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x7C, 0x00, 0x0F,
  0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1E,
  0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3E, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x7C,
  0x7C, 0x00, 0xF8, 0x3F, 0x03, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x78, 0xFF,
  0xE0, 0x0F, 0x3F, 0xFE, 0x01, 0xEF, 0xFF, 0xC0, 0x7D, 0xC0, 0xFC, 0x0F,
  0x60, 0x0F, 0x81, 0xE8, 0x00, 0xF0, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03,
  0xE0, 0xF0, 0x00, 0x3C, 0x3E, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0xF0,
  0x00, 0x3E, 0x1E, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1E,
  0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x0F, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x40, 0x0F, 0xC1,
  0xEE, 0x07, 0xF0, 0x3C, 0xFF, 0xFC, 0x07, 0x9F, 0xFF, 0x00, 0xF1, 0xFF,
  0xC0, 0x1E, 0x0F, 0xE0, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFF, 0xC3, 0xC1, 0xFF, 0xF1, 0xE1, 0xFF, 0xFD, 0xE0,
  0xFC, 0x0F, 0xF0, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0x7C, 0x78, 0x00, 0x3E,
  0x7C, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x8F, 0x00, 0x03,
  0xCF, 0x80, 0x01, 0xE7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x79, 0xE0, 0x00,
  0x78, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x1F, 0x1E, 0x00,
  0x0F, 0x8F, 0x00, 0x0F, 0xC7, 0xC0, 0x0F, 0xC3, 0xE0, 0x0D, 0xE0, 0xFC,
  0x1E, 0xF0, 0x7F, 0xFE, 0x78, 0x1F, 0xFE, 0x3C, 0x07, 0xFE, 0x1E, 0x00,
  0xFC, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0xFF, 0xE0, 0x7F, 0xFF, 0xE1,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE7, 0xFE, 0x01, 0xEF, 0x00, 0x01, 0xEC,
  0x00, 0x03, 0xD0, 0x00, 0x03, 0xD0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F,
  0xFF, 0xF0, 0x7E, 0x01, 0xF8, 0x3C, 0x00, 0x38, 0x3C, 0x00, 0x08, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC1, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0xF1, 0xF0, 0x00,
  0xF9, 0xFE, 0x01, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x60, 0x3C,
  0x01, 0xE0, 0x78, 0x0F, 0xE0, 0xF0, 0x3F, 0x81, 0xE1, 0xFC, 0x03, 0xC7,
  0xF0, 0x0F, 0x3F, 0x80, 0x1F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x1E, 0x00,
  0x1E, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00,
  0x1E, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x78, 0x00,
  0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x78, 0x78, 0x00,
  0x78, 0x78, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF8, 0xF0, 0x00,
  0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x06, 0xF0, 0x7C, 0x1C,
  0xF0, 0x7F, 0xFC, 0xF0, 0x3F, 0xF8, 0xF0, 0x1F, 0xF1, 0xE0, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x06, 0x3F, 0xE0, 0x0F, 0x9F, 0xF0, 0x03, 0xCF, 0xF8,
  0x01, 0xEF, 0xFC, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x3E, 0x07,
  0x00, 0x1F, 0x07, 0x80, 0x0F, 0x83, 0xC0, 0x07, 0x81, 0xE0, 0x03, 0xC0,
  0xF0, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x38, 0x00, 0xF8, 0x3C, 0x00, 0x78,
  0x1E, 0x00, 0x7C, 0x0F, 0x00, 0x3E, 0x07, 0x80, 0x3E, 0x03, 0xC0, 0x3E,
  0x01, 0xC0, 0x3F, 0x00, 0xE0, 0x3F, 0x00, 0xF0, 0x3F, 0x00, 0x78, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xC3, 0xC0, 0x78, 0x78, 0x78, 0x0E, 0x07,
  0x0F, 0x01, 0xC0, 0xF1, 0xE0, 0x78, 0x1E, 0x38, 0x0F, 0x03, 0xC7, 0x01,
  0xE0, 0x79, 0xE0, 0x38, 0x0F, 0x3C, 0x07, 0x01, 0xE7, 0x80, 0xE0, 0x3C,
  0xF0, 0x3C, 0x07, 0x9C, 0x07, 0x80, 0xF3, 0x80, 0xF0, 0x1E, 0xF0, 0x1C,
  0x03, 0xDE, 0x03, 0x80, 0x73, 0xC0, 0xF0, 0x1E, 0x78, 0x1E, 0x03, 0xCE,
  0x03, 0xC0, 0x79, 0xC0, 0x78, 0x0E, 0x78, 0x0F, 0x03, 0xCF, 0x03, 0xC0,
  0x79, 0xE0, 0x78, 0x1E, 0x3C, 0x1F, 0x87, 0xC7, 0xC7, 0xF1, 0xF0, 0xFF,
  0xCF, 0xFE, 0x0F, 0xF1, 0xFF, 0x81, 0xFE, 0x3F, 0xE0, 0x1F, 0x01, 0xF0,
  0x00, 0x00, 0x3C, 0x01, 0xF0, 0x01, 0xF8, 0x1F, 0xE0, 0x1F, 0xF0, 0xFF,
  0x80, 0xFF, 0xC7, 0xFF, 0x07, 0xE7, 0x3C, 0x3C, 0x3E, 0x1C, 0xE0, 0xF3,
  0xF0, 0x7B, 0x03, 0xC7, 0x01, 0xFC, 0x0F, 0x18, 0x07, 0xE0, 0x3C, 0x00,
  0x1F, 0x80, 0xF0, 0x00, 0x7C, 0x03, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x40, 0x3E, 0x00, 0x0F, 0x00, 0xF8, 0x00,
  0x3C, 0x07, 0xE0, 0x18, 0xF0, 0x1B, 0x80, 0xF3, 0xC0, 0xEE, 0x0F, 0xCF,
  0x07, 0xBC, 0x7C, 0x1E, 0x3C, 0xF3, 0xE0, 0x7F, 0xF3, 0xFF, 0x01, 0xFF,
  0x87, 0xF8, 0x03, 0xFC, 0x1F, 0xC0, 0x07, 0xC0, 0x3C, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x01, 0xE0,
  0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00,
  0x3C, 0x07, 0x80, 0x07, 0x80, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x07,
  0x80, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x03,
  0xC0, 0x78, 0x00, 0x78, 0x1E, 0x00, 0x1F, 0x03, 0xC0, 0x03, 0xE0, 0x7C,
  0x00, 0xFC, 0x0F, 0x80, 0x3F, 0x01, 0xF0, 0x0D, 0xE0, 0x1F, 0x87, 0xBC,
  0x03, 0xFF, 0xE7, 0x80, 0x3F, 0xF8, 0xF0, 0x03, 0xFE, 0x3E, 0x00, 0x3F,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF0, 0x08, 0x00, 0x3E, 0x01, 0x80, 0x0F, 0xC0, 0x7C, 0x07,
  0xF0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0xC1, 0xF0, 0xFF, 0xF8,
  0x78, 0x7F, 0xFF, 0x9E, 0x1F, 0x07, 0xFF, 0x87, 0x00, 0x3F, 0xE3, 0xC0,
  0x03, 0xE0, 0xF0, 0x01, 0xF0, 0x3C, 0x00, 0xF8, 0x0F, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x0C, 0x00, 0xF8,
  0x07, 0x00, 0x7C, 0x01, 0xE0, 0x3E, 0x00, 0x78, 0x1E, 0x00, 0x0E, 0x0F,
  0xC0, 0x03, 0x8F, 0xFF, 0x80, 0xF3, 0xDF, 0xFE, 0x3C, 0xF0, 0xFF, 0xFF,
  0x3C, 0x07, 0xFF, 0x8F, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x1F, 0xFF,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0,
  0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C,
  0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x0F,
  0x01, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x80, 0xFF, 0x00, 0x3C, 0x3F, 0xF0, 0x07, 0x87, 0xFE, 0x00, 0xE1, 0xE3,
  0xE0, 0x3C, 0x78, 0x3E, 0x07, 0x0F, 0x03, 0xC1, 0xE1, 0xC0, 0x7C, 0x78,
  0x78, 0x07, 0xFF, 0x0E, 0x00, 0x7F, 0xC3, 0xC0, 0x07, 0xF0, 0x18, 0x00,
  0x78, 0x00,
};

const GFXglyph IBMPlexMono_Italic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 11, 36, 31, 10, -36 },
  { 51, 15, 14, 31, 11, -38 },
  { 78, 31, 36, 31, 1, -36 },
  { 218, 29, 47, 31, 1, -41 },
  { 389, 34, 37, 31, -1, -36 },
  { 547, 30, 37, 31, 0, -36 },
  { 686, 6, 14, 31, 15, -38 },
  { 697, 19, 46, 31, 10, -39 },
  { 807, 19, 46, 31, 2, -39 },
  { 917, 26, 25, 31, 3, -28 },
  { 999, 25, 26, 31, 3, -29 },
  { 1081, 12, 14, 31, 7, -7 },
  { 1102, 15, 4, 31, 8, -17 },
  { 1110, 7, 7, 31, 10, -7 },
  { 1117, 29, 46, 31, 1, -39 },
  { 1284, 26, 37, 31, 3, -36 },
  { 1405, 25, 36, 31, 2, -36 },
  { 1518, 27, 36, 31, 1, -36 },
  { 1640, 27, 37, 31, 1, -36 },
  { 1765, 27, 36, 31, 1, -36 },
  { 1887, 27, 37, 31, 2, -36 },
  { 2012, 24, 37, 31, 3, -36 },
  { 2123, 26, 36, 31, 5, -36 },
  { 2240, 27, 37, 31, 2, -36 },
  { 2365, 25, 36, 31, 4, -36 },
  { 2478, 11, 27, 31, 10, -27 },
  { 2516, 14, 34, 31, 7, -27 },
  { 2576, 25, 29, 31, 4, -30 },
  { 2667, 26, 14, 31, 3, -23 },
  { 2713, 25, 29, 31, 2, -30 },
  { 2804, 21, 36, 31, 7, -36 },
  { 2899, 26, 42, 31, 3, -36 },
  { 3036, 27, 36, 31, 0, -36 },
  { 3158, 26, 36, 31, 2, -36 },
  { 3275, 26, 37, 31, 4, -36 },
  { 3396, 26, 36, 31, 3, -36 },
  { 3513, 28, 36, 31, 2, -36 },
  { 3639, 29, 36, 31, 2, -36 },
  { 3770, 26, 37, 31, 3, -36 },
  { 3891, 28, 36, 31, 2, -36 },
  { 4017, 28, 36, 31, 2, -36 },
  { 4143, 25, 37, 31, 3, -36 },
  { 4259, 31, 36, 31, 2, -36 },
  { 4399, 22, 36, 31, 4, -36 },
  { 4498, 30, 36, 31, 1, -36 },
  { 4633, 28, 36, 31, 2, -36 },
  { 4759, 26, 37, 31, 3, -36 },
  { 4880, 28, 36, 31, 2, -36 },
  { 5006, 26, 46, 31, 3, -36 },
  { 5156, 28, 36, 31, 2, -36 },
  { 5282, 29, 37, 31, 1, -36 },
  { 5417, 29, 36, 31, 4, -36 },
  { 5548, 26, 37, 31, 4, -36 },
  { 5669, 26, 36, 31, 6, -36 },
  { 5786, 30, 36, 31, 2, -36 },
  { 5921, 34, 36, 31, -1, -36 },
  { 6074, 28, 36, 31, 5, -36 },
  { 6200, 31, 36, 31, 0, -36 },
  { 6340, 22, 46, 31, 8, -39 },
  { 6467, 14, 46, 31, 9, -39 },
  { 6548, 21, 46, 31, 1, -39 },
  { 6669, 26, 21, 31, 3, -36 },
  { 6738, 25, 4, 31, 0, 5 },
  { 6751, 6, 10, 31, 12, -40 },
  { 6759, 24, 28, 31, 3, -27 },
  { 6843, 25, 39, 31, 3, -38 },
  { 6965, 23, 28, 31, 4, -27 },
  { 7046, 27, 39, 31, 3, -38 },
  { 7178, 23, 28, 31, 4, -27 },
  { 7259, 34, 49, 31, -1, -38 },
  { 7468, 26, 38, 31, 2, -27 },
  { 7592, 23, 38, 31, 3, -38 },
  { 7702, 23, 39, 31, 4, -38 },
  { 7815, 24, 49, 31, 3, -38 },
  { 7962, 26, 39, 31, 3, -38 },
  { 8089, 22, 39, 31, 5, -38 },
  { 8197, 28, 27, 31, 1, -27 },
  { 8292, 23, 27, 31, 3, -27 },
  { 8370, 24, 28, 31, 3, -27 },
  { 8454, 27, 37, 31, 1, -27 },
  { 8579, 25, 37, 31, 3, -27 },
  { 8695, 24, 26, 31, 6, -26 },
  { 8773, 25, 28, 31, 2, -27 },
  { 8861, 23, 37, 31, 4, -36 },
  { 8968, 24, 27, 31, 4, -26 },
  { 9049, 25, 27, 31, 3, -27 },
  { 9134, 27, 28, 31, 2, -27 },
  { 9229, 30, 28, 31, 0, -27 },
  { 9334, 27, 37, 31, 1, -26 },
  { 9459, 26, 28, 31, 3, -27 },
  { 9550, 23, 46, 31, 6, -39 },
  { 9683, 11, 46, 31, 10, -39 },
  { 9747, 24, 46, 31, 2, -39 },
  { 9885, 27, 12, 31, 2, -21 },
};

const GFXfont IBMPlexMono_Italic51pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic51pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic51pt7bGlyphs,
  0x20, 0x7E, 66
};

#endif // _IBMPLEXMONO_ITALIC51PT7B_H_
