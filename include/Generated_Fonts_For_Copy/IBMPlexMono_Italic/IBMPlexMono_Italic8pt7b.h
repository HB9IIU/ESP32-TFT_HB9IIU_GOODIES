#ifndef _IBMPLEXMONO_ITALIC8PT7B_H_
#define _IBMPLEXMONO_ITALIC8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic8pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xF0, 0x39, 0x96, 0xCF, 0x50, 0x33, 0xD8, 0x63, 0x79, 0x00,
  0x6D, 0xAC, 0xAE, 0xD8, 0x22, 0x95, 0xCB, 0x7C, 0xC0, 0x72, 0x49, 0x20,
  0x24, 0x92, 0xB0, 0x27, 0xD9, 0x60, 0x5D, 0x40, 0x60, 0xE0, 0x80, 0x18,
  0x88, 0x44, 0x22, 0x00, 0x32, 0xA3, 0x69, 0x38, 0x36, 0x22, 0x2F, 0x35,
  0x11, 0x6F, 0x35, 0x13, 0x1F, 0x13, 0x55, 0xF2, 0x3A, 0x11, 0x61, 0x78,
  0x12, 0x47, 0x97, 0xFA, 0x24, 0x48, 0x32, 0x54, 0xE9, 0x38, 0x76, 0xF3,
  0x80, 0x90, 0x41, 0x80, 0x16, 0x84, 0x20, 0x78, 0x3C, 0x42, 0x12, 0xC0,
  0x74, 0xA1, 0x80, 0x32, 0xAF, 0xAD, 0x51, 0x80, 0x23, 0x55, 0xB9, 0x75,
  0x5B, 0x9F, 0x69, 0x88, 0xAE, 0x62, 0x92, 0xA9, 0x70, 0x7A, 0x11, 0x68,
  0x78, 0x7A, 0x11, 0x68, 0x40, 0x69, 0x8E, 0xAE, 0x4A, 0x55, 0x69, 0x48,
  0x79, 0x08, 0x42, 0x78, 0x31, 0x11, 0x1E, 0x4A, 0x98, 0xC9, 0x48, 0x92,
  0x49, 0xC0, 0x4A, 0xFD, 0x69, 0x48, 0x4A, 0x5D, 0x69, 0x48, 0x32, 0xA3,
  0x29, 0x38, 0x72, 0x52, 0xE8, 0x40, 0x32, 0xA3, 0x29, 0x38, 0xC0, 0x72,
  0x52, 0xEA, 0x48, 0x32, 0xD0, 0x61, 0x78, 0xF4, 0x44, 0x48, 0x99, 0xAA,
  0xAE, 0x99, 0xAA, 0xC4, 0x8C, 0x6B, 0xE7, 0x68, 0x4A, 0x88, 0x45, 0x48,
  0x9A, 0xA4, 0x48, 0x78, 0x88, 0x44, 0x78, 0x74, 0x48, 0x88, 0xE0, 0x91,
  0x24, 0x98, 0x64, 0x92, 0x70, 0x46, 0xAB, 0xF0, 0x80, 0x79, 0x97, 0x44,
  0x79, 0x9F, 0xF2, 0x70, 0x08, 0x9D, 0x29, 0x38, 0xF7, 0x70, 0x19, 0x1E,
  0x42, 0x13, 0x08, 0x79, 0x97, 0x1E, 0x44, 0x75, 0x99, 0x43, 0x2A, 0x80,
  0x10, 0x71, 0x22, 0xE2, 0x42, 0x1C, 0xAA, 0x5C, 0xC9, 0x4B, 0x80, 0xFD,
  0xAD, 0xA0, 0x75, 0x99, 0xF6, 0xF0, 0x79, 0x95, 0xA8, 0x79, 0x97, 0x12,
  0xF4, 0x88, 0x74, 0x3F, 0x4A, 0xCB, 0x80, 0xB6, 0xF0, 0xB6, 0xE0, 0xB5,
  0x6D, 0xE0, 0xF9, 0x09, 0xE0, 0x59, 0x97, 0x1E, 0x72, 0x5F, 0x74, 0x48,
  0x48, 0xE0, 0xFE, 0x72, 0x21, 0x62, 0xE0, 0xF8,
};

const GFXglyph IBMPlexMono_Italic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 6, 5, 2, -6 },
  { 2, 2, 2, 5, 2, -6 },
  { 3, 5, 6, 5, 0, -6 },
  { 7, 5, 7, 5, 0, -6 },
  { 12, 5, 6, 5, 0, -6 },
  { 16, 5, 6, 5, 0, -6 },
  { 20, 1, 2, 5, 2, -6 },
  { 21, 3, 7, 5, 2, -6 },
  { 24, 3, 7, 5, 0, -6 },
  { 27, 5, 4, 5, 0, -4 },
  { 30, 3, 4, 5, 1, -4 },
  { 32, 2, 2, 5, 1, -1 },
  { 33, 3, 1, 5, 1, -3 },
  { 34, 1, 1, 5, 2, -1 },
  { 35, 5, 7, 5, 0, -6 },
  { 40, 5, 6, 5, 0, -6 },
  { 44, 4, 6, 5, 0, -6 },
  { 47, 4, 6, 5, 0, -6 },
  { 50, 4, 6, 5, 0, -6 },
  { 53, 4, 6, 5, 0, -6 },
  { 56, 5, 6, 5, 0, -6 },
  { 60, 4, 6, 5, 0, -6 },
  { 63, 4, 6, 5, 1, -6 },
  { 66, 5, 6, 5, 0, -6 },
  { 70, 3, 6, 5, 1, -6 },
  { 73, 1, 4, 5, 2, -4 },
  { 74, 2, 5, 5, 1, -4 },
  { 76, 4, 5, 5, 1, -5 },
  { 79, 5, 3, 5, 0, -4 },
  { 81, 4, 5, 5, 0, -5 },
  { 84, 3, 6, 5, 1, -6 },
  { 87, 5, 7, 5, 0, -6 },
  { 92, 4, 6, 5, 0, -6 },
  { 95, 4, 6, 5, 0, -6 },
  { 98, 4, 6, 5, 1, -6 },
  { 101, 5, 6, 5, 0, -6 },
  { 105, 5, 6, 5, 0, -6 },
  { 109, 5, 6, 5, 0, -6 },
  { 113, 4, 6, 5, 1, -6 },
  { 116, 5, 6, 5, 0, -6 },
  { 120, 5, 6, 5, 0, -6 },
  { 124, 4, 6, 5, 0, -6 },
  { 127, 5, 6, 5, 0, -6 },
  { 131, 3, 6, 5, 1, -6 },
  { 134, 5, 6, 5, 0, -6 },
  { 138, 5, 6, 5, 0, -6 },
  { 142, 5, 6, 5, 0, -6 },
  { 146, 5, 6, 5, 0, -6 },
  { 150, 5, 7, 5, 0, -6 },
  { 155, 5, 6, 5, 0, -6 },
  { 159, 5, 6, 5, 0, -6 },
  { 163, 4, 6, 5, 1, -6 },
  { 166, 4, 6, 5, 1, -6 },
  { 169, 4, 6, 5, 1, -6 },
  { 172, 5, 6, 5, 0, -6 },
  { 176, 5, 6, 5, 0, -6 },
  { 180, 4, 6, 5, 1, -6 },
  { 183, 5, 6, 5, 0, -6 },
  { 187, 4, 7, 5, 1, -6 },
  { 191, 3, 7, 5, 1, -6 },
  { 194, 3, 7, 5, 0, -6 },
  { 197, 4, 4, 5, 1, -6 },
  { 199, 4, 1, 5, 0, 1 },
  { 200, 1, 1, 5, 2, -6 },
  { 201, 4, 4, 5, 0, -4 },
  { 203, 4, 6, 5, 0, -6 },
  { 206, 3, 4, 5, 1, -4 },
  { 208, 5, 6, 5, 0, -6 },
  { 212, 3, 4, 5, 1, -4 },
  { 214, 5, 8, 5, 0, -6 },
  { 219, 4, 6, 5, 0, -4 },
  { 222, 4, 6, 5, 0, -6 },
  { 225, 3, 6, 5, 1, -6 },
  { 228, 4, 8, 5, 0, -6 },
  { 232, 5, 6, 5, 0, -6 },
  { 236, 3, 6, 5, 1, -6 },
  { 239, 5, 4, 5, 0, -4 },
  { 242, 4, 4, 5, 0, -4 },
  { 244, 3, 4, 5, 1, -4 },
  { 246, 4, 6, 5, 0, -4 },
  { 249, 4, 6, 5, 0, -4 },
  { 252, 4, 4, 5, 1, -4 },
  { 254, 4, 4, 5, 0, -4 },
  { 256, 3, 6, 5, 1, -6 },
  { 259, 3, 4, 5, 1, -4 },
  { 261, 3, 4, 5, 1, -4 },
  { 263, 5, 4, 5, 0, -4 },
  { 266, 5, 4, 5, 0, -4 },
  { 269, 4, 6, 5, 0, -4 },
  { 272, 4, 4, 5, 0, -4 },
  { 274, 4, 7, 5, 1, -6 },
  { 278, 1, 7, 5, 2, -6 },
  { 279, 4, 7, 5, 0, -6 },
  { 283, 5, 1, 5, 0, -3 },
};

const GFXfont IBMPlexMono_Italic8pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic8pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic8pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _IBMPLEXMONO_ITALIC8PT7B_H_
