#ifndef _IBMPLEXMONO_ITALIC12PT7B_H_
#define _IBMPLEXMONO_ITALIC12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x25, 0x24, 0x36, 0xB6, 0x80, 0x1A, 0x29, 0xD9, 0x42, 0x9D, 0xD2,
  0x28, 0x08, 0x79, 0xAA, 0x83, 0x03, 0x85, 0x6A, 0x78, 0x40, 0x31, 0x52,
  0x54, 0x78, 0x2E, 0x52, 0x52, 0x8C, 0x38, 0x48, 0x91, 0x4D, 0x12, 0x26,
  0xB6, 0xE0, 0x19, 0x08, 0x84, 0x42, 0x10, 0x42, 0x08, 0x30, 0x82, 0x10,
  0x84, 0x22, 0x11, 0x30, 0x10, 0x8F, 0xC8, 0x52, 0x40, 0x10, 0x82, 0x3F,
  0x20, 0x82, 0x00, 0x7A, 0xE0, 0xF0, 0x02, 0x08, 0x10, 0x40, 0x82, 0x04,
  0x10, 0x20, 0x82, 0x00, 0x39, 0x18, 0x6D, 0xA6, 0x28, 0xBC, 0x18, 0xE4,
  0x82, 0x10, 0x41, 0x3F, 0x1C, 0x4D, 0x08, 0x20, 0x86, 0x10, 0x7E, 0x1C,
  0x44, 0x10, 0xC2, 0x40, 0xB1, 0x3C, 0x04, 0x18, 0x51, 0x24, 0x9F, 0xC2,
  0x04, 0x7D, 0x04, 0x2E, 0xC8, 0x28, 0x9C, 0x19, 0x11, 0x7C, 0xC6, 0x3E,
  0x7E, 0x10, 0x84, 0x10, 0x82, 0x10, 0x3C, 0x45, 0x09, 0xE6, 0x48, 0xB1,
  0x3C, 0x7B, 0x18, 0x63, 0x78, 0x21, 0x38, 0x6C, 0x01, 0xB0, 0x6C, 0x00,
  0xB4, 0x80, 0x04, 0x66, 0x20, 0x40, 0xC0, 0x80, 0xFC, 0x0F, 0x80, 0x83,
  0x06, 0x13, 0x22, 0x00, 0x74, 0x44, 0xE4, 0x03, 0x18, 0x39, 0x1B, 0x6B,
  0xAB, 0x2B, 0xA0, 0x70, 0x08, 0x61, 0x49, 0x25, 0xF4, 0x61, 0x79, 0x18,
  0xBC, 0x8A, 0x28, 0xBC, 0x39, 0x18, 0x20, 0x82, 0x28, 0x9C, 0x79, 0x34,
  0x61, 0x86, 0x28, 0xBC, 0x7D, 0x08, 0x3E, 0x82, 0x08, 0x3E, 0x7D, 0x08,
  0x3E, 0x82, 0x08, 0x20, 0x39, 0x18, 0x20, 0x9A, 0x28, 0x9E, 0x22, 0x45,
  0x0B, 0xE4, 0x48, 0x91, 0x62, 0x3E, 0x10, 0x20, 0x81, 0x02, 0x04, 0x7E,
  0x3D, 0x20, 0x82, 0x08, 0x29, 0x3C, 0x46, 0x92, 0x45, 0x0D, 0x12, 0x22,
  0x44, 0x42, 0x10, 0x84, 0x42, 0x1F, 0x22, 0xCD, 0x6A, 0xD5, 0x48, 0xA1,
  0x42, 0x22, 0x65, 0x4A, 0xA5, 0x49, 0x93, 0x46, 0x39, 0x18, 0x61, 0x86,
  0x28, 0xBC, 0x79, 0x14, 0x61, 0xFA, 0x08, 0x20, 0x39, 0x18, 0x61, 0x86,
  0x28, 0xBC, 0x28, 0x70, 0x79, 0x14, 0x61, 0xFA, 0x49, 0x22, 0x3C, 0xC5,
  0x01, 0x80, 0xC0, 0xB1, 0x3C, 0xFE, 0x20, 0x41, 0x02, 0x04, 0x08, 0x10,
  0x45, 0x18, 0x62, 0x8A, 0x28, 0xBC, 0x87, 0x09, 0x22, 0x45, 0x0A, 0x18,
  0x30, 0x83, 0x0A, 0xD5, 0xAD, 0x9B, 0x36, 0x4C, 0x63, 0x24, 0x14, 0x18,
  0x18, 0x28, 0x44, 0x84, 0x86, 0x89, 0x21, 0x82, 0x04, 0x08, 0x10, 0x3E,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x7E, 0x3A, 0x10, 0x84, 0x22, 0x10, 0x84,
  0x38, 0x92, 0x24, 0x91, 0x24, 0x80, 0x38, 0x42, 0x11, 0x08, 0x42, 0x10,
  0xBC, 0x10, 0xA4, 0xA2, 0x84, 0xFC, 0xC0, 0x7C, 0x63, 0x19, 0xF4, 0x41,
  0x04, 0x1E, 0xCA, 0x18, 0xA2, 0xF0, 0x7E, 0x61, 0x28, 0xB8, 0x04, 0x10,
  0x5E, 0x8A, 0x28, 0xA6, 0xE8, 0x7C, 0x7D, 0x08, 0xB8, 0x0F, 0x08, 0x08,
  0x3E, 0x48, 0x10, 0x10, 0x10, 0x90, 0xD0, 0x60, 0x3E, 0x89, 0x12, 0x24,
  0xCE, 0xA2, 0x38, 0x42, 0x10, 0xFC, 0xC6, 0x31, 0x88, 0x11, 0x81, 0xC2,
  0x10, 0xAB, 0x60, 0x08, 0x40, 0xF1, 0x08, 0x42, 0x96, 0x98, 0x41, 0x04,
  0x1E, 0xCA, 0x2B, 0x2B, 0x98, 0xF1, 0x08, 0x42, 0x21, 0x2A, 0x60, 0x76,
  0xB5, 0x4C, 0xA9, 0x52, 0x80, 0x7E, 0x63, 0x18, 0xC4, 0x7C, 0x63, 0x18,
  0xB8, 0x3C, 0xC9, 0x0A, 0x24, 0x4F, 0x20, 0x40, 0x7E, 0x28, 0xA2, 0x9B,
  0xA1, 0x04, 0xEC, 0xC2, 0x08, 0x41, 0x00, 0x7C, 0x58, 0x38, 0xF8, 0x21,
  0x3E, 0x44, 0x25, 0x6C, 0x4E, 0x28, 0xA2, 0x9B, 0xA0, 0xCA, 0x52, 0x99,
  0x70, 0x96, 0x9A, 0x69, 0xAB, 0xE0, 0x36, 0xB4, 0x4C, 0x8B, 0x7F, 0x00,
  0x26, 0x89, 0x12, 0x24, 0xCE, 0xA2, 0x38, 0x76, 0x21, 0x1A, 0xCA, 0xE0,
  0x1C, 0x82, 0x04, 0x13, 0x81, 0x08, 0x41, 0x07, 0x00, 0x24, 0xA4, 0x92,
  0x52, 0x00, 0x70, 0x84, 0x42, 0x0D, 0x88, 0x21, 0x38, 0x66, 0xA9, 0x80,
};

const GFXglyph IBMPlexMono_Italic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 8, 7, 2, -8 },
  { 4, 3, 3, 7, 3, -9 },
  { 6, 7, 8, 7, 0, -8 },
  { 13, 7, 10, 7, 0, -9 },
  { 22, 8, 8, 7, 0, -8 },
  { 30, 7, 8, 7, 0, -8 },
  { 37, 1, 3, 7, 4, -9 },
  { 38, 5, 11, 7, 2, -9 },
  { 45, 5, 11, 7, 0, -9 },
  { 52, 6, 6, 7, 1, -7 },
  { 57, 6, 7, 7, 1, -7 },
  { 63, 2, 4, 7, 2, -2 },
  { 64, 3, 1, 7, 2, -4 },
  { 65, 2, 2, 7, 2, -2 },
  { 66, 7, 11, 7, 0, -9 },
  { 76, 6, 8, 7, 1, -8 },
  { 82, 6, 8, 7, 0, -8 },
  { 88, 7, 8, 7, 0, -8 },
  { 95, 7, 8, 7, 0, -8 },
  { 102, 7, 8, 7, 0, -8 },
  { 109, 6, 8, 7, 1, -8 },
  { 115, 5, 8, 7, 1, -8 },
  { 120, 6, 8, 7, 1, -8 },
  { 126, 7, 8, 7, 0, -8 },
  { 133, 6, 8, 7, 1, -8 },
  { 139, 3, 7, 7, 2, -7 },
  { 142, 3, 9, 7, 2, -7 },
  { 146, 6, 7, 7, 1, -7 },
  { 152, 6, 3, 7, 1, -5 },
  { 155, 5, 7, 7, 1, -7 },
  { 160, 5, 8, 7, 2, -8 },
  { 165, 6, 9, 7, 1, -8 },
  { 172, 6, 8, 7, 0, -8 },
  { 178, 6, 8, 7, 1, -8 },
  { 184, 6, 8, 7, 1, -8 },
  { 190, 6, 8, 7, 1, -8 },
  { 196, 6, 8, 7, 1, -8 },
  { 202, 6, 8, 7, 1, -8 },
  { 208, 6, 8, 7, 1, -8 },
  { 214, 7, 8, 7, 0, -8 },
  { 221, 7, 8, 7, 0, -8 },
  { 228, 6, 8, 7, 1, -8 },
  { 234, 7, 8, 7, 1, -8 },
  { 241, 5, 8, 7, 1, -8 },
  { 246, 7, 8, 7, 0, -8 },
  { 253, 7, 8, 7, 0, -8 },
  { 260, 6, 8, 7, 1, -8 },
  { 266, 6, 8, 7, 1, -8 },
  { 272, 6, 10, 7, 1, -8 },
  { 280, 6, 8, 7, 1, -8 },
  { 286, 7, 8, 7, 0, -8 },
  { 293, 7, 8, 7, 1, -8 },
  { 300, 6, 8, 7, 1, -8 },
  { 306, 7, 8, 7, 1, -8 },
  { 313, 7, 8, 7, 1, -8 },
  { 320, 8, 8, 7, 0, -8 },
  { 328, 7, 8, 7, 1, -8 },
  { 335, 7, 8, 7, 0, -8 },
  { 342, 5, 11, 7, 2, -9 },
  { 349, 3, 11, 7, 2, -9 },
  { 354, 5, 11, 7, 0, -9 },
  { 361, 6, 5, 7, 1, -8 },
  { 365, 6, 1, 7, 0, 1 },
  { 366, 1, 2, 7, 3, -9 },
  { 367, 5, 6, 7, 1, -6 },
  { 371, 6, 9, 7, 1, -9 },
  { 378, 5, 6, 7, 1, -6 },
  { 382, 6, 9, 7, 1, -9 },
  { 389, 5, 6, 7, 1, -6 },
  { 393, 8, 11, 7, 0, -9 },
  { 404, 7, 8, 7, 0, -6 },
  { 411, 5, 9, 7, 1, -9 },
  { 417, 5, 9, 7, 1, -9 },
  { 423, 5, 11, 7, 1, -9 },
  { 430, 6, 9, 7, 1, -9 },
  { 437, 5, 9, 7, 1, -9 },
  { 443, 7, 6, 7, 0, -6 },
  { 449, 5, 6, 7, 1, -6 },
  { 453, 5, 6, 7, 1, -6 },
  { 457, 7, 8, 7, 0, -6 },
  { 464, 6, 8, 7, 1, -6 },
  { 470, 6, 6, 7, 1, -6 },
  { 475, 5, 6, 7, 1, -6 },
  { 479, 5, 8, 7, 1, -8 },
  { 484, 6, 6, 7, 1, -6 },
  { 489, 5, 6, 7, 1, -6 },
  { 493, 6, 6, 7, 1, -6 },
  { 498, 7, 6, 7, 0, -6 },
  { 504, 7, 8, 7, 0, -6 },
  { 511, 6, 6, 7, 1, -6 },
  { 516, 6, 11, 7, 1, -9 },
  { 525, 3, 11, 7, 2, -9 },
  { 530, 5, 11, 7, 1, -9 },
  { 537, 6, 3, 7, 1, -5 },
};

const GFXfont IBMPlexMono_Italic12pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic12pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _IBMPLEXMONO_ITALIC12PT7B_H_
