#ifndef _IBMPLEXMONO_ITALIC41PT7B_H_
#define _IBMPLEXMONO_ITALIC41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x3C, 0x1E, 0x0F, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x08, 0x04, 0x02, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x7E, 0x3F, 0x1F, 0x8F, 0x80, 0x78, 0x77,
  0x0E, 0x70, 0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0xF0, 0xEE, 0x1C, 0xE1, 0xCE,
  0x1C, 0xE1, 0xC0, 0x00, 0x0F, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x03, 0x87,
  0x00, 0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE1, 0xC0, 0x00, 0xE0,
  0xE0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x70, 0x07, 0xF8, 0x3F, 0xC3, 0xFC,
  0x1F, 0xE3, 0xFE, 0x1F, 0xF0, 0x0E, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x03,
  0x87, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC1, 0x80, 0x3F, 0xE1, 0xFF, 0x1F,
  0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x88, 0x38, 0x70, 0x00, 0x38, 0x38, 0x00,
  0x1C, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x0F, 0x00,
  0x03, 0x87, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC3, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFE, 0x03, 0xE7, 0x3E, 0x0F, 0x0E, 0x3E,
  0x1C, 0x1C, 0x18, 0x78, 0x30, 0x20, 0xF0, 0x60, 0x01, 0xE0, 0xC0, 0x03,
  0xC3, 0x80, 0x07, 0x87, 0x00, 0x07, 0xCE, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0x9F, 0x00, 0x07,
  0x1E, 0x00, 0x0C, 0x1E, 0x00, 0x18, 0x3C, 0x00, 0x30, 0x78, 0x00, 0xE0,
  0xF0, 0x81, 0xC1, 0xE7, 0x83, 0x07, 0x8F, 0x86, 0x1F, 0x0F, 0xCC, 0x7C,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x70, 0x1F, 0xE0, 0x0E, 0x07, 0xFE, 0x01, 0xC0, 0x78, 0x70, 0x38, 0x0E,
  0x07, 0x03, 0x80, 0xE0, 0x70, 0x70, 0x0E, 0x07, 0x0E, 0x00, 0xC0, 0x70,
  0xE0, 0x0C, 0x07, 0x1C, 0x00, 0xC0, 0xE3, 0x80, 0x0E, 0x1E, 0x38, 0x00,
  0xFF, 0xC7, 0x00, 0x07, 0xF8, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0x3F, 0xF0,
  0x01, 0xC7, 0x87, 0x00, 0x1C, 0x70, 0x30, 0x03, 0x8E, 0x03, 0x00, 0x70,
  0xE0, 0x70, 0x07, 0x0E, 0x07, 0x00, 0xE0, 0xE0, 0x70, 0x1C, 0x0E, 0x0F,
  0x03, 0x80, 0xE1, 0xE0, 0x38, 0x0F, 0xFC, 0x07, 0x00, 0x7F, 0x80, 0xE0,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xE0,
  0x01, 0xE1, 0xF0, 0x03, 0xC0, 0x70, 0x03, 0x80, 0x70, 0x03, 0x80, 0x70,
  0x03, 0x80, 0x70, 0x03, 0x80, 0x70, 0x03, 0xC0, 0x70, 0x01, 0xC0, 0xF0,
  0x01, 0xC0, 0xE0, 0x00, 0xE1, 0xE0, 0x07, 0xE7, 0x80, 0x1F, 0xFF, 0x00,
  0x3C, 0x78, 0x00, 0x78, 0x78, 0x00, 0x70, 0x38, 0x00, 0xF0, 0x1C, 0x00,
  0xF0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x06, 0xE0, 0x0F, 0x07,
  0xF0, 0x0F, 0x8E, 0xF0, 0x1B, 0x8E, 0x78, 0x33, 0xDC, 0x7F, 0xF1, 0xFC,
  0x3F, 0xE1, 0xF8, 0x0F, 0x80, 0xF0, 0x39, 0xCE, 0xF7, 0x39, 0xCE, 0x77,
  0xB8, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xE0, 0x03,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x01, 0x00, 0xE0, 0x2F, 0x07, 0x0F, 0xFF, 0x77,
  0xF9, 0xFF, 0xFF, 0x01, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xFE, 0x00, 0x1E, 0x70, 0x01, 0xE3, 0xC0, 0x1E, 0x0E, 0x00, 0xE0, 0x38,
  0x0E, 0x01, 0xC0, 0x30, 0x04, 0x00, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x8F, 0x87, 0xC3,
  0xC3, 0xC1, 0xE0, 0xE0, 0xF0, 0x70, 0x38, 0x38, 0x1C, 0x00, 0x7F, 0xFB,
  0xFF, 0xBF, 0xFC, 0x7B, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x07,
  0xFF, 0xC0, 0xF8, 0x1E, 0x0F, 0x00, 0xF1, 0xE0, 0x0F, 0x3C, 0x00, 0x73,
  0x80, 0x07, 0x78, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0xF0, 0x7F, 0x0F, 0x87, 0xE1, 0xF8, 0xFE, 0x1F, 0x0F, 0xE0, 0xE0,
  0xFE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x1E, 0xE0, 0x01, 0xCE, 0x00,
  0x1C, 0xE0, 0x03, 0xCE, 0x00, 0x78, 0xF0, 0x0F, 0x07, 0x81, 0xF0, 0x7F,
  0xFE, 0x03, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0xF7, 0x80, 0x7C, 0xE0, 0x1F, 0x1C, 0x07, 0xC3, 0x81,
  0xF0, 0x70, 0x1C, 0x1E, 0x03, 0x03, 0xC0, 0x40, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0xFF,
  0x01, 0xF0, 0x3E, 0x07, 0x80, 0x78, 0x3C, 0x00, 0xE1, 0xE0, 0x03, 0xC1,
  0x80, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xF8, 0x3E, 0x07,
  0x80, 0x78, 0x3C, 0x00, 0xF0, 0x20, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0x80,
  0x03, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC2, 0x00, 0x0E, 0x1C, 0x00, 0x78, 0xF0, 0x03, 0xC1, 0xF0, 0x3F, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0x70, 0x00, 0x39,
  0xC0, 0x01, 0xC7, 0x00, 0x0F, 0x3C, 0x00, 0x78, 0xE0, 0x01, 0xC3, 0x80,
  0x0E, 0x0E, 0x00, 0x70, 0x38, 0x03, 0x81, 0xE0, 0x1E, 0x07, 0x80, 0xF0,
  0x1C, 0x03, 0x80, 0x70, 0x1C, 0x01, 0xC0, 0xE0, 0x07, 0x07, 0x00, 0x3C,
  0x3C, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0xFC, 0x01,
  0xDF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7C, 0x0F, 0x87, 0x80, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x80, 0x07, 0x8E, 0x00, 0x38, 0xF8, 0x03, 0xC3, 0xE0, 0x7C,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x01, 0xE7, 0xF0, 0x3C, 0xFF, 0x83, 0xBF, 0xFC, 0x3B, 0x03, 0xE7, 0xC0,
  0x1E, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0x70, 0x00, 0xF7, 0x00, 0x0F, 0xF0,
  0x00, 0xF7, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x1E, 0x78, 0x03, 0xC3,
  0xC0, 0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x3F, 0xFF,
  0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xE0, 0x01, 0xE7, 0x00, 0x0E, 0x38,
  0x00, 0xF3, 0xC0, 0x07, 0x1C, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F,
  0x81, 0xF0, 0xF0, 0x07, 0x8F, 0x00, 0x1C, 0x78, 0x00, 0xE3, 0x80, 0x07,
  0x1C, 0x00, 0x38, 0xE0, 0x03, 0x87, 0x80, 0x3C, 0x1E, 0x07, 0xC0, 0x7F,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xFE, 0x03, 0xC0, 0x78, 0x3C, 0x01, 0xE3,
  0x80, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xEE, 0x00, 0x0F, 0x70, 0x00,
  0x7B, 0x80, 0x03, 0xDE, 0x00, 0x3C, 0xF0, 0x03, 0xE3, 0xE0, 0x7E, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0xFF,
  0xE0, 0x7F, 0xFE, 0x1F, 0x03, 0xE3, 0xC0, 0x1C, 0xF0, 0x03, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xBE, 0x07, 0x73, 0xFF, 0xDE, 0x3F, 0xF3,
  0x81, 0xF8, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x00, 0x0F, 0x0F, 0xC7, 0xE3, 0xE1, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x7E, 0x3F, 0x1F, 0x8F, 0x80, 0x03, 0xC0, 0xFC, 0x1F, 0x83, 0xE0, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x1F, 0x03, 0xE0, 0x78, 0x1E, 0x03, 0xC0, 0x70, 0x1E,
  0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x07, 0x80, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x10, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xF8, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x03, 0xF8, 0x03,
  0xFF, 0x81, 0xFF, 0xF0, 0xF8, 0x3E, 0x78, 0x07, 0x9C, 0x00, 0xFF, 0x00,
  0x3C, 0x80, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xC0, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F,
  0x81, 0xE0, 0xF0, 0x07, 0x07, 0x00, 0x1C, 0x78, 0x00, 0xE3, 0x80, 0x07,
  0x1C, 0x0F, 0x39, 0xC1, 0xFD, 0xCE, 0x1F, 0xEE, 0x70, 0xF1, 0xF3, 0x8F,
  0x07, 0x38, 0x70, 0x39, 0xC7, 0x81, 0xCE, 0x38, 0x0E, 0x71, 0xC0, 0x73,
  0x8E, 0x03, 0x9C, 0x70, 0x38, 0xC3, 0x81, 0xCE, 0x1C, 0x1E, 0x70, 0xE0,
  0xF3, 0x87, 0xFB, 0x9C, 0x1F, 0xDC, 0xE0, 0xFC, 0xC7, 0x00, 0x08, 0x18,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1D, 0xC0, 0x00,
  0x77, 0x00, 0x03, 0x9E, 0x00, 0x0E, 0x78, 0x00, 0x70, 0xE0, 0x01, 0xC3,
  0x80, 0x0F, 0x0E, 0x00, 0x38, 0x38, 0x01, 0xE0, 0xE0, 0x07, 0x03, 0xC0,
  0x3C, 0x0F, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0x70, 0x1E, 0x01, 0xC0, 0x7F,
  0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x78, 0x01, 0xE1, 0xC0, 0x07,
  0x8F, 0x00, 0x1E, 0x38, 0x00, 0x39, 0xE0, 0x00, 0xE7, 0x00, 0x03, 0xBC,
  0x00, 0x0E, 0xE0, 0x00, 0x3C, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF,
  0xFC, 0x1C, 0x01, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x3C, 0x38, 0x01, 0xE3,
  0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x01,
  0xC1, 0xC0, 0x3E, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x38,
  0x03, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x3C, 0xF0, 0x01, 0xE7, 0x80, 0x0F,
  0x3C, 0x00, 0x79, 0xC0, 0x03, 0x8E, 0x00, 0x3C, 0x70, 0x01, 0xE7, 0x80,
  0x3E, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0x83, 0xE0, 0xF0, 0x0F, 0x07,
  0x00, 0x3C, 0x78, 0x00, 0xE7, 0x80, 0x08, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x10, 0x78, 0x00, 0xE1, 0xC0, 0x07, 0x8E, 0x00,
  0x78, 0x78, 0x07, 0x81, 0xE0, 0x78, 0x0F, 0xFF, 0xC0, 0x3F, 0xF8, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x1E,
  0x07, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x3C, 0x38, 0x01, 0xE1, 0xC0, 0x07,
  0x0E, 0x00, 0x38, 0xF0, 0x01, 0xC7, 0x80, 0x0E, 0x3C, 0x00, 0x71, 0xC0,
  0x03, 0x8E, 0x00, 0x3C, 0x70, 0x01, 0xE7, 0x80, 0x0F, 0x3C, 0x00, 0x79,
  0xE0, 0x03, 0x8E, 0x00, 0x1C, 0x70, 0x01, 0xE3, 0x80, 0x0F, 0x3C, 0x00,
  0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x78, 0x70, 0x07, 0x83, 0x80, 0xFC, 0x1F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF0, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xE0,
  0x7C, 0x1E, 0x0F, 0x00, 0xF1, 0xE0, 0x07, 0x3C, 0x00, 0x73, 0xC0, 0x08,
  0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x3F, 0xEF, 0x03, 0xFE, 0xE0, 0x3F, 0xEE, 0x04,
  0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x3C, 0xF0,
  0x03, 0xCF, 0x00, 0x7C, 0x78, 0x0F, 0x87, 0xC1, 0xB8, 0x3F, 0xFB, 0x81,
  0xFF, 0x38, 0x0F, 0xC3, 0x80, 0x0F, 0x00, 0x1C, 0x3C, 0x00, 0x70, 0xE0,
  0x03, 0xC3, 0x80, 0x0F, 0x0E, 0x00, 0x3C, 0x78, 0x00, 0xE1, 0xE0, 0x03,
  0x87, 0x80, 0x0E, 0x1C, 0x00, 0x78, 0x70, 0x01, 0xE1, 0xC0, 0x07, 0x8F,
  0x00, 0x1C, 0x3C, 0x00, 0x70, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFC, 0x38, 0x00, 0xF1, 0xE0, 0x03, 0x87, 0x80, 0x0E, 0x1E, 0x00, 0x38,
  0x70, 0x00, 0xE1, 0xC0, 0x07, 0x87, 0x00, 0x1E, 0x3C, 0x00, 0x70, 0xF0,
  0x01, 0xC3, 0xC0, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0xF0, 0xE0, 0x03,
  0xC0, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC3, 0xC0, 0x1E, 0x0E, 0x00, 0xF0,
  0x78, 0x0F, 0x03, 0xE0, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x3C, 0x0E,
  0x00, 0x78, 0x0E, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x1E,
  0x07, 0x80, 0x1E, 0x0F, 0x00, 0x1C, 0x1E, 0x00, 0x1C, 0x3C, 0x00, 0x1C,
  0x78, 0x00, 0x3C, 0xF0, 0x00, 0x3D, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xBC, 0x00, 0x3F, 0x1C, 0x00, 0x3E, 0x1E, 0x00, 0x7C, 0x1E, 0x00, 0x78,
  0x0E, 0x00, 0x78, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x80, 0x70,
  0x03, 0x80, 0xF0, 0x03, 0xC0, 0xF0, 0x01, 0xC0, 0xF0, 0x01, 0xE0, 0xE0,
  0x01, 0xE0, 0xE0, 0x00, 0xF0, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0x07,
  0x80, 0x1F, 0x07, 0x80, 0x1F, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F,
  0xC0, 0x7E, 0x0F, 0xC0, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0xE1, 0xDE, 0x1C,
  0xE1, 0xDC, 0x1C, 0xE3, 0x9C, 0x1C, 0x63, 0x1C, 0x1C, 0x77, 0x1C, 0x1C,
  0x7E, 0x1C, 0x1C, 0x7E, 0x1C, 0x3C, 0x3C, 0x38, 0x38, 0x3C, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x30, 0x38, 0x38, 0x10, 0x38, 0x38, 0x20, 0x78, 0x78,
  0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70,
  0x00, 0x70, 0x70, 0x00, 0xF0, 0xF0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xE0,
  0x00, 0xE0, 0x0F, 0x80, 0x1C, 0x3F, 0x00, 0x70, 0xFC, 0x01, 0xC3, 0xF0,
  0x07, 0x0F, 0xC0, 0x3C, 0x7F, 0x00, 0xE1, 0xCE, 0x03, 0x87, 0x38, 0x0E,
  0x1C, 0xE0, 0x38, 0x73, 0x80, 0xE1, 0xC7, 0x07, 0x8F, 0x1C, 0x1C, 0x38,
  0x70, 0x70, 0xE1, 0xC1, 0xC3, 0x87, 0x07, 0x0E, 0x0E, 0x1C, 0x38, 0x38,
  0xF1, 0xE0, 0xE3, 0x87, 0x03, 0x8E, 0x1C, 0x07, 0x38, 0x70, 0x1C, 0xE1,
  0xC0, 0x73, 0x87, 0x01, 0xDE, 0x3C, 0x07, 0x70, 0xE0, 0x0F, 0xC3, 0x80,
  0x3F, 0x0E, 0x00, 0xFC, 0x38, 0x03, 0xF0, 0xE0, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0xF8, 0x1E, 0x0F, 0x00, 0xF1, 0xE0,
  0x0F, 0x3C, 0x00, 0x73, 0x80, 0x07, 0x78, 0x00, 0x77, 0x80, 0x07, 0x70,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x1E,
  0xE0, 0x01, 0xCE, 0x00, 0x3C, 0xE0, 0x03, 0xCE, 0x00, 0x78, 0xF0, 0x0F,
  0x07, 0x81, 0xF0, 0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x07,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xC0, 0x1E, 0x0E, 0x00,
  0x3C, 0x38, 0x00, 0xF0, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C,
  0x78, 0x00, 0xF1, 0xC0, 0x03, 0xC7, 0x00, 0x0E, 0x1C, 0x00, 0x78, 0xF0,
  0x07, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8,
  0x07, 0xFF, 0xC0, 0xF8, 0x1E, 0x0F, 0x00, 0xF1, 0xE0, 0x0F, 0x3C, 0x00,
  0x73, 0x80, 0x07, 0x78, 0x00, 0x77, 0x80, 0x07, 0x70, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x1E, 0xE0, 0x01, 0xCE,
  0x00, 0x3C, 0xE0, 0x03, 0xCE, 0x00, 0x78, 0xF0, 0x0F, 0x07, 0x81, 0xF0,
  0x7F, 0xFE, 0x03, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xE0,
  0x40, 0x0F, 0x0E, 0x00, 0xF1, 0xE0, 0x07, 0xBC, 0x00, 0x3F, 0x80, 0x03,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x83, 0xC0, 0x1E, 0x0E, 0x00, 0x3C, 0x38, 0x00, 0xF0, 0xE0, 0x03, 0xC7,
  0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xC0, 0x03, 0xC7, 0x00,
  0x0E, 0x1C, 0x00, 0x78, 0xF0, 0x07, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0x00, 0xE0, 0xF0, 0x03, 0x81, 0xC0, 0x1E, 0x07, 0x00, 0x78,
  0x1E, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xF0, 0x1C, 0x01, 0xC0, 0x70, 0x07,
  0x83, 0xC0, 0x1E, 0x0F, 0x00, 0x38, 0x3C, 0x00, 0xF0, 0xE0, 0x01, 0xE0,
  0x00, 0x3F, 0x80, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3E, 0x03, 0xE0,
  0xF0, 0x03, 0xE1, 0xC0, 0x01, 0x87, 0x80, 0x02, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x08, 0x00, 0x1C, 0x78, 0x00, 0x78, 0xF8, 0x01, 0xF0,
  0xFC, 0x0F, 0xC0, 0xFF, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1E, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x1E, 0x38, 0x00, 0xF1, 0xC0,
  0x07, 0x9E, 0x00, 0x38, 0xF0, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0xF1,
  0xC0, 0x07, 0x8E, 0x00, 0x3C, 0xF0, 0x01, 0xC7, 0x80, 0x0E, 0x38, 0x00,
  0x71, 0xC0, 0x07, 0x8E, 0x00, 0x3C, 0x70, 0x01, 0xE7, 0x80, 0x0E, 0x3C,
  0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00, 0x3C, 0x70, 0x01, 0xC3, 0x80, 0x0E,
  0x1E, 0x00, 0xF0, 0xF0, 0x0F, 0x03, 0xC0, 0xF8, 0x1F, 0xFF, 0x80, 0x7F,
  0xF8, 0x00, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x3D, 0xC0, 0x00, 0xE7, 0x00,
  0x07, 0x9C, 0x00, 0x1C, 0x70, 0x00, 0xF1, 0xC0, 0x03, 0xC7, 0x00, 0x0E,
  0x1E, 0x00, 0x78, 0x38, 0x01, 0xC0, 0xE0, 0x0F, 0x03, 0x80, 0x38, 0x0E,
  0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x0F, 0x03,
  0x80, 0x1C, 0x1E, 0x00, 0x70, 0x70, 0x01, 0xC3, 0xC0, 0x07, 0x0E, 0x00,
  0x1C, 0x78, 0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00, 0x03, 0xB8, 0x00, 0x0E,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x38, 0x00, 0x07, 0x38, 0x00, 0x0F, 0x38, 0x00,
  0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00,
  0x1C, 0x38, 0x3C, 0x1C, 0x38, 0x7C, 0x1C, 0x70, 0x7C, 0x1C, 0x70, 0x7C,
  0x38, 0x70, 0xEC, 0x38, 0x70, 0xEC, 0x38, 0x70, 0xCC, 0x38, 0x71, 0xCC,
  0x70, 0x71, 0xCC, 0x70, 0x73, 0x8C, 0x70, 0x73, 0x8C, 0x70, 0x73, 0x0C,
  0xE0, 0x67, 0x0C, 0xE0, 0x67, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E,
  0xC0, 0xEE, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x78, 0x07,
  0x00, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0xF0, 0x01, 0xE0, 0x3C,
  0x00, 0x1C, 0x0F, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x38, 0x78, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x77, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0x78, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x78, 0xE0, 0x00,
  0x1E, 0x1E, 0x00, 0x07, 0x81, 0xC0, 0x00, 0xE0, 0x3C, 0x00, 0x3C, 0x03,
  0x80, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x07, 0x00, 0xF0, 0x00, 0xF0, 0x1C,
  0x00, 0x0E, 0x0F, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x79,
  0xC0, 0x01, 0xE3, 0xC0, 0x07, 0x83, 0x80, 0x0F, 0x07, 0x00, 0x3C, 0x0F,
  0x00, 0xF0, 0x0E, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x1C, 0x1E, 0x00, 0x38,
  0x78, 0x00, 0x78, 0xE0, 0x00, 0x73, 0xC0, 0x00, 0xEF, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0xE0, 0x0C, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x60, 0x0E,
  0x01, 0xC0, 0x38, 0x03, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x00,
  0x70, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x18,
  0x03, 0x80, 0x70, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x0E, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x1C, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x01, 0xE7, 0x00,
  0x1C, 0x70, 0x03, 0x83, 0x80, 0x78, 0x38, 0x0F, 0x01, 0xC0, 0xE0, 0x1C,
  0x1C, 0x01, 0xC3, 0xC0, 0x0E, 0x38, 0x00, 0xE7, 0x00, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0x40, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x33, 0xC7, 0x1C, 0x38, 0xE1, 0x87, 0x01, 0xF8, 0x70, 0x7F,
  0xC7, 0x0F, 0xFE, 0x71, 0xF0, 0x3F, 0x1E, 0x01, 0xE3, 0xC0, 0x0E, 0x38,
  0x00, 0xE7, 0x80, 0x0E, 0x70, 0x01, 0xE7, 0x00, 0x1E, 0xF0, 0x01, 0xCF,
  0x00, 0x1C, 0xF0, 0x01, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x7C,
  0x70, 0x0F, 0x87, 0xC3, 0xB8, 0x3F, 0xF3, 0xF3, 0xFE, 0x3F, 0x0F, 0xC1,
  0xF0, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE1, 0xF8, 0x1E, 0x7F, 0xC1, 0xEF, 0xFE, 0x1D, 0xC1, 0xF1, 0xD0, 0x0F,
  0x1E, 0x00, 0x71, 0xE0, 0x07, 0x3C, 0x00, 0x73, 0xC0, 0x07, 0x38, 0x00,
  0x73, 0x80, 0x07, 0x38, 0x00, 0xF3, 0x80, 0x0F, 0x78, 0x00, 0xE7, 0x00,
  0x0E, 0x78, 0x01, 0xE7, 0x80, 0x3C, 0x7E, 0x0F, 0x87, 0x7F, 0xF0, 0xF3,
  0xFE, 0x0E, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x7C,
  0x1F, 0x3C, 0x01, 0xCE, 0x00, 0x77, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x6E,
  0x00, 0x3F, 0xC0, 0x1E, 0x70, 0x0F, 0x1F, 0x07, 0x83, 0xFF, 0xE0, 0x7F,
  0xE0, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x07, 0xE1, 0xC0, 0x7F, 0xE7, 0x03, 0xFF,
  0xDC, 0x1F, 0x03, 0x70, 0x78, 0x07, 0xC3, 0xC0, 0x0F, 0x0E, 0x00, 0x38,
  0x78, 0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x3C, 0x00, 0x78, 0xF0,
  0x01, 0xE3, 0xC0, 0x07, 0x0F, 0x00, 0x1C, 0x3C, 0x00, 0xF0, 0xF0, 0x07,
  0xC1, 0xC0, 0x3F, 0x07, 0xC1, 0xBC, 0x0F, 0xFE, 0xE0, 0x3F, 0xF3, 0x80,
  0x3F, 0x0E, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0x0F, 0x81,
  0xE3, 0xC0, 0x1E, 0x70, 0x03, 0xDC, 0x00, 0x7B, 0x80, 0x1E, 0xF0, 0x3F,
  0xDF, 0xFF, 0xE3, 0xFF, 0xF0, 0x7F, 0xE0, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x67, 0x80, 0x1E, 0x70, 0x07, 0x8F, 0x83, 0xE0, 0xFF, 0xF8,
  0x0F, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x40, 0x78, 0x00, 0x1C, 0x0F,
  0x00, 0x07, 0xC1, 0xC0, 0x00, 0x3C, 0x38, 0x00, 0x03, 0xC7, 0x00, 0x00,
  0x3C, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x38, 0x1F, 0xF9, 0xC1, 0xFF, 0xEE, 0x1F, 0x03,
  0x70, 0xF0, 0x0F, 0x8F, 0x00, 0x3C, 0x70, 0x01, 0xC7, 0x80, 0x0E, 0x38,
  0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00, 0x1C, 0xF0, 0x01, 0xC7, 0x80, 0x0E,
  0x3C, 0x00, 0x71, 0xE0, 0x07, 0x87, 0x00, 0x7C, 0x3C, 0x07, 0xE1, 0xF0,
  0x6E, 0x07, 0xFF, 0x70, 0x1F, 0xF3, 0x80, 0x7E, 0x1C, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x20, 0x07, 0x83, 0xC0, 0xF8, 0x3F, 0xFF,
  0x80, 0x7F, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x01, 0xC3, 0xE0, 0x39, 0xFF, 0x07, 0x3F, 0xE1,
  0xEC, 0x3E, 0x3F, 0x03, 0xC7, 0x40, 0x38, 0xF0, 0x07, 0x1C, 0x00, 0xE3,
  0x80, 0x1C, 0xF0, 0x03, 0x9C, 0x00, 0x73, 0x80, 0x1E, 0x70, 0x03, 0x8E,
  0x00, 0x71, 0xC0, 0x0E, 0x78, 0x01, 0xCE, 0x00, 0x79, 0xC0, 0x0F, 0x38,
  0x01, 0xC7, 0x00, 0x39, 0xE0, 0x07, 0x00, 0x00, 0x38, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFE, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x01, 0x00,
  0xE0, 0x30, 0x1C, 0x0F, 0x03, 0x87, 0xC0, 0xF1, 0xF0, 0x1C, 0x7C, 0x03,
  0x9E, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x02, 0x01, 0xC0,
  0x70, 0x1C, 0x0F, 0x81, 0xC0, 0x7C, 0x3C, 0x03, 0xE3, 0x80, 0x1F, 0x38,
  0x00, 0xFB, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0xF8, 0x03, 0x9F, 0xF0, 0x1D, 0xFF, 0xC1, 0xEC, 0x1E, 0x0F, 0xC0, 0x70,
  0x74, 0x03, 0x83, 0xC0, 0x1C, 0x1C, 0x01, 0xE0, 0xE0, 0x0E, 0x0F, 0x01,
  0xE0, 0x70, 0x3E, 0x03, 0x9F, 0xC0, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x47,
  0x1E, 0x07, 0x78, 0x70, 0x7B, 0x83, 0xC7, 0x9C, 0x0E, 0x78, 0xE0, 0x7F,
  0x87, 0x01, 0xF8, 0x78, 0x07, 0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFE,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x0F, 0x01, 0x03, 0x80, 0xE0, 0xE0, 0x7C, 0x38, 0x3C,
  0x0E, 0x3E, 0x07, 0x9F, 0x01, 0xCF, 0x80, 0x7F, 0x80, 0x1F, 0xC0, 0x03,
  0xC0, 0x00, 0x0E, 0x78, 0x7C, 0x1D, 0xF9, 0xFC, 0x3F, 0xF7, 0xF8, 0xF8,
  0xEC, 0x71, 0xE0, 0xF0, 0xE3, 0xC1, 0xC1, 0xC7, 0x03, 0x83, 0x8E, 0x0E,
  0x07, 0x1C, 0x1C, 0x0E, 0x70, 0x38, 0x1C, 0xE0, 0x70, 0x71, 0xC0, 0xE0,
  0xE3, 0x81, 0xC1, 0xC7, 0x07, 0x03, 0x8E, 0x0E, 0x07, 0x38, 0x1C, 0x0E,
  0x70, 0x38, 0x38, 0xE0, 0x70, 0x71, 0xC1, 0xC0, 0xE3, 0x83, 0x81, 0xCF,
  0x07, 0x03, 0x80, 0x0E, 0x1F, 0x01, 0xCF, 0xF8, 0x79, 0xFF, 0x0F, 0x61,
  0xF1, 0xF8, 0x1E, 0x3A, 0x01, 0xC7, 0x80, 0x38, 0xE0, 0x07, 0x3C, 0x00,
  0xE7, 0x80, 0x1C, 0xE0, 0x03, 0x9C, 0x00, 0xF3, 0x80, 0x1C, 0x70, 0x03,
  0x9E, 0x00, 0x73, 0xC0, 0x0E, 0x70, 0x03, 0xCE, 0x00, 0x79, 0xC0, 0x0E,
  0x38, 0x01, 0xCF, 0x00, 0x38, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFE,
  0x0F, 0x83, 0xE3, 0xC0, 0x1C, 0xF0, 0x03, 0xDC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1D,
  0xC0, 0x03, 0xB8, 0x00, 0xF7, 0x00, 0x1C, 0xF0, 0x07, 0x8F, 0x03, 0xE0,
  0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x7E, 0x00, 0x07, 0x0F, 0xC0, 0x79, 0xFF,
  0x03, 0xDF, 0xFC, 0x1D, 0xC1, 0xF0, 0xE8, 0x07, 0x87, 0x80, 0x1C, 0x3C,
  0x00, 0xE3, 0xC0, 0x07, 0x1E, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x0E,
  0x38, 0x00, 0xF1, 0xC0, 0x07, 0x9E, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x80,
  0x1E, 0x3C, 0x01, 0xE1, 0xF8, 0x3E, 0x0E, 0xFF, 0xE0, 0xF3, 0xFE, 0x07,
  0x0F, 0xE0, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x70, 0x7F, 0xE7, 0x0F, 0xFF, 0x71, 0xF0, 0x37, 0x1E, 0x01,
  0xF3, 0xC0, 0x0F, 0x38, 0x00, 0xE7, 0x80, 0x0E, 0x70, 0x00, 0xE7, 0x00,
  0x0E, 0xF0, 0x01, 0xEF, 0x00, 0x1C, 0xF0, 0x01, 0xCF, 0x00, 0x1C, 0xF0,
  0x03, 0xCF, 0x00, 0x7C, 0x70, 0x0F, 0xC7, 0xC1, 0xB8, 0x3F, 0xF3, 0x83,
  0xFE, 0x38, 0x0F, 0xC3, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x7F, 0xC3, 0xF7, 0xFC, 0xFF, 0xFF, 0xDF, 0xF0, 0x39, 0x80, 0x03,
  0xA0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x0F,
  0xFF, 0xE0, 0xF0, 0x1F, 0x1E, 0x00, 0x41, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC2, 0x00, 0x1C, 0x70, 0x03,
  0xCF, 0xC0, 0x78, 0x7F, 0xFF, 0x81, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x08, 0x1E, 0x03, 0x83, 0x81, 0xF8, 0x70, 0x7C, 0x0E, 0x3F, 0x01, 0xCF,
  0x80, 0x3F, 0xE0, 0x07, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0xE3, 0x80,
  0x1C, 0xF0, 0x03, 0x9C, 0x00, 0xF3, 0x80, 0x1E, 0x70, 0x03, 0x8E, 0x00,
  0x73, 0xC0, 0x0E, 0x78, 0x01, 0xCE, 0x00, 0x79, 0xC0, 0x0F, 0x38, 0x01,
  0xC7, 0x00, 0x39, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x7C, 0x70, 0x17,
  0x8F, 0x0E, 0xE1, 0xFF, 0x9C, 0x1F, 0xE3, 0x81, 0xF8, 0x70, 0xFF, 0x00,
  0xDF, 0xE0, 0x3B, 0xF8, 0x07, 0x87, 0x00, 0x70, 0xE0, 0x0E, 0x1C, 0x01,
  0xC3, 0x80, 0x38, 0xF0, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x3C, 0x70, 0x07,
  0x0E, 0x00, 0xE1, 0xC0, 0x3C, 0x38, 0x0F, 0x0F, 0x01, 0xE1, 0xC0, 0x78,
  0x38, 0x3E, 0x07, 0x1F, 0x80, 0xFF, 0xE0, 0x1F, 0xF0, 0x01, 0xF8, 0x00,
  0x38, 0x1C, 0x31, 0xC0, 0xC3, 0xCE, 0x0E, 0x0E, 0x70, 0x70, 0x73, 0x83,
  0x83, 0xB8, 0x1C, 0x1D, 0xC0, 0xE0, 0xEE, 0x06, 0x07, 0x70, 0x70, 0x3B,
  0x83, 0x81, 0xD8, 0x1C, 0x0F, 0xC0, 0xE0, 0x7E, 0x07, 0x07, 0x70, 0x70,
  0x3B, 0x83, 0x81, 0xDC, 0x1C, 0x1C, 0xE1, 0x61, 0xE7, 0x1B, 0x9E, 0x3F,
  0x9F, 0xF1, 0xFC, 0xFF, 0x07, 0xC3, 0xE0, 0x00, 0x00, 0xF0, 0x3C, 0x03,
  0xF8, 0xFE, 0x07, 0xF9, 0xFF, 0x0F, 0xB9, 0xC7, 0x3E, 0x3B, 0x87, 0x38,
  0x1B, 0x07, 0x10, 0x1A, 0x07, 0x00, 0x1E, 0x07, 0x00, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xE0,
  0x3C, 0x00, 0xE0, 0x7C, 0x0C, 0xE0, 0x7C, 0x1E, 0xE0, 0xDC, 0x7C, 0xF1,
  0xDC, 0xF0, 0x7F, 0x8F, 0xE0, 0x7F, 0x0F, 0xC0, 0x3E, 0x07, 0x80, 0x07,
  0x00, 0x38, 0x38, 0x01, 0xC3, 0xC0, 0x0E, 0x1C, 0x00, 0xF0, 0xE0, 0x07,
  0x87, 0x00, 0x38, 0x38, 0x01, 0xC1, 0xC0, 0x0E, 0x1E, 0x00, 0x70, 0xE0,
  0x07, 0x87, 0x00, 0x38, 0x38, 0x01, 0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0xF0,
  0xF0, 0x07, 0x87, 0x80, 0x7C, 0x1C, 0x07, 0xC0, 0xF0, 0x6E, 0x07, 0xFE,
  0x70, 0x1F, 0xE3, 0x80, 0x3E, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0x20, 0x0F, 0x03, 0xC0, 0xF8, 0x3F, 0xFF, 0x80, 0x7F, 0xF8,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x38, 0x7F, 0xF3, 0xC7, 0xFF, 0xFE,
  0x38, 0x3F, 0xF3, 0x80, 0x3F, 0x1C, 0x00, 0xE0, 0xE0, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x0C, 0x03, 0xC0, 0xE0, 0x38, 0x03, 0x87, 0x80, 0x1C, 0x7F, 0x80,
  0xE7, 0xFF, 0xE3, 0x3D, 0xFF, 0xF9, 0xE1, 0xFF, 0xCE, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x1F, 0xF8, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x00,
  0x3C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x1C, 0x0E, 0x00, 0x03, 0xFE,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x02, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F,
  0xF8, 0x00, 0x07, 0x80, 0x10, 0xFE, 0x01, 0xC7, 0xF8, 0x0E, 0x71, 0xE0,
  0xE7, 0x07, 0x07, 0x38, 0x1C, 0x73, 0x80, 0xFF, 0x9C, 0x03, 0xF8, 0x60,
  0x0F, 0x00,
};

const GFXglyph IBMPlexMono_Italic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 9, 29, 25, 8, -29 },
  { 34, 12, 11, 25, 9, -30 },
  { 51, 25, 29, 25, 0, -29 },
  { 142, 23, 37, 25, 1, -33 },
  { 249, 28, 29, 25, -1, -29 },
  { 351, 24, 29, 25, 0, -29 },
  { 438, 5, 11, 25, 12, -30 },
  { 445, 16, 37, 25, 8, -31 },
  { 519, 15, 37, 25, 2, -31 },
  { 589, 21, 20, 25, 2, -22 },
  { 642, 19, 21, 25, 3, -23 },
  { 692, 9, 12, 25, 6, -6 },
  { 706, 13, 3, 25, 6, -14 },
  { 711, 6, 5, 25, 8, -5 },
  { 715, 23, 37, 25, 1, -31 },
  { 822, 20, 29, 25, 3, -29 },
  { 895, 19, 29, 25, 2, -29 },
  { 964, 22, 29, 25, 1, -29 },
  { 1044, 22, 29, 25, 1, -29 },
  { 1124, 22, 29, 25, 1, -29 },
  { 1204, 21, 29, 25, 2, -29 },
  { 1281, 20, 29, 25, 2, -29 },
  { 1354, 21, 29, 25, 4, -29 },
  { 1431, 21, 29, 25, 2, -29 },
  { 1508, 19, 29, 25, 4, -29 },
  { 1577, 9, 21, 25, 8, -21 },
  { 1601, 11, 27, 25, 6, -21 },
  { 1639, 19, 24, 25, 4, -25 },
  { 1696, 21, 11, 25, 2, -18 },
  { 1725, 20, 24, 25, 2, -25 },
  { 1785, 18, 29, 25, 5, -29 },
  { 1851, 21, 34, 25, 2, -29 },
  { 1941, 22, 29, 25, 0, -29 },
  { 2021, 21, 29, 25, 2, -29 },
  { 2098, 21, 29, 25, 3, -29 },
  { 2175, 21, 29, 25, 2, -29 },
  { 2252, 22, 29, 25, 2, -29 },
  { 2332, 23, 29, 25, 2, -29 },
  { 2416, 20, 29, 25, 3, -29 },
  { 2489, 22, 29, 25, 2, -29 },
  { 2569, 22, 29, 25, 2, -29 },
  { 2649, 21, 29, 25, 2, -29 },
  { 2726, 24, 29, 25, 2, -29 },
  { 2813, 18, 29, 25, 3, -29 },
  { 2879, 24, 29, 25, 1, -29 },
  { 2966, 22, 29, 25, 2, -29 },
  { 3046, 20, 29, 25, 3, -29 },
  { 3119, 22, 29, 25, 2, -29 },
  { 3199, 20, 37, 25, 3, -29 },
  { 3292, 22, 29, 25, 2, -29 },
  { 3372, 23, 29, 25, 1, -29 },
  { 3456, 23, 29, 25, 4, -29 },
  { 3540, 21, 29, 25, 3, -29 },
  { 3617, 22, 29, 25, 4, -29 },
  { 3697, 24, 29, 25, 2, -29 },
  { 3784, 27, 29, 25, -1, -29 },
  { 3882, 23, 29, 25, 4, -29 },
  { 3966, 25, 29, 25, 0, -29 },
  { 4057, 17, 37, 25, 7, -31 },
  { 4136, 11, 37, 25, 7, -31 },
  { 4187, 18, 37, 25, 0, -31 },
  { 4271, 20, 17, 25, 3, -29 },
  { 4314, 20, 3, 25, 0, 4 },
  { 4322, 6, 8, 25, 9, -32 },
  { 4328, 20, 21, 25, 2, -21 },
  { 4381, 20, 30, 25, 2, -30 },
  { 4456, 18, 21, 25, 3, -21 },
  { 4504, 22, 30, 25, 2, -30 },
  { 4587, 19, 21, 25, 3, -21 },
  { 4637, 27, 38, 25, -1, -30 },
  { 4766, 21, 29, 25, 1, -21 },
  { 4843, 19, 30, 25, 2, -30 },
  { 4915, 19, 31, 25, 3, -31 },
  { 4989, 20, 39, 25, 2, -31 },
  { 5087, 21, 30, 25, 2, -30 },
  { 5166, 18, 30, 25, 4, -30 },
  { 5234, 23, 21, 25, 0, -21 },
  { 5295, 19, 21, 25, 2, -21 },
  { 5345, 19, 21, 25, 3, -21 },
  { 5395, 21, 29, 25, 1, -21 },
  { 5472, 20, 29, 25, 2, -21 },
  { 5545, 20, 21, 25, 4, -21 },
  { 5598, 20, 21, 25, 2, -21 },
  { 5651, 19, 29, 25, 3, -29 },
  { 5720, 19, 21, 25, 3, -21 },
  { 5770, 19, 21, 25, 3, -21 },
  { 5820, 21, 21, 25, 2, -21 },
  { 5876, 24, 21, 25, 0, -21 },
  { 5939, 21, 29, 25, 1, -21 },
  { 6016, 21, 21, 25, 2, -21 },
  { 6072, 19, 37, 25, 5, -31 },
  { 6160, 9, 37, 25, 8, -31 },
  { 6202, 19, 37, 25, 2, -31 },
  { 6290, 21, 9, 25, 2, -17 },
};

const GFXfont IBMPlexMono_Italic41pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic41pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic41pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _IBMPLEXMONO_ITALIC41PT7B_H_
