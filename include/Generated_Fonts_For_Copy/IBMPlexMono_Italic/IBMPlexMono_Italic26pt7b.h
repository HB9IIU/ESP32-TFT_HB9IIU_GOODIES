#ifndef _IBMPLEXMONO_ITALIC26PT7B_H_
#define _IBMPLEXMONO_ITALIC26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x71, 0x86, 0x18, 0x61, 0x04, 0x30, 0xC2, 0x00, 0x00, 0x07,
  0x3C, 0xF3, 0x80, 0x33, 0x63, 0x63, 0x63, 0x66, 0x66, 0xE6, 0x00, 0xC6,
  0x01, 0x8C, 0x01, 0x8C, 0x01, 0x88, 0x03, 0x18, 0x3F, 0x1F, 0x3F, 0x3F,
  0x06, 0x30, 0x06, 0x30, 0x06, 0x60, 0x0C, 0x60, 0x7C, 0x7C, 0xFC, 0xFC,
  0x18, 0xC0, 0x18, 0xC0, 0x19, 0x80, 0x31, 0x80, 0x31, 0x80, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x01, 0xF8, 0x1F, 0xF8, 0xF6, 0x73, 0x18, 0xCC, 0x60,
  0x31, 0x80, 0xC4, 0x03, 0xD0, 0x07, 0xF0, 0x03, 0xF0, 0x0D, 0xC0, 0x23,
  0x80, 0x86, 0x82, 0x1B, 0x18, 0xCF, 0x67, 0x1F, 0xF8, 0x1F, 0x80, 0x10,
  0x00, 0x40, 0x03, 0x00, 0x07, 0x80, 0xC3, 0xF0, 0x61, 0xC4, 0x30, 0x61,
  0x8C, 0x18, 0x46, 0x04, 0x33, 0x01, 0x8C, 0xC0, 0x7E, 0x60, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x37, 0xE0, 0x19, 0x8C, 0x0C, 0xC3, 0x06, 0x30, 0xC1,
  0x8C, 0x30, 0xC3, 0x18, 0x60, 0xFE, 0x38, 0x1E, 0x00, 0x03, 0xE0, 0x0F,
  0xE0, 0x38, 0xE0, 0x60, 0xC0, 0xC1, 0x81, 0x83, 0x03, 0x0E, 0x03, 0x18,
  0x1F, 0xE0, 0xE7, 0x01, 0x8C, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0xF0,
  0x79, 0xF1, 0xB6, 0x7E, 0x7C, 0x78, 0x70, 0x6F, 0x6D, 0xB0, 0x01, 0xC0,
  0xC0, 0x60, 0x30, 0x08, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x01,
  0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x10, 0x06, 0x01, 0x80, 0x20,
  0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x60,
  0x08, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x18, 0x06,
  0x03, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x80, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x40, 0x63, 0x0B, 0xFF, 0xF1, 0xFE, 0x01, 0xC0,
  0x0F, 0x80, 0x76, 0x03, 0x8C, 0x0C, 0x38, 0x60, 0x40, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xF0, 0x60, 0x06, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x39, 0xDC, 0xE6, 0x73, 0x18, 0xFF, 0xFF, 0x7F, 0xFE,
  0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0x80, 0x06,
  0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x20,
  0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0x07, 0xC0, 0xFF, 0x8E, 0x1C, 0x60,
  0x76, 0x01, 0xB0, 0x0F, 0x80, 0x78, 0x03, 0xC7, 0x3E, 0x39, 0xF1, 0x8D,
  0x80, 0x6C, 0x07, 0x60, 0x33, 0x03, 0x9C, 0x38, 0x7F, 0x81, 0xF0, 0x00,
  0x03, 0xC0, 0x3E, 0x03, 0xB0, 0x39, 0x83, 0x8C, 0x18, 0xE0, 0x86, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xE0, 0x7F, 0x87, 0x0E, 0x70,
  0x33, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xFF, 0xF7, 0xFF, 0x80,
  0x03, 0xE0, 0x7F, 0xC7, 0x0E, 0x70, 0x30, 0x01, 0x80, 0x1C, 0x01, 0xC0,
  0xF8, 0x0F, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x1B, 0x01,
  0xDC, 0x1C, 0x7F, 0xC1, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x07, 0x80,
  0x36, 0x01, 0x98, 0x0C, 0x60, 0x71, 0x81, 0x8C, 0x0C, 0x30, 0x60, 0xC3,
  0x03, 0x18, 0x0C, 0x7F, 0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x0F, 0xFC, 0x3F, 0xF1, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x3C, 0x0F, 0xFC, 0x38, 0x70, 0x40, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xC6, 0x07, 0x3C, 0x38, 0x3F, 0xC0, 0x7C, 0x00, 0x01, 0xE0,
  0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x67, 0x86, 0xFE, 0xD0, 0xEE,
  0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x06, 0xC0, 0x6E, 0x1C, 0x7F, 0x83,
  0xE0, 0xFF, 0xFF, 0xFF, 0xB0, 0x0D, 0x80, 0xCC, 0x06, 0x00, 0x60, 0x07,
  0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0C, 0x00,
  0x60, 0x06, 0x00, 0x70, 0x07, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0xE1, 0xC1,
  0xCE, 0x03, 0x30, 0x0C, 0xC0, 0x61, 0x83, 0x83, 0xF8, 0x1F, 0xE0, 0xC1,
  0xC6, 0x03, 0xB8, 0x06, 0xC0, 0x1B, 0x00, 0xEE, 0x03, 0x3C, 0x1C, 0x7F,
  0xE0, 0x7E, 0x00, 0x07, 0xC0, 0xFF, 0x0E, 0x1C, 0xE0, 0x66, 0x03, 0xF0,
  0x1F, 0x00, 0xF8, 0x06, 0xE0, 0x73, 0x85, 0x9F, 0xF8, 0x3C, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x03, 0xC0, 0x00, 0x38, 0xF3, 0x8E,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x3C, 0xF3, 0x80, 0x1C, 0x3C, 0x70, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xE1, 0xC7, 0x0E, 0x18, 0x70, 0xC1, 0x80,
  0x00, 0x08, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x0E, 0x01, 0xC0, 0x18,
  0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01,
  0x00, 0x7F, 0xFD, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xBF, 0xFE, 0x10, 0x00, 0xC0, 0x0F, 0x80, 0x0E, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0xE0, 0x03, 0x00, 0x70, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0x30, 0x02, 0x00, 0x00, 0x0F, 0x87, 0xFD, 0xC3, 0xB0, 0x3C, 0x06, 0x00,
  0xC0, 0x38, 0x0E, 0x0F, 0x81, 0x80, 0x60, 0x0C, 0x00, 0x00, 0x00, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0x03, 0xE0, 0x3F, 0xC1, 0xC1, 0x86, 0x06,
  0x30, 0x0C, 0xC7, 0x32, 0x3E, 0x98, 0xC6, 0x66, 0x19, 0x98, 0x66, 0x61,
  0x99, 0x86, 0x44, 0x33, 0x18, 0xCC, 0x7F, 0x11, 0xEC, 0x60, 0x01, 0x80,
  0x07, 0x00, 0x0F, 0xF0, 0x0F, 0xC0, 0x00, 0xE0, 0x03, 0x80, 0x1B, 0x00,
  0x6C, 0x03, 0x30, 0x0C, 0xC0, 0x63, 0x01, 0x8C, 0x0C, 0x30, 0x30, 0xE1,
  0x81, 0x87, 0xFE, 0x3F, 0xF8, 0xC0, 0x67, 0x01, 0x98, 0x06, 0xE0, 0x1F,
  0x00, 0x70, 0x1F, 0xE0, 0xFF, 0xC6, 0x06, 0x30, 0x33, 0x81, 0x98, 0x0C,
  0xC0, 0x66, 0x06, 0x3F, 0xE1, 0xFF, 0x1C, 0x0C, 0xC0, 0x36, 0x01, 0xB0,
  0x1D, 0x80, 0xCC, 0x0E, 0xFF, 0xE7, 0xFE, 0x00, 0x03, 0xE0, 0x7F, 0x87,
  0x0E, 0x70, 0x33, 0x01, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x04, 0x60, 0x3B, 0x81, 0x8E, 0x18, 0x7F, 0xC0,
  0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0xC1, 0x83, 0x86, 0x06, 0x18, 0x1C, 0x60,
  0x73, 0x80, 0xCC, 0x07, 0x30, 0x1C, 0xC0, 0x63, 0x01, 0x8C, 0x06, 0x60,
  0x39, 0x80, 0xC6, 0x07, 0x18, 0x38, 0x7F, 0xC3, 0xFC, 0x00, 0x1F, 0xFC,
  0x7F, 0xF1, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x3F, 0xF8, 0xFF, 0xE7, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0xFF, 0xF3, 0xFF, 0x80, 0x1F, 0xFE, 0x3F, 0xF8, 0x60, 0x00,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x3F, 0xF8, 0x7F,
  0xE1, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xE0, 0x01, 0x80, 0x00, 0x07, 0xC0, 0x7F, 0x87, 0x1C, 0x60, 0x77, 0x01,
  0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x1F, 0xB0, 0xFD, 0x80, 0x6C,
  0x06, 0x60, 0x33, 0x03, 0x9C, 0x3C, 0x7F, 0x61, 0xF7, 0x00, 0x18, 0x0C,
  0x60, 0x31, 0x80, 0xCE, 0x03, 0x30, 0x1C, 0xC0, 0x63, 0x01, 0x8C, 0x06,
  0x3F, 0xF9, 0xFF, 0xE6, 0x01, 0x98, 0x0C, 0x60, 0x31, 0x80, 0xC6, 0x03,
  0x38, 0x0C, 0xC0, 0x73, 0x01, 0x80, 0x1F, 0xFC, 0x7F, 0xF0, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0xFF, 0xF3,
  0xFF, 0x80, 0x0F, 0xF1, 0xFF, 0x00, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xCC, 0x0C, 0xC1,
  0xCE, 0x38, 0x7F, 0x83, 0xE0, 0x18, 0x07, 0x18, 0x0C, 0x18, 0x18, 0x18,
  0x30, 0x38, 0xE0, 0x31, 0xC0, 0x31, 0x80, 0x33, 0x00, 0x37, 0x00, 0x3D,
  0x80, 0x79, 0x80, 0x70, 0xC0, 0x60, 0xC0, 0x60, 0xE0, 0x60, 0x60, 0x60,
  0x70, 0xE0, 0x30, 0xC0, 0x38, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x07, 0x00, 0xFF, 0xFF, 0xFC, 0x18, 0x0E, 0x78, 0x3C, 0xF0, 0xF1,
  0xE1, 0xE3, 0x46, 0xC6, 0xCD, 0x8D, 0xB3, 0x33, 0xC4, 0x63, 0x98, 0xC6,
  0x31, 0x8C, 0x63, 0x10, 0xC6, 0x01, 0x98, 0x06, 0x30, 0x0C, 0x60, 0x18,
  0xC0, 0x31, 0x80, 0x60, 0x1C, 0x0C, 0x70, 0x31, 0xE0, 0xCD, 0x83, 0x36,
  0x0C, 0xD8, 0x63, 0x31, 0x8C, 0xC6, 0x33, 0x19, 0x8C, 0x66, 0x11, 0x98,
  0x6C, 0x61, 0xB1, 0x86, 0xC6, 0x1B, 0x30, 0x3C, 0xC0, 0xF3, 0x03, 0x80,
  0x07, 0xC0, 0xFF, 0x8E, 0x1C, 0x60, 0x76, 0x01, 0xB0, 0x0F, 0x80, 0x78,
  0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0D, 0x80, 0x6C, 0x07, 0x60, 0x33, 0x03,
  0x9C, 0x38, 0x7F, 0x81, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0xE1, 0x81, 0xC6,
  0x03, 0x38, 0x0C, 0xC0, 0x33, 0x01, 0xCC, 0x0E, 0x3F, 0xF8, 0xFF, 0x87,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03,
  0x00, 0x00, 0x07, 0xC0, 0xFF, 0x8E, 0x1C, 0x60, 0x76, 0x01, 0xB0, 0x0F,
  0x80, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0D, 0x80, 0x6C, 0x07, 0x60,
  0x33, 0x03, 0x9C, 0x38, 0x7F, 0x81, 0xF8, 0x03, 0x80, 0x0C, 0x60, 0x77,
  0x01, 0xF0, 0x06, 0x00, 0x1F, 0xF0, 0x7F, 0xE1, 0x81, 0xC6, 0x03, 0x38,
  0x0C, 0xC0, 0x33, 0x01, 0xCC, 0x0E, 0x3F, 0xF8, 0xFF, 0x87, 0x18, 0x18,
  0x60, 0x60, 0xC1, 0x83, 0x06, 0x0E, 0x18, 0x18, 0xE0, 0x63, 0x00, 0xC0,
  0x07, 0xE0, 0x7F, 0xE3, 0xC1, 0xCC, 0x03, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0F, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1A, 0x00,
  0xEC, 0x03, 0x3C, 0x1C, 0x7F, 0xE0, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x19, 0x80, 0xCC, 0x06, 0xE0,
  0x36, 0x03, 0xB0, 0x19, 0x80, 0xCC, 0x06, 0x60, 0x36, 0x01, 0xB0, 0x1D,
  0x80, 0xCC, 0x06, 0x60, 0x33, 0x03, 0x9C, 0x38, 0x7F, 0x81, 0xF8, 0x00,
  0xC0, 0x1F, 0x00, 0x6C, 0x03, 0x30, 0x0C, 0xC0, 0x61, 0x81, 0x86, 0x0E,
  0x18, 0x30, 0x61, 0xC1, 0x86, 0x06, 0x38, 0x18, 0xC0, 0x63, 0x00, 0xD8,
  0x03, 0x60, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x30, 0x07, 0x30, 0x06,
  0x20, 0x06, 0x60, 0x06, 0x60, 0x04, 0x63, 0x8C, 0x63, 0x8C, 0x62, 0x8C,
  0x66, 0x88, 0x66, 0x98, 0x6C, 0x98, 0x6C, 0x98, 0x68, 0x90, 0x58, 0xB0,
  0xD8, 0xF0, 0xD0, 0xF0, 0xF0, 0xE0, 0xF0, 0xE0, 0x18, 0x03, 0x86, 0x03,
  0x83, 0x03, 0x80, 0xC3, 0x80, 0x61, 0x80, 0x19, 0x80, 0x0D, 0x80, 0x03,
  0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xCC, 0x00, 0xC6, 0x00,
  0xE1, 0x80, 0xE0, 0xC0, 0x60, 0x70, 0x60, 0x18, 0x60, 0x0E, 0x00, 0xE0,
  0x0E, 0xC0, 0x39, 0xC0, 0x61, 0x81, 0x83, 0x07, 0x03, 0x0C, 0x06, 0x30,
  0x0C, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x0F, 0xFF, 0x1F,
  0xFF, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xFF, 0xFC, 0xFF, 0xF8, 0x0F, 0xE1, 0xFC,
  0x20, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x04, 0x00, 0x80, 0x3F, 0xC7, 0xF0, 0x81, 0x83, 0x06, 0x04, 0x0C, 0x18,
  0x30, 0x20, 0x40, 0xC1, 0x83, 0x02, 0x04, 0x0C, 0x18, 0x30, 0x20, 0x60,
  0xC1, 0x81, 0x03, 0x0F, 0xE1, 0xFC, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80,
  0x10, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30, 0x06, 0x3F, 0xC7, 0xF8,
  0x03, 0x80, 0x1E, 0x01, 0xB0, 0x19, 0x81, 0xC6, 0x0C, 0x30, 0xC0, 0xCC,
  0x06, 0xE0, 0x36, 0x00, 0xE0, 0x08, 0xFF, 0xFF, 0xFF, 0x80, 0xD9, 0xB2,
  0x0F, 0x98, 0xFE, 0xCE, 0x16, 0xE0, 0x66, 0x03, 0x30, 0x19, 0x80, 0xDC,
  0x06, 0xE0, 0x73, 0x03, 0x18, 0x78, 0xFE, 0xF3, 0xE3, 0x80, 0x0C, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE7, 0x86, 0xFE, 0x34,
  0x39, 0xC0, 0xCC, 0x06, 0x60, 0x37, 0x01, 0xB0, 0x0D, 0x80, 0xEC, 0x06,
  0x70, 0xF3, 0xFF, 0x31, 0xE0, 0x0F, 0x81, 0xFE, 0x30, 0x66, 0x03, 0x60,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x6C, 0x0E, 0x61, 0xC7, 0xF8, 0x1E,
  0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60,
  0xF9, 0x87, 0xF6, 0x38, 0x79, 0xC0, 0xE6, 0x03, 0x18, 0x0C, 0x60, 0x33,
  0x80, 0xCE, 0x07, 0x18, 0x1C, 0x61, 0xE1, 0xFD, 0x83, 0xE6, 0x00, 0x0F,
  0xC1, 0xFE, 0x30, 0x76, 0x03, 0xC0, 0xEF, 0xFC, 0xFF, 0x0C, 0x00, 0xC0,
  0x4C, 0x06, 0xE0, 0xC7, 0xF8, 0x1F, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x7F, 0xFC, 0x3F, 0xFE,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x20, 0xC0, 0x18,
  0x60, 0x06, 0x30, 0x01, 0x98, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x98,
  0xFE, 0xCE, 0x1E, 0x60, 0x76, 0x03, 0x30, 0x19, 0x80, 0xDC, 0x06, 0xE0,
  0x73, 0x05, 0x9C, 0x78, 0xFE, 0xC1, 0xE6, 0x00, 0x30, 0x03, 0x18, 0x38,
  0xFF, 0x81, 0xF0, 0x00, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x33, 0xC7, 0x7E, 0x78, 0x67, 0x06, 0x60, 0x76, 0x06, 0x60, 0x6E,
  0x06, 0xC0, 0x6C, 0x06, 0xC0, 0xCC, 0x0C, 0xC0, 0xC0, 0x03, 0x00, 0x78,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x06, 0x00, 0x60,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC2, 0x0C, 0x71, 0x8E, 0x1B, 0x81, 0xF0,
  0x0E, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC1, 0xFC, 0x20, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x03, 0x00, 0x30, 0x83, 0x0C, 0x30, 0x63, 0x03, 0xB0, 0x1E,
  0x00, 0xE0, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xCF, 0x0E, 0xFC, 0x68, 0x63, 0x83, 0x98, 0x18, 0xC1, 0xC6, 0x38, 0x77,
  0x03, 0x30, 0x58, 0xC7, 0xC7, 0x76, 0x1F, 0x30, 0x60, 0xFE, 0x1F, 0xC0,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x03, 0x00, 0x61, 0x8C, 0x79, 0x9C, 0x37, 0x07, 0xC0, 0xE0, 0x00,
  0x33, 0x1C, 0x6F, 0x7C, 0xE7, 0x19, 0x8E, 0x33, 0x18, 0x66, 0x30, 0x98,
  0x63, 0x30, 0xC6, 0x61, 0x0C, 0xC6, 0x19, 0x8C, 0x22, 0x18, 0xCC, 0x31,
  0x80, 0x33, 0xC3, 0x7E, 0x68, 0x67, 0x06, 0x60, 0x76, 0x06, 0x60, 0x6E,
  0x06, 0xC0, 0x6C, 0x06, 0xC0, 0xCC, 0x0C, 0xC0, 0xC0, 0x0F, 0x83, 0xFE,
  0x70, 0x66, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x6C, 0x06,
  0xE1, 0xC7, 0xF8, 0x3F, 0x00, 0x0C, 0xF0, 0x6F, 0xE1, 0xA1, 0xC7, 0x03,
  0x18, 0x0C, 0x60, 0x33, 0x80, 0xCC, 0x03, 0x30, 0x1C, 0xC0, 0x63, 0x87,
  0x8F, 0xFC, 0x63, 0xC1, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80,
  0x00, 0x0F, 0x98, 0xFE, 0xCE, 0x1E, 0xE0, 0x76, 0x03, 0x30, 0x19, 0x80,
  0xDC, 0x06, 0xE0, 0x73, 0x03, 0x98, 0x78, 0xFE, 0xC3, 0xE6, 0x00, 0x30,
  0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0xFC, 0xFF, 0xDF, 0x1E, 0x01,
  0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x00, 0x07, 0xE0, 0xFF, 0x8E, 0x0E, 0x60, 0x03, 0x00, 0x1F,
  0x80, 0x7F, 0x80, 0x3E, 0x00, 0x32, 0x01, 0xB8, 0x1C, 0xFF, 0xC1, 0xF8,
  0x00, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x0F, 0xFF, 0xFF, 0xF0,
  0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x21, 0x86, 0x19, 0xF3,
  0x38, 0x3F, 0x01, 0xC0, 0x30, 0x36, 0x03, 0x60, 0x36, 0x07, 0x60, 0x66,
  0x06, 0x60, 0x6C, 0x06, 0xC0, 0xEC, 0x1C, 0xE3, 0xC7, 0xEC, 0x3C, 0xC0,
  0xF8, 0x6F, 0x83, 0x30, 0x33, 0x03, 0x30, 0x33, 0x03, 0x30, 0x73, 0x06,
  0x20, 0xE6, 0x1C, 0x67, 0x87, 0xF0, 0x3C, 0x00, 0x31, 0x98, 0x86, 0x36,
  0x18, 0xD8, 0x43, 0x63, 0x0D, 0x8C, 0x34, 0x30, 0xD0, 0xC6, 0xC2, 0x1B,
  0x18, 0xEC, 0xF3, 0x3E, 0xF8, 0x71, 0xC0, 0x07, 0x1C, 0x3E, 0x7C, 0xE5,
  0x9B, 0x8A, 0x34, 0x1C, 0x60, 0x30, 0x00, 0x60, 0x01, 0xC0, 0xC3, 0x85,
  0x8F, 0x1B, 0x16, 0xE7, 0xEF, 0x87, 0x8E, 0x00, 0x18, 0x19, 0x80, 0xCC,
  0x06, 0x60, 0x73, 0x03, 0x18, 0x18, 0xC0, 0xCC, 0x06, 0x60, 0x73, 0x07,
  0x1C, 0x78, 0x7E, 0xC1, 0xE6, 0x00, 0x30, 0x03, 0x18, 0x38, 0xFF, 0x81,
  0xF0, 0x00, 0x0F, 0x9C, 0xFF, 0xE3, 0x0F, 0x88, 0x0C, 0x20, 0xE0, 0x06,
  0x00, 0x30, 0x03, 0x84, 0x1C, 0x30, 0xC0, 0x47, 0xF1, 0xBB, 0xFE, 0xC1,
  0xF0, 0x03, 0xF0, 0x7F, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x30, 0x06, 0x0F, 0xC0, 0xFC, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x3F, 0x03,
  0xF0, 0x0C, 0x30, 0x82, 0x18, 0x61, 0x86, 0x18, 0x43, 0x0C, 0x30, 0xC3,
  0x08, 0x61, 0x86, 0x18, 0x61, 0x0C, 0x30, 0x0F, 0xC0, 0xFC, 0x00, 0x40,
  0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x60, 0x07, 0x00,
  0x3F, 0x03, 0xF0, 0x60, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00,
  0x30, 0x02, 0x00, 0x60, 0xFE, 0x0F, 0xC0, 0x1C, 0x0C, 0xF8, 0x26, 0x71,
  0x98, 0xCE, 0x41, 0xF3, 0x03, 0x80,
};

const GFXglyph IBMPlexMono_Italic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 6, 18, 16, 5, -18 },
  { 15, 8, 7, 16, 5, -19 },
  { 22, 16, 18, 16, 0, -18 },
  { 58, 14, 24, 16, 1, -21 },
  { 100, 18, 18, 16, -1, -18 },
  { 141, 15, 18, 16, 0, -18 },
  { 175, 3, 7, 16, 8, -19 },
  { 178, 10, 24, 16, 5, -20 },
  { 208, 10, 24, 16, 1, -20 },
  { 238, 14, 13, 16, 1, -14 },
  { 261, 12, 12, 16, 2, -14 },
  { 279, 5, 8, 16, 4, -4 },
  { 284, 8, 2, 16, 4, -9 },
  { 286, 4, 4, 16, 5, -4 },
  { 288, 14, 24, 16, 1, -20 },
  { 330, 13, 18, 16, 2, -18 },
  { 360, 13, 18, 16, 1, -18 },
  { 390, 13, 18, 16, 1, -18 },
  { 420, 13, 18, 16, 1, -18 },
  { 450, 14, 18, 16, 0, -18 },
  { 482, 14, 18, 16, 1, -18 },
  { 514, 12, 18, 16, 2, -18 },
  { 541, 13, 18, 16, 3, -18 },
  { 571, 14, 18, 16, 1, -18 },
  { 603, 13, 18, 16, 2, -18 },
  { 633, 6, 14, 16, 5, -14 },
  { 644, 7, 18, 16, 4, -14 },
  { 660, 13, 15, 16, 2, -15 },
  { 685, 14, 8, 16, 1, -12 },
  { 699, 13, 15, 16, 1, -15 },
  { 724, 11, 18, 16, 3, -18 },
  { 749, 14, 21, 16, 1, -18 },
  { 786, 14, 18, 16, 0, -18 },
  { 818, 13, 18, 16, 1, -18 },
  { 848, 13, 18, 16, 2, -18 },
  { 878, 14, 18, 16, 1, -18 },
  { 910, 14, 18, 16, 1, -18 },
  { 942, 15, 18, 16, 1, -18 },
  { 976, 13, 18, 16, 2, -18 },
  { 1006, 14, 18, 16, 1, -18 },
  { 1038, 14, 18, 16, 1, -18 },
  { 1070, 12, 18, 16, 2, -18 },
  { 1097, 16, 18, 16, 1, -18 },
  { 1133, 11, 18, 16, 2, -18 },
  { 1158, 15, 18, 16, 1, -18 },
  { 1192, 14, 18, 16, 1, -18 },
  { 1224, 13, 18, 16, 2, -18 },
  { 1254, 14, 18, 16, 1, -18 },
  { 1286, 13, 23, 16, 2, -18 },
  { 1324, 14, 18, 16, 1, -18 },
  { 1356, 14, 18, 16, 1, -18 },
  { 1388, 15, 18, 16, 2, -18 },
  { 1422, 13, 18, 16, 2, -18 },
  { 1452, 14, 18, 16, 3, -18 },
  { 1484, 16, 18, 16, 1, -18 },
  { 1520, 17, 18, 16, 0, -18 },
  { 1559, 15, 18, 16, 2, -18 },
  { 1593, 16, 18, 16, 0, -18 },
  { 1629, 11, 24, 16, 4, -20 },
  { 1662, 7, 24, 16, 5, -20 },
  { 1683, 11, 24, 16, 0, -20 },
  { 1716, 13, 11, 16, 2, -18 },
  { 1734, 13, 2, 16, 0, 2 },
  { 1738, 3, 5, 16, 6, -20 },
  { 1740, 13, 13, 16, 1, -13 },
  { 1762, 13, 19, 16, 1, -19 },
  { 1793, 12, 13, 16, 2, -13 },
  { 1813, 14, 19, 16, 1, -19 },
  { 1847, 12, 13, 16, 2, -13 },
  { 1867, 17, 24, 16, 0, -19 },
  { 1918, 13, 18, 16, 1, -13 },
  { 1948, 12, 19, 16, 2, -19 },
  { 1977, 12, 19, 16, 2, -19 },
  { 2006, 12, 24, 16, 2, -19 },
  { 2042, 13, 19, 16, 2, -19 },
  { 2073, 11, 19, 16, 3, -19 },
  { 2100, 15, 13, 16, 0, -13 },
  { 2125, 12, 13, 16, 2, -13 },
  { 2145, 12, 13, 16, 2, -13 },
  { 2165, 14, 18, 16, 0, -13 },
  { 2197, 13, 18, 16, 1, -13 },
  { 2227, 12, 13, 16, 3, -13 },
  { 2247, 13, 13, 16, 1, -13 },
  { 2269, 12, 18, 16, 2, -18 },
  { 2296, 12, 13, 16, 2, -13 },
  { 2316, 12, 13, 16, 2, -13 },
  { 2336, 14, 13, 16, 1, -13 },
  { 2359, 15, 13, 16, 0, -13 },
  { 2384, 13, 18, 16, 1, -13 },
  { 2414, 14, 13, 16, 1, -13 },
  { 2437, 12, 24, 16, 3, -20 },
  { 2473, 6, 24, 16, 5, -20 },
  { 2491, 12, 24, 16, 1, -20 },
  { 2527, 14, 6, 16, 1, -11 },
};

const GFXfont IBMPlexMono_Italic26pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic26pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic26pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _IBMPLEXMONO_ITALIC26PT7B_H_
