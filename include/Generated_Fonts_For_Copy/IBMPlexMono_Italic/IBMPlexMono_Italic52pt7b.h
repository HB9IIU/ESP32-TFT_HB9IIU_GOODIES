#ifndef _IBMPLEXMONO_ITALIC52PT7B_H_
#define _IBMPLEXMONO_ITALIC52PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x7F, 0x0F,
  0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x07, 0xC0, 0x3C, 0x1E, 0x78, 0x3C, 0xF0,
  0x79, 0xE0, 0xF3, 0x81, 0xEF, 0x07, 0x9E, 0x0F, 0x3C, 0x1E, 0x78, 0x3C,
  0xF0, 0x79, 0xC0, 0xF7, 0x83, 0xCF, 0x07, 0x9E, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x3C, 0x0F,
  0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF1, 0xFF, 0xC0, 0xFF,
  0xE3, 0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0x78, 0x1C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x07, 0x81, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x1F, 0xFC, 0x0F, 0xFE, 0x3F,
  0xF8, 0x1F, 0xF8, 0x7F, 0xF0, 0x7F, 0xF0, 0xFF, 0xC0, 0xFF, 0xE0, 0x07,
  0x81, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x81,
  0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x1C,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xE0, 0x1F, 0xE7, 0x3F, 0x80, 0xF8, 0x38, 0x7E, 0x0F, 0x81,
  0xC1, 0xF0, 0x78, 0x0E, 0x07, 0x03, 0xC0, 0xF0, 0x20, 0x3E, 0x07, 0x00,
  0x01, 0xF0, 0x38, 0x00, 0x0F, 0x81, 0xC0, 0x00, 0x7C, 0x0E, 0x00, 0x01,
  0xE0, 0x70, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x7F, 0x38, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xCF, 0xF0, 0x00, 0x0E, 0x1F, 0x80,
  0x00, 0x70, 0x7C, 0x00, 0x03, 0x81, 0xF0, 0x00, 0x1C, 0x0F, 0x80, 0x01,
  0xE0, 0x7C, 0x00, 0x0E, 0x03, 0xE0, 0x00, 0x70, 0x1F, 0x0C, 0x03, 0x80,
  0xF0, 0xF0, 0x1C, 0x0F, 0x8F, 0xC0, 0xE0, 0xFC, 0x3F, 0x0F, 0x0F, 0xC0,
  0xFE, 0x71, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x3C, 0x07, 0xFF, 0x80,
  0x0F, 0x01, 0xF0, 0xF0, 0x01, 0xC0, 0x3C, 0x0F, 0x00, 0x78, 0x0F, 0x00,
  0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0xF0, 0x0F,
  0x00, 0xF0, 0x3C, 0x01, 0xE0, 0x1E, 0x0F, 0x00, 0x3C, 0x03, 0xC1, 0xE0,
  0x07, 0x80, 0x70, 0x78, 0x00, 0xF0, 0x1E, 0x1E, 0x00, 0x0E, 0x03, 0xC3,
  0x80, 0x01, 0xE1, 0xF0, 0xF0, 0x00, 0x1F, 0xFC, 0x3C, 0x00, 0x03, 0xFF,
  0x07, 0x00, 0x00, 0x1F, 0x81, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x38, 0x3F, 0xE0,
  0x00, 0x0F, 0x0F, 0xFE, 0x00, 0x03, 0xC3, 0xC1, 0xE0, 0x00, 0xF0, 0xF0,
  0x1C, 0x00, 0x1E, 0x1E, 0x03, 0x80, 0x07, 0x87, 0x80, 0x78, 0x01, 0xE0,
  0xF0, 0x0F, 0x00, 0x38, 0x1E, 0x01, 0xE0, 0x0F, 0x03, 0x80, 0x38, 0x03,
  0xC0, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C,
  0x07, 0x80, 0x3C, 0x0F, 0x01, 0xE0, 0x07, 0xC3, 0xC0, 0x3C, 0x00, 0x7F,
  0xF0, 0x0F, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x3C,
  0x01, 0xF0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xE0,
  0x07, 0x80, 0x03, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x0F, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x3C, 0x3E, 0x00, 0x07, 0xF9, 0xF8, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0xFE, 0xFF, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x1E, 0x03, 0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF8, 0x07, 0xC0, 0x01,
  0xF0, 0x07, 0x80, 0x03, 0xC0, 0x0F, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x8F,
  0x00, 0x1F, 0x01, 0xDE, 0x00, 0x3E, 0x07, 0xFE, 0x00, 0x5E, 0x0F, 0x7C,
  0x01, 0xBC, 0x3C, 0x78, 0x07, 0x7C, 0x78, 0xFC, 0x1E, 0x7D, 0xE0, 0xFF,
  0xF8, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0x00, 0xFF, 0x80, 0xFC, 0x00, 0xFC,
  0x00, 0xF0, 0x00, 0x1E, 0x38, 0xF1, 0xE3, 0xC7, 0x8F, 0x1C, 0x78, 0xF1,
  0xE3, 0xC7, 0x9E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x60, 0x0F, 0x00, 0xDF, 0x03, 0x81, 0xFF, 0xF9, 0xE7, 0xFD,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x3E,
  0x7C, 0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x81, 0xE0, 0x07, 0xC0, 0x78, 0x01,
  0xE0, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x1C, 0x00, 0x60, 0x02, 0x00, 0x10,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFA, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0xF0, 0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0x81, 0xF8, 0x1F,
  0x01, 0xF0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0x7F,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x3E, 0x7F, 0xFF, 0xFF, 0xFE,
  0xFE, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0x81, 0xF8, 0x07, 0xC0, 0x0F, 0x01, 0xF0, 0x01, 0xF0, 0x7C,
  0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x0F,
  0x8F, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x3E, 0x78, 0x00, 0x07, 0xCF, 0x00,
  0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x0F, 0x03, 0xCF, 0x03, 0xF0, 0x79,
  0xE0, 0xFE, 0x0F, 0x3C, 0x1F, 0xC1, 0xEF, 0x83, 0xF0, 0x7D, 0xF0, 0x3C,
  0x0F, 0xBE, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x9E,
  0x00, 0x01, 0xF3, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x8F, 0x00, 0x01,
  0xF0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x03, 0xE0, 0x03, 0xE0, 0x7C,
  0x00, 0xF8, 0x07, 0xE0, 0x7E, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xEF, 0x00,
  0x07, 0xE7, 0x80, 0x07, 0xE3, 0xC0, 0x0F, 0xC1, 0xE0, 0x0F, 0xC1, 0xF0,
  0x0F, 0xC0, 0xF0, 0x03, 0xC0, 0x78, 0x01, 0x80, 0x3C, 0x00, 0x80, 0x1E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x1F, 0x81, 0xF0, 0x01,
  0xF0, 0x7C, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xE0, 0xE0, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFC, 0x0F, 0xE0,
  0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xE0, 0x1C, 0x00, 0x1F, 0x00, 0x80,
  0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x81,
  0x00, 0x00, 0xF8, 0x38, 0x00, 0x0F, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00,
  0x3E, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x1E, 0x78, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x87, 0x80, 0x01, 0xF0,
  0x78, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x0F, 0x00,
  0x0F, 0x00, 0xF0, 0x01, 0xF0, 0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x03, 0xC0,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x1E, 0x01, 0xE0, 0x01, 0xE0,
  0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFE, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x7E, 0x00, 0x07, 0x1F, 0xFC, 0x00, 0xF7, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x00, 0xFE, 0x07, 0xF0, 0x0F, 0x80, 0x1F, 0x81, 0xF0, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF8, 0x10, 0x00, 0x0F, 0x03, 0x80, 0x01, 0xF0, 0x7C, 0x00,
  0x3F, 0x0F, 0xE0, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x78, 0x7F, 0x00, 0x7C, 0xFF, 0xE0, 0x3C, 0xFF,
  0xF8, 0x3E, 0xFF, 0xFE, 0x1E, 0xE0, 0x3F, 0x9F, 0xC0, 0x07, 0xCF, 0xC0,
  0x01, 0xE7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xDE,
  0x00, 0x01, 0xEF, 0x80, 0x01, 0xF3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0xF8,
  0xF8, 0x01, 0xF8, 0x3F, 0x03, 0xF8, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x78, 0x00, 0x07, 0x9E,
  0x00, 0x03, 0xE7, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x3E,
  0x1C, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x3E, 0x00,
  0x3E, 0x07, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0,
  0xF8, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x1E, 0x0F, 0x80,
  0x03, 0xE0, 0x78, 0x00, 0x3C, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x03, 0xF0,
  0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xE0, 0x0F, 0xC0, 0x3F, 0x01, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x7C, 0xF8,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0x78, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF8, 0x7C, 0x00, 0x3F, 0x07,
  0xF0, 0x0F, 0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x1F, 0xC0, 0xFE, 0x3F, 0x00, 0x3E, 0x3E,
  0x00, 0x1F, 0x7C, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x7E, 0xFC,
  0x00, 0xDE, 0x7E, 0x03, 0xBC, 0x7F, 0xFF, 0xBC, 0x3F, 0xFE, 0x7C, 0x1F,
  0xFC, 0x78, 0x03, 0xF0, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xC1, 0xFC, 0x3F,
  0x87, 0xF1, 0xFE, 0x1F, 0x83, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x1F, 0xC7, 0xF8, 0xFF, 0x1F, 0xC3, 0xF8, 0x3E, 0x00, 0x00,
  0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x07, 0xE0, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0,
  0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x80, 0x3F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC0, 0x08, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0x03, 0xF9, 0xF8, 0x03, 0xE7,
  0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7C, 0xC0, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0x80, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFC, 0x03, 0xF0, 0x1F, 0x81, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0x3C,
  0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF1, 0xE0, 0x1E,
  0x1C, 0x78, 0x1F, 0xC7, 0x3C, 0x0F, 0xFB, 0xCF, 0x07, 0xFE, 0xF3, 0xC3,
  0xF0, 0xFC, 0xE0, 0xF0, 0x1F, 0x78, 0x3C, 0x03, 0x9E, 0x1E, 0x00, 0xE7,
  0x87, 0x80, 0x79, 0xE1, 0xE0, 0x1E, 0x78, 0xF8, 0x07, 0x9C, 0x3C, 0x01,
  0xEF, 0x0F, 0x00, 0x73, 0xC3, 0xC0, 0x3C, 0xF0, 0xF0, 0x0F, 0x3C, 0x3C,
  0x03, 0xCF, 0x0F, 0x01, 0xF3, 0xC3, 0xE0, 0xBC, 0xF0, 0x7C, 0xEE, 0x3C,
  0x1F, 0xF7, 0x8F, 0x03, 0xFD, 0xE3, 0xC0, 0xFE, 0x78, 0xF0, 0x04, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3C, 0xF0,
  0x00, 0x07, 0x8F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x0F,
  0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x03, 0xC0,
  0x03, 0xC0, 0x7C, 0x00, 0x78, 0x07, 0x80, 0x1F, 0x00, 0xF0, 0x03, 0xC0,
  0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x07, 0xC0, 0x0F, 0x00,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF8, 0x3E, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE1, 0xF0, 0x00, 0x3C, 0x3C,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0xF9, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xE0, 0x3C, 0x00, 0xFC, 0x07, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3C,
  0x00, 0x0F, 0x07, 0x80, 0x03, 0xE0, 0xF0, 0x00, 0x7C, 0x1E, 0x00, 0x0F,
  0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x7C, 0x1E, 0x00, 0x1F, 0x03, 0xC0,
  0x07, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF8, 0x0F, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0xF8, 0x3C, 0x00,
  0x0F, 0x07, 0x80, 0x01, 0xE1, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7,
  0x80, 0x00, 0xF8, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0xF8, 0xF8, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0xC3, 0xC0, 0x03, 0xF0, 0x7F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFC, 0x03, 0xF8, 0x1F, 0x81, 0xF8, 0x03, 0xE0, 0x7C, 0x00, 0x7C,
  0x3E, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x81, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x30, 0xF8, 0x00, 0x1F, 0x3E,
  0x00, 0x07, 0x87, 0x80, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0x7E, 0x00, 0xF8,
  0x0F, 0xC0, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0x80, 0x3F, 0x01, 0xE0, 0x03,
  0xE0, 0x78, 0x00, 0x78, 0x1E, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xC3, 0xE0,
  0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0xF1, 0xF0, 0x00, 0x3C, 0x7C, 0x00, 0x0F, 0x1E, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x7C, 0x78, 0x00, 0x1F, 0x3E, 0x00,
  0x07, 0xCF, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x3E, 0x3C,
  0x00, 0x0F, 0x8F, 0x00, 0x03, 0xC7, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x78,
  0x78, 0x00, 0x3E, 0x1E, 0x00, 0x1F, 0x07, 0x80, 0x0F, 0xC1, 0xE0, 0x0F,
  0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xF0, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xC0, 0x1F, 0x81, 0xF8, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x00, 0xF0,
  0x3C, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0x40, 0x7C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3C, 0x03, 0xFF, 0xC7, 0x80, 0x7F, 0xF8, 0xF0,
  0x0F, 0xFF, 0x3E, 0x01, 0xFF, 0xC7, 0xC0, 0x00, 0x78, 0xF8, 0x00, 0x0F,
  0x1F, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x87, 0x80,
  0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x03, 0xF0,
  0x3E, 0x00, 0xDE, 0x07, 0xE0, 0x7B, 0xC0, 0x7F, 0xFE, 0xF0, 0x0F, 0xFF,
  0x9E, 0x00, 0x7F, 0xE3, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x1E, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x3C, 0x0F, 0x80, 0x01, 0xE0,
  0x7C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0xC0, 0xF0,
  0x00, 0x3E, 0x07, 0x80, 0x01, 0xE0, 0x7C, 0x00, 0x0F, 0x03, 0xE0, 0x00,
  0x78, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3E, 0x07, 0x80, 0x01, 0xF0,
  0x3C, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x78, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xE0, 0x00,
  0x78, 0x1F, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0,
  0x3C, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0xF8,
  0x00, 0x1E, 0x07, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x7C, 0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0xF0,
  0x3E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x40,
  0x01, 0xE0, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x01,
  0xF0, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x03, 0xC0, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0xF8, 0x03, 0xC0, 0x01, 0xF0,
  0x03, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80,
  0x07, 0x80, 0x1F, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x07, 0x80, 0xFC, 0x00,
  0x07, 0x81, 0xF8, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x0F, 0x03, 0xE0, 0x00,
  0x0F, 0x07, 0xC0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x0F, 0x1F, 0x00, 0x00,
  0x0F, 0x3F, 0x80, 0x00, 0x1F, 0x7F, 0x80, 0x00, 0x1E, 0xFF, 0xC0, 0x00,
  0x1F, 0xF3, 0xC0, 0x00, 0x1F, 0xE3, 0xC0, 0x00, 0x1F, 0xC3, 0xE0, 0x00,
  0x3F, 0x81, 0xE0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xF0, 0x00, 0x7C, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x7F, 0x03, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x7B, 0x80,
  0x7F, 0x81, 0xEE, 0x01, 0xFE, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x79,
  0xE0, 0x79, 0xC1, 0xE7, 0x83, 0xC7, 0x0F, 0x1E, 0x0F, 0x1E, 0x3C, 0xF0,
  0x3C, 0x79, 0xE3, 0xC0, 0xF0, 0xE7, 0x0F, 0x03, 0xC3, 0xBC, 0x3C, 0x0F,
  0x0F, 0xE0, 0xF0, 0x78, 0x3F, 0x83, 0xC1, 0xE0, 0x7C, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x81, 0xE0, 0x30,
  0x1E, 0x0F, 0x00, 0x80, 0x78, 0x3C, 0x04, 0x03, 0xC0, 0xF0, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00,
  0x03, 0xC0, 0x03, 0xF0, 0x00, 0x78, 0x1F, 0xC0, 0x03, 0xC0, 0xFE, 0x00,
  0x3C, 0x0F, 0xF0, 0x01, 0xE0, 0x7F, 0x80, 0x0F, 0x03, 0xDE, 0x00, 0x78,
  0x1E, 0xF0, 0x03, 0xC0, 0xF7, 0x80, 0x1E, 0x07, 0xBC, 0x01, 0xE0, 0x78,
  0xE0, 0x0F, 0x03, 0xC7, 0x80, 0x78, 0x1E, 0x3C, 0x03, 0xC0, 0xF1, 0xE0,
  0x1E, 0x07, 0x8F, 0x00, 0xF0, 0x3C, 0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x78,
  0x1E, 0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x3C,
  0x0F, 0x07, 0x81, 0xE0, 0x78, 0x78, 0x1E, 0x03, 0xC3, 0xC0, 0xF0, 0x1E,
  0x1E, 0x07, 0x80, 0x78, 0xF0, 0x3C, 0x03, 0xC7, 0x81, 0xE0, 0x1E, 0x38,
  0x0F, 0x00, 0xF3, 0xC0, 0xF0, 0x03, 0x9E, 0x07, 0x80, 0x1E, 0xF0, 0x3C,
  0x00, 0xF7, 0x81, 0xE0, 0x07, 0xBC, 0x0F, 0x00, 0x1F, 0xC0, 0x78, 0x00,
  0xFE, 0x07, 0x80, 0x07, 0xF0, 0x3C, 0x00, 0x3F, 0x81, 0xE0, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0x81, 0xF8, 0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x01,
  0xF0, 0x7C, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x78, 0x78,
  0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0x78, 0x00, 0x07,
  0xCF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xCF, 0x80,
  0x00, 0x79, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D,
  0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3C, 0xF0, 0x00,
  0x07, 0x9E, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x8F,
  0x80, 0x01, 0xF0, 0xF0, 0x00, 0x7C, 0x1E, 0x00, 0x0F, 0x83, 0xE0, 0x03,
  0xE0, 0x7C, 0x00, 0xF8, 0x07, 0xE0, 0x7E, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE,
  0x03, 0xC0, 0x03, 0xF0, 0x3C, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF0, 0x7C,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0xF0, 0x78, 0x00, 0x0F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x0F, 0xC0, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0x81, 0xF8, 0x07, 0xC0, 0x1F,
  0x01, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC3, 0xE0,
  0x00, 0x78, 0x78, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3E,
  0x78, 0x00, 0x07, 0xCF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00,
  0x03, 0xCF, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x3C, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x3C, 0x78,
  0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF0, 0xF0, 0x00, 0x7C, 0x1E, 0x00, 0x0F,
  0x83, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x07, 0xE0, 0x7E, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0x80, 0x01, 0xF0, 0x18, 0x00, 0x1E, 0x07, 0x80, 0x03,
  0xE1, 0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xC0, 0x03,
  0xF0, 0x3C, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF0, 0x7C, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00,
  0x0F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x01, 0xE0, 0x7C, 0x00,
  0x1E, 0x03, 0xC0, 0x01, 0xE0, 0x3E, 0x00, 0x3E, 0x01, 0xE0, 0x03, 0xE0,
  0x1E, 0x00, 0x3C, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8,
  0x03, 0xC0, 0x07, 0x80, 0x7C, 0x00, 0x7C, 0x07, 0x80, 0x03, 0xC0, 0x78,
  0x00, 0x3E, 0x07, 0x80, 0x03, 0xE0, 0x78, 0x00, 0x1E, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x7F, 0x01, 0xF0, 0x00, 0xFC, 0x1F,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x40, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x08, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x1F, 0x1F, 0x80, 0x01, 0xF0, 0x7E, 0x00, 0x1F,
  0x81, 0xFC, 0x03, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xE1, 0xE0, 0x00,
  0x7C, 0x3C, 0x00, 0x0F, 0x0F, 0x80, 0x01, 0xE1, 0xF0, 0x00, 0x3C, 0x3C,
  0x00, 0x07, 0x87, 0x80, 0x01, 0xF0, 0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x07,
  0x87, 0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0xF8, 0x78, 0x00, 0x1F, 0x0F, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x78,
  0x7C, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x7C, 0x3C, 0x00,
  0x0F, 0x87, 0x80, 0x01, 0xE1, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87,
  0x80, 0x00, 0xF0, 0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0xF0, 0x3E,
  0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x80, 0x7E, 0x07, 0xF0, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1F, 0x78, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0xF8, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0xF0,
  0x3C, 0x00, 0x3E, 0x07, 0x80, 0x07, 0x80, 0xF0, 0x01, 0xF0, 0x0F, 0x00,
  0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00,
  0xF0, 0x0F, 0x00, 0x1E, 0x01, 0xE0, 0x03, 0xC0, 0x78, 0x00, 0x38, 0x0F,
  0x00, 0x07, 0x83, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x1F, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x78, 0xF8, 0x00, 0x0F, 0x1E, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x1E, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78,
  0x38, 0x0F, 0x80, 0xF0, 0x70, 0x1F, 0x01, 0xE0, 0xE0, 0x7E, 0x07, 0x83,
  0xC0, 0xFC, 0x0F, 0x07, 0x81, 0xF8, 0x1E, 0x0F, 0x07, 0xF0, 0x3C, 0x1E,
  0x0E, 0xE0, 0xF0, 0x3C, 0x3D, 0xC1, 0xE0, 0x78, 0x73, 0xC3, 0xC0, 0xF0,
  0xE7, 0x87, 0x81, 0xE3, 0xCF, 0x0E, 0x03, 0x87, 0x1E, 0x3C, 0x07, 0x0E,
  0x3C, 0x78, 0x0E, 0x3C, 0x78, 0xF0, 0x3C, 0x70, 0xF1, 0xC0, 0x79, 0xE0,
  0xE7, 0x80, 0xF3, 0xC1, 0xCF, 0x01, 0xE7, 0x03, 0x9E, 0x03, 0xDE, 0x07,
  0x38, 0x07, 0xB8, 0x0E, 0xF0, 0x0F, 0x70, 0x1D, 0xE0, 0x1D, 0xE0, 0x3B,
  0xC0, 0x3B, 0x80, 0x77, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC,
  0x01, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x3C, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x0F, 0x80, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0x3E, 0x3E, 0x00,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x00,
  0xF8, 0xF8, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0xF0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x07, 0x80,
  0x01, 0xF0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x1F, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0x1F, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0x9E, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7C,
  0x1E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x03, 0xC0, 0x03, 0xE0, 0x1F,
  0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x78, 0x1F, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x78, 0xF8, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0,
  0x01, 0xC0, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x7C, 0xF0, 0x00, 0x0F, 0x1F, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x3E, 0x03, 0xC0, 0x07, 0x80,
  0x78, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x03,
  0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x3E, 0x00, 0x03, 0x87, 0x80, 0x00,
  0x79, 0xE0, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0xF3, 0x00, 0x00, 0x18, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x33, 0xCF, 0x9E, 0x78, 0xE3, 0xC7, 0x1C, 0x20, 0x00, 0x7E, 0x07, 0x80,
  0xFF, 0xC3, 0xC0, 0xFF, 0xF1, 0xE0, 0xFF, 0xFD, 0xE0, 0xFC, 0x0F, 0xF0,
  0xFC, 0x01, 0xF8, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3C, 0x00, 0x0F,
  0x3E, 0x00, 0x07, 0x1E, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xCF, 0x80, 0x01,
  0xE7, 0xC0, 0x00, 0xF3, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x78, 0xF0, 0x00,
  0x3C, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x1F, 0x1E, 0x00, 0x0F, 0x8F, 0x00,
  0x0F, 0xC7, 0xC0, 0x0F, 0xC1, 0xF0, 0x0D, 0xE0, 0xFC, 0x1E, 0xFF, 0x7F,
  0xFE, 0x7F, 0x9F, 0xFE, 0x1F, 0x87, 0xFE, 0x07, 0xC0, 0xFC, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0,
  0x7E, 0x00, 0xF0, 0xFF, 0xC0, 0x78, 0xFF, 0xF0, 0x3C, 0xFF, 0xFC, 0x1E,
  0xF0, 0x7E, 0x1F, 0xE0, 0x0F, 0x8F, 0x60, 0x07, 0xC7, 0xE0, 0x01, 0xE3,
  0xE0, 0x00, 0xF1, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0xF8, 0x00, 0x1E,
  0x78, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xCF, 0x00, 0x03,
  0xE7, 0x80, 0x01, 0xF7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x79, 0xE0, 0x00,
  0x7C, 0xF0, 0x00, 0x3C, 0x7C, 0x00, 0x3E, 0x7F, 0x00, 0x3E, 0x3D, 0xC0,
  0x7E, 0x1E, 0x7F, 0xFF, 0x0F, 0x3F, 0xFF, 0x07, 0x8F, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0xFC, 0x0F, 0xC3, 0xE0, 0x07, 0xC7, 0x80, 0x07, 0x9F, 0x00,
  0x0E, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x23, 0xC0, 0x00, 0x67, 0x80, 0x01, 0xEF,
  0x00, 0x07, 0xCF, 0x00, 0x1F, 0x1F, 0x00, 0x7C, 0x3F, 0x83, 0xF0, 0x3F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x3F, 0x83, 0xC0, 0x1F, 0xFC, 0x78, 0x07, 0xFF, 0xCF, 0x01, 0xFF,
  0xF9, 0xE0, 0x7F, 0x03, 0xBC, 0x1F, 0x80, 0x17, 0x87, 0xC0, 0x03, 0xE0,
  0xF8, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x87, 0xC0, 0x00, 0xF0, 0xF0, 0x00,
  0x1E, 0x1E, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x1E, 0x1E,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x03,
  0xE1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x1F, 0x07, 0x80, 0x03, 0xE0, 0xF8,
  0x00, 0xFC, 0x0F, 0x80, 0x77, 0x81, 0xF8, 0x1C, 0xF0, 0x3F, 0xFF, 0xBC,
  0x03, 0xFF, 0xE7, 0x80, 0x3F, 0xF8, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F,
  0xE0, 0x7E, 0x1F, 0x80, 0x1E, 0x1E, 0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x7C,
  0x00, 0x1F, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x3E, 0xF8, 0x00, 0xFC, 0xF0,
  0x1F, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x10, 0xF0, 0x00, 0x1C, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0x7F, 0x03, 0xF0, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x0C, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x03, 0xF0, 0x1E, 0x00,
  0x00, 0x7E, 0x07, 0x80, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x01, 0xF8, 0xF0,
  0x00, 0x00, 0x3F, 0x3C, 0x00, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x83, 0xC0, 0x3F, 0xF8, 0xF0, 0x1F,
  0xFF, 0x3C, 0x0F, 0xFF, 0xCF, 0x07, 0xF0, 0x3B, 0xC3, 0xF0, 0x02, 0xF1,
  0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x1E, 0x3E, 0x00, 0x07, 0x8F, 0x80, 0x01,
  0xE3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x7C, 0x00, 0x0F, 0x1F, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x1F, 0x1E,
  0x00, 0x07, 0xC7, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x7E,
  0x0F, 0x80, 0x37, 0x83, 0xF0, 0x39, 0xE0, 0xFF, 0xFE, 0x78, 0x1F, 0xFF,
  0x3C, 0x03, 0xFF, 0x8F, 0x00, 0x3F, 0x83, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x80, 0x03, 0xE0,
  0x70, 0x01, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x83, 0xF0, 0x0F, 0x8F, 0xF8, 0x0F,
  0x1F, 0xFC, 0x0F, 0x3F, 0xFE, 0x0F, 0x38, 0x3F, 0x0F, 0x60, 0x1F, 0x0F,
  0xC0, 0x1F, 0x1F, 0x80, 0x0F, 0x1F, 0x00, 0x0F, 0x1F, 0x00, 0x0F, 0x1E,
  0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C,
  0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x7C,
  0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78,
  0x00, 0x3C, 0x78, 0x00, 0x3C, 0xF8, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x04, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1F, 0x01, 0xE0, 0x3E, 0x01,
  0xE0, 0x7C, 0x01, 0xE1, 0xF8, 0x01, 0xE3, 0xF0, 0x03, 0xC7, 0xE0, 0x03,
  0xCF, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0xC0, 0x20, 0x07, 0x80, 0x30, 0x07, 0x80, 0x78,
  0x07, 0x80, 0xFC, 0x07, 0x80, 0x7E, 0x07, 0x80, 0x3F, 0x0F, 0x80, 0x1F,
  0x8F, 0x00, 0x0F, 0xCF, 0x00, 0x07, 0xEF, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC1, 0xF8,
  0x00, 0xF8, 0xFF, 0xC0, 0x1E, 0x3F, 0xFC, 0x03, 0xCF, 0xFF, 0x80, 0x7B,
  0xC1, 0xF8, 0x0F, 0x60, 0x1F, 0x01, 0xF8, 0x01, 0xE0, 0x7E, 0x00, 0x3C,
  0x0F, 0x80, 0x07, 0x81, 0xF0, 0x01, 0xF0, 0x3C, 0x00, 0x3C, 0x07, 0x80,
  0x0F, 0x00, 0xF0, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x07, 0x81, 0xFC, 0x00,
  0xF3, 0xFE, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0xF8, 0x78,
  0x01, 0x1E, 0x0F, 0x80, 0xF3, 0xC0, 0xF0, 0x3F, 0x78, 0x1F, 0x0F, 0xCF,
  0x01, 0xE3, 0xF1, 0xE0, 0x3E, 0xFC, 0x7C, 0x03, 0xFF, 0x0F, 0x00, 0x7F,
  0xC1, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x08, 0x1E, 0x00, 0xE0, 0xF0, 0x0F,
  0x87, 0x80, 0xFC, 0x3C, 0x0F, 0x81, 0xE0, 0xF8, 0x1E, 0x1F, 0x80, 0xF1,
  0xF8, 0x07, 0x9F, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0xF0, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x1E, 0x03, 0xC0, 0x79, 0xF8, 0x7F, 0x83, 0xDF,
  0xE7, 0xFC, 0x3D, 0xFF, 0x3F, 0xE1, 0xEC, 0x7B, 0x8F, 0x8F, 0xC1, 0xD0,
  0x3C, 0x7C, 0x0F, 0x81, 0xC3, 0xC0, 0x78, 0x0E, 0x1E, 0x03, 0xC0, 0x70,
  0xE0, 0x1C, 0x07, 0x8F, 0x01, 0xE0, 0x3C, 0x78, 0x0F, 0x01, 0xE3, 0xC0,
  0x78, 0x0F, 0x1E, 0x03, 0xC0, 0x70, 0xF0, 0x1C, 0x07, 0x87, 0x00, 0xE0,
  0x3C, 0x78, 0x0F, 0x01, 0xE3, 0xC0, 0x78, 0x0F, 0x1E, 0x03, 0xC0, 0x78,
  0xF0, 0x1E, 0x03, 0x87, 0x80, 0xE0, 0x3C, 0x38, 0x0F, 0x01, 0xE3, 0xC0,
  0x78, 0x0F, 0x1E, 0x03, 0xC0, 0x78, 0xF0, 0x1E, 0x03, 0x87, 0x80, 0xF0,
  0x1C, 0x38, 0x0F, 0x01, 0xE0, 0x0F, 0x83, 0xF0, 0x0F, 0x0F, 0xF8, 0x0F,
  0x1F, 0xFC, 0x0F, 0x3F, 0xFE, 0x0F, 0x38, 0x3F, 0x0F, 0x60, 0x1F, 0x1F,
  0xC0, 0x1F, 0x1F, 0x80, 0x0F, 0x1F, 0x00, 0x0F, 0x1F, 0x00, 0x0F, 0x1E,
  0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x3E, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C,
  0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x7C,
  0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78,
  0x00, 0x3C, 0x78, 0x00, 0x3C, 0xF8, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0,
  0x00, 0x78, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0xFE, 0x07, 0xE0, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0x3C,
  0x7C, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xDF, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xBC, 0x00,
  0x07, 0xCF, 0x00, 0x03, 0xC7, 0x80, 0x03, 0xE3, 0xC0, 0x03, 0xE1, 0xF0,
  0x03, 0xF0, 0x7E, 0x07, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xC0, 0xFC, 0x00, 0x78, 0x7F,
  0xE0, 0x0F, 0x1F, 0xFE, 0x01, 0xE7, 0xFF, 0xE0, 0x7D, 0xE0, 0xFC, 0x0F,
  0xF0, 0x07, 0xC1, 0xEC, 0x00, 0xF8, 0x3F, 0x00, 0x0F, 0x07, 0xC0, 0x01,
  0xE0, 0xF0, 0x00, 0x3C, 0x3E, 0x00, 0x07, 0x87, 0xC0, 0x00, 0xF0, 0xF0,
  0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x1F,
  0x1F, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x0F, 0x00,
  0x03, 0xE1, 0xE0, 0x00, 0x78, 0x3E, 0x00, 0x1F, 0x0F, 0xE0, 0x07, 0xC1,
  0xEE, 0x03, 0xF0, 0x3C, 0xFF, 0xFE, 0x07, 0x9F, 0xFF, 0x80, 0xF1, 0xFF,
  0xC0, 0x1E, 0x0F, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x07, 0x80, 0xFF, 0xE3, 0xC0, 0xFF, 0xF9, 0xE0, 0xFF, 0xFC, 0xF0,
  0xFE, 0x07, 0x78, 0xFC, 0x00, 0xBC, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x1E,
  0x3C, 0x00, 0x0F, 0x3E, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xCF, 0x00, 0x01,
  0xEF, 0x80, 0x01, 0xE7, 0xC0, 0x00, 0xF3, 0xC0, 0x00, 0x79, 0xE0, 0x00,
  0x3C, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x1F, 0x3C, 0x00, 0x0F, 0x1E, 0x00,
  0x0F, 0x8F, 0x00, 0x07, 0xC7, 0xC0, 0x05, 0xE1, 0xF0, 0x0E, 0xF0, 0xFC,
  0x0E, 0xF0, 0x7F, 0xFF, 0x78, 0x1F, 0xFF, 0x3C, 0x07, 0xFE, 0x1E, 0x00,
  0xFE, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8,
  0xFF, 0xBF, 0xF8, 0xFF, 0xDF, 0xFC, 0xFF, 0xE0, 0x1E, 0x70, 0x00, 0x0F,
  0x60, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xE0, 0x1F,
  0xC1, 0xF0, 0x01, 0xC0, 0xF8, 0x00, 0x20, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x10, 0x00, 0x0F, 0x0E, 0x00, 0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xFC,
  0x03, 0xF8, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x04, 0x03, 0xC0, 0x1C,
  0x07, 0x80, 0x3E, 0x07, 0x80, 0xFE, 0x07, 0x81, 0xFC, 0x07, 0x87, 0xF0,
  0x07, 0x8F, 0xE0, 0x07, 0xBF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x0F,
  0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x1F, 0x3C, 0x00, 0x1E,
  0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E,
  0x3C, 0x00, 0x3E, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C,
  0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x7C, 0xF8, 0x00, 0x78,
  0xF0, 0x00, 0xF8, 0xF0, 0x00, 0xF8, 0xF8, 0x01, 0x78, 0xF8, 0x03, 0x78,
  0x78, 0x06, 0xF8, 0x7E, 0x1E, 0xF0, 0x7F, 0xFC, 0xF0, 0x3F, 0xF8, 0xF0,
  0x1F, 0xF0, 0xF0, 0x07, 0xE0, 0x00, 0x7F, 0xE0, 0x03, 0x3F, 0xE0, 0x07,
  0x9F, 0xF0, 0x03, 0xCF, 0xF8, 0x01, 0xF8, 0x3C, 0x00, 0x78, 0x1E, 0x00,
  0x3C, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0,
  0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x01, 0xF0, 0x78, 0x00, 0xF0, 0x3C,
  0x00, 0x78, 0x1C, 0x00, 0x7C, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x3E, 0x07,
  0x80, 0x1E, 0x03, 0xC0, 0x1F, 0x01, 0xE0, 0x1F, 0x00, 0xE0, 0x3F, 0x00,
  0xF0, 0x3F, 0x80, 0x78, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0E, 0x03, 0xC0, 0xC3, 0xC0,
  0x78, 0x3C, 0x78, 0x0F, 0x07, 0x8F, 0x01, 0xC0, 0xF1, 0xE0, 0x38, 0x0E,
  0x38, 0x0F, 0x01, 0xC7, 0x01, 0xE0, 0x39, 0xE0, 0x3C, 0x07, 0x3C, 0x07,
  0x80, 0xE7, 0x80, 0xE0, 0x1C, 0xF0, 0x1C, 0x03, 0x9C, 0x07, 0x80, 0x73,
  0x80, 0xF0, 0x1E, 0xF0, 0x1E, 0x03, 0xDE, 0x03, 0xC0, 0x7B, 0xC0, 0x70,
  0x0F, 0x78, 0x0E, 0x01, 0xEE, 0x03, 0xC0, 0x79, 0xC0, 0x78, 0x0F, 0x78,
  0x0F, 0x01, 0xEF, 0x03, 0xE0, 0x79, 0xE0, 0x7C, 0x0F, 0x3C, 0x1B, 0x83,
  0xC7, 0xC7, 0x78, 0xF8, 0xFF, 0xCF, 0xFE, 0x0F, 0xF9, 0xFF, 0x81, 0xFE,
  0x1F, 0xE0, 0x0F, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0xFE,
  0x0F, 0xF0, 0x07, 0xFC, 0x3F, 0xF0, 0x1F, 0xF8, 0xFF, 0xE0, 0x7E, 0x79,
  0xE3, 0xE1, 0xF8, 0xF7, 0x83, 0xCF, 0xC1, 0xEE, 0x07, 0x8E, 0x01, 0xD8,
  0x0F, 0x18, 0x03, 0xF0, 0x1E, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x0F, 0x80,
  0x70, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0xE0, 0x1F, 0x80, 0x03, 0xC0, 0x3F, 0x00, 0x07, 0x80, 0x7E, 0x01, 0x8F,
  0x01, 0xBC, 0x0F, 0x1E, 0x07, 0x78, 0x3F, 0x3C, 0x0E, 0xF1, 0xF8, 0x3C,
  0x79, 0xE7, 0xE0, 0x7F, 0xF1, 0xFF, 0x80, 0xFF, 0xC3, 0xFE, 0x00, 0xFF,
  0x07, 0xF0, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x78,
  0x00, 0x3C, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x3E,
  0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x07, 0x80,
  0x03, 0xC0, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x1F, 0x07, 0x80, 0x03, 0xC0,
  0xF0, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00,
  0x7C, 0x0F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xE0, 0x7C, 0x00, 0x7C, 0x0F,
  0x80, 0x1F, 0x81, 0xF0, 0x06, 0xF0, 0x1F, 0x01, 0xFE, 0x03, 0xF0, 0x77,
  0xC0, 0x7F, 0xFC, 0xF0, 0x07, 0xFF, 0x1E, 0x00, 0x7F, 0xC3, 0xC0, 0x03,
  0xF0, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1F, 0x01, 0x00, 0x07, 0xC0, 0x38, 0x01, 0xF8, 0x0F, 0xC0,
  0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x03, 0xC1, 0xFF, 0xF0, 0xF0, 0xFF,
  0xFF, 0x3C, 0x3F, 0xFF, 0xFF, 0x1F, 0x07, 0xFF, 0xC7, 0x80, 0x3F, 0xE1,
  0xC0, 0x03, 0xF0, 0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x7C, 0x0F, 0x00, 0x3C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x04, 0x00,
  0xF8, 0x07, 0x80, 0x7C, 0x01, 0xE0, 0x3E, 0x00, 0x38, 0x1F, 0x00, 0x0F,
  0x0F, 0xE0, 0x03, 0xCF, 0xFF, 0x80, 0xF3, 0xDF, 0xFF, 0x1C, 0xF0, 0xFF,
  0xFF, 0x3C, 0x07, 0xFF, 0xCF, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x7E, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xF0, 0x0F, 0x00,
  0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x78, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E,
  0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1C, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0xC0, 0x7F, 0x80, 0x0F, 0x0F,
  0xFC, 0x00, 0xE0, 0xFF, 0xE0, 0x1E, 0x1F, 0x1E, 0x01, 0xC1, 0xE1, 0xF0,
  0x3C, 0x3C, 0x0F, 0x87, 0x83, 0x80, 0x78, 0xF8, 0x78, 0x07, 0xFF, 0x07,
  0x00, 0x3F, 0xF0, 0x70, 0x01, 0xFE, 0x0B, 0x00, 0x0F, 0x80,
};

const GFXglyph IBMPlexMono_Italic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 12, 36, 31, 10, -36 },
  { 55, 15, 14, 31, 11, -38 },
  { 82, 31, 36, 31, 1, -36 },
  { 222, 29, 48, 31, 1, -42 },
  { 396, 35, 38, 31, -1, -37 },
  { 563, 31, 38, 31, 0, -37 },
  { 711, 7, 14, 31, 15, -38 },
  { 724, 19, 47, 31, 11, -40 },
  { 836, 19, 47, 31, 2, -40 },
  { 948, 26, 26, 31, 3, -29 },
  { 1033, 26, 26, 31, 3, -29 },
  { 1118, 12, 14, 31, 7, -7 },
  { 1139, 16, 4, 31, 8, -18 },
  { 1147, 8, 7, 31, 10, -7 },
  { 1154, 30, 47, 31, 1, -40 },
  { 1331, 27, 38, 31, 3, -37 },
  { 1460, 25, 36, 31, 2, -36 },
  { 1573, 27, 37, 31, 2, -37 },
  { 1698, 28, 38, 31, 1, -37 },
  { 1831, 28, 36, 31, 1, -36 },
  { 1957, 28, 37, 31, 2, -36 },
  { 2087, 25, 37, 31, 3, -36 },
  { 2203, 26, 36, 31, 5, -36 },
  { 2320, 28, 38, 31, 2, -37 },
  { 2453, 24, 37, 31, 5, -37 },
  { 2564, 11, 28, 31, 10, -28 },
  { 2603, 14, 35, 31, 7, -28 },
  { 2665, 25, 30, 31, 5, -31 },
  { 2759, 26, 14, 31, 3, -23 },
  { 2805, 25, 30, 31, 3, -31 },
  { 2899, 22, 37, 31, 7, -37 },
  { 3001, 26, 43, 31, 3, -37 },
  { 3141, 27, 36, 31, 0, -36 },
  { 3263, 27, 36, 31, 2, -36 },
  { 3385, 26, 38, 31, 4, -37 },
  { 3509, 26, 36, 31, 3, -36 },
  { 3626, 29, 36, 31, 2, -36 },
  { 3757, 29, 36, 31, 2, -36 },
  { 3888, 27, 38, 31, 3, -37 },
  { 4017, 29, 36, 31, 2, -36 },
  { 4148, 29, 36, 31, 2, -36 },
  { 4279, 26, 37, 31, 3, -36 },
  { 4400, 32, 36, 31, 2, -36 },
  { 4544, 22, 36, 31, 4, -36 },
  { 4643, 30, 36, 31, 1, -36 },
  { 4778, 29, 36, 31, 2, -36 },
  { 4909, 27, 38, 31, 3, -37 },
  { 5038, 28, 36, 31, 2, -36 },
  { 5164, 27, 47, 31, 3, -37 },
  { 5323, 28, 36, 31, 2, -36 },
  { 5449, 29, 38, 31, 1, -37 },
  { 5587, 29, 36, 31, 5, -36 },
  { 5718, 27, 37, 31, 4, -36 },
  { 5843, 27, 36, 31, 6, -36 },
  { 5965, 31, 36, 31, 2, -36 },
  { 6105, 34, 36, 31, -1, -36 },
  { 6258, 29, 36, 31, 5, -36 },
  { 6389, 32, 36, 31, 0, -36 },
  { 6533, 22, 47, 31, 8, -40 },
  { 6663, 14, 47, 31, 9, -40 },
  { 6746, 22, 47, 31, 1, -40 },
  { 6876, 27, 21, 31, 3, -36 },
  { 6947, 25, 4, 31, 0, 5 },
  { 6960, 6, 10, 31, 12, -40 },
  { 6968, 25, 28, 31, 3, -27 },
  { 7056, 25, 39, 31, 3, -38 },
  { 7178, 23, 28, 31, 4, -27 },
  { 7259, 27, 39, 31, 3, -38 },
  { 7391, 24, 28, 31, 4, -27 },
  { 7475, 34, 49, 31, -1, -38 },
  { 7684, 26, 38, 31, 2, -27 },
  { 7808, 24, 38, 31, 3, -38 },
  { 7922, 24, 40, 31, 4, -39 },
  { 8042, 24, 50, 31, 3, -39 },
  { 8192, 27, 39, 31, 3, -38 },
  { 8324, 21, 39, 31, 6, -38 },
  { 8427, 29, 27, 31, 1, -27 },
  { 8525, 24, 27, 31, 3, -27 },
  { 8606, 25, 28, 31, 3, -27 },
  { 8694, 27, 37, 31, 1, -27 },
  { 8819, 25, 37, 31, 3, -27 },
  { 8935, 25, 27, 31, 6, -27 },
  { 9020, 26, 28, 31, 2, -27 },
  { 9111, 24, 37, 31, 4, -36 },
  { 9222, 24, 28, 31, 4, -27 },
  { 9306, 25, 27, 31, 3, -27 },
  { 9391, 27, 28, 31, 2, -27 },
  { 9486, 31, 28, 31, 0, -27 },
  { 9595, 27, 38, 31, 1, -27 },
  { 9724, 26, 28, 31, 3, -27 },
  { 9815, 24, 47, 31, 6, -40 },
  { 9956, 12, 47, 31, 10, -40 },
  { 10027, 24, 47, 31, 2, -40 },
  { 10168, 28, 12, 31, 2, -22 },
};

const GFXfont IBMPlexMono_Italic52pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic52pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic52pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _IBMPLEXMONO_ITALIC52PT7B_H_
