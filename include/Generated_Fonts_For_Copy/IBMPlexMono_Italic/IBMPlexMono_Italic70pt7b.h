#ifndef _IBMPLEXMONO_ITALIC70PT7B_H_
#define _IBMPLEXMONO_ITALIC70PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic70pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x3F,
  0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC0, 0x7F,
  0xC0, 0x7F, 0x80, 0x3F, 0x00, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x01,
  0xF3, 0xF0, 0x1F, 0x3E, 0x03, 0xF3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0,
  0x3E, 0x3E, 0x03, 0xE7, 0xE0, 0x3E, 0x7C, 0x07, 0xE7, 0xC0, 0x7C, 0x7C,
  0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xCF, 0xC0, 0x7C, 0xF8, 0x0F, 0xCF,
  0x80, 0xF8, 0xF8, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x7C,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x7E,
  0x00, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00,
  0x00, 0x7E, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0xF8, 0x00,
  0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC1, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0x80,
  0x7F, 0xFF, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x01, 0xF8,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x83,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x3F, 0xFF,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFC,
  0x79, 0xFF, 0x80, 0x1F, 0xE0, 0xF0, 0x7F, 0x80, 0x7F, 0x01, 0xE0, 0x7F,
  0x81, 0xFC, 0x03, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xE0,
  0x1E, 0x00, 0x60, 0x1F, 0x80, 0x3C, 0x00, 0x00, 0x3F, 0x00, 0x78, 0x00,
  0x00, 0x7E, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x01, 0xE0, 0x00, 0x01, 0xF8,
  0x07, 0xC0, 0x00, 0x03, 0xF0, 0x0F, 0x00, 0x00, 0x07, 0xF0, 0x1E, 0x00,
  0x00, 0x07, 0xE0, 0x3C, 0x00, 0x00, 0x0F, 0xE0, 0x78, 0x00, 0x00, 0x1F,
  0xF0, 0xF0, 0x00, 0x00, 0x1F, 0xFB, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xCF, 0xFC, 0x00, 0x00, 0x07, 0x83, 0xFC, 0x00,
  0x00, 0x0F, 0x03, 0xF8, 0x00, 0x00, 0x1E, 0x03, 0xF8, 0x00, 0x00, 0x3C,
  0x03, 0xF0, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x01, 0xE0, 0x0F, 0xC0,
  0x00, 0x03, 0xC0, 0x1F, 0x80, 0x00, 0x07, 0x80, 0x3F, 0x00, 0x00, 0x0F,
  0x00, 0x7E, 0x00, 0x00, 0x1E, 0x00, 0xFC, 0x04, 0x00, 0x7C, 0x01, 0xF8,
  0x1C, 0x00, 0xF0, 0x07, 0xF0, 0x7C, 0x01, 0xE0, 0x0F, 0xC1, 0xFC, 0x03,
  0xC0, 0x3F, 0x83, 0xFC, 0x07, 0x80, 0xFE, 0x03, 0xFE, 0x0F, 0x07, 0xF8,
  0x03, 0xFF, 0x1E, 0x3F, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x7C,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x01, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x01, 0xF0,
  0x01, 0xF0, 0x07, 0xC0, 0x01, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF0,
  0x01, 0xF0, 0x0F, 0x80, 0x01, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xE0,
  0x03, 0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x03, 0xE0,
  0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0x01, 0xE0,
  0x07, 0xC1, 0xF0, 0x00, 0x01, 0xE0, 0x07, 0xC1, 0xF0, 0x00, 0x01, 0xF0,
  0x0F, 0x83, 0xE0, 0x00, 0x01, 0xF8, 0x3F, 0x07, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x08, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01,
  0xF0, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0xFC, 0x1F, 0x80, 0x00, 0x07,
  0xC1, 0xF0, 0x0F, 0x80, 0x00, 0x0F, 0xC3, 0xF0, 0x07, 0x80, 0x00, 0x0F,
  0x83, 0xE0, 0x07, 0xC0, 0x00, 0x1F, 0x03, 0xC0, 0x07, 0xC0, 0x00, 0x3E,
  0x07, 0xC0, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x7C,
  0x07, 0xC0, 0x07, 0xC0, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0xF8,
  0x07, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x07, 0x80, 0x0F, 0x80, 0x03, 0xE0,
  0x07, 0x80, 0x0F, 0x80, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0x80, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x1F, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x3E, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0xFE, 0x00, 0x3E, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7C, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x3E,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x00, 0xFF, 0xC7, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x03,
  0xFC, 0x7F, 0xC0, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x23, 0xF0, 0x00, 0x1F, 0x80, 0x3D, 0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0xFC,
  0x00, 0x0F, 0xF0, 0x1F, 0x7E, 0x00, 0x06, 0xF8, 0x0F, 0x9F, 0x80, 0x07,
  0x7E, 0x0F, 0x8F, 0xC0, 0x07, 0xBF, 0x0F, 0xC7, 0xF0, 0x07, 0x8F, 0xC7,
  0xC1, 0xFC, 0x07, 0xC7, 0xE7, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0xC0,
  0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xE0, 0x00, 0x1F, 0x1F, 0x1F, 0x3F,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0xFC,
  0xF8, 0xF8, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x1C, 0x00, 0x7C, 0x00, 0x77, 0xF0, 0x0F,
  0x80, 0x7E, 0xFF, 0x81, 0xF0, 0x7F, 0xFF, 0xFF, 0x7C, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0x1F, 0xC0, 0x0F, 0x80, 0x07, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x03, 0xD0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7E,
  0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x01,
  0xF0, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x00, 0x0F, 0x87, 0xF9, 0xFF, 0xBF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFE, 0x7F, 0x87, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFC,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0xFC, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x7E, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x00, 0x3F, 0x7F, 0x00, 0xF8, 0x03, 0xF7, 0xE0, 0x1F, 0xC0, 0x3F, 0x7E,
  0x03, 0xFE, 0x07, 0xE7, 0xE0, 0x3F, 0xE0, 0x7E, 0x7E, 0x03, 0xFC, 0x07,
  0xE7, 0xE0, 0x3F, 0xC0, 0x7E, 0x7E, 0x03, 0xFC, 0x07, 0xE7, 0xC0, 0x1F,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0x1F,
  0x8F, 0xC0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x1F, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x7C, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF8,
  0x03, 0xF0, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x03,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xBF, 0x00, 0x00, 0x7F, 0x9F, 0x80, 0x00, 0x7F, 0x8F, 0xC0, 0x00, 0x7F,
  0x87, 0xC0, 0x00, 0x7F, 0x03, 0xE0, 0x00, 0xFF, 0x03, 0xF0, 0x00, 0xFF,
  0x01, 0xF8, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x06, 0x00, 0x1F, 0x00, 0x02, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xF0, 0x3F, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x0E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x3F,
  0xC0, 0x1F, 0xC0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x03, 0xC0,
  0x00, 0x1F, 0x80, 0x0C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x7E, 0x02, 0x00, 0x00, 0x03, 0xF0, 0x18, 0x00, 0x00,
  0x3F, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x00,
  0xFD, 0xF8, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x00, 0x3F,
  0x07, 0xC0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0xFC, 0x00,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0xC0,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0xFF,
  0x00, 0x00, 0x3E, 0x1F, 0xFF, 0x00, 0x01, 0xF3, 0xFF, 0xFC, 0x00, 0x1F,
  0x3F, 0xFF, 0xF8, 0x00, 0xFB, 0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0x01, 0xFF,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x20, 0x00, 0x00, 0x7E, 0x01, 0x80, 0x00, 0x07, 0xE0, 0x3C, 0x00,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0x80,
  0xFF, 0x80, 0x07, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x1F, 0xE0, 0x00, 0xF8, 0x7F, 0xFC, 0x00, 0xFC, 0x7F, 0xFF, 0x80,
  0xFC, 0xFF, 0xFF, 0xE0, 0x7E, 0xFF, 0xFF, 0xF8, 0x3E, 0xFC, 0x07, 0xFE,
  0x3F, 0xF0, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x0F,
  0xEF, 0xF0, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00,
  0xFD, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xF9, 0xF0, 0x00,
  0x00, 0xFC, 0xF8, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x7E, 0x3F, 0x00,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFF, 0x01, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0x7C, 0x00,
  0x00, 0x1F, 0x8F, 0x80, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0xFC, 0x7C,
  0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x01, 0xF8,
  0x3E, 0x00, 0x00, 0x7F, 0x07, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xE0, 0x1F, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x00,
  0x7E, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x3E,
  0x1F, 0x80, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00,
  0x00, 0xFC, 0x7E, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x01,
  0xFC, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xC0, 0x03, 0xF8,
  0x1F, 0xC0, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00,
  0xFB, 0xF0, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x01, 0xFE, 0x7F, 0x00,
  0x01, 0xFF, 0x3F, 0xC0, 0x03, 0xDF, 0x0F, 0xF8, 0x07, 0xDF, 0x83, 0xFF,
  0xFF, 0xCF, 0x81, 0xFF, 0xFF, 0xCF, 0xC0, 0x3F, 0xFF, 0xC7, 0xE0, 0x0F,
  0xFF, 0xC7, 0xE0, 0x00, 0xFF, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE,
  0x07, 0xFE, 0x03, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x3F, 0xC0, 0x7F, 0xE0,
  0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0x80,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xF0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0x80,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x80, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFC,
  0x00, 0x7F, 0x8F, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x3F, 0x18, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0x00, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0x07, 0xC3, 0xE0, 0x03, 0xF0, 0xF8, 0x7C, 0x01, 0xFF, 0x1F, 0x1F, 0x00,
  0x7F, 0xF3, 0xE3, 0xE0, 0x1F, 0xFF, 0x7C, 0x7C, 0x07, 0xFF, 0xEF, 0x8F,
  0x81, 0xFE, 0x0D, 0xF3, 0xE0, 0x3F, 0x00, 0xFE, 0x7C, 0x0F, 0xC0, 0x0F,
  0x8F, 0x81, 0xF8, 0x01, 0xF1, 0xF0, 0x3E, 0x00, 0x3E, 0x3E, 0x0F, 0xC0,
  0x07, 0xCF, 0xC1, 0xF8, 0x00, 0xF9, 0xF0, 0x3E, 0x00, 0x1F, 0x3E, 0x07,
  0xC0, 0x07, 0xC7, 0xC1, 0xF8, 0x00, 0xF8, 0xF8, 0x3F, 0x00, 0x1F, 0x1F,
  0x07, 0xE0, 0x03, 0xE7, 0xE0, 0xF8, 0x00, 0x7C, 0xF8, 0x1F, 0x00, 0x1F,
  0x9F, 0x03, 0xE0, 0x03, 0xE3, 0xE0, 0x7C, 0x00, 0x7C, 0x7C, 0x0F, 0x80,
  0x1F, 0x8F, 0x81, 0xF0, 0x03, 0xF1, 0xF0, 0x3F, 0x00, 0xBE, 0x3E, 0x03,
  0xE0, 0x37, 0xC7, 0xC0, 0x7F, 0x1F, 0xF0, 0xF8, 0x0F, 0xFF, 0xBE, 0x1F,
  0x00, 0xFF, 0xE7, 0xC3, 0xE0, 0x1F, 0xFC, 0xF8, 0x7C, 0x01, 0xFF, 0x1F,
  0x0F, 0x80, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFD, 0xF0, 0x00,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x00, 0x7C,
  0x7C, 0x00, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x00, 0x0F, 0x87, 0xE0, 0x00,
  0x00, 0x3E, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x07, 0xE1, 0xFC, 0x00,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x01, 0xFE, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x1F, 0x00, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x07, 0xF0, 0x3E, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03,
  0xF8, 0x07, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x01, 0xFC, 0x3F, 0x00,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x3F,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07,
  0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0xFE,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3C, 0x07, 0xE0, 0x00, 0x02, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x10, 0x07, 0xC0,
  0x00, 0x01, 0xC0, 0x7E, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00,
  0xFC, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xFF,
  0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0x80, 0x1F, 0xF0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x1F, 0x80,
  0x01, 0xFC, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0xFE, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x7E, 0x00,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x0F,
  0x80, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x00, 0xFC, 0x1F, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x3E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x7E,
  0x00, 0x0F, 0xF0, 0x07, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x81,
  0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x03, 0xC0, 0xFC, 0x00, 0x00, 0x40, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x0F, 0xFF, 0xF3, 0xF0, 0x01, 0xFF, 0xFC, 0x7E, 0x00, 0x3F,
  0xFF, 0x8F, 0xC0, 0x0F, 0xFF, 0xF1, 0xF8, 0x01, 0xFF, 0xFE, 0x3F, 0x00,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x3E, 0x1F,
  0x80, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0x1F,
  0x0F, 0xC0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0x1F, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xC0,
  0x00, 0x3F, 0x81, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x03, 0xFE, 0x03,
  0xF8, 0x00, 0xEF, 0x80, 0x7F, 0xC0, 0xF9, 0xF0, 0x07, 0xFF, 0xFF, 0x3E,
  0x00, 0x7F, 0xFF, 0xC7, 0xC0, 0x07, 0xFF, 0xF0, 0xF8, 0x00, 0x7F, 0xF8,
  0x3F, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x08,
  0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x3F, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xC0, 0x00, 0x0F, 0xF0,
  0x03, 0xE0, 0x00, 0x07, 0xF8, 0x01, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x7E,
  0x00, 0x01, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x7C, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x00, 0x03,
  0xF0, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0x80, 0x7F, 0x80, 0x00, 0x07, 0xE0, 0x3F, 0xC0,
  0x00, 0x01, 0xF8, 0x1F, 0xE0, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0x83, 0xF8, 0x00, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x00, 0x01, 0xF0,
  0xFF, 0x00, 0x00, 0x00, 0xFC, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0x3F, 0xF8,
  0x00, 0x00, 0x0F, 0xDF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xDF, 0x80, 0x00,
  0x00, 0xFF, 0xE3, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x1F, 0x80, 0x00, 0x07, 0xFC, 0x07, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xE0,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x0F, 0xBE, 0x03, 0xE7, 0xC0, 0x1F,
  0x7E, 0x03, 0xE7, 0xC0, 0x3F, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03,
  0xE7, 0xC0, 0x7C, 0x7C, 0x03, 0xE3, 0xC0, 0x7C, 0x7C, 0x07, 0xE3, 0xE0,
  0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0xF8, 0xFC, 0x07, 0xC3, 0xE1, 0xF0, 0xF8,
  0x07, 0xC1, 0xE3, 0xE0, 0xF8, 0x07, 0xC1, 0xF3, 0xE0, 0xF8, 0x07, 0xC1,
  0xF7, 0xC0, 0xF8, 0x0F, 0xC1, 0xF7, 0xC0, 0xF8, 0x0F, 0x80, 0xFF, 0x81,
  0xF8, 0x0F, 0x80, 0xFF, 0x81, 0xF0, 0x0F, 0x80, 0xFF, 0x01, 0xF0, 0x0F,
  0x80, 0xFE, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x1F, 0x80, 0x7C,
  0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0x00, 0x78, 0x03, 0xE0,
  0x1F, 0x00, 0x30, 0x03, 0xE0, 0x1F, 0x00, 0x30, 0x03, 0xE0, 0x1F, 0x00,
  0x20, 0x03, 0xE0, 0x3F, 0x00, 0x20, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0x07,
  0xE0, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7C, 0x03, 0xFE, 0x00, 0x01, 0xF0, 0x1F, 0xF8, 0x00,
  0x07, 0xC0, 0x7F, 0xE0, 0x00, 0x1F, 0x01, 0xFF, 0x80, 0x00, 0xFC, 0x07,
  0xFE, 0x00, 0x03, 0xF0, 0x1F, 0xFC, 0x00, 0x0F, 0x80, 0x7D, 0xF0, 0x00,
  0x3E, 0x03, 0xF7, 0xC0, 0x00, 0xF8, 0x0F, 0xDF, 0x00, 0x03, 0xE0, 0x3F,
  0x7E, 0x00, 0x1F, 0x80, 0xF8, 0xF8, 0x00, 0x7E, 0x03, 0xE3, 0xE0, 0x01,
  0xF0, 0x0F, 0x8F, 0x80, 0x07, 0xC0, 0x7E, 0x3E, 0x00, 0x1F, 0x01, 0xF8,
  0x7C, 0x00, 0x7C, 0x07, 0xE1, 0xF0, 0x03, 0xF0, 0x1F, 0x07, 0xC0, 0x0F,
  0xC0, 0x7C, 0x1F, 0x00, 0x3E, 0x01, 0xF0, 0x7E, 0x00, 0xF8, 0x0F, 0xC0,
  0xF8, 0x03, 0xE0, 0x3F, 0x03, 0xE0, 0x0F, 0x80, 0xFC, 0x0F, 0x80, 0x7E,
  0x03, 0xE0, 0x3E, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x1F, 0x01, 0xF8, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x1F, 0x03, 0xF0,
  0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x7C, 0x00, 0xF8, 0x3F, 0x01, 0xF0, 0x03,
  0xE0, 0xF8, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x3F, 0x00, 0x3E, 0x0F, 0x80,
  0xFC, 0x00, 0x7C, 0x7E, 0x03, 0xE0, 0x01, 0xF1, 0xF8, 0x0F, 0x80, 0x07,
  0xC7, 0xE0, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0xF8, 0x00, 0x7E, 0x7C, 0x07,
  0xE0, 0x00, 0xF9, 0xF0, 0x1F, 0x80, 0x03, 0xEF, 0xC0, 0x7C, 0x00, 0x0F,
  0xBF, 0x01, 0xF0, 0x00, 0x3E, 0xFC, 0x07, 0xC0, 0x00, 0xFF, 0xE0, 0x1F,
  0x00, 0x01, 0xFF, 0x80, 0xFC, 0x00, 0x07, 0xFE, 0x03, 0xF0, 0x00, 0x1F,
  0xF8, 0x0F, 0x80, 0x00, 0x7F, 0xE0, 0x3E, 0x00, 0x00, 0xFF, 0x80, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0,
  0x1F, 0xC0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0x3E, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x03, 0xF7,
  0xF0, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x01, 0xF8, 0xFC, 0x00,
  0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00, 0x3F, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x7F, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x00, 0x3F, 0xE0, 0x1F,
  0x80, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x7C,
  0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x7F, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x1F, 0x80,
  0x00, 0x3F, 0x80, 0x7C, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFC,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0xFC, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x7E, 0x00, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x00, 0x3F, 0x7F, 0x00, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x00, 0x7F, 0x7E,
  0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x00, 0xFE, 0xFC, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x1F,
  0x8F, 0xC0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x1F, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x7C, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x01, 0xFC,
  0x03, 0xF0, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x03,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x03, 0x00, 0x00, 0x3F,
  0x00, 0x78, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0xC1, 0xF8, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x00, 0x3F, 0xE0,
  0x1F, 0x80, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x0F, 0xC0,
  0x7C, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x7F, 0x03,
  0xE0, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x1F,
  0x80, 0x00, 0x3F, 0x80, 0x7C, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x03, 0xF8, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x00,
  0xF0, 0x0F, 0xC0, 0x00, 0x00, 0xC0, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x08, 0x00,
  0x00, 0x03, 0xF0, 0x38, 0x00, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x00, 0x1F,
  0x83, 0xF8, 0x00, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x07, 0xFC,
  0x00, 0x0F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x00, 0x7E, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x7C,
  0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x07, 0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x01, 0xF8,
  0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x1F,
  0x87, 0xC0, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x00, 0x1F, 0x87, 0xC0, 0x00,
  0x03, 0xF0, 0x7C, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0xFC,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x3E, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x7C, 0x00,
  0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0xF8, 0x1F,
  0x80, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x07, 0xC7, 0xE0, 0x00,
  0x00, 0x7C, 0x7C, 0x00, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x00, 0x7C, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x83, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0x00,
  0xF8, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x1F, 0xC0, 0x1F, 0x01,
  0xF0, 0x07, 0xF0, 0x07, 0xC0, 0x7C, 0x01, 0xFC, 0x01, 0xF0, 0x1F, 0x00,
  0xFF, 0x00, 0xFC, 0x07, 0xC0, 0x3F, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0xF0,
  0x0F, 0x80, 0x7C, 0x07, 0xFC, 0x03, 0xE0, 0x1F, 0x01, 0xEF, 0x01, 0xF8,
  0x07, 0xC0, 0xFB, 0xE0, 0x7C, 0x01, 0xF0, 0x3E, 0xF8, 0x1F, 0x00, 0xF8,
  0x0F, 0x3E, 0x07, 0xC0, 0x3E, 0x07, 0xCF, 0x81, 0xF0, 0x0F, 0x81, 0xE3,
  0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x3E, 0x0F,
  0x80, 0x3E, 0x0F, 0x0F, 0x83, 0xE0, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0x03,
  0xE1, 0xF0, 0xF8, 0x7C, 0x00, 0xF8, 0x78, 0x1E, 0x1F, 0x00, 0x3E, 0x3E,
  0x07, 0x87, 0xC0, 0x0F, 0x0F, 0x01, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x78,
  0xF8, 0x01, 0xF1, 0xF0, 0x1E, 0x3E, 0x00, 0x7C, 0x78, 0x07, 0x8F, 0x80,
  0x1F, 0x3E, 0x01, 0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x79, 0xF0, 0x01, 0xF7,
  0xC0, 0x1E, 0x7C, 0x00, 0x7D, 0xF0, 0x07, 0x9F, 0x00, 0x1F, 0x78, 0x01,
  0xE7, 0x80, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x8F,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x01,
  0xFC, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x1F,
  0x80, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x01,
  0xF8, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0x00, 0x7C, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0xF8,
  0xF8, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03,
  0xF0, 0x3E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x7C, 0x00,
  0x07, 0xE0, 0x0F, 0xC0, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x1F, 0x80, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x0F, 0x81, 0xF8,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x03, 0xE3,
  0xF0, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x00,
  0xFD, 0xE0, 0x00, 0x00, 0x0F, 0x98, 0x00, 0x00, 0x01, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x08, 0x1E, 0x3F, 0x0F,
  0x87, 0xC3, 0xF0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xC1, 0xF0, 0x78, 0x30,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x83, 0xF0, 0x07, 0xFF, 0xF0,
  0xFC, 0x07, 0xFF, 0xFE, 0x3E, 0x03, 0xFF, 0xFF, 0xCF, 0x81, 0xFF, 0x80,
  0xF7, 0xE0, 0x7F, 0x00, 0x0F, 0xF8, 0x3F, 0x80, 0x01, 0xFE, 0x0F, 0xC0,
  0x00, 0x3F, 0x87, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0x3E,
  0x3F, 0x00, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x1F, 0x0F, 0xC0, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x00, 0xFC, 0x3E, 0x00,
  0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xE0, 0xFC,
  0x00, 0x02, 0xF8, 0x3F, 0x00, 0x01, 0xFE, 0x07, 0xE0, 0x00, 0xDF, 0x81,
  0xFC, 0x00, 0xF7, 0xE0, 0x7F, 0xC0, 0xF9, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F,
  0xE1, 0xFF, 0xFE, 0x0F, 0xF8, 0x3F, 0xFF, 0x03, 0xFE, 0x07, 0xFF, 0x80,
  0x3F, 0x80, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x7F, 0x80, 0x03, 0xE0, 0x7F, 0xF8, 0x01, 0xF8, 0x7F, 0xFF, 0x00, 0x7E,
  0x3F, 0xFF, 0xE0, 0x1F, 0x9F, 0xFF, 0xFC, 0x07, 0xCF, 0xC0, 0xFF, 0x01,
  0xF3, 0x80, 0x0F, 0xE0, 0x7D, 0xC0, 0x01, 0xF8, 0x3F, 0x60, 0x00, 0x7E,
  0x0F, 0xF0, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x07, 0xC7, 0xE0, 0x00,
  0x03, 0xF1, 0xF8, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x3F, 0x1F, 0x00,
  0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x07, 0xE3,
  0xE0, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0x3F,
  0x1F, 0x80, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x01,
  0xF8, 0x7F, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xDC, 0x00,
  0x7F, 0x83, 0xF7, 0xC0, 0x7F, 0xC0, 0xFC, 0xFF, 0xFF, 0xF0, 0x3F, 0x3F,
  0xFF, 0xF8, 0x0F, 0x87, 0xFF, 0xF8, 0x03, 0xE0, 0x7F, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80,
  0x7F, 0xC0, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x78, 0x7E, 0x00, 0x00, 0x81, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x21, 0xF8, 0x00, 0x00, 0x71, 0xF0, 0x00, 0x01,
  0xFB, 0xE0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7F,
  0x0F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x00, 0xF8, 0x00, 0x3F,
  0xFE, 0x07, 0xC0, 0x03, 0xFF, 0xFC, 0x3E, 0x00, 0x3F, 0xFF, 0xF3, 0xF0,
  0x07, 0xFF, 0xFF, 0x9F, 0x80, 0x3F, 0xE0, 0x3E, 0xFC, 0x03, 0xF8, 0x00,
  0x77, 0xC0, 0x3F, 0x80, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x3F, 0x00,
  0x00, 0x0F, 0x81, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00,
  0x0F, 0x81, 0xF8, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0x00,
  0x00, 0x7F, 0x01, 0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x6F, 0xC0,
  0x3F, 0x00, 0x07, 0x7C, 0x01, 0xFC, 0x00, 0x73, 0xE0, 0x07, 0xF8, 0x1F,
  0x3F, 0x00, 0x3F, 0xFF, 0xF9, 0xF8, 0x00, 0xFF, 0xFF, 0x8F, 0xC0, 0x03,
  0xFF, 0xF8, 0x7E, 0x00, 0x0F, 0xFF, 0x03, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x1F, 0x3F, 0x00,
  0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0xFE, 0x7E, 0x00, 0x03, 0xFC, 0x7E, 0x00, 0x1F, 0xF8, 0xFC, 0x03,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x10, 0xFC, 0x00,
  0x00, 0x38, 0x7C, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7C, 0x7E, 0x00,
  0x00, 0xFC, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x06, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x38, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xFC, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xF8, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xF3, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x1F, 0x00, 0x1F, 0xFF,
  0xE1, 0xF0, 0x03, 0xFF, 0xFF, 0x3F, 0x00, 0x7F, 0xFF, 0xF3, 0xF0, 0x0F,
  0xF8, 0x0F, 0xBF, 0x01, 0xFC, 0x00, 0x3B, 0xE0, 0x3F, 0x80, 0x01, 0xFE,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x07, 0xC1, 0xF8,
  0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0x0F, 0x83, 0xF0, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x0F, 0x83, 0xF0,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00,
  0x7F, 0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x1F, 0x80, 0x01, 0xFF, 0x01, 0xF8,
  0x00, 0x3B, 0xF0, 0x1F, 0xC0, 0x07, 0xBE, 0x00, 0xFF, 0x01, 0xF3, 0xE0,
  0x0F, 0xFF, 0xFE, 0x3E, 0x00, 0x7F, 0xFF, 0xC7, 0xE0, 0x03, 0xFF, 0xF8,
  0x7E, 0x00, 0x1F, 0xFF, 0x07, 0xE0, 0x00, 0x7F, 0x80, 0x7C, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x01, 0x00, 0x00, 0x3F, 0x00, 0x18, 0x00, 0x07, 0xF0, 0x03, 0xE0,
  0x00, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x03, 0xF0,
  0x7F, 0xF0, 0x03, 0xE0, 0xFF, 0xF8, 0x03, 0xE1, 0xFF, 0xFC, 0x03, 0xE3,
  0xFF, 0xFE, 0x07, 0xE7, 0xC1, 0xFE, 0x07, 0xEF, 0x00, 0x7F, 0x07, 0xEC,
  0x00, 0x3F, 0x07, 0xD8, 0x00, 0x3F, 0x07, 0xD8, 0x00, 0x3F, 0x07, 0xF0,
  0x00, 0x1F, 0x0F, 0xE0, 0x00, 0x1F, 0x0F, 0xE0, 0x00, 0x1F, 0x0F, 0xC0,
  0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3F, 0x0F, 0x80,
  0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x80,
  0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7E, 0x1F, 0x00,
  0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7C, 0x3F, 0x00,
  0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xFC, 0x3E, 0x00,
  0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xF8, 0x7E, 0x00,
  0x00, 0xF8, 0x7C, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF8, 0x7C, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x08, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x7F, 0x00, 0x7C, 0x01, 0xFE, 0x00, 0x7C, 0x03, 0xFC, 0x00, 0x7C,
  0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0xF8,
  0x3F, 0x80, 0x00, 0xF8, 0xFF, 0x00, 0x00, 0xF9, 0xFE, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x04, 0x00, 0x0F, 0x80,
  0x07, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x03, 0xF0,
  0x01, 0xFC, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x7C,
  0x00, 0x0F, 0xF0, 0x3E, 0x00, 0x03, 0xFC, 0x1F, 0x00, 0x00, 0xFE, 0x1F,
  0x80, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x0F, 0xE7, 0xC0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x7F, 0xF8, 0x00,
  0x3E, 0x0F, 0xFF, 0xC0, 0x03, 0xE1, 0xFF, 0xFE, 0x00, 0x3E, 0x3F, 0xFF,
  0xE0, 0x07, 0xE7, 0xC0, 0xFF, 0x00, 0x7E, 0xF0, 0x07, 0xF0, 0x07, 0xEC,
  0x00, 0x3F, 0x00, 0x7D, 0x80, 0x03, 0xF0, 0x07, 0xD8, 0x00, 0x1F, 0x00,
  0x7F, 0x00, 0x01, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x07, 0xF0, 0x01,
  0xF8, 0x01, 0xFE, 0x00, 0x1F, 0x80, 0x7F, 0x80, 0x01, 0xF0, 0x3F, 0xE0,
  0x00, 0x1F, 0x1F, 0xF8, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00, 0x3F, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x08, 0x3F, 0x07, 0xE0, 0x00, 0xC3,
  0xE0, 0x3F, 0x00, 0x1E, 0x3E, 0x03, 0xF0, 0x03, 0xF3, 0xE0, 0x1F, 0x80,
  0xFE, 0x7E, 0x01, 0xF8, 0x1F, 0xC7, 0xE0, 0x0F, 0xC3, 0xF8, 0x7E, 0x00,
  0xFC, 0x7F, 0x07, 0xC0, 0x07, 0xEF, 0xE0, 0x7C, 0x00, 0x7F, 0xFC, 0x07,
  0xC0, 0x03, 0xFF, 0x80, 0xFC, 0x00, 0x3F, 0xF0, 0x0F, 0xC0, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0,
  0x02, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x20, 0x07, 0xC0, 0x01, 0xC0, 0x1F, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0xFF,
  0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x3F, 0x01, 0xFC, 0x00,
  0xF8, 0x0F, 0xE0, 0x03, 0xE0, 0xFF, 0x00, 0x1F, 0x87, 0xF8, 0x00, 0x7E,
  0x3F, 0xC0, 0x01, 0xF9, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC7, 0xF8, 0x1F, 0xF0, 0x0F,
  0x9F, 0xF8, 0x7F, 0xF0, 0x3F, 0x7F, 0xF1, 0xFF, 0xE0, 0x7C, 0xFF, 0xE7,
  0xFF, 0xC0, 0xFB, 0x87, 0xEE, 0x1F, 0xC1, 0xFC, 0x07, 0xF8, 0x1F, 0x83,
  0xF8, 0x0F, 0xE0, 0x3F, 0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x3F,
  0x00, 0x7C, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x03, 0xE0,
  0xF8, 0x01, 0xF0, 0x07, 0xC1, 0xF0, 0x07, 0xE0, 0x0F, 0x83, 0xE0, 0x0F,
  0x80, 0x1F, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x00, 0xFC,
  0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0xF8, 0x03,
  0xF0, 0x07, 0xC1, 0xF0, 0x07, 0xC0, 0x0F, 0x87, 0xE0, 0x0F, 0x80, 0x1F,
  0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x3E, 0x00,
  0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x07,
  0xC3, 0xF0, 0x07, 0xC0, 0x0F, 0x87, 0xC0, 0x0F, 0x80, 0x3E, 0x0F, 0x80,
  0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x01,
  0xF0, 0x7C, 0x01, 0xF0, 0x03, 0xE1, 0xF0, 0x03, 0xE0, 0x07, 0xC3, 0xE0,
  0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3F, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x7F, 0xF0, 0x03, 0xE0,
  0xFF, 0xF8, 0x03, 0xE1, 0xFF, 0xFC, 0x03, 0xE3, 0xFF, 0xFE, 0x07, 0xE7,
  0xC1, 0xFE, 0x07, 0xEF, 0x00, 0x7F, 0x07, 0xEC, 0x00, 0x3F, 0x07, 0xD8,
  0x00, 0x3F, 0x07, 0xD8, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x1F, 0x0F, 0xE0,
  0x00, 0x1F, 0x0F, 0xE0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x1F, 0x0F, 0xC0,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x3F, 0x1F, 0x80,
  0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x00,
  0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x7E, 0x3F, 0x00,
  0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x7C, 0x3E, 0x00,
  0x00, 0x7C, 0x3E, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0xFC, 0x7E, 0x00,
  0x00, 0xFC, 0x7E, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x01, 0xF8, 0xFC, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x07, 0xF0,
  0x1F, 0xC0, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00,
  0x0F, 0x8F, 0xC0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x03, 0xE7, 0xE0,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0xFC,
  0x7C, 0x00, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x07,
  0xE1, 0xF0, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00,
  0x7F, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xE0, 0x7F, 0xF8, 0x00, 0x3F, 0x0F,
  0xFF, 0xE0, 0x01, 0xF8, 0xFF, 0xFF, 0x80, 0x0F, 0xCF, 0xFF, 0xFE, 0x00,
  0x7C, 0xFC, 0x0F, 0xF0, 0x03, 0xE7, 0x00, 0x1F, 0xC0, 0x1F, 0x70, 0x00,
  0x7E, 0x01, 0xFB, 0x00, 0x03, 0xF0, 0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0x7F,
  0x00, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x0F,
  0x80, 0xFC, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x0F, 0xC0,
  0xF8, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00,
  0x1F, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0xF8,
  0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x00, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0xFE, 0x01,
  0xF7, 0x00, 0x0F, 0xE0, 0x1F, 0xBE, 0x03, 0xFE, 0x00, 0xFC, 0xFF, 0xFF,
  0xF0, 0x07, 0xE7, 0xFF, 0xFF, 0x00, 0x3E, 0x1F, 0xFF, 0xE0, 0x01, 0xF0,
  0x3F, 0xFE, 0x00, 0x0F, 0x80, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0x81, 0xF0, 0x07, 0xFF, 0xF8, 0x7C, 0x03, 0xFF, 0xFF,
  0x3F, 0x03, 0xFF, 0xFF, 0xCF, 0xC0, 0xFF, 0x80, 0xFB, 0xF0, 0x7F, 0x00,
  0x0E, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x3F, 0x87, 0xE0,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x7E, 0x3F,
  0x00, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x01, 0xF1,
  0xF8, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00,
  0x3E, 0x3F, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x07, 0xE3, 0xE0, 0x00,
  0x01, 0xF8, 0xF8, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x03, 0xFC, 0x3F,
  0x80, 0x01, 0xBF, 0x07, 0xE0, 0x00, 0xEF, 0x81, 0xFC, 0x00, 0x73, 0xE0,
  0x3F, 0xC0, 0xFC, 0xF8, 0x0F, 0xFF, 0xFE, 0x7E, 0x01, 0xFF, 0xFF, 0x1F,
  0x80, 0x3F, 0xFF, 0x87, 0xE0, 0x07, 0xFF, 0x81, 0xF0, 0x00, 0x7F, 0x80,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xF0, 0x01, 0xF3, 0xE0, 0x00, 0x01, 0xFB,
  0xC0, 0x00, 0x00, 0xFD, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3E,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xC0, 0x1F, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x1C,
  0x03, 0xE0, 0x00, 0x02, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x08, 0x00, 0x00, 0x3F, 0x0F, 0x00, 0x00, 0x0F, 0x87, 0xE0, 0x00,
  0x07, 0xE3, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0xF0, 0x07, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0xC0, 0x1F, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0xFF, 0x81, 0xF8, 0x03, 0xFC, 0x03, 0xF0, 0x1F, 0xF0, 0x07,
  0xC0, 0x7F, 0x80, 0x0F, 0x83, 0xFE, 0x00, 0x1F, 0x0F, 0xF8, 0x00, 0x3F,
  0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x0F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x80,
  0x00, 0x3E, 0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3E, 0x1F, 0x00,
  0x00, 0x7E, 0x1F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00,
  0x00, 0x7C, 0x3F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00,
  0x00, 0xFC, 0x3E, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x7E, 0x00,
  0x00, 0xF8, 0x7E, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x01, 0xF8, 0x7C, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00,
  0x01, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x03, 0xF0, 0xF8, 0x00,
  0x03, 0xF0, 0xF8, 0x00, 0x07, 0xF0, 0xF8, 0x00, 0x0F, 0xF0, 0xFC, 0x00,
  0x0B, 0xE0, 0xFC, 0x00, 0x1B, 0xE0, 0xFC, 0x00, 0x33, 0xE0, 0xFE, 0x00,
  0xF7, 0xE0, 0x7F, 0x83, 0xE7, 0xE0, 0x7F, 0xFF, 0xC7, 0xE0, 0x3F, 0xFF,
  0xC7, 0xC0, 0x1F, 0xFF, 0x87, 0xC0, 0x0F, 0xFE, 0x07, 0xC0, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x7F, 0xFC, 0x00, 0x3F, 0x3F, 0xFE,
  0x00, 0x0F, 0xDF, 0xFF, 0x00, 0x07, 0xEF, 0xFF, 0x80, 0x03, 0xF7, 0xFF,
  0xC0, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x3F, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC,
  0x0F, 0x80, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x03,
  0xF0, 0x0F, 0x80, 0x01, 0xF8, 0x07, 0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x01,
  0xFC, 0x03, 0xF0, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0xFE, 0x00, 0xF8, 0x00,
  0xFE, 0x00, 0x7C, 0x01, 0xFE, 0x00, 0x3E, 0x01, 0xFE, 0x00, 0x3F, 0x03,
  0xFE, 0x00, 0x1F, 0x8F, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x60, 0x7C, 0x00, 0xF8, 0x1F,
  0x03, 0xE0, 0x07, 0x80, 0x7C, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0xF8, 0x03,
  0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x03, 0xC3,
  0xE0, 0x07, 0xC0, 0x1F, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0xF8, 0x03, 0xE0,
  0x07, 0xC7, 0xC0, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0xF8, 0x01, 0xF3, 0xE0,
  0x07, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xE0, 0x03,
  0xE7, 0xC0, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0xF8, 0x01, 0xF1, 0xF0, 0x07,
  0xC0, 0x0F, 0x8F, 0x00, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF0, 0x03, 0xE7,
  0xC0, 0x1F, 0x00, 0x1F, 0x3E, 0x00, 0xF8, 0x01, 0xF9, 0xF0, 0x07, 0xC0,
  0x0F, 0x8F, 0x80, 0x3E, 0x00, 0x7C, 0x78, 0x01, 0xF0, 0x07, 0xE7, 0xC0,
  0x1F, 0x80, 0x3E, 0x3E, 0x00, 0xFC, 0x01, 0xF1, 0xF0, 0x07, 0xE0, 0x1F,
  0x8F, 0x80, 0x7F, 0x01, 0xF8, 0x7C, 0x03, 0xF8, 0x0F, 0xC3, 0xF0, 0x3F,
  0xC0, 0xFC, 0x1F, 0x87, 0x9F, 0x0F, 0xC0, 0xFF, 0xF8, 0xFF, 0xFE, 0x03,
  0xFF, 0xC7, 0xFF, 0xE0, 0x1F, 0xFC, 0x3F, 0xFE, 0x00, 0x7F, 0xC0, 0xFF,
  0xC0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0x01, 0xFE, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x00,
  0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0x7F, 0x9F,
  0x0F, 0x87, 0xE0, 0x3F, 0xC3, 0xE7, 0xC0, 0xF8, 0x3F, 0xC0, 0xF9, 0xE0,
  0x3E, 0x1F, 0xE0, 0x3E, 0xF0, 0x0F, 0xC3, 0xE0, 0x0F, 0xB8, 0x03, 0xF0,
  0xE0, 0x03, 0xEE, 0x00, 0xF8, 0x10, 0x00, 0xFF, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0xC0, 0x0F, 0x80, 0x00, 0x0F, 0xE0, 0x03, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xC0, 0x0F, 0xF0, 0x01, 0x83, 0xF0, 0x07, 0x7C, 0x00, 0xF0, 0xFC, 0x01,
  0xDF, 0x00, 0xFC, 0x3F, 0x00, 0xF7, 0xC0, 0x7F, 0x87, 0xC0, 0x79, 0xF0,
  0x7F, 0x81, 0xF0, 0x3E, 0x7C, 0x3F, 0xC0, 0x7E, 0x1F, 0x0F, 0x9F, 0xE0,
  0x1F, 0xFF, 0xC3, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x3E, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x1F, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x1F,
  0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7C,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x3E, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x07, 0xF0,
  0x0F, 0xC0, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0x1B, 0xE0, 0x0F, 0xE0, 0x03,
  0xBE, 0x00, 0xFE, 0x00, 0x73, 0xE0, 0x07, 0xF8, 0x1E, 0x7E, 0x00, 0x7F,
  0xFF, 0xE7, 0xE0, 0x03, 0xFF, 0xFC, 0x7E, 0x00, 0x1F, 0xFF, 0x87, 0xC0,
  0x00, 0xFF, 0xF0, 0x7C, 0x00, 0x03, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x10, 0x00, 0x03, 0xF0, 0x03, 0x80, 0x00, 0x7F, 0x00, 0x7C, 0x00, 0x1F,
  0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0x81, 0xFF, 0xFF, 0xC3, 0xF0, 0x7F,
  0xFF, 0xFE, 0x7E, 0x1F, 0xC0, 0xFF, 0xEF, 0xC3, 0xE0, 0x03, 0xFF, 0xF0,
  0x7C, 0x00, 0x0F, 0xFC, 0x1F, 0x00, 0x00, 0x7F, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x7C, 0x00, 0x07, 0xF0, 0x0F, 0x80, 0x01, 0xFC, 0x01, 0xF0, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0x00, 0x03, 0xF0,
  0x01, 0xE0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x0F,
  0xC0, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x0F, 0x81, 0xFC, 0x00, 0x01, 0xF0,
  0x7F, 0xE0, 0x00, 0x3E, 0x1F, 0xFF, 0xC0, 0x07, 0xE7, 0xFF, 0xFF, 0xC0,
  0x7C, 0xFD, 0xFF, 0xFF, 0x8F, 0x9F, 0x87, 0xFF, 0xFF, 0xE3, 0xE0, 0x1F,
  0xFF, 0xFC, 0x7C, 0x00, 0x7F, 0xFF, 0x0F, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xC0, 0x07, 0xFC, 0x00, 0x07, 0xC0, 0xFF, 0xF0, 0x00,
  0x3C, 0x0F, 0xFF, 0xC0, 0x03, 0xE0, 0x7F, 0xFE, 0x00, 0x1F, 0x07, 0xE1,
  0xF8, 0x01, 0xF0, 0x7E, 0x07, 0xE0, 0x0F, 0x83, 0xE0, 0x1F, 0x00, 0xF8,
  0x3E, 0x00, 0xFC, 0x0F, 0xC1, 0xF0, 0x03, 0xF0, 0xFC, 0x1F, 0x00, 0x0F,
  0xFF, 0xC0, 0xF8, 0x00, 0x7F, 0xFE, 0x07, 0x80, 0x01, 0xFF, 0xE0, 0x7C,
  0x00, 0x07, 0xFC, 0x00, 0x60, 0x00, 0x0F, 0xC0, 0x00,
};

const GFXglyph IBMPlexMono_Italic70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 42, 0, -1 },
  { 1, 16, 50, 42, 13, -49 },
  { 101, 20, 19, 42, 15, -52 },
  { 149, 42, 49, 42, 1, -49 },
  { 407, 39, 65, 42, 2, -57 },
  { 724, 48, 51, 42, -2, -50 },
  { 1030, 41, 51, 42, 0, -50 },
  { 1292, 8, 19, 42, 21, -52 },
  { 1311, 26, 63, 42, 14, -53 },
  { 1516, 26, 63, 42, 3, -53 },
  { 1721, 35, 35, 42, 4, -38 },
  { 1875, 33, 35, 42, 5, -39 },
  { 2020, 15, 19, 42, 10, -9 },
  { 2056, 21, 5, 42, 11, -24 },
  { 2070, 11, 10, 42, 13, -9 },
  { 2084, 40, 63, 42, 2, -53 },
  { 2399, 36, 51, 42, 4, -50 },
  { 2629, 33, 49, 42, 3, -49 },
  { 2832, 37, 50, 42, 2, -50 },
  { 3064, 37, 51, 42, 2, -50 },
  { 3300, 38, 49, 42, 1, -49 },
  { 3533, 37, 50, 42, 3, -49 },
  { 3765, 33, 50, 42, 4, -49 },
  { 3972, 35, 49, 42, 7, -49 },
  { 4187, 37, 51, 42, 3, -50 },
  { 4423, 33, 50, 42, 6, -50 },
  { 4630, 16, 38, 42, 13, -37 },
  { 4706, 19, 47, 42, 10, -37 },
  { 4818, 34, 40, 42, 6, -41 },
  { 4988, 36, 19, 42, 4, -31 },
  { 5074, 34, 40, 42, 3, -41 },
  { 5244, 30, 51, 42, 9, -50 },
  { 5436, 35, 58, 42, 4, -50 },
  { 5690, 38, 49, 42, -1, -49 },
  { 5923, 36, 49, 42, 3, -49 },
  { 6144, 36, 51, 42, 5, -50 },
  { 6374, 36, 49, 42, 4, -49 },
  { 6595, 38, 49, 42, 3, -49 },
  { 6828, 39, 49, 42, 3, -49 },
  { 7067, 35, 51, 42, 5, -50 },
  { 7291, 38, 49, 42, 3, -49 },
  { 7524, 38, 49, 42, 3, -49 },
  { 7757, 35, 50, 42, 4, -49 },
  { 7976, 42, 49, 42, 3, -49 },
  { 8234, 30, 49, 42, 5, -49 },
  { 8418, 40, 49, 42, 2, -49 },
  { 8663, 38, 49, 42, 3, -49 },
  { 8896, 36, 51, 42, 4, -50 },
  { 9126, 38, 49, 42, 3, -49 },
  { 9359, 36, 63, 42, 4, -50 },
  { 9643, 38, 49, 42, 3, -49 },
  { 9876, 39, 51, 42, 2, -50 },
  { 10125, 39, 49, 42, 6, -49 },
  { 10364, 36, 50, 42, 5, -49 },
  { 10589, 36, 49, 42, 8, -49 },
  { 10810, 42, 49, 42, 3, -49 },
  { 11068, 46, 49, 42, -1, -49 },
  { 11350, 40, 49, 42, 6, -49 },
  { 11595, 43, 49, 42, 0, -49 },
  { 11859, 30, 63, 42, 11, -53 },
  { 12096, 18, 63, 42, 13, -53 },
  { 12238, 30, 63, 42, 1, -53 },
  { 12475, 35, 28, 42, 5, -49 },
  { 12598, 34, 5, 42, 0, 7 },
  { 12620, 9, 14, 42, 16, -55 },
  { 12636, 34, 38, 42, 4, -37 },
  { 12798, 34, 53, 42, 4, -52 },
  { 13024, 31, 38, 42, 5, -37 },
  { 13172, 37, 53, 42, 4, -52 },
  { 13418, 32, 38, 42, 5, -37 },
  { 13570, 46, 67, 42, -1, -52 },
  { 13956, 36, 52, 42, 2, -37 },
  { 14190, 32, 52, 42, 4, -52 },
  { 14398, 32, 53, 42, 6, -52 },
  { 14610, 33, 67, 42, 4, -52 },
  { 14887, 36, 53, 42, 4, -52 },
  { 15126, 30, 53, 42, 7, -52 },
  { 15325, 39, 37, 42, 1, -37 },
  { 15506, 32, 37, 42, 4, -37 },
  { 15654, 34, 38, 42, 4, -37 },
  { 15816, 37, 51, 42, 1, -37 },
  { 16052, 34, 51, 42, 4, -37 },
  { 16269, 33, 36, 42, 8, -36 },
  { 16418, 34, 38, 42, 3, -37 },
  { 16580, 31, 50, 42, 6, -49 },
  { 16774, 32, 37, 42, 6, -36 },
  { 16922, 33, 38, 42, 5, -37 },
  { 17079, 37, 37, 42, 3, -36 },
  { 17251, 42, 38, 42, 0, -37 },
  { 17451, 36, 51, 42, 2, -36 },
  { 17681, 35, 38, 42, 4, -37 },
  { 17848, 32, 63, 42, 8, -53 },
  { 18100, 15, 63, 42, 14, -53 },
  { 18219, 33, 63, 42, 3, -53 },
  { 18479, 37, 15, 42, 3, -29 },
};

const GFXfont IBMPlexMono_Italic70pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic70pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic70pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _IBMPLEXMONO_ITALIC70PT7B_H_
