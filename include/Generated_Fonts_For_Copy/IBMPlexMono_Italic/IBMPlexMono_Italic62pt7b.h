#ifndef _IBMPLEXMONO_ITALIC62PT7B_H_
#define _IBMPLEXMONO_ITALIC62PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic62pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0,
  0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30,
  0x01, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x01, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF,
  0x83, 0xFE, 0x0F, 0xF0, 0x1F, 0x80, 0x1F, 0x03, 0xC7, 0x81, 0xF1, 0xE0,
  0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xE3, 0xC0, 0x78, 0xF0, 0x3E,
  0x3C, 0x0F, 0x9F, 0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x3C, 0x78, 0x0F, 0x1E,
  0x07, 0xC7, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x1F, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x00, 0x7C, 0x0F,
  0x80, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x0F, 0x00,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x03, 0xFF, 0xE0,
  0x3F, 0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xF0, 0x1F, 0xFF, 0x0F,
  0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x0F,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x07, 0x80, 0xF8, 0x00,
  0x00, 0x3C, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x3F, 0xFE, 0x03,
  0xFF, 0xE1, 0xFF, 0xF0, 0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x7F,
  0xF8, 0x0F, 0xFF, 0xC0, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0x3E, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x1E,
  0x00, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x78, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xCF, 0x3F, 0xE0, 0x1F, 0xC1, 0xE1,
  0xFC, 0x03, 0xF0, 0x3C, 0x0F, 0xC0, 0xFC, 0x07, 0x80, 0xF0, 0x1F, 0x00,
  0xE0, 0x0C, 0x03, 0xE0, 0x1C, 0x01, 0x00, 0xFC, 0x07, 0x80, 0x00, 0x1F,
  0x80, 0xF0, 0x00, 0x03, 0xF0, 0x1E, 0x00, 0x00, 0x7E, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x70, 0x00, 0x00, 0xFC, 0x0E, 0x00, 0x00, 0x1F, 0xC3, 0xC0,
  0x00, 0x01, 0xFE, 0x78, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0x9F, 0xF0,
  0x00, 0x00, 0xF0, 0xFE, 0x00, 0x00, 0x1C, 0x0F, 0xE0, 0x00, 0x03, 0x80,
  0xFC, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0x3E, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x0E, 0x00, 0xF8, 0x18,
  0x03, 0xC0, 0x3F, 0x07, 0x80, 0x78, 0x07, 0xC1, 0xF8, 0x0F, 0x01, 0xF8,
  0x7F, 0x81, 0xE0, 0x7E, 0x03, 0xF8, 0x3C, 0x1F, 0xC0, 0x7F, 0xE7, 0x1F,
  0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xF0, 0x07, 0xFF, 0xC0, 0x00, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x7C, 0x01,
  0xF8, 0x3E, 0x00, 0x1E, 0x00, 0x7C, 0x07, 0x80, 0x0F, 0x80, 0x3E, 0x01,
  0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00,
  0xF0, 0x01, 0xF0, 0x03, 0xC0, 0x7C, 0x00, 0x78, 0x01, 0xF0, 0x1E, 0x00,
  0x1E, 0x00, 0x7C, 0x0F, 0x00, 0x07, 0x80, 0x1E, 0x07, 0xC0, 0x01, 0xE0,
  0x07, 0x83, 0xE0, 0x00, 0x78, 0x03, 0xE0, 0xF0, 0x00, 0x1E, 0x00, 0xF0,
  0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x0F, 0x00,
  0x00, 0x3F, 0xFF, 0x87, 0xC0, 0x00, 0x07, 0xFF, 0x83, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xE0, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x7F, 0xFE, 0x00,
  0x00, 0x78, 0x3F, 0x0F, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0xF0, 0x00, 0x0F,
  0x07, 0x80, 0x3C, 0x00, 0x07, 0x83, 0xE0, 0x0F, 0x00, 0x03, 0xE0, 0xF0,
  0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x3C,
  0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x00, 0x1F, 0x01, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x03,
  0xC0, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x00, 0x3E, 0x0F,
  0xC0, 0x1F, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0x80, 0x01, 0xFF, 0xF0, 0x03,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x03, 0xF0,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x1F, 0xFB,
  0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x06, 0xF8, 0x00, 0x3F, 0x00,
  0xFF, 0x80, 0x03, 0xF0, 0x1F, 0xFC, 0x00, 0x3F, 0x81, 0xEF, 0xC0, 0x06,
  0xF8, 0x3E, 0x7C, 0x00, 0xE7, 0xC3, 0xC7, 0xE0, 0x0E, 0x7C, 0x7C, 0x3F,
  0x03, 0xC3, 0xEF, 0x83, 0xFF, 0xFC, 0x3F, 0xF8, 0x1F, 0xFF, 0x81, 0xFF,
  0x00, 0x7F, 0xF0, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x1F, 0x1F,
  0x1E, 0x1E, 0x1E, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C, 0x7C, 0x7C, 0x7C,
  0x78, 0x78, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x20, 0x01, 0xE0, 0x02, 0x3C, 0x01, 0xE0, 0x0E, 0x7F, 0x83, 0xE0,
  0x7F, 0x7F, 0xE3, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7E, 0xF8,
  0x00, 0x00, 0xFC, 0xF8, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x0F, 0xC0, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x0F, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x1F, 0xE0, 0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xE0,
  0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80,
  0x3E, 0x00, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x3E, 0x07, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x00,
  0xF8, 0xFC, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x07,
  0xCF, 0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x3E,
  0xFC, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0xFB, 0xE0, 0x1F, 0x01, 0xF7,
  0xC0, 0xFE, 0x03, 0xEF, 0x81, 0xFE, 0x07, 0xFF, 0x03, 0xF8, 0x1F, 0xFE,
  0x07, 0xF0, 0x3F, 0xF8, 0x0F, 0xE0, 0x7D, 0xF0, 0x0F, 0x80, 0xFB, 0xE0,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x0F, 0xDF, 0x00,
  0x00, 0x1F, 0x3E, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0xFC, 0xF8, 0x00,
  0x01, 0xF1, 0xF0, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x3F, 0x07, 0xC0, 0x00, 0xFC, 0x0F, 0x80, 0x03, 0xF8, 0x1F, 0x80, 0x0F,
  0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFD, 0xF0, 0x00, 0x3F, 0x9F, 0x00, 0x03,
  0xF8, 0xF8, 0x00, 0x3F, 0x87, 0xC0, 0x03, 0xF8, 0x3E, 0x00, 0x7F, 0x81,
  0xF0, 0x07, 0xF8, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x00, 0xF0, 0x07, 0xC0,
  0x03, 0x00, 0x3E, 0x00, 0x10, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0x01,
  0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x01, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x07, 0xF8, 0x03, 0xF8,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x30,
  0x00, 0x07, 0xC0, 0x08, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x02, 0x00, 0x00, 0x3F, 0x03, 0x00, 0x00,
  0x1F, 0x87, 0xC0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x1F, 0xC0, 0x7F, 0x80, 0x7F, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x1F, 0x1F,
  0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x0F, 0x80,
  0x1F, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x01, 0xF0, 0x03, 0xC0,
  0x00, 0xF8, 0x03, 0xC0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC1, 0xFC, 0x00, 0x07, 0x8F, 0xFF,
  0x80, 0x07, 0x9F, 0xFF, 0xC0, 0x07, 0xBF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0x80, 0x01,
  0xF8, 0x03, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x10, 0x00, 0x01, 0xF8, 0x38, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03,
  0xF0, 0xFE, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F,
  0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x83, 0xFC, 0x00, 0xFC,
  0x7F, 0xF8, 0x07, 0xC7, 0xFF, 0xF0, 0x7E, 0xFF, 0xFF, 0xC3, 0xEF, 0xFF,
  0xFE, 0x1F, 0x78, 0x07, 0xF9, 0xF7, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x3F,
  0x7E, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F,
  0xBE, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0xFE, 0x3F,
  0x00, 0x0F, 0xE1, 0xFE, 0x01, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0x80, 0x00, 0x0F,
  0x9F, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x07, 0xE1, 0xE0, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x3E, 0x07,
  0x80, 0x00, 0x7C, 0x10, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFE, 0x01, 0xFF,
  0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0xF8, 0x03, 0xF8, 0x07, 0xF0,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x0F, 0xF0,
  0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xFC,
  0x7C, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x7C,
  0xF8, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x7C,
  0xF8, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x0F, 0xF0,
  0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFE,
  0x00, 0x3F, 0x87, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xF8, 0xF8, 0x00,
  0x03, 0xE7, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00,
  0x7D, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0x9F,
  0x00, 0x00, 0xFE, 0x7E, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x3F, 0xC3, 0xFC,
  0x07, 0xDF, 0x0F, 0xFF, 0xFE, 0xFC, 0x1F, 0xFF, 0xF3, 0xE0, 0x3F, 0xFF,
  0x9F, 0x80, 0x7F, 0xFC, 0x7C, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x3F,
  0xC1, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xC0, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x1F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F,
  0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F,
  0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x40, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0x02, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x87, 0xF8, 0x1F, 0xE3, 0xF8, 0x01, 0xFD, 0xF8, 0x00,
  0x3F, 0x7E, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7C, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xE0, 0x3F, 0x80, 0x3E, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1E, 0x07, 0xC0, 0x00,
  0x3C, 0x1F, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x01,
  0xF1, 0xF0, 0x07, 0xC3, 0xE3, 0xC0, 0x3F, 0xE7, 0xCF, 0x80, 0xFF, 0xEF,
  0x9F, 0x03, 0xFF, 0xDE, 0x3C, 0x0F, 0xE1, 0xBC, 0x78, 0x1F, 0x00, 0xF9,
  0xF0, 0x7C, 0x01, 0xF3, 0xE0, 0xF8, 0x03, 0xE7, 0xC1, 0xE0, 0x07, 0xCF,
  0x87, 0xC0, 0x0F, 0x1E, 0x0F, 0x80, 0x1E, 0x3C, 0x1F, 0x00, 0x3C, 0xF8,
  0x3E, 0x00, 0x79, 0xF0, 0xF8, 0x01, 0xF3, 0xE1, 0xF0, 0x03, 0xE7, 0xC3,
  0xE0, 0x07, 0x8F, 0x07, 0xC0, 0x0F, 0x1E, 0x0F, 0x80, 0x3E, 0x3C, 0x1F,
  0x00, 0x7C, 0x78, 0x3E, 0x01, 0xF8, 0xF0, 0x3C, 0x03, 0xF1, 0xE0, 0x7C,
  0x0F, 0xE3, 0xC0, 0xFC, 0x77, 0x87, 0x81, 0xFF, 0xEF, 0x0F, 0x01, 0xFF,
  0x9E, 0x1E, 0x01, 0xFE, 0x7C, 0x3C, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00,
  0x3E, 0x3E, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x01, 0xF0, 0x78, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x0F, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x01, 0xE0, 0x1F,
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x7C,
  0x07, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x01,
  0xF8, 0x3E, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x0F, 0x87, 0xE0, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0x3E, 0x3E, 0x00,
  0x00, 0x0F, 0x9F, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7C, 0x00, 0x1F, 0xC0, 0xF8,
  0x00, 0x1F, 0x81, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x0F, 0xC0,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x7E, 0x0F, 0x80, 0x01, 0xF8, 0x1F, 0x00, 0x0F, 0xE0, 0x3F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC,
  0x07, 0xC0, 0x01, 0xFC, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x3F, 0x1F,
  0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x01, 0xF1, 0xF0,
  0x00, 0x07, 0xE3, 0xE0, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x7F, 0x0F, 0x80,
  0x03, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x00,
  0x7C, 0x3E, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x01, 0x81, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x80, 0xF8, 0x00, 0x01, 0xC1, 0xF0, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x0F, 0x87, 0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0xC0, 0x01,
  0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0x80, 0x1F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xF8, 0x01, 0xF0, 0x07, 0xFC, 0x01, 0xF0, 0x01, 0xFC, 0x03, 0xF0, 0x00,
  0x7E, 0x03, 0xE0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x3F, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x07, 0xE0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00,
  0x3F, 0x0F, 0x80, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x3F, 0x0F, 0x80, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0x7E, 0x1F, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00,
  0x7C, 0x1F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x01,
  0xF8, 0x3E, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x07,
  0xF0, 0x3E, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x1F, 0xC0, 0x7C, 0x00, 0x7F,
  0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F,
  0xE0, 0x7F, 0x80, 0x7F, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3E, 0x07, 0xE0,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x00, 0x81, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x7F, 0xFE, 0x7E, 0x00, 0xFF, 0xFC,
  0xFC, 0x01, 0xFF, 0xF9, 0xF8, 0x03, 0xFF, 0xF3, 0xF0, 0x07, 0xFF, 0xE7,
  0xC0, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x3E, 0x3E,
  0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x01, 0xF1, 0xF0,
  0x00, 0x03, 0xC3, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xFC, 0x0F, 0x80, 0x07, 0xF8, 0x1F, 0x80,
  0x1D, 0xF0, 0x1F, 0xC0, 0xF3, 0xC0, 0x3F, 0xFF, 0xCF, 0x80, 0x3F, 0xFF,
  0x1F, 0x00, 0x3F, 0xFC, 0x3E, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x3E, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x7C, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x7E, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00,
  0x3F, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x7C, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x7C,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00,
  0x3E, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x08, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xE0,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF8,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x3F, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x0F, 0x83, 0xF0,
  0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x03, 0xE3, 0xF8, 0x00, 0x00, 0x1F,
  0x3F, 0xC0, 0x00, 0x01, 0xFB, 0xFF, 0x00, 0x00, 0x0F, 0xBF, 0xF8, 0x00,
  0x00, 0x7F, 0xF7, 0xC0, 0x00, 0x03, 0xFF, 0x1F, 0x00, 0x00, 0x1F, 0xF0,
  0xF8, 0x00, 0x00, 0xFF, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x1F, 0x00, 0x00,
  0x7F, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xE0,
  0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x03,
  0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x07, 0xFC, 0x07, 0xDE,
  0x00, 0xFF, 0xC0, 0x7D, 0xE0, 0x0F, 0x7C, 0x07, 0xDF, 0x01, 0xF7, 0xC0,
  0x7C, 0xF0, 0x3E, 0x7C, 0x07, 0x8F, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x7C,
  0x78, 0x0F, 0x8F, 0x87, 0x8F, 0x80, 0xF8, 0x78, 0xF8, 0xF8, 0x0F, 0x87,
  0x8F, 0x0F, 0x80, 0xF8, 0x79, 0xE0, 0xF8, 0x0F, 0x07, 0xFE, 0x0F, 0x00,
  0xF0, 0x3F, 0xC0, 0xF0, 0x1F, 0x03, 0xFC, 0x1F, 0x01, 0xF0, 0x3F, 0x81,
  0xF0, 0x1F, 0x03, 0xF8, 0x1F, 0x01, 0xF0, 0x3F, 0x01, 0xF0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x01, 0xC0, 0x3E, 0x03,
  0xE0, 0x1C, 0x03, 0xE0, 0x3E, 0x00, 0x80, 0x3E, 0x03, 0xE0, 0x10, 0x03,
  0xE0, 0x3C, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x7C, 0x00,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x07,
  0x80, 0xF8, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x00, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0xE0, 0x3F, 0xC0, 0x00, 0x78, 0x07, 0xFC, 0x00,
  0x0F, 0x00, 0xFF, 0x80, 0x03, 0xE0, 0x1F, 0xF0, 0x00, 0x7C, 0x03, 0xFE,
  0x00, 0x0F, 0x80, 0x7B, 0xC0, 0x01, 0xF0, 0x1F, 0x7C, 0x00, 0x3C, 0x03,
  0xEF, 0x80, 0x07, 0x80, 0x7C, 0xF0, 0x01, 0xF0, 0x0F, 0x9E, 0x00, 0x3E,
  0x01, 0xE3, 0xE0, 0x07, 0xC0, 0x3C, 0x7C, 0x00, 0xF8, 0x0F, 0x87, 0x80,
  0x1E, 0x01, 0xF0, 0xF0, 0x03, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x07, 0xC3,
  0xE0, 0x1F, 0x00, 0xF0, 0x7C, 0x03, 0xE0, 0x1E, 0x07, 0x80, 0x7C, 0x07,
  0xC0, 0xF0, 0x0F, 0x00, 0xF8, 0x1F, 0x01, 0xE0, 0x1F, 0x03, 0xE0, 0x7C,
  0x03, 0xE0, 0x3C, 0x0F, 0x80, 0x78, 0x07, 0x81, 0xF0, 0x0F, 0x00, 0xF8,
  0x3E, 0x03, 0xE0, 0x1F, 0x07, 0x80, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x80,
  0x3C, 0x3E, 0x01, 0xF0, 0x07, 0x87, 0xC0, 0x3C, 0x00, 0xF8, 0xF8, 0x07,
  0x80, 0x1F, 0x1F, 0x01, 0xF0, 0x01, 0xE3, 0xC0, 0x3E, 0x00, 0x3C, 0xF8,
  0x07, 0xC0, 0x07, 0xDF, 0x00, 0xF8, 0x00, 0xFB, 0xE0, 0x1E, 0x00, 0x1F,
  0x7C, 0x07, 0xC0, 0x01, 0xEF, 0x80, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0x00,
  0x07, 0xFC, 0x03, 0xE0, 0x00, 0xFF, 0x80, 0x7C, 0x00, 0x0F, 0xF0, 0x0F,
  0x00, 0x01, 0xFE, 0x03, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7C,
  0x3E, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x1F, 0x3E,
  0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00, 0xFB, 0xE0,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7D, 0xF0, 0x00,
  0x00, 0xFB, 0xE0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07, 0xEF, 0x80, 0x00,
  0x0F, 0xDF, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00,
  0xFC, 0xF8, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x0F,
  0x87, 0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF8,
  0x1F, 0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0x3F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x1F, 0x00, 0x03, 0xF8, 0x0F, 0x80, 0x00, 0x7E, 0x07, 0xC0, 0x00,
  0x3F, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0xC1, 0xF8, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x3E, 0x00,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x3F, 0x0F, 0x80,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x1F, 0x81, 0xF0,
  0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xC0,
  0x7F, 0x00, 0xFE, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3E, 0x07, 0xE0, 0x00,
  0x7E, 0x1F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x01,
  0xF1, 0xF0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x0F,
  0x9F, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x7D,
  0xF8, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x07, 0xEF, 0x80, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x1F, 0x3E, 0x00,
  0x00, 0x3E, 0x7C, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x01, 0xF1, 0xF0, 0x00,
  0x07, 0xE3, 0xE0, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00,
  0xFC, 0x0F, 0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F,
  0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x04,
  0x00, 0x07, 0xE0, 0x0C, 0x00, 0x07, 0xE0, 0x3C, 0x00, 0x07, 0xC0, 0xFC,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x1F, 0x00, 0x03, 0xF8, 0x0F, 0x80, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x3F,
  0x03, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00,
  0x7C, 0x1F, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x3F, 0x0F, 0x80, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x1F, 0x81, 0xF0, 0x00,
  0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0x80,
  0xFC, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x03, 0xE0,
  0x07, 0xC0, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x1F,
  0x00, 0x07, 0xC0, 0x0F, 0x80, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0xF8, 0x03,
  0xE0, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xC0, 0x3F, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x00, 0xC0, 0x7C, 0x00, 0x00, 0x40,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x83, 0x00, 0x00, 0x07, 0xE1, 0xE0, 0x00, 0x01, 0xF0, 0xFC, 0x00,
  0x00, 0xFC, 0x3F, 0x80, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x7F, 0x81, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x80,
  0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x3F, 0x00,
  0x00, 0xFC, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x7E, 0x00,
  0x01, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x03, 0xF0, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xE0, 0xF8, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x0F, 0xC0, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x80, 0xF8, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x01, 0xFF, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7E, 0xF8, 0x00,
  0x00, 0x7C, 0xF8, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x03, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xE0, 0x3C, 0x00,
  0x07, 0xC0, 0x3C, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0x3E, 0x00,
  0x0F, 0x80, 0x3E, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x1F, 0x01,
  0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x03,
  0xE0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x0F, 0x9F,
  0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x07, 0xBE,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x00, 0x7C,
  0x3E, 0x00, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00,
  0x00, 0xF0, 0x7C, 0x00, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x00, 0x7C, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x01,
  0xF0, 0x3C, 0x03, 0xF0, 0x0F, 0x81, 0xE0, 0x1F, 0x80, 0x78, 0x1F, 0x01,
  0xFC, 0x03, 0xC0, 0xF8, 0x0F, 0xE0, 0x3E, 0x07, 0xC0, 0xFF, 0x01, 0xF0,
  0x3E, 0x07, 0xF8, 0x0F, 0x01, 0xF0, 0x3F, 0xC0, 0x78, 0x0F, 0x03, 0xCE,
  0x07, 0xC0, 0x78, 0x1E, 0x70, 0x3E, 0x03, 0xC0, 0xF3, 0x81, 0xE0, 0x1E,
  0x0F, 0x1E, 0x0F, 0x00, 0xF0, 0x78, 0xF0, 0xF8, 0x07, 0x87, 0xC7, 0x87,
  0xC0, 0x7C, 0x3C, 0x3C, 0x3C, 0x03, 0xE1, 0xE1, 0xE1, 0xE0, 0x1F, 0x1E,
  0x0F, 0x1F, 0x00, 0xF8, 0xF0, 0x78, 0xF8, 0x07, 0x87, 0x83, 0xC7, 0x80,
  0x3C, 0x78, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0xF1, 0xE0, 0x0F, 0x3E, 0x07,
  0x9F, 0x00, 0x79, 0xE0, 0x3C, 0xF0, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0x1E,
  0xF8, 0x0F, 0x3C, 0x00, 0xF7, 0x80, 0x7B, 0xE0, 0x0F, 0xBC, 0x03, 0xDF,
  0x00, 0x7F, 0xC0, 0x1E, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x3E,
  0x00, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0x87, 0xE0, 0x00, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x00, 0x03,
  0xF3, 0xE0, 0x00, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x3F,
  0x00, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xF9, 0xF0, 0x00, 0x00, 0x7E, 0x3E,
  0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x03,
  0xF0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x07, 0xE0, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x00,
  0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x00, 0x3E, 0x1F, 0x80, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x00, 0x7D, 0xF8,
  0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xF9, 0xE0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x00, 0x07,
  0xC0, 0x1F, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0x7C, 0x03, 0xF0, 0x00, 0x78, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x03, 0xCF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00,
  0x0F, 0x10, 0x00, 0x00, 0x18, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x18, 0x78, 0xFC, 0x7C, 0x7C, 0x3C, 0x3E, 0x1E, 0x1E, 0x0F, 0x0F, 0x04,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0xE1, 0xF0, 0x0F, 0xFF, 0xC7, 0xC0,
  0x7F, 0xFF, 0x9F, 0x03, 0xF8, 0x0F, 0x7C, 0x1F, 0x80, 0x0D, 0xF0, 0xFC,
  0x00, 0x1F, 0xC3, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xF8, 0x7C, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x00,
  0xF9, 0xF8, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7C,
  0x7C, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x1F, 0x1F,
  0x00, 0x00, 0xF8, 0xF8, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F, 0x8F, 0x80,
  0x00, 0x3E, 0x1E, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x07, 0xE1, 0xF0, 0x00,
  0x3F, 0x07, 0xC0, 0x01, 0xFC, 0x1F, 0x80, 0x0D, 0xF0, 0x3F, 0x00, 0x77,
  0xC0, 0xFE, 0x07, 0x9F, 0xF1, 0xFF, 0xFC, 0x7F, 0xC3, 0xFF, 0xE0, 0xFF,
  0x07, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x0F, 0xE0, 0x00, 0xF0, 0x7F, 0xF0, 0x03, 0xE1, 0xFF, 0xF8, 0x07, 0xC7,
  0xFF, 0xF0, 0x0F, 0x9E, 0x07, 0xF0, 0x1F, 0x70, 0x03, 0xF0, 0x3F, 0xC0,
  0x07, 0xE0, 0x7B, 0x00, 0x07, 0xC1, 0xFC, 0x00, 0x0F, 0x83, 0xF0, 0x00,
  0x0F, 0x87, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0x7C, 0x3C, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07,
  0xE3, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3E,
  0x1E, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x03, 0xF1,
  0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x7C, 0x3F, 0x00, 0x01, 0xF0, 0x7F, 0x00, 0x07, 0xE0, 0xFF,
  0x00, 0x1F, 0x81, 0xF7, 0x80, 0xFE, 0x03, 0xE7, 0xFF, 0xF8, 0x07, 0x8F,
  0xFF, 0xE0, 0x1F, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xC0, 0x7F, 0x01, 0xFC, 0x1F, 0x80, 0x0F, 0xC3, 0xE0, 0x00, 0xF8, 0xF8,
  0x00, 0x1F, 0x3F, 0x00, 0x01, 0x87, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x47, 0xC0, 0x00, 0x1C, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xF9, 0xF0, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x83, 0xE0, 0x07,
  0xE0, 0x7F, 0x03, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x7F, 0x01, 0xF0, 0x01, 0xFF, 0xE0, 0xF8, 0x01, 0xFF, 0xFC, 0x7C,
  0x01, 0xFF, 0xFF, 0x3E, 0x01, 0xFE, 0x07, 0xBE, 0x01, 0xF8, 0x00, 0xFF,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07,
  0xE0, 0x7C, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00,
  0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0x80,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0xF8,
  0x00, 0x3F, 0xC0, 0x7E, 0x00, 0x3B, 0xE0, 0x1F, 0x80, 0x39, 0xE0, 0x0F,
  0xE0, 0x7D, 0xF0, 0x03, 0xFF, 0xFC, 0xF8, 0x00, 0xFF, 0xFC, 0x7C, 0x00,
  0x3F, 0xF8, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xF8,
  0x0F, 0xE0, 0x7E, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xF1, 0xF0, 0x00, 0x1F,
  0x3E, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x3F, 0x7C, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xFE, 0xF8, 0x00, 0x7F,
  0xCF, 0x80, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x10, 0xF8, 0x00, 0x03, 0xCF,
  0x80, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0x7E, 0x00,
  0x3F, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0x80, 0x0F,
  0x80, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x00,
  0x00, 0x7E, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x78, 0x00, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x3E,
  0x00, 0x00, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xCF, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x1F, 0x00, 0x7F, 0xFF, 0x1F, 0x00, 0xFF,
  0xFF, 0x9F, 0x01, 0xFE, 0x07, 0xBE, 0x03, 0xF0, 0x01, 0xFE, 0x07, 0xE0,
  0x00, 0xFE, 0x07, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0x80,
  0x00, 0x7E, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00,
  0x00, 0x7C, 0x3F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00,
  0x00, 0x7C, 0x3E, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00,
  0x01, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xF0, 0x3E, 0x00,
  0x07, 0xF0, 0x3E, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x0D, 0xF0, 0x1F, 0x80,
  0x39, 0xE0, 0x1F, 0xC0, 0xF9, 0xE0, 0x0F, 0xFF, 0xF3, 0xE0, 0x07, 0xFF,
  0xE3, 0xE0, 0x03, 0xFF, 0x83, 0xE0, 0x00, 0xFE, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x30, 0x00,
  0x1F, 0x00, 0x78, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x0F, 0xE0, 0x07, 0xC3, 0xFF, 0x80, 0x7C, 0x7F, 0xFC, 0x07, 0xCF,
  0xFF, 0xE0, 0xF9, 0xFF, 0xFE, 0x0F, 0x9E, 0x0F, 0xF0, 0xFB, 0x80, 0x3F,
  0x0F, 0xB0, 0x03, 0xF0, 0xFE, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF1, 0xFC,
  0x00, 0x1F, 0x1F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x01,
  0xF1, 0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x1E, 0x3E,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x3E, 0x3C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3C, 0x7C, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7C, 0x78, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8,
  0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x40, 0x07, 0xC0, 0x0E, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x80,
  0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x3F, 0x00,
  0x0F, 0x07, 0xE0, 0x01, 0xF0, 0xFC, 0x00, 0x1F, 0x1F, 0x80, 0x01, 0xF3,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x18,
  0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7E, 0x01,
  0xF0, 0x01, 0xF8, 0x0F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0xFC, 0x3E, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x0F, 0xCF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x1F, 0xC0, 0x01, 0xF0, 0xFF, 0xE0,
  0x03, 0xE3, 0xFF, 0xE0, 0x07, 0x8F, 0xFF, 0xE0, 0x1F, 0x3C, 0x0F, 0xE0,
  0x3E, 0xE0, 0x0F, 0xC0, 0x7D, 0x80, 0x0F, 0x80, 0xFE, 0x00, 0x1F, 0x01,
  0xF8, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0xF8, 0x1F,
  0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x7E, 0x01, 0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80,
  0x7E, 0x00, 0x1F, 0x07, 0xF0, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x7C, 0x7E,
  0x00, 0x00, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x47, 0xC0, 0xF8,
  0x01, 0xCF, 0x81, 0xF0, 0x07, 0xDF, 0x01, 0xF0, 0x1F, 0xBE, 0x03, 0xE0,
  0x7E, 0x78, 0x03, 0xE1, 0xF9, 0xF0, 0x07, 0xC7, 0xE3, 0xE0, 0x0F, 0x9F,
  0x87, 0xC0, 0x0F, 0xFE, 0x0F, 0x80, 0x1F, 0xF8, 0x1F, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x02, 0x01, 0xF0, 0x01, 0xC0, 0x7C, 0x00, 0xFC, 0x1F,
  0x00, 0x7E, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x3F, 0x00, 0xF8, 0x1F, 0x80,
  0x3E, 0x0F, 0xC0, 0x0F, 0x87, 0xE0, 0x03, 0xE3, 0xF0, 0x00, 0xF9, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x01, 0xF3, 0xF8, 0x1F, 0xE0, 0x79,
  0xFF, 0x0F, 0xF8, 0x1E, 0xFF, 0xC7, 0xFF, 0x0F, 0xB0, 0xFB, 0x87, 0xC3,
  0xF8, 0x3E, 0xC1, 0xF0, 0xFC, 0x07, 0xE0, 0x3C, 0x3E, 0x01, 0xF0, 0x0F,
  0x0F, 0x80, 0x7C, 0x03, 0xC3, 0xC0, 0x1E, 0x01, 0xF1, 0xF0, 0x0F, 0x80,
  0x7C, 0x7C, 0x03, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0x07, 0x87, 0x80, 0x3C,
  0x01, 0xE1, 0xE0, 0x0F, 0x00, 0x78, 0x78, 0x03, 0xC0, 0x3E, 0x3E, 0x01,
  0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x00, 0xF0, 0xF0,
  0x07, 0x80, 0x3C, 0x3C, 0x01, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x07, 0xC7,
  0xC0, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x80, 0x7C, 0x7C, 0x03, 0xE0, 0x1E,
  0x1E, 0x00, 0xF0, 0x07, 0x87, 0x80, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x00,
  0xF8, 0xF8, 0x07, 0xC0, 0x3E, 0x3E, 0x01, 0xF0, 0x0F, 0x8F, 0x80, 0x7C,
  0x03, 0xC3, 0xC0, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x7C, 0x3F, 0xF8, 0x07, 0xC7, 0xFF, 0xC0, 0x78, 0xFF,
  0xFE, 0x0F, 0x9E, 0x0F, 0xE0, 0xF9, 0x80, 0x3F, 0x0F, 0xB0, 0x03, 0xF0,
  0xFA, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x1F, 0x1F, 0x80,
  0x01, 0xF1, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x1F,
  0x1F, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x1E, 0x3E, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x3E, 0x3E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x03,
  0xE3, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7C, 0x7C,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xC7, 0x80, 0x00,
  0x7C, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0x80,
  0xFE, 0x03, 0xF0, 0x01, 0xF0, 0x3F, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x3E,
  0x1F, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3E, 0xFC,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7D, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0x7C,
  0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x7C, 0xF8, 0x00,
  0x03, 0xE3, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x1F,
  0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x80, 0x7F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x78, 0x3F, 0xF8, 0x00, 0x7C, 0x3F, 0xFF, 0x00,
  0x3E, 0x3F, 0xFF, 0x80, 0x1F, 0x3C, 0x0F, 0xE0, 0x0F, 0xB8, 0x01, 0xF8,
  0x07, 0xF8, 0x00, 0xFC, 0x03, 0xD8, 0x00, 0x3E, 0x03, 0xF8, 0x00, 0x1F,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00,
  0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x3E, 0x07, 0xE0,
  0x00, 0x3E, 0x03, 0xF8, 0x00, 0x3F, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0xFB,
  0xC0, 0x7F, 0x00, 0x7C, 0xFF, 0xFF, 0x00, 0x7C, 0x7F, 0xFF, 0x00, 0x3E,
  0x0F, 0xFF, 0x00, 0x1F, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xF0,
  0x7C, 0x03, 0xFF, 0xF8, 0xF8, 0x0F, 0xFF, 0xF9, 0xF0, 0x3F, 0xC0, 0xF7,
  0xC0, 0xFC, 0x00, 0x7F, 0x83, 0xF0, 0x00, 0x7F, 0x07, 0xC0, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0xFC, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x1F, 0x1F,
  0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x8F, 0x80,
  0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF8, 0x3C, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x1F, 0xC1, 0xF0, 0x00,
  0x6F, 0x83, 0xF0, 0x01, 0xDE, 0x03, 0xF0, 0x07, 0x3C, 0x07, 0xF0, 0x3C,
  0xF8, 0x07, 0xFF, 0xF9, 0xF0, 0x07, 0xFF, 0xE3, 0xE0, 0x07, 0xFF, 0x07,
  0xC0, 0x03, 0xF8, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xEF, 0xFF, 0xC7, 0xFF, 0xBF,
  0xFF, 0x3F, 0xFE, 0x00, 0x7D, 0xFF, 0xF8, 0x03, 0xE7, 0x80, 0x00, 0x0F,
  0xB8, 0x00, 0x00, 0x3E, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0x80, 0x03, 0xE0, 0x7C,
  0x00, 0x07, 0x01, 0xF0, 0x00, 0x08, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x40, 0x00,
  0x07, 0xC3, 0x80, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0xF8, 0xFE, 0x00, 0x0F,
  0xC1, 0xFF, 0x00, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x0C,
  0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x7F, 0x03, 0xE0, 0x1F, 0xC0, 0x3E,
  0x03, 0xF8, 0x07, 0xC0, 0xFE, 0x00, 0x7C, 0x1F, 0xC0, 0x07, 0xC7, 0xF8,
  0x00, 0x7C, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0xF8, 0x00,
  0x07, 0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3C, 0x3E,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F,
  0x00, 0x01, 0xF0, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x2F,
  0x87, 0xC0, 0x03, 0xF8, 0x3F, 0x00, 0x37, 0xC0, 0xFC, 0x03, 0xBE, 0x07,
  0xF0, 0x79, 0xF0, 0x1F, 0xFF, 0x8F, 0x80, 0xFF, 0xF8, 0x7C, 0x01, 0xFF,
  0x83, 0xC0, 0x07, 0xF0, 0x20, 0x00, 0x7F, 0xF0, 0x00, 0x31, 0xFF, 0xC0,
  0x07, 0xCF, 0xFF, 0x00, 0x1F, 0xBF, 0xFC, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x1E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x03,
  0xE0, 0x3E, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0xE0,
  0x0F, 0x80, 0x3F, 0x00, 0x3E, 0x01, 0xFC, 0x00, 0xF0, 0x0F, 0xE0, 0x07,
  0xC0, 0xFF, 0x00, 0x1F, 0x1F, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0xF8, 0x06, 0x1F, 0x00, 0xF8, 0x3E, 0x1F, 0x00, 0xF0, 0x1E, 0x1E, 0x00,
  0xF0, 0x1F, 0x1E, 0x00, 0xF0, 0x1F, 0x1E, 0x00, 0xF0, 0x0F, 0x1E, 0x01,
  0xF0, 0x0F, 0x3E, 0x01, 0xF0, 0x0F, 0x3E, 0x01, 0xE0, 0x0F, 0x3E, 0x01,
  0xE0, 0x0F, 0x3C, 0x01, 0xE0, 0x0F, 0x3C, 0x01, 0xE0, 0x0F, 0x3C, 0x03,
  0xE0, 0x0F, 0x7C, 0x03, 0xE0, 0x0F, 0x7C, 0x03, 0xC0, 0x1F, 0x7C, 0x03,
  0xC0, 0x1F, 0x78, 0x03, 0xC0, 0x1F, 0x78, 0x03, 0xC0, 0x1E, 0x78, 0x07,
  0xC0, 0x1E, 0xF8, 0x07, 0xC0, 0x1E, 0xF8, 0x07, 0x80, 0x3E, 0xF8, 0x07,
  0x80, 0x3C, 0xF0, 0x07, 0x80, 0x3C, 0xF0, 0x0F, 0x80, 0x7C, 0xF0, 0x0F,
  0x80, 0x78, 0xF0, 0x0F, 0x80, 0xF8, 0xF0, 0x1F, 0x81, 0xF0, 0xF8, 0x37,
  0x81, 0xF0, 0xF8, 0x77, 0xC7, 0xE0, 0xFF, 0xE3, 0xFF, 0xC0, 0x7F, 0xE3,
  0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0x80, 0x0F, 0x80, 0x00, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xFC,
  0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xDF, 0x1E, 0x1F, 0x03, 0xF8, 0x79,
  0xE0, 0x7C, 0x7F, 0x03, 0xCE, 0x03, 0xE3, 0xF0, 0x1E, 0x70, 0x1F, 0x0E,
  0x00, 0xF7, 0x00, 0xF8, 0x40, 0x07, 0xB0, 0x07, 0xC0, 0x00, 0x3D, 0x80,
  0x3E, 0x00, 0x01, 0xFC, 0x01, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xE0, 0x07, 0xE0, 0x00, 0x0F, 0x00, 0x6F, 0x00,
  0x00, 0xF8, 0x03, 0x78, 0x01, 0x87, 0xC0, 0x3B, 0xC0, 0x3E, 0x3E, 0x01,
  0xDE, 0x03, 0xF1, 0xF0, 0x1C, 0xF0, 0x7F, 0x07, 0xC1, 0xE7, 0xC7, 0xF0,
  0x3E, 0x1E, 0x3E, 0x7F, 0x01, 0xFF, 0xF0, 0xFF, 0xE0, 0x07, 0xFF, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xE0, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x78, 0x0F, 0x80, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x01, 0xF0,
  0x1F, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x07, 0xF0,
  0x1F, 0x80, 0x0D, 0xF0, 0x0F, 0x80, 0x19, 0xE0, 0x0F, 0xC0, 0x3B, 0xE0,
  0x0F, 0xE0, 0xF3, 0xE0, 0x07, 0xFF, 0xE3, 0xE0, 0x03, 0xFF, 0xE3, 0xE0,
  0x01, 0xFF, 0x83, 0xE0, 0x00, 0x7E, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x30, 0x00, 0x3F, 0x00,
  0x78, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x1F, 0x03, 0xFF, 0xF8, 0x1E,
  0x07, 0xFF, 0xFE, 0x3E, 0x07, 0xC0, 0xFF, 0xBE, 0x0F, 0x80, 0x1F, 0xFE,
  0x0F, 0x00, 0x07, 0xFC, 0x0F, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x03, 0xF0,
  0x1E, 0x00, 0x07, 0xE0, 0x1E, 0x00, 0x0F, 0xC0, 0x1E, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x20, 0x00, 0x7E, 0x00, 0xE0,
  0x00, 0xFC, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF0, 0x03, 0xF0, 0x00, 0xF0,
  0x07, 0xE0, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0xF8, 0x1F, 0xC0, 0x00, 0x78,
  0x3F, 0xFC, 0x00, 0x78, 0x7F, 0xFF, 0xC0, 0x78, 0x7C, 0xFF, 0xFE, 0x78,
  0x78, 0x1F, 0xFF, 0xF8, 0xF8, 0x03, 0xFF, 0xF8, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F,
  0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x3E, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0C, 0x03, 0xFE, 0x00, 0x0F,
  0x07, 0xFF, 0x00, 0x0F, 0x0F, 0xFF, 0x80, 0x1E, 0x1F, 0x0F, 0x80, 0x1E,
  0x1E, 0x07, 0xC0, 0x3E, 0x3E, 0x03, 0xE0, 0x3C, 0x3C, 0x03, 0xE0, 0x78,
  0x78, 0x01, 0xF0, 0xF8, 0x78, 0x00, 0xFF, 0xF0, 0xF8, 0x00, 0xFF, 0xE0,
  0xF0, 0x00, 0x7F, 0xC0, 0x30, 0x00, 0x1F, 0x00,
};

const GFXglyph IBMPlexMono_Italic62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 37, 0, -1 },
  { 1, 14, 44, 37, 12, -43 },
  { 78, 18, 17, 37, 13, -46 },
  { 117, 37, 43, 37, 1, -43 },
  { 316, 35, 57, 37, 1, -50 },
  { 566, 42, 45, 37, -1, -44 },
  { 803, 36, 45, 37, 0, -44 },
  { 1006, 8, 17, 37, 18, -46 },
  { 1023, 23, 56, 37, 13, -47 },
  { 1184, 23, 56, 37, 3, -47 },
  { 1345, 32, 31, 37, 3, -34 },
  { 1469, 30, 30, 37, 4, -34 },
  { 1582, 14, 17, 37, 9, -8 },
  { 1612, 18, 5, 37, 10, -21 },
  { 1624, 9, 8, 37, 12, -7 },
  { 1633, 35, 56, 37, 2, -47 },
  { 1878, 31, 45, 37, 4, -44 },
  { 2053, 29, 43, 37, 3, -43 },
  { 2209, 32, 44, 37, 2, -44 },
  { 2385, 33, 45, 37, 1, -44 },
  { 2571, 33, 43, 37, 1, -43 },
  { 2749, 32, 44, 37, 3, -43 },
  { 2925, 29, 44, 37, 4, -43 },
  { 3085, 31, 43, 37, 6, -43 },
  { 3252, 32, 45, 37, 3, -44 },
  { 3432, 30, 44, 37, 5, -44 },
  { 3597, 13, 33, 37, 12, -32 },
  { 3651, 16, 41, 37, 9, -32 },
  { 3733, 30, 36, 37, 5, -37 },
  { 3868, 32, 16, 37, 3, -27 },
  { 3932, 30, 36, 37, 3, -37 },
  { 4067, 26, 45, 37, 8, -44 },
  { 4214, 31, 51, 37, 4, -44 },
  { 4412, 34, 43, 37, -1, -43 },
  { 4595, 31, 43, 37, 3, -43 },
  { 4762, 31, 45, 37, 5, -44 },
  { 4937, 32, 43, 37, 3, -43 },
  { 5109, 34, 43, 37, 3, -43 },
  { 5292, 34, 43, 37, 3, -43 },
  { 5475, 31, 45, 37, 4, -44 },
  { 5650, 35, 43, 37, 2, -43 },
  { 5839, 34, 43, 37, 3, -43 },
  { 6022, 30, 44, 37, 4, -43 },
  { 6187, 37, 43, 37, 3, -43 },
  { 6386, 26, 43, 37, 5, -43 },
  { 6526, 36, 43, 37, 2, -43 },
  { 6720, 35, 43, 37, 2, -43 },
  { 6909, 31, 45, 37, 4, -44 },
  { 7084, 33, 43, 37, 3, -43 },
  { 7262, 31, 56, 37, 4, -44 },
  { 7479, 33, 43, 37, 3, -43 },
  { 7657, 34, 45, 37, 2, -44 },
  { 7849, 35, 43, 37, 5, -43 },
  { 8038, 32, 44, 37, 5, -43 },
  { 8214, 32, 43, 37, 7, -43 },
  { 8386, 37, 43, 37, 3, -43 },
  { 8585, 41, 43, 37, -1, -43 },
  { 8806, 35, 43, 37, 6, -43 },
  { 8995, 38, 43, 37, 0, -43 },
  { 9200, 26, 56, 37, 10, -47 },
  { 9382, 16, 56, 37, 11, -47 },
  { 9494, 26, 56, 37, 1, -47 },
  { 9676, 31, 25, 37, 4, -43 },
  { 9773, 30, 5, 37, 0, 6 },
  { 9792, 8, 12, 37, 14, -48 },
  { 9804, 30, 34, 37, 3, -33 },
  { 9932, 31, 47, 37, 3, -46 },
  { 10115, 27, 34, 37, 5, -33 },
  { 10230, 33, 47, 37, 3, -46 },
  { 10424, 28, 34, 37, 5, -33 },
  { 10543, 41, 59, 37, -1, -46 },
  { 10846, 32, 46, 37, 2, -33 },
  { 11030, 28, 46, 37, 4, -46 },
  { 11191, 28, 47, 37, 5, -46 },
  { 11356, 29, 59, 37, 4, -46 },
  { 11570, 31, 47, 37, 4, -46 },
  { 11753, 26, 47, 37, 7, -46 },
  { 11906, 34, 33, 37, 1, -33 },
  { 12047, 28, 33, 37, 4, -33 },
  { 12163, 29, 34, 37, 4, -33 },
  { 12287, 33, 45, 37, 1, -33 },
  { 12473, 31, 45, 37, 3, -33 },
  { 12648, 30, 32, 37, 7, -32 },
  { 12768, 30, 34, 37, 3, -33 },
  { 12896, 28, 44, 37, 5, -43 },
  { 13050, 29, 33, 37, 5, -32 },
  { 13170, 30, 33, 37, 4, -32 },
  { 13294, 32, 33, 37, 3, -32 },
  { 13426, 37, 34, 37, 0, -33 },
  { 13584, 32, 45, 37, 2, -32 },
  { 13764, 32, 34, 37, 3, -33 },
  { 13900, 29, 56, 37, 7, -47 },
  { 14103, 14, 56, 37, 12, -47 },
  { 14201, 29, 56, 37, 3, -47 },
  { 14404, 32, 13, 37, 3, -26 },
};

const GFXfont IBMPlexMono_Italic62pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic62pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic62pt7bGlyphs,
  0x20, 0x7E, 81
};

#endif // _IBMPLEXMONO_ITALIC62PT7B_H_
