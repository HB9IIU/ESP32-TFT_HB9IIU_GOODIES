#ifndef _IBMPLEXMONO_ITALIC57PT7B_H_
#define _IBMPLEXMONO_ITALIC57PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic57pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0xC1, 0xFE, 0x0F,
  0xF8, 0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0x7C, 0x00, 0x1E, 0x0F, 0x9F, 0x07,
  0xCF, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x7C, 0xF8,
  0x3E, 0x78, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x83, 0xE7,
  0xC1, 0xF3, 0xC0, 0xF1, 0xE0, 0x78, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00,
  0x3C, 0x0F, 0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x01, 0xE0, 0x7C, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x3E, 0x07, 0x80, 0x0F, 0xFF, 0x01,
  0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F, 0xFC, 0x3F, 0xF8,
  0x0F, 0xFF, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0xFF, 0xF0, 0x1F, 0xFC, 0x3F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF,
  0xC3, 0xFF, 0x80, 0xFF, 0xF0, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0xF0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x3E,
  0x07, 0x80, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01,
  0xF0, 0x3C, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC,
  0x01, 0xFE, 0x39, 0xFE, 0x01, 0xF8, 0x38, 0x7F, 0x03, 0xF0, 0x78, 0x1F,
  0x03, 0xE0, 0x78, 0x0E, 0x07, 0xC0, 0x78, 0x0C, 0x07, 0xC0, 0x70, 0x00,
  0x07, 0xC0, 0x70, 0x00, 0x07, 0xC0, 0x70, 0x00, 0x07, 0xC0, 0xF0, 0x00,
  0x07, 0xC0, 0xF0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x07, 0xE0, 0xE0, 0x00,
  0x03, 0xF8, 0xE0, 0x00, 0x01, 0xFE, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xC7, 0xF0, 0x00, 0x03, 0xC1, 0xF8,
  0x00, 0x03, 0xC0, 0xF8, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x03, 0x80, 0x78,
  0x00, 0x03, 0x80, 0x78, 0x00, 0x03, 0x80, 0x78, 0x00, 0x07, 0x80, 0xF8,
  0x10, 0x07, 0x80, 0xF8, 0x38, 0x07, 0x80, 0xF8, 0x7C, 0x07, 0x01, 0xF0,
  0xFE, 0x07, 0x03, 0xF0, 0x7F, 0x07, 0x07, 0xE0, 0x3F, 0xCF, 0x1F, 0xC0,
  0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3C, 0x00, 0xFF, 0x80,
  0x01, 0xE0, 0x0F, 0xFF, 0x00, 0x07, 0x80, 0x7F, 0xFE, 0x00, 0x3C, 0x01,
  0xF0, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0xF0, 0x0F, 0x80, 0x3C, 0x03, 0xC0,
  0x3C, 0x01, 0xE0, 0x0F, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x1E,
  0x00, 0xF0, 0x3C, 0x00, 0x78, 0x03, 0xC1, 0xE0, 0x01, 0xC0, 0x0F, 0x0F,
  0x00, 0x07, 0x00, 0x78, 0x3C, 0x00, 0x1C, 0x01, 0xE1, 0xE0, 0x00, 0x78,
  0x0F, 0x0F, 0x00, 0x01, 0xF0, 0x7C, 0x7C, 0x00, 0x07, 0xFF, 0xE1, 0xE0,
  0x00, 0x0F, 0xFF, 0x08, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xC3, 0xFF, 0xC0, 0x00, 0x3E,
  0x1F, 0xFF, 0x80, 0x00, 0xF0, 0xF8, 0x3E, 0x00, 0x07, 0x83, 0xC0, 0x78,
  0x00, 0x3C, 0x1E, 0x00, 0xE0, 0x00, 0xF0, 0x78, 0x03, 0x80, 0x07, 0x83,
  0xC0, 0x0E, 0x00, 0x3C, 0x0F, 0x00, 0x78, 0x00, 0xF0, 0x3C, 0x01, 0xE0,
  0x07, 0x80, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x07, 0xC0, 0x3C, 0x00, 0x78, 0x3E, 0x01,
  0xE0, 0x01, 0xFF, 0xF8, 0x07, 0x80, 0x03, 0xFF, 0xC0, 0x3C, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x1F,
  0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x03, 0xE0, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00,
  0xF0, 0x0F, 0x80, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x07, 0xF1, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x07, 0xE3, 0xF8, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x1F, 0x00,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x1F,
  0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x33, 0xE0, 0x01, 0xF0, 0x1F, 0xF8,
  0x00, 0xFE, 0x07, 0xBE, 0x00, 0x37, 0x83, 0xC7, 0x80, 0x1D, 0xF1, 0xF1,
  0xF0, 0x06, 0x7C, 0x78, 0x7E, 0x07, 0x8F, 0xBE, 0x0F, 0xFF, 0xC3, 0xFF,
  0x01, 0xFF, 0xF0, 0x7F, 0x80, 0x3F, 0xF0, 0x0F, 0xE0, 0x03, 0xF0, 0x01,
  0xE0, 0x00, 0x3E, 0x7C, 0xF1, 0xE3, 0xC7, 0x9F, 0x3E, 0x78, 0xF1, 0xE3,
  0xCF, 0x9F, 0x3C, 0x78, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x03,
  0x80, 0x3C, 0x01, 0xDF, 0x81, 0xE0, 0x7F, 0xFF, 0x8F, 0x3F, 0xF7, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xF3, 0xC0, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x1F,
  0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x00, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x01,
  0xF0, 0x07, 0x80, 0x0F, 0x00, 0x08, 0x00, 0x20, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xF8, 0x3F, 0x81,
  0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x01, 0xF0,
  0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3E, 0x3F, 0xBF, 0xDF, 0xFF,
  0xF7, 0xFB, 0xF8, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0,
  0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x1F, 0x00,
  0x00, 0xF3, 0xE0, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x0F,
  0x7C, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0xF7, 0x80,
  0xF8, 0x0F, 0xF8, 0x1F, 0xC1, 0xFF, 0x81, 0xFC, 0x1F, 0xF8, 0x3F, 0xC1,
  0xFF, 0x83, 0xF8, 0x1F, 0xF8, 0x3F, 0x81, 0xFF, 0x01, 0xF0, 0x1E, 0xF0,
  0x00, 0x03, 0xEF, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x03, 0xEF, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x0F, 0x8F,
  0x00, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00,
  0x3E, 0x07, 0xC0, 0x0F, 0xC0, 0x3F, 0x03, 0xF8, 0x03, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xBC, 0x00, 0x07, 0xF3, 0xC0, 0x00, 0xFE, 0x7C, 0x00,
  0x1F, 0xC7, 0xC0, 0x03, 0xF0, 0x7C, 0x00, 0xFE, 0x07, 0xC0, 0x0F, 0xC0,
  0x78, 0x00, 0xF8, 0x07, 0x80, 0x07, 0x00, 0xF8, 0x00, 0x60, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0,
  0x7F, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0x1F,
  0x0F, 0xC0, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0xC0, 0x40, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0xFF, 0x03, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x38,
  0x00, 0x1F, 0x00, 0x40, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x18, 0x00, 0x03, 0xE1,
  0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7C, 0x1F, 0x80, 0x07, 0xE0, 0x3F,
  0x80, 0x7F, 0x80, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3E,
  0x78, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x01, 0xF0, 0x3C,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3C, 0x03, 0xE0,
  0x00, 0xF0, 0x07, 0x80, 0x03, 0xE0, 0x0F, 0x00, 0x0F, 0x80, 0x1E, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xE0, 0x01, 0xF0, 0x07,
  0xC0, 0x03, 0xC0, 0x1F, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x0F, 0x01, 0xF0,
  0x00, 0x3E, 0x03, 0xC0, 0x00, 0x7C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC1, 0xFC, 0x00, 0x0F, 0x1F, 0xFE, 0x00, 0x3C, 0xFF, 0xFC,
  0x00, 0xF7, 0xFF, 0xF8, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0x80, 0x0F, 0xC0,
  0x7C, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x30, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x3E,
  0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x80, 0x0F, 0xC0, 0x7F, 0x80, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x3F, 0x80, 0x0F,
  0x1F, 0xFE, 0x01, 0xF3, 0xFF, 0xF0, 0x1E, 0x7F, 0xFF, 0x83, 0xEF, 0x01,
  0xFC, 0x3D, 0xC0, 0x0F, 0xE3, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xE7,
  0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x1E, 0x7C, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E,
  0x78, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x7C, 0x78, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x83, 0xE0, 0x03, 0xF0, 0x3F, 0x80, 0xFE,
  0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x78, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x3E,
  0x78, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x8F, 0x00,
  0x01, 0xF0, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x3E, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3C, 0x1F, 0x00, 0x00,
  0xF0, 0x7C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x7C,
  0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0xFC, 0x01,
  0xF8, 0x0F, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0xF8, 0x00,
  0x7E, 0x07, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0xFB,
  0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x7C, 0xF8,
  0x00, 0x03, 0xF1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7E, 0x1F, 0x80,
  0x03, 0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0xFF,
  0x03, 0xF8, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x1E,
  0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x7F, 0x3F, 0x00, 0x1B, 0xE7, 0xF8, 0x0F, 0xF8, 0x7F, 0xFF, 0xDF, 0x07,
  0xFF, 0xE7, 0xC0, 0x7F, 0xF8, 0xF8, 0x03, 0xFC, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xE0, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x7F, 0x0F, 0xF0, 0xFF, 0x8F, 0xF0, 0xFF, 0x0F, 0xE0, 0x7C, 0x00, 0x00,
  0x7C, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0,
  0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x04, 0x00, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x80, 0x04, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xC1, 0xFC, 0x0F, 0xE1, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0x7C,
  0xF8, 0x00, 0x3E, 0x78, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xC4, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x03,
  0xC0, 0xF8, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x78, 0x7C, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x1E, 0x3E, 0x01, 0xF0, 0xF1, 0xE0, 0x1F, 0xE7, 0x8F, 0x03,
  0xFF, 0x3C, 0x78, 0x1F, 0xFD, 0xE7, 0xC1, 0xF8, 0x6F, 0x3C, 0x1F, 0x01,
  0xF1, 0xE0, 0xF8, 0x07, 0x8F, 0x07, 0x80, 0x3C, 0xF8, 0x7C, 0x01, 0xE7,
  0xC3, 0xC0, 0x0F, 0x3C, 0x1E, 0x00, 0xF9, 0xE0, 0xF0, 0x07, 0x8F, 0x0F,
  0x80, 0x3C, 0x78, 0x7C, 0x01, 0xE3, 0xC3, 0xE0, 0x0F, 0x3E, 0x1E, 0x00,
  0xF9, 0xE0, 0xF0, 0x07, 0xCF, 0x07, 0x80, 0x7C, 0x78, 0x3E, 0x03, 0xE3,
  0xC0, 0xF0, 0x3F, 0x1E, 0x07, 0xE7, 0x78, 0xF0, 0x3F, 0xFB, 0xC7, 0x80,
  0xFF, 0xBE, 0x3C, 0x03, 0xF9, 0xE0, 0xF0, 0x06, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x3E,
  0xF0, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x03, 0xC7,
  0xC0, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x7C, 0x1E,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0x80, 0xF8,
  0x00, 0x0F, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x78, 0x03, 0xC0,
  0x01, 0xF0, 0x07, 0x80, 0x03, 0xC0, 0x0F, 0x00, 0x0F, 0x80, 0x1F, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3E,
  0x00, 0x07, 0x80, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0x03, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0,
  0x3C, 0x00, 0x7F, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xC0, 0xF8,
  0x00, 0x1F, 0x07, 0x80, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0xC1, 0xE0, 0x00,
  0x3E, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8,
  0x3C, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0xF8, 0x0F, 0x00, 0x1F, 0x80, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF0, 0x0F, 0x00, 0x0F, 0xC0, 0x78, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C,
  0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0xF8, 0x78,
  0x00, 0x07, 0xC3, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0xFC, 0x7C, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x7E,
  0x1E, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x0F, 0x80, 0x07, 0xC0,
  0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x01, 0x01, 0xE0,
  0x00, 0x0E, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x7C, 0x0F, 0x80, 0x07, 0xC0, 0x7E, 0x00, 0x7E, 0x01, 0xFC, 0x0F, 0xE0,
  0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x3E, 0x01, 0xFE, 0x01, 0xF0, 0x03,
  0xF0, 0x0F, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8,
  0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x78,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x3E,
  0x1E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C, 0x7C,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1E, 0x00, 0x01, 0xF0, 0xF0, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E,
  0x1F, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xF8, 0x7C,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0xC0, 0xF8, 0x03,
  0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF8, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0x3E, 0x07,
  0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF1, 0xF0, 0x00,
  0x0E, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x03, 0xFF, 0xEF, 0x80, 0x3F, 0xFC, 0xF8, 0x03, 0xFF, 0xCF, 0x80,
  0x7F, 0xFC, 0xF8, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0x78, 0xF8, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x78, 0xF8,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x87, 0xC0, 0x01,
  0xF0, 0x7C, 0x00, 0x3F, 0x07, 0xE0, 0x0E, 0xF0, 0x3F, 0x83, 0xCF, 0x03,
  0xFF, 0xFD, 0xF0, 0x1F, 0xFF, 0x9F, 0x00, 0xFF, 0xE1, 0xE0, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x1E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x3C, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x7C, 0x0F, 0x80,
  0x00, 0x78, 0x0F, 0x80, 0x00, 0x78, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x80,
  0x00, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x01, 0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x03, 0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x03, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x07, 0x80, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x07, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x03, 0xC0, 0x01,
  0xF0, 0x1F, 0x00, 0x1F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x3F, 0x80,
  0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xE0, 0x3E, 0x00, 0x03, 0xF0,
  0x07, 0x80, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x03, 0xC0, 0x0F, 0xC0, 0x00, 0x78, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00,
  0x0F, 0x83, 0xF0, 0x00, 0x01, 0xE0, 0xFC, 0x00, 0x00, 0x3C, 0x1F, 0x00,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x00, 0x3E, 0x7F,
  0x00, 0x00, 0x07, 0xDF, 0xF0, 0x00, 0x00, 0xF7, 0xFE, 0x00, 0x00, 0x1F,
  0xF3, 0xE0, 0x00, 0x07, 0xFC, 0x7C, 0x00, 0x00, 0xFF, 0x07, 0xC0, 0x00,
  0x1F, 0xC0, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x07, 0x80, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x1E, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0xC0, 0x07, 0xF8,
  0x1F, 0xE0, 0x07, 0xFC, 0x0F, 0xF0, 0x03, 0xFC, 0x07, 0xBC, 0x03, 0xDE,
  0x03, 0xDE, 0x01, 0xEF, 0x01, 0xEF, 0x01, 0xE7, 0x81, 0xF7, 0x80, 0xF7,
  0xC0, 0xF1, 0xE0, 0xF3, 0xE0, 0x78, 0xF0, 0xF9, 0xE0, 0x3C, 0x78, 0x78,
  0xF0, 0x1E, 0x3C, 0x78, 0x78, 0x0F, 0x0E, 0x3C, 0x3C, 0x0F, 0x87, 0xBC,
  0x3E, 0x07, 0x83, 0xDE, 0x1F, 0x03, 0xC1, 0xFE, 0x0F, 0x01, 0xE0, 0x7F,
  0x07, 0x80, 0xF0, 0x3F, 0x03, 0xC0, 0x78, 0x1F, 0x01, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3C, 0x03, 0x80, 0xF8, 0x1E, 0x01, 0xC0, 0x78, 0x0F, 0x00,
  0xC0, 0x3C, 0x07, 0x80, 0x60, 0x1E, 0x03, 0xC0, 0x20, 0x0F, 0x03, 0xE0,
  0x00, 0x0F, 0x81, 0xE0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x1F,
  0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x03, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0x01, 0xFC, 0x00, 0x1F, 0x03, 0xFC, 0x00, 0x1E,
  0x03, 0xFC, 0x00, 0x1E, 0x03, 0xFE, 0x00, 0x1E, 0x03, 0xDE, 0x00, 0x3E,
  0x03, 0xDE, 0x00, 0x3E, 0x03, 0xDE, 0x00, 0x3E, 0x07, 0xDF, 0x00, 0x3C,
  0x07, 0xCF, 0x00, 0x3C, 0x07, 0x8F, 0x00, 0x3C, 0x07, 0x8F, 0x00, 0x7C,
  0x07, 0x8F, 0x00, 0x7C, 0x07, 0x8F, 0x80, 0x7C, 0x0F, 0x87, 0x80, 0x78,
  0x0F, 0x87, 0x80, 0x78, 0x0F, 0x07, 0x80, 0x78, 0x0F, 0x07, 0xC0, 0xF8,
  0x0F, 0x03, 0xC0, 0xF8, 0x0F, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0xF0,
  0x1F, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xE0, 0xF0, 0x1E, 0x01, 0xE1, 0xF0,
  0x1E, 0x01, 0xE1, 0xF0, 0x1E, 0x01, 0xE1, 0xF0, 0x3E, 0x01, 0xE1, 0xE0,
  0x3E, 0x00, 0xF1, 0xE0, 0x3C, 0x00, 0xF1, 0xE0, 0x3C, 0x00, 0xF3, 0xE0,
  0x3C, 0x00, 0xF3, 0xE0, 0x3C, 0x00, 0xFB, 0xE0, 0x7C, 0x00, 0x7B, 0xC0,
  0x7C, 0x00, 0x7B, 0xC0, 0x78, 0x00, 0x7B, 0xC0, 0x78, 0x00, 0x7F, 0xC0,
  0x78, 0x00, 0x3F, 0xC0, 0x78, 0x00, 0x3F, 0xC0, 0xF8, 0x00, 0x3F, 0x80,
  0xF8, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x00,
  0x3E, 0x07, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF1,
  0xF0, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x0F, 0x3E, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x0F,
  0x7C, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3E, 0xF0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x3E, 0xF0,
  0x00, 0x03, 0xEF, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x07, 0xCF, 0x00, 0x00,
  0x7C, 0xF0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x0F,
  0x80, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0xC0, 0x3F, 0x03,
  0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xC0, 0x01, 0xF8, 0x1F,
  0x00, 0x03, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x7C, 0x1E, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07,
  0xC3, 0xC0, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x7F, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0xFC,
  0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x1F, 0x00, 0x00,
  0xF3, 0xE0, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x0F, 0x7C,
  0x00, 0x00, 0xF7, 0xC0, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0xF7, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3E, 0xF0, 0x00,
  0x03, 0xEF, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x7C,
  0xF0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x0F, 0x8F, 0x00,
  0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x3E,
  0x07, 0xC0, 0x0F, 0xC0, 0x7F, 0x03, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x80, 0x01, 0xF0, 0x1C, 0x00, 0x1F, 0x83, 0xE0,
  0x00, 0xF8, 0x7C, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE,
  0x03, 0xC0, 0x01, 0xF8, 0x1F, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1E, 0x00, 0x01, 0xF0, 0x78,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x3E, 0x0F, 0x00, 0x00,
  0xF8, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7F, 0x07, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0x80, 0x03, 0xE0,
  0x1F, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x7C,
  0x01, 0xE0, 0x00, 0xF8, 0x07, 0x80, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0xF8, 0x3C,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFE, 0x01, 0xFE, 0x01,
  0xF8, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0E, 0x07,
  0xC0, 0x00, 0x0C, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x10, 0x00, 0x00, 0xF8, 0x38,
  0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0xFE, 0x00, 0x03, 0xF0, 0x7F,
  0x00, 0x07, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x1E, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x07, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00,
  0x03, 0xE0, 0xF0, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C,
  0x1E, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1E, 0x0F,
  0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xC0,
  0x00, 0x3E, 0x0F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xC1, 0xF0, 0x00,
  0x0F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x07,
  0xC1, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x78, 0x3E, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF0, 0x3E,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x78, 0x07, 0xC0,
  0x03, 0xE0, 0x1F, 0x00, 0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x0F,
  0x9E, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x07, 0xC7,
  0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x1F, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xE0, 0x3C, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x7C, 0x03, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x0F,
  0x80, 0x3E, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x01, 0xE0, 0x07, 0xC0,
  0x07, 0x80, 0x1E, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x78, 0x03, 0xC0, 0x01,
  0xE0, 0x1F, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3C,
  0x0F, 0x80, 0x00, 0xF0, 0x7C, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x0F, 0x9E, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x7C,
  0x7C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x0F,
  0x0F, 0x01, 0xF8, 0x07, 0x87, 0x80, 0xFC, 0x07, 0xC3, 0xC0, 0x7E, 0x03,
  0xC1, 0xE0, 0x7F, 0x01, 0xE0, 0xF0, 0x3F, 0x80, 0xF0, 0x78, 0x1D, 0xC0,
  0xF8, 0x3C, 0x1E, 0xE0, 0x78, 0x1E, 0x0F, 0x70, 0x3C, 0x1F, 0x07, 0x38,
  0x1E, 0x0F, 0x07, 0x9E, 0x1F, 0x07, 0x83, 0xCF, 0x0F, 0x03, 0xC3, 0xC7,
  0x87, 0x81, 0xE1, 0xE3, 0xC3, 0xC0, 0xF0, 0xE1, 0xE3, 0xE0, 0x78, 0xF0,
  0xF1, 0xE0, 0x3C, 0x78, 0x78, 0xF0, 0x1E, 0x38, 0x3C, 0x78, 0x0F, 0x3C,
  0x1E, 0x3C, 0x07, 0x9E, 0x0F, 0x3C, 0x03, 0xCE, 0x07, 0x9E, 0x03, 0xCF,
  0x03, 0xCF, 0x01, 0xE7, 0x81, 0xE7, 0x80, 0xF7, 0x80, 0xF7, 0x80, 0x7B,
  0xC0, 0x7B, 0xC0, 0x3D, 0xE0, 0x3D, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x7E,
  0x00, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x00,
  0x3E, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xDF, 0x00, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x0F, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x00, 0x7E, 0x3C, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x1F, 0x00,
  0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x07, 0xC0,
  0x1F, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0xC0, 0x7E, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x01, 0xF1,
  0xF0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xF0, 0x00,
  0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xF7,
  0xC0, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x7C, 0x1E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x03, 0xC0, 0x03,
  0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x03, 0xE0, 0x03, 0xC0, 0x3E, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x78, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x7C, 0x80, 0x00, 0x01, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x11, 0xF3, 0xE3,
  0xC7, 0xC7, 0x8F, 0x0F, 0x1E, 0x1C, 0x30, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xFE, 0x1F, 0x01, 0xFF, 0xF1, 0xE0, 0x3F, 0xFF, 0x9E, 0x07, 0xF0, 0x3D,
  0xE0, 0xFC, 0x00, 0xFE, 0x1F, 0x80, 0x07, 0xE1, 0xF0, 0x00, 0x7E, 0x3E,
  0x00, 0x03, 0xC3, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC7, 0xC0, 0x00,
  0x7C, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7C, 0x78, 0x00, 0x07, 0x8F,
  0x80, 0x00, 0x78, 0xF8, 0x00, 0x07, 0x8F, 0x80, 0x00, 0xF8, 0xF8, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0,
  0xF8, 0x00, 0x3F, 0x07, 0x80, 0x03, 0xF0, 0x7C, 0x00, 0x7F, 0x07, 0xE0,
  0x0D, 0xF0, 0x7F, 0x03, 0x9F, 0xF3, 0xFF, 0xF9, 0xFE, 0x1F, 0xFF, 0x0F,
  0xE0, 0xFF, 0xE0, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0x81, 0xFC, 0x00, 0x78, 0x7F, 0xF0, 0x07, 0x8F, 0xFF,
  0x80, 0xF9, 0xFF, 0xFC, 0x0F, 0xBC, 0x0F, 0xE0, 0xFB, 0x00, 0x3E, 0x0F,
  0x60, 0x03, 0xE0, 0xFC, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF1, 0xF8, 0x00,
  0x1F, 0x1F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x1E, 0x00, 0x01, 0xF1,
  0xE0, 0x00, 0x1F, 0x1E, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x3E, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x3E,
  0x3C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xB0, 0x03, 0xF0, 0x7B, 0xC0, 0xFE,
  0x0F, 0x9F, 0xFF, 0xC0, 0xF9, 0xFF, 0xF8, 0x0F, 0x87, 0xFF, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xF0, 0x3F, 0x83, 0xF0, 0x03, 0xE0, 0xF8,
  0x00, 0x78, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x04, 0x0F, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x06, 0x3E,
  0x00, 0x03, 0xE7, 0x80, 0x00, 0xF1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x3E,
  0x0F, 0x80, 0x1F, 0x03, 0xF8, 0x1F, 0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x3F, 0x80, 0xF0, 0x03, 0xFF, 0xC3,
  0xC0, 0x1F, 0xFF, 0x9F, 0x00, 0xFF, 0xFF, 0x7C, 0x07, 0xF0, 0x1D, 0xF0,
  0x3F, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0xF8, 0x3E,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x3E, 0x1F, 0x00,
  0x00, 0xF0, 0x7C, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x7C, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1E,
  0x0F, 0x80, 0x00, 0x78, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x01, 0xF8, 0x1E, 0x00, 0x0F, 0xC0, 0x7C,
  0x00, 0x6F, 0x01, 0xF8, 0x03, 0x3C, 0x07, 0xF0, 0x3D, 0xF0, 0x0F, 0xFF,
  0xE7, 0xC0, 0x1F, 0xFF, 0x1F, 0x00, 0x3F, 0xF8, 0x78, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x07, 0xF0, 0x1F, 0xC3, 0xF0, 0x01, 0xF0, 0xF8, 0x00,
  0x7C, 0x7C, 0x00, 0x0F, 0x3E, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x7D, 0xF0, 0x00, 0x7F, 0x78, 0x00, 0x7F, 0x9E, 0x03, 0xFF, 0xCF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x3F, 0xFC, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xC7, 0x80, 0x00, 0x79, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x0F,
  0x80, 0x0F, 0x83, 0xF8, 0x1F, 0xC0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xC0, 0x0F,
  0x80, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0xF0, 0x00, 0x00,
  0x7E, 0x03, 0xC0, 0x00, 0x00, 0xFC, 0x0F, 0x00, 0x00, 0x01, 0xF8, 0x7C,
  0x00, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x00,
  0x0F, 0x9E, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFF, 0xC3, 0xC0, 0x3F, 0xFF, 0x3E, 0x03,
  0xFF, 0xFD, 0xF0, 0x3F, 0x80, 0xEF, 0x83, 0xF0, 0x03, 0xF8, 0x3F, 0x00,
  0x0F, 0xC1, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F,
  0x87, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x1E, 0x1F,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C, 0x7C, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xE0, 0xF0, 0x00, 0x7F, 0x07,
  0xC0, 0x06, 0xF0, 0x3F, 0x00, 0x77, 0x80, 0xFC, 0x0F, 0x3C, 0x07, 0xFF,
  0xF3, 0xE0, 0x1F, 0xFF, 0x1F, 0x00, 0x7F, 0xF0, 0xF8, 0x00, 0xFE, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x40, 0x00, 0xFC, 0x07, 0x80,
  0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x1F, 0xC0, 0x0F, 0x87, 0xFE, 0x01, 0xF3, 0xFF, 0xE0,
  0x3C, 0xFF, 0xFC, 0x07, 0x9C, 0x0F, 0xC1, 0xF7, 0x00, 0xF8, 0x3E, 0xC0,
  0x1F, 0x07, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x1E, 0x1F, 0x00, 0x03, 0xC3, 0xE0, 0x00,
  0x78, 0x78, 0x00, 0x1F, 0x0F, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x7C, 0x7C,
  0x00, 0x0F, 0x0F, 0x80, 0x01, 0xE1, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F,
  0x87, 0x80, 0x01, 0xF0, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0x87, 0xC0,
  0x00, 0xF0, 0xF8, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0xF8,
  0x78, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x20,
  0x03, 0xC0, 0x0C, 0x01, 0xF0, 0x07, 0x80, 0x7C, 0x07, 0xF0, 0x1E, 0x03,
  0xF0, 0x07, 0x81, 0xF8, 0x01, 0xE0, 0xFC, 0x00, 0xF8, 0x7E, 0x00, 0x3E,
  0x3F, 0x00, 0x0F, 0xBF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0xC0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x0F, 0xC0,
  0x3E, 0x00, 0xFC, 0x07, 0xC0, 0x0F, 0xC0, 0xF8, 0x00, 0xFC, 0x1E, 0x00,
  0x0F, 0xC3, 0xC0, 0x00, 0xFC, 0x78, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x03,
  0xE1, 0xFF, 0x80, 0x1E, 0x3F, 0xFE, 0x00, 0xF3, 0xFF, 0xF8, 0x07, 0x9C,
  0x0F, 0xC0, 0x7D, 0xC0, 0x3E, 0x03, 0xFC, 0x00, 0xF8, 0x1F, 0xC0, 0x07,
  0xC0, 0xFC, 0x00, 0x3C, 0x07, 0xC0, 0x01, 0xE0, 0x3E, 0x00, 0x0F, 0x03,
  0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x07, 0x80,
  0x1F, 0x80, 0x3C, 0x03, 0xF8, 0x01, 0xE0, 0xFF, 0x00, 0x1F, 0x1F, 0xC0,
  0x00, 0xF8, 0xF8, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x3C, 0x1F, 0x00, 0x21,
  0xE0, 0x78, 0x03, 0x8F, 0x03, 0xE0, 0x3E, 0xF8, 0x1F, 0x03, 0xF7, 0xC0,
  0x7C, 0x3F, 0x3E, 0x03, 0xE3, 0xF1, 0xE0, 0x0F, 0xBF, 0x0F, 0x00, 0x7F,
  0xF0, 0x78, 0x01, 0xFF, 0x07, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x04, 0x07, 0xC0, 0x0E, 0x07, 0xC0, 0x1F,
  0x07, 0x80, 0x7E, 0x07, 0x80, 0xFC, 0x07, 0x81, 0xF8, 0x0F, 0x83, 0xF0,
  0x0F, 0x87, 0xE0, 0x0F, 0x9F, 0xC0, 0x0F, 0x3F, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0xF8, 0x1F, 0x3F, 0x87, 0xF8, 0x3C, 0xFF, 0x9F, 0xF8, 0x7B, 0xFF, 0x3F,
  0xF0, 0xF6, 0x3E, 0xE3, 0xE1, 0xF8, 0x3F, 0x83, 0xC3, 0xE0, 0x7E, 0x07,
  0x8F, 0x80, 0xF8, 0x0F, 0x1F, 0x01, 0xF0, 0x1E, 0x3C, 0x03, 0xC0, 0x3C,
  0x78, 0x07, 0x80, 0x78, 0xF0, 0x0F, 0x00, 0xF1, 0xE0, 0x1E, 0x03, 0xE7,
  0xC0, 0x7C, 0x07, 0x8F, 0x00, 0xF0, 0x0F, 0x1E, 0x01, 0xE0, 0x1E, 0x3C,
  0x03, 0xC0, 0x3C, 0x78, 0x07, 0x80, 0x78, 0xF0, 0x0F, 0x01, 0xF3, 0xE0,
  0x3E, 0x03, 0xC7, 0x80, 0x78, 0x07, 0x8F, 0x00, 0xF0, 0x0F, 0x1E, 0x01,
  0xE0, 0x1E, 0x3C, 0x03, 0xC0, 0x3C, 0x78, 0x07, 0x80, 0xF1, 0xF0, 0x1E,
  0x01, 0xE3, 0xC0, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0x07, 0x8F, 0x00, 0xF0,
  0x0F, 0x1E, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0xF8, 0x7F,
  0xE0, 0x1E, 0x3F, 0xFE, 0x03, 0xCF, 0xFF, 0xC0, 0x79, 0xC0, 0xFC, 0x1F,
  0x70, 0x0F, 0x83, 0xEC, 0x01, 0xF0, 0x7F, 0x00, 0x1F, 0x0F, 0xC0, 0x03,
  0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x0F, 0x80, 0x01, 0xE1, 0xF0,
  0x00, 0x3C, 0x3E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xF0, 0xF0, 0x00, 0x3E,
  0x1E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x1E, 0x1F, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0xF8, 0x78, 0x00, 0x1F, 0x0F, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x78, 0x7C, 0x00, 0x0F, 0x0F, 0x80, 0x01, 0xE1, 0xE0, 0x00,
  0x7C, 0x3C, 0x00, 0x0F, 0x87, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3C, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0x03, 0xF0, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xE1,
  0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x79, 0xF0, 0x00,
  0x0F, 0x3C, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xF7, 0xC0, 0x00, 0x1E, 0xF8, 0x00, 0x07, 0xDE, 0x00, 0x00,
  0xFB, 0xC0, 0x00, 0x1F, 0x78, 0x00, 0x03, 0xEF, 0x00, 0x00, 0xF9, 0xE0,
  0x00, 0x1F, 0x3C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0x78, 0x00, 0x3E,
  0x0F, 0x80, 0x0F, 0xC0, 0xFC, 0x07, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x07, 0x87, 0xFF, 0x00, 0x1E, 0x3F, 0xFE, 0x00, 0xF9, 0xFF, 0xFC,
  0x03, 0xEF, 0x03, 0xF8, 0x0F, 0xB0, 0x03, 0xE0, 0x3D, 0x80, 0x0F, 0x80,
  0xFC, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x1F, 0x80, 0x01, 0xF0, 0x7C,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x7C, 0x1E, 0x00,
  0x01, 0xF0, 0x78, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00,
  0x7C, 0x3E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x3E,
  0x0F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x7B, 0x00, 0x3F, 0x01, 0xEF,
  0x03, 0xF8, 0x0F, 0x9F, 0xFF, 0xC0, 0x3E, 0x7F, 0xFE, 0x00, 0xF8, 0x7F,
  0xF0, 0x03, 0xC0, 0x7F, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xFF, 0x0F, 0x01, 0xFF, 0xF9, 0xF0, 0x3F, 0xFF, 0xDF, 0x07, 0xF0, 0x1D,
  0xF0, 0xFC, 0x00, 0xFE, 0x1F, 0x80, 0x07, 0xE1, 0xF0, 0x00, 0x3E, 0x3E,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3E, 0x3C, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x3C, 0x7C, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x78, 0xF8, 0x00,
  0x07, 0x8F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF8,
  0xF8, 0x00, 0x1F, 0x87, 0x80, 0x03, 0xF0, 0x7C, 0x00, 0x6F, 0x07, 0xE0,
  0x0E, 0xF0, 0x7F, 0x03, 0xDF, 0x03, 0xFF, 0xF9, 0xF0, 0x1F, 0xFF, 0x1F,
  0x00, 0xFF, 0xE1, 0xE0, 0x03, 0xF8, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x7F, 0xFC, 0x0F, 0xF7, 0xFF,
  0x87, 0xFE, 0xFF, 0xF8, 0xFF, 0xEF, 0xFF, 0x9F, 0xFE, 0x00, 0xFB, 0xC0,
  0x00, 0x0F, 0xB0, 0x00, 0x00, 0xF6, 0x00, 0x00, 0x0F, 0x40, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x7F, 0x00, 0xFE, 0x0F, 0x80, 0x07, 0x83, 0xE0, 0x00,
  0x60, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE1, 0x80, 0x00, 0x3C, 0x78, 0x00,
  0x0F, 0x9F, 0x80, 0x03, 0xE1, 0xFE, 0x01, 0xFC, 0x1F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0xC0,
  0x3E, 0x00, 0x78, 0x0F, 0x80, 0x7F, 0x03, 0xC0, 0x3F, 0x80, 0xF0, 0x3F,
  0x80, 0x3C, 0x1F, 0xC0, 0x1F, 0x1F, 0xC0, 0x07, 0xCF, 0xE0, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x07, 0xC7, 0x80, 0x01, 0xF1, 0xE0, 0x00, 0x7C, 0xF8, 0x00,
  0x1E, 0x3E, 0x00, 0x07, 0x8F, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0xF8, 0xF0,
  0x00, 0x3E, 0x3C, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0xF1,
  0xF0, 0x00, 0x3C, 0x78, 0x00, 0x1F, 0x1E, 0x00, 0x07, 0xC7, 0x80, 0x01,
  0xF3, 0xE0, 0x00, 0x78, 0xF8, 0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x8F, 0x00,
  0x03, 0xE3, 0xC0, 0x00, 0xF8, 0xF0, 0x00, 0x7E, 0x3C, 0x00, 0x3F, 0x0F,
  0x80, 0x0B, 0xC3, 0xE0, 0x07, 0xF0, 0xF8, 0x03, 0x7C, 0x3F, 0x83, 0xDF,
  0x07, 0xFF, 0xE7, 0x80, 0xFF, 0xF1, 0xE0, 0x1F, 0xF8, 0x78, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x9F, 0xFC, 0x00, 0xFB, 0xFF, 0x80, 0x1F,
  0x7F, 0xF0, 0x01, 0xEF, 0xFC, 0x00, 0x3C, 0x07, 0x80, 0x07, 0xC0, 0xF0,
  0x00, 0xF8, 0x1E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C,
  0x1E, 0x00, 0x0F, 0x83, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x3C, 0x0F, 0x00,
  0x07, 0x81, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0x81,
  0xE0, 0x01, 0xF0, 0x3C, 0x00, 0x7C, 0x07, 0x80, 0x0F, 0x80, 0xF0, 0x03,
  0xE0, 0x3E, 0x00, 0xFC, 0x07, 0xC0, 0x3F, 0x00, 0xF0, 0x0F, 0xC0, 0x1E,
  0x07, 0xF0, 0x03, 0xC7, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x3C, 0x03, 0xC1, 0xE0, 0xF0, 0x0F, 0x07, 0xC3, 0xC0, 0x38, 0x0F, 0x0F,
  0x01, 0xE0, 0x3C, 0x78, 0x07, 0x80, 0xF1, 0xE0, 0x1E, 0x03, 0xC7, 0x80,
  0x78, 0x0F, 0x1E, 0x01, 0xE0, 0x3C, 0x78, 0x0F, 0x00, 0xF1, 0xE0, 0x3C,
  0x03, 0xCF, 0x00, 0xF0, 0x0F, 0x3C, 0x03, 0xC0, 0x3C, 0xF0, 0x0F, 0x00,
  0xF3, 0xC0, 0x3C, 0x03, 0xCF, 0x01, 0xE0, 0x0F, 0x3C, 0x07, 0x80, 0x3D,
  0xE0, 0x1E, 0x01, 0xE7, 0x80, 0x78, 0x07, 0x9E, 0x01, 0xE0, 0x1E, 0x78,
  0x0F, 0x80, 0xF9, 0xE0, 0x3C, 0x03, 0xC7, 0x80, 0xF0, 0x0F, 0x1E, 0x03,
  0xC0, 0x7C, 0xF8, 0x1F, 0x03, 0xE3, 0xE0, 0xFE, 0x0F, 0x87, 0xC7, 0x78,
  0x7C, 0x1F, 0xF9, 0xFF, 0xE0, 0x7F, 0xE3, 0xFF, 0x00, 0xFF, 0x0F, 0xF8,
  0x01, 0xF0, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x7F, 0xC0, 0x0F, 0xFC, 0x3F, 0xF8, 0x07, 0xFF, 0x1F, 0xFE, 0x03, 0xF3,
  0xC7, 0x87, 0xC3, 0xF8, 0xF3, 0xC1, 0xF1, 0xF8, 0x1C, 0xE0, 0x7C, 0xFC,
  0x07, 0x30, 0x0F, 0x0C, 0x01, 0xFC, 0x03, 0xC4, 0x00, 0x7E, 0x00, 0xF0,
  0x00, 0x1F, 0x80, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x07, 0xE0, 0x00, 0x3E, 0x01,
  0xB8, 0x01, 0x0F, 0x80, 0xEE, 0x01, 0xE3, 0xE0, 0x3B, 0x80, 0xF8, 0xF8,
  0x1C, 0xF0, 0x7C, 0x3E, 0x0F, 0x3C, 0x7E, 0x07, 0xC7, 0x8F, 0x3F, 0x01,
  0xFF, 0xE3, 0xFF, 0x80, 0x7F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x1F, 0xC0,
  0x01, 0xF8, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x1E, 0x00, 0x07,
  0xC0, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xE0, 0x7C, 0x00, 0x0F, 0x03,
  0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x3E, 0x07, 0x80,
  0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x78, 0x1F, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x3E, 0x07, 0x80, 0x01, 0xF0, 0x3C, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x78, 0x1F, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x3E, 0x07, 0x80,
  0x01, 0xF0, 0x3C, 0x00, 0x1F, 0x81, 0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x0F,
  0xC0, 0x7C, 0x00, 0xDE, 0x03, 0xF0, 0x0D, 0xF0, 0x1F, 0xC1, 0xEF, 0x80,
  0x7F, 0xFE, 0x7C, 0x01, 0xFF, 0xE3, 0xE0, 0x07, 0xFE, 0x1E, 0x00, 0x0F,
  0xC0, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x08, 0x00, 0x1F, 0x00,
  0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xFE, 0x07, 0xC1, 0xFF, 0xFC, 0x3E, 0x1F, 0xFF, 0xF1,
  0xF0, 0xF8, 0x1F, 0xEF, 0x0F, 0x80, 0x3F, 0xF8, 0x78, 0x00, 0x3F, 0x83,
  0xC0, 0x01, 0xF8, 0x1E, 0x00, 0x1F, 0x80, 0xF0, 0x01, 0xF8, 0x07, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0xE0, 0x03, 0xE0, 0x0F, 0x00, 0x3E,
  0x00, 0x3C, 0x03, 0xE0, 0x01, 0xE0, 0x3E, 0x00, 0x0F, 0x03, 0xE0, 0x00,
  0x7C, 0x3F, 0xE0, 0x01, 0xE3, 0xFF, 0xF8, 0x0F, 0x3E, 0x7F, 0xFC, 0x79,
  0xF0, 0x7F, 0xFF, 0xCF, 0x80, 0x7F, 0xFC, 0x78, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x78, 0x03, 0xC0,
  0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x08, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x20, 0x3F, 0xC0, 0x03, 0xC3, 0xFF, 0x00, 0x1E, 0x3F,
  0xFC, 0x00, 0xF1, 0xF1, 0xF0, 0x0F, 0x1F, 0x07, 0x80, 0x78, 0xF0, 0x3E,
  0x07, 0x8F, 0x00, 0xF0, 0x3C, 0x78, 0x07, 0xC7, 0xC7, 0x80, 0x1F, 0xFE,
  0x3C, 0x00, 0x7F, 0xE1, 0xE0, 0x01, 0xFE, 0x02, 0x00, 0x07, 0xC0, 0x00,
};

const GFXglyph IBMPlexMono_Italic57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 13, 41, 34, 11, -40 },
  { 68, 17, 16, 34, 12, -42 },
  { 102, 34, 40, 34, 1, -40 },
  { 272, 32, 53, 34, 1, -46 },
  { 484, 38, 41, 34, -1, -40 },
  { 679, 34, 41, 34, 0, -40 },
  { 854, 7, 16, 34, 17, -42 },
  { 868, 21, 51, 34, 12, -43 },
  { 1002, 22, 51, 34, 2, -43 },
  { 1143, 29, 28, 34, 3, -31 },
  { 1245, 27, 28, 34, 4, -31 },
  { 1340, 13, 16, 34, 8, -8 },
  { 1366, 17, 4, 34, 9, -19 },
  { 1375, 9, 8, 34, 11, -7 },
  { 1384, 33, 51, 34, 1, -43 },
  { 1595, 28, 41, 34, 4, -40 },
  { 1739, 28, 40, 34, 2, -40 },
  { 1879, 29, 40, 34, 2, -40 },
  { 2024, 30, 41, 34, 1, -40 },
  { 2178, 31, 40, 34, 1, -40 },
  { 2333, 30, 41, 34, 3, -40 },
  { 2487, 28, 41, 34, 3, -40 },
  { 2631, 28, 40, 34, 6, -40 },
  { 2771, 30, 41, 34, 2, -40 },
  { 2925, 27, 40, 34, 5, -40 },
  { 3060, 12, 31, 34, 11, -30 },
  { 3107, 15, 38, 34, 8, -30 },
  { 3179, 27, 33, 34, 5, -34 },
  { 3291, 29, 15, 34, 3, -25 },
  { 3346, 27, 33, 34, 3, -34 },
  { 3458, 25, 41, 34, 7, -40 },
  { 3587, 29, 46, 34, 3, -40 },
  { 3754, 31, 40, 34, -1, -40 },
  { 3909, 29, 40, 34, 3, -40 },
  { 4054, 29, 41, 34, 4, -40 },
  { 4203, 29, 40, 34, 3, -40 },
  { 4348, 31, 40, 34, 3, -40 },
  { 4503, 31, 40, 34, 3, -40 },
  { 4658, 28, 41, 34, 4, -40 },
  { 4802, 32, 40, 34, 2, -40 },
  { 4962, 32, 40, 34, 2, -40 },
  { 5122, 29, 41, 34, 3, -40 },
  { 5271, 35, 40, 34, 2, -40 },
  { 5446, 25, 40, 34, 4, -40 },
  { 5571, 33, 40, 34, 1, -40 },
  { 5736, 32, 40, 34, 2, -40 },
  { 5896, 28, 41, 34, 4, -40 },
  { 6040, 30, 40, 34, 3, -40 },
  { 6190, 28, 51, 34, 4, -40 },
  { 6369, 30, 40, 34, 3, -40 },
  { 6519, 32, 41, 34, 1, -40 },
  { 6683, 32, 40, 34, 5, -40 },
  { 6843, 30, 41, 34, 4, -40 },
  { 6997, 30, 40, 34, 6, -40 },
  { 7147, 33, 40, 34, 3, -40 },
  { 7312, 38, 40, 34, -1, -40 },
  { 7502, 32, 40, 34, 5, -40 },
  { 7662, 35, 40, 34, 0, -40 },
  { 7837, 24, 51, 34, 9, -43 },
  { 7990, 15, 51, 34, 10, -43 },
  { 8086, 24, 51, 34, 1, -43 },
  { 8239, 29, 23, 34, 4, -40 },
  { 8323, 28, 4, 34, 0, 5 },
  { 8337, 7, 11, 34, 13, -44 },
  { 8347, 28, 31, 34, 3, -30 },
  { 8456, 28, 43, 34, 3, -42 },
  { 8607, 26, 31, 34, 4, -30 },
  { 8708, 30, 43, 34, 3, -42 },
  { 8870, 26, 31, 34, 4, -30 },
  { 8971, 38, 54, 34, -1, -42 },
  { 9228, 29, 42, 34, 2, -30 },
  { 9381, 27, 42, 34, 3, -42 },
  { 9523, 26, 44, 34, 5, -43 },
  { 9666, 27, 55, 34, 3, -43 },
  { 9852, 29, 43, 34, 3, -42 },
  { 10008, 24, 43, 34, 6, -42 },
  { 10137, 31, 30, 34, 1, -30 },
  { 10254, 27, 30, 34, 3, -30 },
  { 10356, 27, 31, 34, 4, -30 },
  { 10461, 30, 41, 34, 1, -30 },
  { 10615, 28, 41, 34, 3, -30 },
  { 10759, 28, 29, 34, 6, -29 },
  { 10861, 27, 31, 34, 3, -30 },
  { 10966, 26, 41, 34, 4, -40 },
  { 11100, 26, 30, 34, 5, -29 },
  { 11198, 27, 30, 34, 4, -30 },
  { 11300, 30, 31, 34, 2, -30 },
  { 11417, 34, 31, 34, 0, -30 },
  { 11549, 29, 41, 34, 2, -29 },
  { 11698, 29, 31, 34, 3, -30 },
  { 11811, 27, 51, 34, 6, -43 },
  { 11984, 13, 51, 34, 11, -43 },
  { 12067, 27, 51, 34, 2, -43 },
  { 12240, 29, 13, 34, 3, -24 },
};

const GFXfont IBMPlexMono_Italic57pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic57pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic57pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _IBMPLEXMONO_ITALIC57PT7B_H_
