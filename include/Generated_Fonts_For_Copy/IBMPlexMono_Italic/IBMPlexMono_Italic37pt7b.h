#ifndef _IBMPLEXMONO_ITALIC37PT7B_H_
#define _IBMPLEXMONO_ITALIC37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x07, 0x07, 0x07, 0x0F, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x0C,
  0x0C, 0x0C, 0x08, 0x08, 0x18, 0x18, 0x00, 0x00, 0x00, 0x00, 0x78, 0xFC,
  0xFC, 0xF8, 0x78, 0x70, 0xEE, 0x19, 0xC3, 0x38, 0xE7, 0x1C, 0xC3, 0xB8,
  0x77, 0x0C, 0xE1, 0x9C, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x60, 0x00,
  0xE1, 0xC0, 0x01, 0xC3, 0x00, 0x03, 0x86, 0x00, 0x0E, 0x1C, 0x00, 0x1C,
  0x30, 0x0F, 0xF0, 0x7F, 0x1F, 0xE1, 0xFE, 0x3F, 0xC3, 0xFC, 0x03, 0x06,
  0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x30, 0x60, 0x00, 0xE1, 0xC0,
  0x01, 0xC3, 0x80, 0x7F, 0x07, 0xF0, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0xC0,
  0x30, 0x70, 0x00, 0x61, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x0E, 0x00, 0x0E,
  0x1C, 0x00, 0x1C, 0x38, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xE0,
  0x1F, 0xFF, 0x81, 0xF3, 0x3E, 0x1E, 0x18, 0x78, 0xE0, 0xC1, 0x87, 0x06,
  0x00, 0x38, 0x70, 0x01, 0xC3, 0x00, 0x0F, 0x18, 0x00, 0x7C, 0xC0, 0x01,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xC7,
  0x80, 0x06, 0x1E, 0x00, 0x30, 0x70, 0x03, 0x83, 0x88, 0x1C, 0x3C, 0x60,
  0xC1, 0xC7, 0x86, 0x1E, 0x1F, 0x33, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0,
  0x03, 0xFC, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0xF0, 0x03, 0x81, 0xFC, 0x01, 0x81, 0xFF, 0x01, 0xC1,
  0xE1, 0x81, 0xC0, 0xE0, 0xE1, 0xC0, 0x60, 0x70, 0xC0, 0x70, 0x38, 0xE0,
  0x38, 0x18, 0xE0, 0x1C, 0x1C, 0x60, 0x0E, 0x1E, 0x70, 0x03, 0xFE, 0x70,
  0x01, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0xE0, 0x03, 0xDF, 0xF8, 0x01, 0x8E, 0x1C, 0x01, 0xCE, 0x06, 0x01, 0xC7,
  0x03, 0x00, 0xC3, 0x03, 0x80, 0xE1, 0x81, 0xC0, 0xE0, 0xC0, 0xE0, 0x60,
  0x70, 0xE0, 0x70, 0x3F, 0xE0, 0x70, 0x0F, 0xF0, 0x70, 0x03, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xF0, 0xF0, 0x03,
  0x81, 0xC0, 0x1C, 0x07, 0x00, 0x70, 0x1C, 0x00, 0xC0, 0x70, 0x03, 0x81,
  0xC0, 0x0E, 0x07, 0x00, 0x1C, 0x38, 0x00, 0xF3, 0xE0, 0x1F, 0xFE, 0x00,
  0xFB, 0xF0, 0x07, 0x8E, 0x00, 0x1C, 0x1C, 0x00, 0xE0, 0x78, 0x03, 0x80,
  0xE0, 0x0E, 0x01, 0xC1, 0x38, 0x07, 0x06, 0xE0, 0x1E, 0x3F, 0xC0, 0xF8,
  0xE7, 0x06, 0x77, 0x1F, 0xF9, 0xFC, 0x3F, 0xC3, 0xE0, 0x7E, 0x07, 0x00,
  0x37, 0x77, 0x77, 0x6E, 0xEE, 0x00, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x03, 0x00, 0x38, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0,
  0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0F, 0x00, 0x07,
  0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x06,
  0x00, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01,
  0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x1C, 0x38, 0x3F, 0xF7, 0x7F,
  0x3F, 0xFF, 0x81, 0xFF, 0x80, 0x07, 0x80, 0x01, 0xF8, 0x00, 0x77, 0x00,
  0x1E, 0x70, 0x07, 0x8E, 0x01, 0xE0, 0xE0, 0x38, 0x0E, 0x0E, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF,
  0xFE, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0F, 0x1F, 0x1E, 0x3C, 0x3C,
  0x38, 0x78, 0x70, 0x60, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7B, 0xFF,
  0xFE, 0x78, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x1F, 0xFF,
  0x07, 0xC1, 0xE0, 0xE0, 0x1E, 0x38, 0x01, 0xCF, 0x00, 0x39, 0xC0, 0x07,
  0x38, 0x00, 0xEF, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x78, 0x77, 0x1F, 0x0E,
  0xE3, 0xE3, 0xFC, 0x38, 0x77, 0x00, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x3B,
  0x80, 0x0E, 0x70, 0x01, 0xC7, 0x00, 0x70, 0xE0, 0x1E, 0x1E, 0x0F, 0x81,
  0xFF, 0xE0, 0x1F, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0xFB, 0x80, 0xF9, 0xC0, 0xF9, 0xC0, 0xF8, 0xE0, 0x78, 0x70,
  0x38, 0x38, 0x08, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x81, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xC1,
  0xF0, 0xF0, 0x1E, 0x3C, 0x01, 0xC7, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xFF, 0xFE,
  0xFF, 0xFF, 0x9F, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x0F, 0xFF,
  0x03, 0xC1, 0xF0, 0xF0, 0x0E, 0x0C, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0xFF, 0x80, 0x1F, 0x80,
  0x03, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x01, 0xE6, 0x00, 0x39, 0xE0, 0x0F, 0x1E, 0x07, 0xC1,
  0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1D, 0xC0, 0x03, 0x9C, 0x00, 0x71,
  0xC0, 0x07, 0x18, 0x00, 0xE3, 0x80, 0x1C, 0x38, 0x03, 0x83, 0x80, 0x70,
  0x38, 0x06, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x07, 0x03, 0x80, 0x70, 0x70,
  0x07, 0x06, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x87, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x1F, 0x80,
  0x6F, 0xF8, 0x1F, 0xFF, 0x83, 0xE0, 0xF8, 0x70, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC6,
  0x00, 0x79, 0xE0, 0x1E, 0x1E, 0x07, 0x83, 0xFF, 0xE0, 0x1F, 0xF8, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x3F,
  0x03, 0x9F, 0xF0, 0xEF, 0xFE, 0x76, 0x07, 0x9E, 0x00, 0xE7, 0x80, 0x3F,
  0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3B, 0x80, 0x0E, 0xF0,
  0x07, 0x9C, 0x03, 0xC7, 0x81, 0xE0, 0xFF, 0xF8, 0x1F, 0xF8, 0x03, 0xF8,
  0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0x80, 0x0E, 0xE0, 0x03,
  0xB8, 0x01, 0xCE, 0x00, 0xF3, 0x80, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0x81, 0xF1, 0xE0, 0x1E,
  0x38, 0x01, 0xCF, 0x00, 0x39, 0xC0, 0x07, 0x18, 0x01, 0xC3, 0x80, 0x38,
  0x78, 0x1E, 0x07, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xFC, 0x0F, 0x01, 0xE3,
  0x80, 0x1C, 0xF0, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x01, 0xEE,
  0x00, 0x39, 0xC0, 0x0F, 0x3E, 0x07, 0xC3, 0xFF, 0xF0, 0x3F, 0xFC, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x78, 0x1E, 0x3C,
  0x03, 0x9E, 0x00, 0xF7, 0x00, 0x1D, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0xC0, 0x1E, 0x70, 0x07, 0x9E, 0x06, 0xE7, 0xFF, 0x70,
  0xFF, 0x9C, 0x0F, 0xCE, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x1F, 0x1F, 0x1F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x78, 0xFC, 0xFC, 0xF8, 0x78, 0x03, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x1F, 0x07, 0x83, 0xC0, 0xF0, 0x38, 0x1E,
  0x07, 0x01, 0x80, 0xE0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x02, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFE, 0x00, 0x10, 0x00, 0x07, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x18, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x03, 0x80, 0x00, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xF8,
  0x3F, 0xFC, 0x7C, 0x1E, 0x70, 0x0E, 0xE0, 0x0F, 0xE0, 0x0F, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x07, 0xF0, 0x0F, 0xC0,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x3C, 0x00,
  0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xC1, 0xE1, 0xE0, 0x1C,
  0x38, 0x01, 0xC7, 0x00, 0x39, 0xC1, 0xE7, 0x38, 0x7E, 0xE6, 0x1F, 0xDD,
  0xC7, 0x87, 0x38, 0xE0, 0xE7, 0x1C, 0x1C, 0xE7, 0x03, 0x98, 0xE0, 0x77,
  0x1C, 0x0E, 0xE3, 0x81, 0x9C, 0x70, 0x73, 0x8E, 0x0E, 0x71, 0xC3, 0xCE,
  0x3F, 0xF9, 0xC3, 0xF7, 0x38, 0x7C, 0xC7, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xB0, 0x00, 0x3B,
  0x80, 0x07, 0x38, 0x00, 0x73, 0x80, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x1C,
  0x38, 0x01, 0xC3, 0x80, 0x38, 0x1C, 0x03, 0x81, 0xC0, 0x38, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1,
  0xC0, 0x1E, 0x3C, 0x00, 0xE3, 0x80, 0x0E, 0x78, 0x00, 0xE7, 0x00, 0x0E,
  0xF0, 0x00, 0xEE, 0x00, 0x0F, 0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFF,
  0x0E, 0x01, 0xE1, 0xC0, 0x1C, 0x38, 0x03, 0xC7, 0x00, 0x78, 0xE0, 0x0E,
  0x1C, 0x01, 0xC7, 0x00, 0x78, 0xE0, 0x1E, 0x1F, 0xFF, 0x83, 0xFF, 0xC0,
  0x7F, 0xFE, 0x0E, 0x01, 0xE3, 0x80, 0x1C, 0x70, 0x03, 0xCE, 0x00, 0x79,
  0xC0, 0x0F, 0x38, 0x01, 0xC7, 0x00, 0x39, 0xC0, 0x0F, 0x38, 0x03, 0xC7,
  0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xE0,
  0x1F, 0xFE, 0x07, 0xC3, 0xE1, 0xE0, 0x1C, 0x38, 0x03, 0x8E, 0x00, 0x39,
  0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x0C, 0x70, 0x03, 0xCE, 0x00, 0x70, 0xE0, 0x1C, 0x1E,
  0x0F, 0x81, 0xFF, 0xE0, 0x1F, 0xF8, 0x01, 0xFC, 0x00, 0x0F, 0xFC, 0x01,
  0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0x03, 0xE0, 0xE0, 0x1C, 0x3C, 0x03, 0xC7,
  0x00, 0x38, 0xE0, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x03, 0x9C,
  0x00, 0x73, 0x80, 0x1E, 0x70, 0x03, 0xCE, 0x00, 0x71, 0xC0, 0x0E, 0x38,
  0x01, 0xCE, 0x00, 0x79, 0xC0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x70, 0xE0,
  0x1E, 0x1C, 0x0F, 0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF1, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x38, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF1,
  0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xFF, 0xF8, 0x3F, 0xFF,
  0x83, 0xFF, 0xF8, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x3F, 0xF0, 0x1F, 0xFE, 0x03, 0xC1, 0xE0, 0xF0, 0x1E, 0x3C, 0x01, 0xC7,
  0x00, 0x31, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x7F, 0x9C, 0x1F, 0xF7, 0x83, 0xFC, 0xF0,
  0x01, 0x9E, 0x00, 0x73, 0xC0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x78, 0xF0,
  0x1F, 0x1F, 0x07, 0xC1, 0xFF, 0xB8, 0x1F, 0xE7, 0x01, 0xF8, 0xE0, 0x07,
  0x00, 0x38, 0x78, 0x01, 0xC3, 0x80, 0x1E, 0x1C, 0x00, 0xE0, 0xE0, 0x07,
  0x07, 0x00, 0x38, 0x38, 0x01, 0xC3, 0xC0, 0x0E, 0x1C, 0x00, 0xF0, 0xE0,
  0x07, 0x07, 0x00, 0x38, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0,
  0xE0, 0x07, 0x87, 0x00, 0x38, 0x38, 0x01, 0xC1, 0xC0, 0x0E, 0x0E, 0x00,
  0x70, 0xF0, 0x03, 0x87, 0x00, 0x3C, 0x38, 0x01, 0xC1, 0xC0, 0x0E, 0x0E,
  0x00, 0x70, 0x70, 0x03, 0x87, 0x80, 0x1C, 0x00, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF0, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE1, 0x80, 0x38, 0xE0, 0x0E,
  0x3C, 0x07, 0x87, 0x83, 0xC0, 0xFF, 0xE0, 0x1F, 0xF0, 0x03, 0xF0, 0x00,
  0x0E, 0x00, 0x3C, 0x38, 0x01, 0xC1, 0xE0, 0x0E, 0x07, 0x00, 0x70, 0x1C,
  0x03, 0x80, 0x70, 0x1C, 0x01, 0xC0, 0xE0, 0x07, 0x07, 0x00, 0x3C, 0x38,
  0x00, 0xE1, 0xC0, 0x03, 0x8E, 0x00, 0x0E, 0x78, 0x00, 0x3B, 0xF0, 0x00,
  0xFD, 0xC0, 0x07, 0xE7, 0x00, 0x1F, 0x0E, 0x00, 0x78, 0x38, 0x01, 0xC0,
  0x70, 0x07, 0x01, 0xC0, 0x1C, 0x07, 0x80, 0xF0, 0x0E, 0x03, 0x80, 0x3C,
  0x0E, 0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0, 0x03, 0x83, 0x80, 0x0F, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFE, 0x0F, 0x00, 0x78, 0x78, 0x03, 0xC3, 0xE0, 0x3E,
  0x1F, 0x03, 0xF0, 0xF8, 0x1F, 0x8E, 0xC1, 0xD8, 0x77, 0x0E, 0xC3, 0xB8,
  0xEE, 0x1D, 0xC6, 0x70, 0xC6, 0x73, 0x86, 0x33, 0x1C, 0x71, 0xF8, 0xC3,
  0x8F, 0x86, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x86, 0x0C, 0x1C, 0x30, 0x60,
  0xE3, 0x82, 0x06, 0x1C, 0x00, 0x30, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x30,
  0x00, 0xE1, 0x80, 0x07, 0x1C, 0x00, 0x30, 0xE0, 0x01, 0x87, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x38, 0x7E, 0x01, 0xC3, 0xF0, 0x0E, 0x1F, 0x80, 0xE0,
  0xFC, 0x07, 0x07, 0x60, 0x38, 0x3B, 0x81, 0xC3, 0x9C, 0x0E, 0x1C, 0xE0,
  0x70, 0xE3, 0x07, 0x07, 0x18, 0x38, 0x38, 0xE1, 0xC1, 0xC7, 0x0E, 0x1C,
  0x38, 0x70, 0xE0, 0xC3, 0x87, 0x07, 0x38, 0x38, 0x39, 0xC1, 0xC1, 0xCE,
  0x0E, 0x06, 0x70, 0xE0, 0x33, 0x87, 0x01, 0xDC, 0x38, 0x0E, 0xC1, 0xC0,
  0x7E, 0x0E, 0x01, 0xF0, 0x70, 0x0F, 0x87, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x07, 0xC1, 0xE0, 0xE0, 0x1E, 0x38, 0x01,
  0xCF, 0x00, 0x39, 0xC0, 0x07, 0x38, 0x00, 0xEF, 0x00, 0x1D, 0xC0, 0x03,
  0xB8, 0x00, 0x77, 0x00, 0x0E, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0E,
  0xE0, 0x01, 0xDC, 0x00, 0x7B, 0x80, 0x0E, 0x70, 0x01, 0xC7, 0x00, 0x70,
  0xE0, 0x1E, 0x1E, 0x0F, 0x81, 0xFF, 0xE0, 0x1F, 0xF8, 0x01, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE1, 0xE0, 0x1E, 0x1C, 0x00,
  0xE1, 0xC0, 0x0F, 0x1C, 0x00, 0xF1, 0xC0, 0x0F, 0x1C, 0x00, 0xE3, 0xC0,
  0x0E, 0x38, 0x01, 0xE3, 0x80, 0x3C, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F,
  0xFC, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x1F, 0xFF,
  0x07, 0xC1, 0xE0, 0xE0, 0x1E, 0x38, 0x01, 0xCF, 0x00, 0x39, 0xC0, 0x07,
  0x38, 0x00, 0xEF, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x0E,
  0xE0, 0x03, 0xFC, 0x00, 0x77, 0x00, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x7B,
  0x80, 0x0E, 0x70, 0x01, 0xC7, 0x00, 0x70, 0xE0, 0x1E, 0x1E, 0x0F, 0x81,
  0xFF, 0xE0, 0x1F, 0xF8, 0x01, 0xFC, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x40,
  0x0E, 0x1C, 0x00, 0xEF, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x1C, 0x00,
  0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE1, 0xE0, 0x1E, 0x1C, 0x00,
  0xE1, 0xC0, 0x0F, 0x1C, 0x00, 0xF1, 0xC0, 0x0F, 0x1C, 0x00, 0xE3, 0xC0,
  0x0E, 0x38, 0x01, 0xE3, 0x80, 0x3C, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F,
  0xFC, 0x07, 0x87, 0x00, 0x70, 0x78, 0x07, 0x03, 0x80, 0x70, 0x38, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x0F, 0x01, 0xE0, 0xE0, 0x0E, 0x0E, 0x00, 0xE0,
  0xE0, 0x07, 0x0E, 0x00, 0x78, 0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x01, 0xFF,
  0xF8, 0x1F, 0x03, 0xE1, 0xE0, 0x07, 0x0E, 0x00, 0x14, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x80, 0x03, 0xC6, 0x00, 0x1C,
  0x78, 0x01, 0xE1, 0xF0, 0x3E, 0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0xE7, 0x00, 0x1C, 0xE0, 0x07, 0x9C, 0x00, 0xE3, 0x80, 0x1C, 0x70,
  0x03, 0x8E, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x03, 0x8E, 0x00, 0x71, 0xC0,
  0x0E, 0x38, 0x01, 0xC7, 0x00, 0x39, 0xC0, 0x07, 0x38, 0x01, 0xC7, 0x00,
  0x38, 0xE0, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x07, 0x0E, 0x00,
  0xE1, 0xC0, 0x3C, 0x3C, 0x0F, 0x03, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFC,
  0x00, 0xE0, 0x00, 0xFE, 0x00, 0x0E, 0xE0, 0x01, 0xCE, 0x00, 0x1C, 0x60,
  0x03, 0x87, 0x00, 0x38, 0x70, 0x07, 0x87, 0x00, 0x70, 0x70, 0x07, 0x07,
  0x00, 0xE0, 0x70, 0x0E, 0x03, 0x01, 0xC0, 0x30, 0x1C, 0x03, 0x83, 0x80,
  0x38, 0x38, 0x03, 0x87, 0x00, 0x38, 0x70, 0x03, 0x8E, 0x00, 0x38, 0xE0,
  0x01, 0x8E, 0x00, 0x1D, 0xC0, 0x01, 0xDC, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0xE3,
  0x00, 0x03, 0x8C, 0x00, 0x0E, 0x30, 0x00, 0x31, 0xC0, 0x01, 0xC7, 0x00,
  0x07, 0x1C, 0x1C, 0x1C, 0x70, 0xF0, 0x71, 0xC3, 0xC1, 0x87, 0x0F, 0x0E,
  0x1C, 0x7E, 0x38, 0x71, 0xB8, 0xE1, 0x8E, 0xE3, 0x06, 0x33, 0x9C, 0x18,
  0xCE, 0x70, 0x67, 0x39, 0xC3, 0x98, 0xE6, 0x0E, 0xE3, 0xB8, 0x3B, 0x86,
  0xE0, 0xEC, 0x1B, 0x83, 0xF0, 0x6C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x80, 0x07, 0x81, 0xC0, 0x07,
  0x80, 0xF0, 0x07, 0x80, 0x38, 0x07, 0x80, 0x1E, 0x03, 0x80, 0x07, 0x03,
  0x80, 0x03, 0x83, 0xC0, 0x00, 0xE3, 0xC0, 0x00, 0x71, 0xC0, 0x00, 0x1D,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0xF1, 0xC0, 0x00, 0xF0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x70, 0x1C, 0x00,
  0x70, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x78, 0x01, 0xE0, 0x38, 0x00, 0x70,
  0x78, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x7B, 0x80, 0x03, 0x9E, 0x00, 0x38,
  0x70, 0x03, 0xC3, 0x80, 0x3C, 0x0E, 0x01, 0xC0, 0x70, 0x1E, 0x03, 0x81,
  0xE0, 0x0E, 0x0E, 0x00, 0x70, 0xE0, 0x01, 0xCF, 0x00, 0x0E, 0x70, 0x00,
  0x77, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0xC0, 0x60,
  0x38, 0x0C, 0x06, 0x03, 0x01, 0xC0, 0xE0, 0x30, 0x18, 0x0C, 0x07, 0x01,
  0x80, 0xC0, 0x60, 0x38, 0x1C, 0x06, 0x03, 0x01, 0x80, 0xE0, 0x30, 0x18,
  0x0C, 0x07, 0x03, 0x80, 0xC0, 0x60, 0x30, 0x1C, 0x06, 0x03, 0x01, 0x80,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60,
  0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01,
  0xF8, 0x00, 0x77, 0x00, 0x1C, 0x60, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x38,
  0x1C, 0x0E, 0x03, 0x83, 0xC0, 0x30, 0x70, 0x07, 0x1C, 0x00, 0xE7, 0x00,
  0x0E, 0xE0, 0x01, 0xE8, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x67, 0x9C, 0x63, 0x8C, 0x60, 0x03, 0xF1, 0xC3, 0xFE, 0x71, 0xFF,
  0xDC, 0xF8, 0x36, 0x3C, 0x03, 0x9E, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x0E,
  0xF0, 0x03, 0xB8, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x0F, 0x38,
  0x03, 0xCF, 0x01, 0x61, 0xE1, 0xF8, 0x7F, 0xEF, 0xCF, 0xF1, 0xF1, 0xF8,
  0x78, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x3E, 0x07, 0x3F, 0xC1,
  0xDF, 0xF8, 0x7E, 0x1F, 0x3A, 0x01, 0xCF, 0x00, 0x73, 0x80, 0x1C, 0xE0,
  0x07, 0x38, 0x01, 0xCC, 0x00, 0x77, 0x00, 0x1D, 0xC0, 0x0F, 0x70, 0x03,
  0x9C, 0x01, 0xE7, 0x00, 0x71, 0xB0, 0x7C, 0xEF, 0xFE, 0x39, 0xFF, 0x0E,
  0x3F, 0x00, 0x01, 0xF0, 0x0F, 0xFC, 0x1F, 0xFE, 0x3E, 0x0F, 0x38, 0x07,
  0x70, 0x02, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x04, 0xE0, 0x07, 0xE0, 0x0E, 0xE0, 0x1E, 0x78, 0x3C, 0x7F, 0xF8,
  0x3F, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x03, 0xF1, 0xC0, 0xFF, 0x9C, 0x1F, 0xFD, 0xC3, 0xE0, 0x5C, 0x3C, 0x03,
  0xC7, 0x80, 0x38, 0x70, 0x03, 0x87, 0x00, 0x38, 0xF0, 0x03, 0x8E, 0x00,
  0x38, 0xE0, 0x03, 0x8E, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0xF0, 0xF0,
  0x1F, 0x07, 0x87, 0x70, 0x7F, 0xE7, 0x03, 0xFC, 0xE0, 0x1F, 0x8E, 0x00,
  0x01, 0xF8, 0x03, 0xFF, 0x07, 0xFF, 0xC7, 0xC0, 0xE3, 0x80, 0x3B, 0x80,
  0x1D, 0x80, 0x1D, 0xC0, 0xFE, 0xFF, 0xFE, 0x7F, 0xFC, 0x3F, 0xE0, 0x1C,
  0x00, 0x0E, 0x00, 0x47, 0x00, 0x3B, 0x80, 0x38, 0xF0, 0x7C, 0x7F, 0xFC,
  0x1F, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x10,
  0x1C, 0x00, 0x1C, 0x0C, 0x00, 0x1F, 0x0E, 0x00, 0x07, 0xC7, 0x00, 0x01,
  0xF3, 0x80, 0x00, 0x7D, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0xE0, 0xFF, 0x9C, 0x3F, 0xFB, 0x87,
  0x81, 0x71, 0xE0, 0x1C, 0x78, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x0E, 0x78,
  0x01, 0xCE, 0x00, 0x39, 0xC0, 0x06, 0x38, 0x01, 0xC7, 0x00, 0x38, 0xE0,
  0x0F, 0x1E, 0x03, 0xE1, 0xE0, 0xDC, 0x3F, 0xF3, 0x03, 0xFC, 0xE0, 0x3F,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x40, 0x1C, 0x1C, 0x0F, 0x87, 0xFF,
  0xE0, 0x3F, 0xF0, 0x03, 0xF8, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C,
  0x3E, 0x0E, 0x7F, 0x87, 0x7F, 0xE3, 0xB0, 0xF1, 0xE0, 0x39, 0xF0, 0x1C,
  0xF0, 0x0E, 0x70, 0x07, 0x38, 0x03, 0x9C, 0x01, 0xCE, 0x00, 0xEE, 0x00,
  0xE7, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x1C, 0xE0, 0x0E, 0x70, 0x07, 0x70,
  0x07, 0x38, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x40, 0xE0, 0xE0, 0x70,
  0xF8, 0x38, 0xF0, 0x18, 0xF0, 0x1C, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x10, 0x0E,
  0x06, 0x07, 0x03, 0xC1, 0xC0, 0x78, 0x70, 0x0F, 0x1C, 0x01, 0xE7, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x1C, 0x3E, 0x03, 0x9F, 0xE0, 0x77, 0xFE, 0x0E, 0xC3, 0xC1,
  0xE0, 0x38, 0x7C, 0x07, 0x0F, 0x00, 0xE1, 0xC0, 0x38, 0x38, 0x0F, 0x07,
  0x0F, 0x80, 0xEF, 0xC0, 0x38, 0xE0, 0x07, 0x1C, 0x04, 0xE1, 0xC1, 0xDC,
  0x38, 0xFB, 0x83, 0xBE, 0x70, 0x7F, 0x1C, 0x07, 0xC3, 0x80, 0xF0, 0x00,
  0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x10,
  0xE0, 0x71, 0xC1, 0xE3, 0x8F, 0x87, 0x3E, 0x0C, 0xF0, 0x3F, 0xC0, 0x3F,
  0x00, 0x78, 0x00, 0x0C, 0xF0, 0xF0, 0xEF, 0xCF, 0xC7, 0x7E, 0xFE, 0x3C,
  0x7C, 0x71, 0xC1, 0xC3, 0x8E, 0x0E, 0x1C, 0x60, 0xE0, 0xE7, 0x07, 0x07,
  0x38, 0x38, 0x31, 0xC1, 0xC1, 0x8E, 0x0C, 0x1C, 0x60, 0x60, 0xE3, 0x07,
  0x07, 0x38, 0x38, 0x31, 0xC1, 0xC1, 0x8E, 0x0C, 0x1C, 0x70, 0x60, 0xE3,
  0x07, 0x07, 0x38, 0x38, 0x38, 0x1C, 0x3E, 0x0E, 0x7F, 0x87, 0x7F, 0xE3,
  0xB0, 0xF1, 0xE0, 0x39, 0xF0, 0x1C, 0xF0, 0x0E, 0x70, 0x07, 0x38, 0x03,
  0x9C, 0x01, 0xCE, 0x00, 0xEE, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x39, 0xC0,
  0x1C, 0xE0, 0x0E, 0x70, 0x07, 0x70, 0x07, 0x38, 0x03, 0x80, 0x01, 0xF8,
  0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7C, 0x1E, 0x3C, 0x03, 0x8E, 0x00, 0x77,
  0x00, 0x1D, 0xC0, 0x07, 0x70, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x0E, 0xE0, 0x03, 0x9C, 0x01, 0xE7, 0x00, 0xF1, 0xE0, 0x78, 0x3F, 0xFC,
  0x07, 0xFE, 0x00, 0x7E, 0x00, 0x0E, 0x1F, 0x01, 0xCF, 0xF0, 0x3B, 0xFF,
  0x07, 0xE1, 0xF1, 0xD0, 0x0E, 0x3C, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x07,
  0x1C, 0x00, 0xE7, 0x00, 0x1C, 0xE0, 0x03, 0x9C, 0x00, 0xF3, 0x80, 0x1C,
  0x70, 0x07, 0x8E, 0x00, 0xE3, 0xB0, 0x7C, 0x77, 0xFF, 0x0E, 0x7F, 0xC1,
  0xC7, 0xE0, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xF1, 0xC3, 0xFE, 0x71,
  0xFF, 0xDC, 0xF8, 0x17, 0x3C, 0x03, 0x9E, 0x00, 0xE7, 0x00, 0x39, 0xC0,
  0x0E, 0xF0, 0x03, 0xB8, 0x00, 0xEE, 0x00, 0x33, 0x80, 0x1C, 0xE0, 0x07,
  0x38, 0x03, 0xCF, 0x01, 0x71, 0xE1, 0xDC, 0x7F, 0xEE, 0x0F, 0xF3, 0x81,
  0xF8, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xF3,
  0xF8, 0x1D, 0x80, 0x07, 0x40, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x78, 0x0F, 0x1C, 0x01,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF0, 0x00, 0x3C, 0x00, 0x03, 0x00, 0x00, 0xC6, 0x00, 0x73, 0xE0,
  0x3C, 0x7F, 0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0x81, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x81, 0xC1, 0xE1, 0xC1, 0xF0, 0xE3, 0xF0, 0x77, 0xE0, 0x3F, 0xC0, 0x1F,
  0xC0, 0x07, 0x80, 0x00, 0x38, 0x03, 0x9C, 0x01, 0xCE, 0x00, 0xE6, 0x00,
  0x77, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x1C, 0xE0, 0x0E, 0x70, 0x07, 0x30,
  0x07, 0xB8, 0x03, 0x9C, 0x01, 0xCE, 0x01, 0xE7, 0x01, 0x73, 0x80, 0xB9,
  0xE1, 0xBC, 0x7F, 0xDC, 0x3F, 0xCE, 0x07, 0xC7, 0x00, 0x7F, 0x01, 0x9F,
  0xC0, 0xEF, 0xE0, 0x1C, 0x38, 0x07, 0x0E, 0x01, 0xC3, 0x80, 0x70, 0xE0,
  0x1C, 0x38, 0x07, 0x0C, 0x01, 0xC7, 0x00, 0xE1, 0xC0, 0x38, 0x70, 0x1E,
  0x1C, 0x0F, 0x07, 0x07, 0x81, 0x83, 0xE0, 0x63, 0xF0, 0x3F, 0xF0, 0x07,
  0xF8, 0x01, 0xF8, 0x00, 0x38, 0x30, 0xC6, 0x0E, 0x1C, 0xC1, 0xC3, 0xB8,
  0x38, 0x77, 0x06, 0x0E, 0xE0, 0xC1, 0xD8, 0x38, 0x3B, 0x07, 0x07, 0x60,
  0xE0, 0xFC, 0x1C, 0x1F, 0x83, 0x03, 0x70, 0x60, 0xEC, 0x1C, 0x1D, 0x83,
  0x83, 0xB0, 0xF0, 0xE7, 0x36, 0x3C, 0xFE, 0xFF, 0x1F, 0x9F, 0xC1, 0xE1,
  0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x0F, 0x87, 0xE0, 0x7F, 0x3F, 0xC7, 0xDD,
  0xC7, 0x3C, 0x36, 0x1C, 0xE0, 0xF0, 0x72, 0x03, 0xC1, 0xC0, 0x0E, 0x07,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x38, 0x1C, 0x00, 0xE0,
  0x70, 0x23, 0x83, 0xE1, 0xCE, 0x1B, 0x8F, 0x3C, 0xEE, 0xF0, 0x7F, 0xBF,
  0x81, 0xFC, 0x7C, 0x03, 0xC1, 0xE0, 0x00, 0x0E, 0x00, 0xE1, 0xC0, 0x1C,
  0x38, 0x03, 0x87, 0x00, 0x61, 0xC0, 0x1C, 0x38, 0x03, 0x87, 0x00, 0x70,
  0xE0, 0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x30, 0xE0, 0x0E, 0x1C, 0x01, 0xC3,
  0x80, 0x78, 0x70, 0x0F, 0x0F, 0x02, 0xE1, 0xE1, 0xF8, 0x1F, 0xF7, 0x03,
  0xFC, 0xE0, 0x1F, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x80, 0x3C, 0x3C,
  0x0F, 0x07, 0xFF, 0xE0, 0x7F, 0xF0, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0xE3,
  0xFF, 0x9C, 0x7F, 0xFF, 0x1C, 0x1F, 0xE3, 0x80, 0x78, 0x60, 0x0E, 0x0C,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0x81, 0x80, 0xE0, 0x38, 0x78, 0x07, 0x1F, 0x80, 0x67, 0xFF, 0x8C, 0xEF,
  0xFF, 0x9C, 0x3F, 0xF3, 0x80, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0xC0,
  0x7F, 0xE0, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x07, 0x81, 0xFF, 0x80, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x7F,
  0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0x03, 0x03, 0x03, 0x07, 0x07, 0x07,
  0x06, 0x06, 0x06, 0x0E, 0x0E, 0x0E, 0x0C, 0x0C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x18, 0x18, 0x38, 0x38, 0x38, 0x38, 0x30, 0x30, 0x70, 0x70, 0x70, 0x70,
  0x60, 0x60, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01,
  0xFF, 0x00, 0x3F, 0x80, 0xFF, 0xC0, 0xF0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0x00, 0x43, 0xF0, 0x1C, 0xFF, 0x03, 0xBC, 0xE0, 0xE7,
  0x0E, 0x1C, 0xC1, 0xE7, 0x38, 0x1F, 0xE6, 0x01, 0xF8, 0xC0, 0x1E, 0x00,
};

const GFXglyph IBMPlexMono_Italic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 8, 26, 22, 7, -26 },
  { 27, 11, 10, 22, 8, -27 },
  { 41, 23, 26, 22, 0, -26 },
  { 116, 21, 34, 22, 1, -30 },
  { 206, 25, 26, 22, -1, -26 },
  { 288, 22, 26, 22, 0, -26 },
  { 360, 4, 10, 22, 11, -27 },
  { 365, 13, 33, 22, 8, -28 },
  { 419, 13, 33, 22, 2, -28 },
  { 473, 19, 18, 22, 2, -20 },
  { 516, 18, 19, 22, 2, -21 },
  { 559, 8, 10, 22, 5, -5 },
  { 569, 11, 3, 22, 6, -13 },
  { 574, 6, 5, 22, 7, -5 },
  { 578, 21, 33, 22, 1, -28 },
  { 665, 19, 26, 22, 2, -26 },
  { 727, 17, 26, 22, 2, -26 },
  { 783, 19, 26, 22, 1, -26 },
  { 845, 19, 26, 22, 1, -26 },
  { 907, 20, 26, 22, 1, -26 },
  { 972, 19, 26, 22, 2, -26 },
  { 1034, 18, 26, 22, 2, -26 },
  { 1093, 18, 26, 22, 4, -26 },
  { 1152, 19, 26, 22, 2, -26 },
  { 1214, 18, 26, 22, 3, -26 },
  { 1273, 8, 20, 22, 7, -20 },
  { 1293, 10, 25, 22, 5, -20 },
  { 1325, 18, 21, 22, 3, -22 },
  { 1373, 19, 11, 22, 2, -17 },
  { 1400, 18, 21, 22, 2, -22 },
  { 1448, 16, 26, 22, 5, -26 },
  { 1500, 19, 30, 22, 2, -26 },
  { 1572, 20, 26, 22, 0, -26 },
  { 1637, 19, 26, 22, 2, -26 },
  { 1699, 19, 26, 22, 3, -26 },
  { 1761, 19, 26, 22, 2, -26 },
  { 1823, 20, 26, 22, 2, -26 },
  { 1888, 20, 26, 22, 2, -26 },
  { 1953, 19, 26, 22, 2, -26 },
  { 2015, 21, 26, 22, 1, -26 },
  { 2084, 20, 26, 22, 2, -26 },
  { 2149, 18, 26, 22, 2, -26 },
  { 2208, 22, 26, 22, 2, -26 },
  { 2280, 16, 26, 22, 3, -26 },
  { 2332, 21, 26, 22, 1, -26 },
  { 2401, 21, 26, 22, 1, -26 },
  { 2470, 19, 26, 22, 2, -26 },
  { 2532, 20, 26, 22, 2, -26 },
  { 2597, 19, 33, 22, 2, -26 },
  { 2676, 20, 26, 22, 2, -26 },
  { 2741, 21, 26, 22, 1, -26 },
  { 2810, 21, 26, 22, 3, -26 },
  { 2879, 19, 26, 22, 3, -26 },
  { 2941, 20, 26, 22, 4, -26 },
  { 3006, 22, 26, 22, 2, -26 },
  { 3078, 25, 26, 22, -1, -26 },
  { 3160, 21, 26, 22, 3, -26 },
  { 3229, 23, 26, 22, 0, -26 },
  { 3304, 16, 33, 22, 6, -28 },
  { 3370, 9, 33, 22, 7, -28 },
  { 3408, 16, 33, 22, 0, -28 },
  { 3474, 19, 15, 22, 2, -26 },
  { 3510, 18, 3, 22, 0, 3 },
  { 3517, 5, 7, 22, 8, -29 },
  { 3522, 18, 19, 22, 2, -19 },
  { 3565, 18, 27, 22, 2, -27 },
  { 3626, 16, 19, 22, 3, -19 },
  { 3664, 20, 27, 22, 2, -27 },
  { 3732, 17, 19, 22, 3, -19 },
  { 3773, 25, 34, 22, -1, -27 },
  { 3880, 19, 26, 22, 1, -19 },
  { 3942, 17, 27, 22, 2, -27 },
  { 4000, 17, 27, 22, 3, -27 },
  { 4058, 18, 34, 22, 2, -27 },
  { 4135, 19, 27, 22, 2, -27 },
  { 4200, 15, 27, 22, 4, -27 },
  { 4251, 21, 19, 22, 0, -19 },
  { 4301, 17, 19, 22, 2, -19 },
  { 4342, 18, 19, 22, 2, -19 },
  { 4385, 19, 26, 22, 1, -19 },
  { 4447, 18, 26, 22, 2, -19 },
  { 4506, 18, 19, 22, 4, -19 },
  { 4549, 18, 19, 22, 2, -19 },
  { 4592, 17, 26, 22, 3, -26 },
  { 4648, 17, 19, 22, 3, -19 },
  { 4689, 18, 19, 22, 2, -19 },
  { 4732, 19, 19, 22, 2, -19 },
  { 4778, 22, 19, 22, 0, -19 },
  { 4831, 19, 26, 22, 1, -19 },
  { 4893, 19, 19, 22, 2, -19 },
  { 4939, 17, 33, 22, 4, -28 },
  { 5010, 8, 33, 22, 7, -28 },
  { 5043, 17, 33, 22, 2, -28 },
  { 5114, 19, 9, 22, 2, -16 },
};

const GFXfont IBMPlexMono_Italic37pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic37pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic37pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _IBMPLEXMONO_ITALIC37PT7B_H_
