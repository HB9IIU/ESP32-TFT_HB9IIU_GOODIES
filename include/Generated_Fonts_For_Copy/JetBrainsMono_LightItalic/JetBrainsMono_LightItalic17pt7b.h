#ifndef _JETBRAINSMONO_LIGHTITALIC17PT7B_H_
#define _JETBRAINSMONO_LIGHTITALIC17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-LightItalic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_LightItalic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x32, 0x22, 0x22, 0x40, 0x6E, 0x4D, 0x2C, 0xB2, 0x88, 0x04,
  0x42, 0x20, 0x88, 0xFF, 0x11, 0x04, 0x41, 0x30, 0x88, 0xFF, 0x89, 0x84,
  0x41, 0x10, 0x04, 0x02, 0x01, 0x07, 0xE2, 0x53, 0x4D, 0xA0, 0x50, 0x3C,
  0x07, 0x02, 0xC2, 0x69, 0x36, 0xB1, 0xF0, 0x20, 0x10, 0x00, 0x10, 0x27,
  0x89, 0x13, 0x22, 0x44, 0xD0, 0xF4, 0x01, 0x00, 0x48, 0x16, 0xC6, 0x88,
  0x93, 0x22, 0x48, 0x78, 0x06, 0x07, 0xC1, 0x18, 0x40, 0x10, 0x06, 0x03,
  0x81, 0xB3, 0x45, 0x91, 0xC4, 0x21, 0x14, 0x79, 0x80, 0xFE, 0x80, 0x06,
  0x30, 0xC1, 0x06, 0x08, 0x10, 0x20, 0xC1, 0x82, 0x06, 0x0C, 0x08, 0x1C,
  0x08, 0x30, 0x10, 0x10, 0x20, 0x60, 0xC1, 0x02, 0x04, 0x08, 0x30, 0x41,
  0x82, 0x18, 0x60, 0x0C, 0x04, 0x32, 0x7F, 0xE0, 0x81, 0xE1, 0x90, 0x8C,
  0x0C, 0x08, 0x08, 0x08, 0xFF, 0x18, 0x18, 0x10, 0x36, 0x64, 0xC8, 0xFC,
  0x5F, 0x80, 0x00, 0x40, 0x20, 0x18, 0x04, 0x03, 0x00, 0x80, 0x60, 0x10,
  0x0C, 0x02, 0x01, 0x80, 0x40, 0x30, 0x08, 0x06, 0x03, 0x00, 0x0C, 0x1F,
  0x88, 0x4C, 0x34, 0x12, 0x09, 0x64, 0x92, 0xC3, 0x61, 0xB0, 0x98, 0xC7,
  0xC0, 0x1E, 0x34, 0x44, 0x04, 0x0C, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x18,
  0xFF, 0x0C, 0x1F, 0x98, 0x48, 0x20, 0x10, 0x18, 0x08, 0x08, 0x08, 0x18,
  0x18, 0x18, 0x0F, 0xE0, 0x3F, 0x03, 0x04, 0x08, 0x1C, 0x06, 0x03, 0x03,
  0x02, 0x82, 0xC6, 0x7C, 0x03, 0x06, 0x0C, 0x18, 0x10, 0x23, 0x43, 0xC2,
  0xFE, 0x02, 0x02, 0x06, 0x3F, 0x90, 0x08, 0x0C, 0x07, 0xE3, 0x18, 0x0C,
  0x06, 0x02, 0x61, 0x31, 0x8F, 0x80, 0x06, 0x0C, 0x18, 0x10, 0x2C, 0x76,
  0x43, 0xC1, 0x83, 0x82, 0xC6, 0x7C, 0xFF, 0xC3, 0xC2, 0x06, 0x04, 0x0C,
  0x08, 0x10, 0x30, 0x20, 0x60, 0xC0, 0x0C, 0x3F, 0x21, 0x61, 0x61, 0x32,
  0x1C, 0x26, 0x42, 0xC3, 0x82, 0xC6, 0x7C, 0x18, 0x7E, 0x43, 0x83, 0x83,
  0x82, 0xC6, 0x7C, 0x0C, 0x18, 0x30, 0x20, 0x40, 0x27, 0x70, 0x00, 0x00,
  0xEE, 0x11, 0xCE, 0x00, 0x00, 0x06, 0x23, 0x11, 0x88, 0x00, 0x01, 0x83,
  0x87, 0x0E, 0x04, 0x07, 0x80, 0x60, 0x0C, 0x02, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFF, 0x40, 0x30, 0x1C, 0x07, 0x01, 0x0E, 0x38, 0xE0, 0x80, 0xF8,
  0x30, 0x41, 0x0D, 0xE6, 0x10, 0x40, 0x0C, 0x30, 0x03, 0x07, 0x63, 0x04,
  0x81, 0x60, 0x59, 0xD4, 0xCD, 0x23, 0x48, 0x92, 0x2C, 0x8B, 0x3E, 0xC0,
  0x30, 0x06, 0x00, 0xF0, 0x06, 0x03, 0x03, 0xC1, 0x61, 0xB0, 0x88, 0x44,
  0x7E, 0x3F, 0x30, 0x90, 0x58, 0x30, 0x3F, 0x10, 0x98, 0x4C, 0x24, 0x33,
  0xE1, 0x08, 0x86, 0xC3, 0x61, 0x21, 0x9F, 0x80, 0x04, 0x1F, 0x88, 0x4C,
  0x36, 0x02, 0x01, 0x00, 0x80, 0x40, 0x60, 0xB0, 0x98, 0xC7, 0xC0, 0x3F,
  0x21, 0x61, 0x61, 0x41, 0x41, 0x43, 0x43, 0xC2, 0xC2, 0x84, 0xF8, 0x3F,
  0x90, 0x08, 0x0C, 0x06, 0x03, 0xF9, 0x00, 0x80, 0x40, 0x60, 0x30, 0x1F,
  0xC0, 0x3F, 0x90, 0x18, 0x0C, 0x04, 0x03, 0xF9, 0x00, 0x80, 0x40, 0x60,
  0x30, 0x10, 0x00, 0x04, 0x1F, 0x88, 0x4C, 0x36, 0x02, 0x01, 0x00, 0x9E,
  0x43, 0x61, 0xB0, 0x98, 0xC7, 0xC0, 0x21, 0x90, 0x98, 0x4C, 0x24, 0x13,
  0xF9, 0x0C, 0x86, 0xC2, 0x61, 0x30, 0x90, 0xC0, 0x3F, 0x86, 0x03, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x30, 0x18, 0x08, 0x04, 0x1F, 0xC0, 0x07, 0xC0,
  0x20, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10, 0x04, 0x41, 0x10, 0xC6, 0x20,
  0xF0, 0x21, 0x90, 0x98, 0xCC, 0xC4, 0x43, 0xE1, 0x30, 0x88, 0xC4, 0x63,
  0x20, 0x90, 0x60, 0x30, 0x20, 0x20, 0x20, 0x60, 0x60, 0x40, 0x40, 0x40,
  0x40, 0xC1, 0xFE, 0x71, 0xA9, 0x54, 0xEA, 0xA5, 0x52, 0xCB, 0x25, 0x86,
  0x83, 0x41, 0x20, 0x90, 0x40, 0x31, 0x98, 0xDC, 0x4E, 0x25, 0x92, 0x49,
  0x2C, 0x96, 0xCE, 0x63, 0x21, 0x90, 0xC0, 0x0C, 0x1F, 0x88, 0x4C, 0x26,
  0x12, 0x09, 0x04, 0x86, 0x43, 0x61, 0x30, 0x98, 0xC7, 0xC0, 0x3F, 0x10,
  0xD8, 0x2C, 0x34, 0x1A, 0x19, 0xF0, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x00,
  0x0C, 0x1F, 0x88, 0x4C, 0x24, 0x12, 0x09, 0x04, 0x86, 0xC3, 0x61, 0xB0,
  0x98, 0xC7, 0xC0, 0x40, 0x30, 0x0C, 0x3F, 0x10, 0xD8, 0x6C, 0x34, 0x13,
  0xF1, 0xF0, 0x98, 0xC4, 0x63, 0x21, 0x90, 0x40, 0x0C, 0x1F, 0x88, 0x4C,
  0x36, 0x01, 0x00, 0xF0, 0x0C, 0x03, 0x01, 0xA0, 0xD8, 0xC7, 0xC0, 0xFF,
  0x18, 0x18, 0x10, 0x10, 0x10, 0x10, 0x30, 0x30, 0x20, 0x20, 0x20, 0x21,
  0x90, 0xD8, 0x4C, 0x24, 0x12, 0x09, 0x0C, 0x86, 0xC2, 0x61, 0x11, 0x8F,
  0x80, 0xC1, 0xC3, 0xC2, 0x46, 0x44, 0x44, 0x4C, 0x48, 0x58, 0x50, 0x70,
  0x60, 0x4C, 0xD3, 0x24, 0xC9, 0x52, 0x55, 0xB5, 0x4D, 0x53, 0x94, 0xE6,
  0x29, 0x8C, 0x63, 0x18, 0x30, 0xC4, 0x21, 0x90, 0x2C, 0x0E, 0x01, 0x00,
  0xE0, 0x68, 0x12, 0x08, 0xC6, 0x13, 0x06, 0xC1, 0xA1, 0x91, 0x8C, 0x86,
  0xC1, 0x40, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x04, 0x00, 0x3F, 0x80, 0x80,
  0x80, 0xC0, 0xC0, 0x40, 0x40, 0x60, 0x20, 0x20, 0x30, 0x1F, 0xC0, 0x3C,
  0x82, 0x18, 0x61, 0x84, 0x10, 0x41, 0x0C, 0x30, 0x82, 0x08, 0x3C, 0x86,
  0x30, 0x84, 0x21, 0x84, 0x21, 0x0C, 0x61, 0x08, 0x43, 0x3C, 0x10, 0xC3,
  0x08, 0x20, 0x82, 0x18, 0x61, 0x04, 0x10, 0x43, 0x3C, 0x18, 0x38, 0x93,
  0x24, 0x50, 0x40, 0xFF, 0xFF, 0xCC, 0x08, 0x3D, 0x63, 0x43, 0x43, 0x43,
  0xC2, 0xC2, 0xC6, 0x7E, 0x20, 0x20, 0x64, 0x7E, 0x63, 0x41, 0x43, 0x43,
  0xC2, 0xC2, 0xC6, 0xBC, 0x08, 0x3E, 0x63, 0x41, 0x40, 0x40, 0xC0, 0xC2,
  0xC6, 0x7C, 0x01, 0x80, 0x82, 0x47, 0xA6, 0x32, 0x19, 0x0C, 0x86, 0xC2,
  0x61, 0x31, 0x8F, 0xC0, 0x08, 0x3E, 0x63, 0x41, 0x43, 0x7F, 0xC0, 0xC0,
  0xC6, 0x7C, 0x03, 0xF0, 0x20, 0x02, 0x00, 0x62, 0x3F, 0xC0, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0xF0,
  0x00, 0x08, 0x3F, 0x63, 0x43, 0x43, 0x43, 0xC2, 0x46, 0x7A, 0x02, 0x06,
  0x04, 0x78, 0x20, 0x20, 0x64, 0x7E, 0x63, 0x41, 0x43, 0x43, 0xC2, 0xC2,
  0x82, 0x86, 0x0E, 0x0C, 0x00, 0x00, 0x7C, 0x0C, 0x08, 0x08, 0x08, 0x08,
  0x18, 0x18, 0xFF, 0x01, 0x80, 0xC0, 0x00, 0x01, 0xF0, 0x18, 0x0C, 0x04,
  0x02, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x20, 0x31, 0xF0, 0x20, 0x10, 0x18,
  0x2C, 0x24, 0x22, 0x21, 0x30, 0xF0, 0x4C, 0x62, 0x31, 0x90, 0x40, 0xF0,
  0x60, 0xC1, 0x82, 0x04, 0x08, 0x10, 0x60, 0xC1, 0x81, 0xF0, 0x09, 0x0F,
  0xE2, 0x49, 0x92, 0x64, 0x93, 0x24, 0x89, 0x26, 0x49, 0xB2, 0x40, 0x04,
  0x7E, 0x63, 0x41, 0x43, 0x43, 0xC2, 0xC2, 0x82, 0x86, 0x08, 0x3E, 0x63,
  0x41, 0x43, 0x43, 0xC2, 0xC2, 0xC6, 0x7C, 0x02, 0x1F, 0x8C, 0x64, 0x12,
  0x19, 0x0D, 0x84, 0xC2, 0x63, 0x2F, 0x10, 0x08, 0x0C, 0x00, 0x08, 0x3D,
  0x63, 0x43, 0x43, 0x43, 0xC2, 0xC2, 0xC6, 0x7A, 0x06, 0x06, 0x04, 0x04,
  0x3F, 0x61, 0x61, 0x40, 0x40, 0x40, 0x40, 0xC0, 0xC0, 0x0C, 0x3F, 0x61,
  0x40, 0x70, 0x3E, 0x02, 0x02, 0xC6, 0x7C, 0x10, 0x10, 0x31, 0xFE, 0x20,
  0x20, 0x20, 0x20, 0x60, 0x60, 0x60, 0x3C, 0x61, 0x41, 0x41, 0x43, 0x43,
  0xC2, 0xC2, 0x46, 0x7C, 0x83, 0x82, 0xC4, 0xC4, 0x48, 0x48, 0x50, 0x50,
  0x60, 0xC8, 0xEA, 0x75, 0x5A, 0xAE, 0x55, 0x32, 0x99, 0x4C, 0xC4, 0x00,
  0x31, 0xC4, 0x41, 0xA0, 0x38, 0x0C, 0x07, 0x83, 0x20, 0x8C, 0xC1, 0x00,
  0x61, 0x41, 0x43, 0x43, 0x43, 0xC2, 0xC6, 0x7A, 0x02, 0x06, 0x04, 0x78,
  0x7F, 0x02, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC0, 0xFE, 0x07, 0x0C, 0x08,
  0x08, 0x08, 0x08, 0x18, 0xF0, 0x30, 0x10, 0x10, 0x10, 0x30, 0x30, 0x30,
  0x1C, 0x11, 0x33, 0x32, 0x22, 0x26, 0x64, 0x44, 0x4C, 0x1C, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x60, 0x30, 0x0F, 0x0E, 0x04, 0x02, 0x03, 0x01, 0x80,
  0xC0, 0xC1, 0xC0, 0x31, 0x59, 0xCF, 0x86,
};

const GFXglyph JetBrainsMono_LightItalic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 4, 12, 10, 3, -12 },
  { 7, 6, 5, 10, 3, -12 },
  { 11, 10, 12, 10, 0, -12 },
  { 26, 9, 17, 10, 1, -15 },
  { 46, 11, 13, 10, 0, -13 },
  { 64, 10, 13, 10, 0, -13 },
  { 81, 2, 5, 10, 5, -12 },
  { 83, 7, 16, 10, 3, -14 },
  { 97, 7, 16, 10, 1, -14 },
  { 111, 9, 8, 10, 1, -10 },
  { 120, 8, 8, 10, 1, -10 },
  { 128, 4, 6, 10, 2, -3 },
  { 131, 6, 1, 10, 2, -6 },
  { 132, 3, 3, 10, 3, -3 },
  { 134, 10, 16, 10, 0, -14 },
  { 154, 9, 13, 10, 1, -13 },
  { 169, 8, 12, 10, 1, -12 },
  { 181, 9, 13, 10, 1, -13 },
  { 196, 8, 12, 10, 1, -12 },
  { 208, 8, 12, 10, 1, -12 },
  { 220, 9, 12, 10, 1, -12 },
  { 234, 8, 12, 10, 1, -12 },
  { 246, 8, 12, 10, 2, -12 },
  { 258, 8, 13, 10, 1, -13 },
  { 271, 8, 13, 10, 2, -13 },
  { 284, 4, 10, 10, 3, -10 },
  { 289, 5, 13, 10, 2, -10 },
  { 298, 9, 9, 10, 1, -10 },
  { 309, 8, 5, 10, 1, -8 },
  { 314, 8, 9, 10, 1, -10 },
  { 323, 6, 12, 10, 3, -12 },
  { 332, 10, 16, 10, 0, -13 },
  { 352, 9, 12, 10, 0, -12 },
  { 366, 9, 12, 10, 1, -12 },
  { 380, 9, 13, 10, 1, -13 },
  { 395, 8, 12, 10, 1, -12 },
  { 407, 9, 12, 10, 1, -12 },
  { 421, 9, 12, 10, 1, -12 },
  { 435, 9, 13, 10, 1, -13 },
  { 450, 9, 12, 10, 1, -12 },
  { 464, 9, 12, 10, 1, -12 },
  { 478, 10, 12, 10, 0, -12 },
  { 493, 9, 12, 10, 1, -12 },
  { 507, 8, 12, 10, 1, -12 },
  { 519, 9, 12, 10, 1, -12 },
  { 533, 9, 12, 10, 1, -12 },
  { 547, 9, 13, 10, 1, -13 },
  { 562, 9, 12, 10, 1, -12 },
  { 576, 9, 16, 10, 1, -13 },
  { 594, 9, 12, 10, 1, -12 },
  { 608, 9, 13, 10, 1, -13 },
  { 623, 8, 12, 10, 2, -12 },
  { 635, 9, 12, 10, 1, -12 },
  { 649, 8, 12, 10, 2, -12 },
  { 661, 10, 12, 10, 1, -12 },
  { 676, 10, 12, 10, 0, -12 },
  { 691, 9, 12, 10, 2, -12 },
  { 705, 9, 12, 10, 1, -12 },
  { 719, 6, 16, 10, 3, -14 },
  { 731, 5, 16, 10, 3, -14 },
  { 741, 6, 16, 10, 2, -14 },
  { 753, 7, 6, 10, 2, -12 },
  { 759, 8, 2, 10, 0, 0 },
  { 761, 3, 2, 10, 5, -13 },
  { 762, 8, 10, 10, 1, -10 },
  { 772, 8, 12, 10, 1, -12 },
  { 784, 8, 10, 10, 1, -10 },
  { 794, 9, 12, 10, 1, -12 },
  { 808, 8, 10, 10, 1, -10 },
  { 818, 12, 15, 10, -1, -12 },
  { 841, 8, 13, 10, 1, -10 },
  { 854, 8, 12, 10, 1, -12 },
  { 866, 8, 13, 10, 1, -13 },
  { 879, 9, 16, 10, 0, -13 },
  { 897, 9, 12, 10, 1, -12 },
  { 911, 7, 12, 10, 2, -12 },
  { 922, 10, 10, 10, 0, -10 },
  { 935, 8, 10, 10, 1, -10 },
  { 945, 8, 10, 10, 1, -10 },
  { 955, 9, 13, 10, 0, -10 },
  { 970, 8, 13, 10, 1, -10 },
  { 983, 8, 10, 10, 1, -10 },
  { 993, 8, 10, 10, 1, -10 },
  { 1003, 8, 12, 10, 2, -12 },
  { 1015, 8, 9, 10, 1, -9 },
  { 1024, 8, 9, 10, 2, -9 },
  { 1033, 9, 9, 10, 1, -9 },
  { 1044, 10, 9, 10, 0, -9 },
  { 1056, 8, 12, 10, 1, -9 },
  { 1068, 8, 9, 10, 1, -9 },
  { 1077, 8, 16, 10, 2, -14 },
  { 1093, 4, 16, 10, 3, -14 },
  { 1101, 9, 16, 10, 0, -14 },
  { 1119, 8, 4, 10, 1, -8 },
};

const GFXfont JetBrainsMono_LightItalic17pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_LightItalic17pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_LightItalic17pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _JETBRAINSMONO_LIGHTITALIC17PT7B_H_
