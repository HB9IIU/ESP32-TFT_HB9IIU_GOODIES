#ifndef _JETBRAINSMONO_LIGHTITALIC47PT7B_H_
#define _JETBRAINSMONO_LIGHTITALIC47PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-LightItalic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_LightItalic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x3F, 0x87, 0xF0, 0xFC, 0x0F, 0x80,
  0x3C, 0x1E, 0xF8, 0x3D, 0xE0, 0x7B, 0xC0, 0xF7, 0x83, 0xCF, 0x07, 0x9E,
  0x0F, 0x38, 0x1E, 0xF0, 0x3D, 0xE0, 0x73, 0xC0, 0xE7, 0x81, 0xCE, 0x03,
  0x9C, 0x0F, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0x38,
  0x0F, 0x00, 0x0F, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x38, 0x0F, 0x00,
  0x0F, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x38, 0x0F, 0x01, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x01,
  0xC0, 0x38, 0x00, 0x38, 0x0F, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x38,
  0x00, 0x38, 0x0F, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x38,
  0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8,
  0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x78, 0x0E, 0x00, 0x0E, 0x01,
  0xC0, 0x01, 0xC0, 0x38, 0x00, 0x78, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x01,
  0xC0, 0x78, 0x00, 0x78, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xF8, 0xC7, 0xC0, 0x78, 0x61, 0xE0,
  0x78, 0x70, 0xF0, 0x3C, 0x38, 0x38, 0x1C, 0x1C, 0x1C, 0x1E, 0x0E, 0x10,
  0x0F, 0x06, 0x00, 0x07, 0x83, 0x00, 0x03, 0xE1, 0x80, 0x00, 0xF1, 0xC0,
  0x00, 0x7E, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0x3E, 0x00, 0x03,
  0x8F, 0x80, 0x01, 0xC3, 0xC0, 0x00, 0xC1, 0xE0, 0x00, 0x60, 0xF0, 0x00,
  0x70, 0x78, 0x78, 0x38, 0x3C, 0x3C, 0x1C, 0x1E, 0x1E, 0x0E, 0x0E, 0x0F,
  0x06, 0x0F, 0x07, 0xC3, 0x0F, 0x01, 0xF1, 0x9F, 0x80, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0xFE, 0x00, 0x0E,
  0x03, 0xFF, 0x00, 0x1C, 0x03, 0xCF, 0x80, 0x38, 0x07, 0x03, 0x80, 0x78,
  0x07, 0x03, 0x80, 0x70, 0x0F, 0x03, 0x80, 0xE0, 0x0E, 0x03, 0x81, 0xC0,
  0x0E, 0x03, 0x83, 0x80, 0x0E, 0x03, 0x87, 0x00, 0x0E, 0x07, 0x8F, 0x00,
  0x0E, 0x07, 0x0E, 0x00, 0x0E, 0x0F, 0x1C, 0x00, 0x0F, 0xFE, 0x38, 0x00,
  0x07, 0xFC, 0x70, 0x00, 0x03, 0xF8, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x02, 0x00,
  0x00, 0x0E, 0x3F, 0xC0, 0x00, 0x1C, 0x7F, 0xE0, 0x00, 0x38, 0xF9, 0xE0,
  0x00, 0x78, 0xE0, 0xF0, 0x00, 0x71, 0xC0, 0x70, 0x00, 0xE1, 0xC0, 0x70,
  0x01, 0xC1, 0xC0, 0xF0, 0x03, 0x81, 0xC0, 0xE0, 0x07, 0x03, 0xC0, 0xE0,
  0x0F, 0x03, 0x80, 0xE0, 0x1E, 0x03, 0xC0, 0xE0, 0x1C, 0x03, 0xC1, 0xC0,
  0x38, 0x01, 0xFF, 0xC0, 0x70, 0x01, 0xFF, 0x80, 0xE0, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xF3,
  0xC0, 0x3C, 0xF0, 0xF8, 0x1E, 0x3C, 0x1E, 0x0F, 0x0F, 0x03, 0xC3, 0x83,
  0x80, 0xF1, 0xE1, 0xE0, 0x1E, 0xF0, 0x78, 0x07, 0xF8, 0x1E, 0x00, 0xFE,
  0x07, 0x80, 0x3F, 0x01, 0xE0, 0x07, 0x80, 0x70, 0x01, 0xF0, 0x1E, 0x00,
  0xFC, 0x07, 0x80, 0x7F, 0x81, 0xF0, 0x7D, 0xE0, 0x7F, 0xFE, 0x3C, 0x0F,
  0xFF, 0x07, 0x81, 0xFF, 0x01, 0xE0, 0x3C, 0xF3, 0xCF, 0x7D, 0xE7, 0x9E,
  0x79, 0xE7, 0x1C, 0x73, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x3C, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01,
  0xF8, 0x00, 0x0F, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x3C, 0x00,
  0x07, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC,
  0x00, 0x3E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x60, 0x1C, 0x03, 0x78, 0x1C, 0x1F,
  0xFE, 0x18, 0x7F, 0xFF, 0x99, 0xFF, 0x3F, 0xDF, 0xFC, 0x07, 0xFF, 0xE0,
  0x00, 0x38, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xEE, 0x00, 0x03, 0xCE, 0x00,
  0x07, 0xCF, 0x00, 0x07, 0x8F, 0x80, 0x0F, 0x07, 0x80, 0x1E, 0x07, 0xC0,
  0x3E, 0x03, 0xC0, 0x7C, 0x03, 0xE0, 0x18, 0x01, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x01, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0xF0, 0x7E, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x01,
  0xE0, 0x3E, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1E, 0x1F, 0x9F, 0xCF, 0xE7, 0xF3,
  0xF9, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x07, 0xC0, 0x7E, 0x0F, 0x80, 0x1E, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x1E,
  0x1E, 0x00, 0x0E, 0x1E, 0x00, 0x0E, 0x1C, 0x00, 0x1E, 0x1C, 0x00, 0x1E,
  0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1C, 0x3C, 0x38, 0x1C,
  0x38, 0x7C, 0x3C, 0x38, 0x7C, 0x3C, 0x78, 0x7C, 0x3C, 0x78, 0x3C, 0x3C,
  0x78, 0x00, 0x3C, 0x78, 0x00, 0x38, 0x78, 0x00, 0x78, 0x70, 0x00, 0x78,
  0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF0,
  0xF0, 0x00, 0xF0, 0xF8, 0x01, 0xE0, 0x78, 0x03, 0xE0, 0x7C, 0x07, 0xC0,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0x70, 0x01, 0xF3, 0xC0, 0x1F,
  0x8F, 0x00, 0x78, 0x3C, 0x01, 0xC0, 0xF0, 0x0C, 0x03, 0xC0, 0x20, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x1F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xE0, 0x3E, 0x07, 0xC0,
  0x1F, 0x07, 0x80, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x1E, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00,
  0x78, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x7C, 0x01, 0xE0, 0x3E, 0x07,
  0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x03, 0x81, 0xE0, 0x1E, 0x0F, 0x00, 0x78, 0x7C, 0x01, 0xE1,
  0xE0, 0x07, 0x8F, 0x00, 0x1E, 0x78, 0x00, 0x71, 0xE0, 0x03, 0xC7, 0x80,
  0x0F, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF0, 0x30, 0x01, 0xE7, 0xFC, 0x03, 0xDF, 0xFC,
  0x07, 0xFF, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0x00, 0xF8, 0x7C, 0x00, 0xF0,
  0xF0, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE3, 0xC0,
  0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x1E, 0x0F, 0x00, 0x7C, 0x1F, 0x01,
  0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7B, 0xF8, 0x01, 0xEF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xC0, 0xFC, 0x3E,
  0x00, 0xF8, 0x78, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x01, 0xEF, 0x00,
  0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00, 0x0E, 0x78, 0x00, 0x3C, 0xF0, 0x00,
  0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x03, 0xC7, 0x80, 0x0F, 0x87, 0x80, 0x3E,
  0x0F, 0x80, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDC, 0x00, 0x0F, 0xF0,
  0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7C, 0x03,
  0xC0, 0xF0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0E, 0x00, 0x1E,
  0x1C, 0x00, 0x3C, 0x38, 0x00, 0x70, 0x78, 0x01, 0xE0, 0xF0, 0x07, 0x81,
  0xF0, 0x1E, 0x01, 0xF0, 0x78, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x3E, 0x3E, 0x01, 0xF0, 0x1E, 0x07, 0xC0,
  0x1E, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x70, 0x00, 0x79, 0xE0, 0x00,
  0xF3, 0xC0, 0x01, 0xE7, 0x80, 0x03, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x1E,
  0x3E, 0x00, 0x78, 0x3E, 0x03, 0xE0, 0x7F, 0xFF, 0x80, 0x7F, 0xFE, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFE, 0x03,
  0xFF, 0xFC, 0x1F, 0x00, 0xF8, 0xF8, 0x01, 0xE3, 0xC0, 0x07, 0x9E, 0x00,
  0x0F, 0x78, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0E,
  0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x3C, 0xF8,
  0x01, 0xF1, 0xF0, 0x0F, 0x87, 0xF1, 0xFE, 0x0F, 0xFF, 0xF0, 0x1F, 0xF7,
  0x80, 0x1F, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFC, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xF8, 0x07,
  0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0xF8,
  0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0x00, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x20, 0x1F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFC, 0x00, 0x08, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F,
  0x80, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xE0, 0xFC, 0x00, 0xF8, 0x03, 0xE0, 0x1E, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0xF0, 0x38, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0E, 0x00, 0x78, 0xF0, 0xE0,
  0x1F, 0xEE, 0x0E, 0x03, 0xFE, 0xE1, 0xE0, 0x78, 0x3E, 0x1E, 0x07, 0x01,
  0xE1, 0xC0, 0xF0, 0x1E, 0x1C, 0x0E, 0x01, 0xE1, 0xC0, 0xE0, 0x1E, 0x1C,
  0x0E, 0x01, 0xC3, 0xC1, 0xE0, 0x1C, 0x3C, 0x1E, 0x01, 0xC3, 0xC1, 0xC0,
  0x3C, 0x38, 0x1C, 0x03, 0xC3, 0x81, 0xC0, 0x3C, 0x38, 0x1C, 0x03, 0x87,
  0x81, 0xC0, 0x78, 0x78, 0x1E, 0x07, 0x87, 0x81, 0xF1, 0xB8, 0x70, 0x0F,
  0xFB, 0x87, 0x00, 0xFF, 0x38, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xEE, 0x00, 0x01,
  0xDE, 0x00, 0x07, 0xBC, 0x00, 0x0E, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x78,
  0xE0, 0x01, 0xE1, 0xC0, 0x03, 0xC3, 0x80, 0x07, 0x07, 0x00, 0x1E, 0x0E,
  0x00, 0x38, 0x1E, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0x78, 0x07, 0x80, 0xF0,
  0x0F, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x78, 0x03, 0x80, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x3C, 0x00, 0x78, 0x78,
  0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xCF, 0x00, 0x07, 0x9E, 0x00,
  0x07, 0x38, 0x00, 0x0E, 0xF0, 0x00, 0x1D, 0xE0, 0x00, 0x3C, 0x07, 0xFF,
  0xE0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0x00, 0xFC, 0x0F, 0x00,
  0x3E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0E, 0x00, 0x1E, 0x0E, 0x00,
  0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1C, 0x1E, 0x00, 0x3C, 0x1E, 0x00,
  0x78, 0x1C, 0x00, 0xF8, 0x1C, 0x07, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xE0, 0x3C, 0x01, 0xF0, 0x38, 0x00, 0xF8, 0x38, 0x00,
  0x78, 0x38, 0x00, 0x78, 0x78, 0x00, 0x38, 0x78, 0x00, 0x38, 0x78, 0x00,
  0x78, 0x78, 0x00, 0x78, 0x70, 0x00, 0x78, 0x70, 0x00, 0xF0, 0xF0, 0x01,
  0xF0, 0xF0, 0x03, 0xE0, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xC0, 0x3E, 0x07, 0x80, 0x1E, 0x0F, 0x00,
  0x1E, 0x0F, 0x00, 0x1E, 0x0E, 0x00, 0x0E, 0x1E, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00,
  0x78, 0x70, 0x00, 0xF0, 0x70, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0x78, 0x03,
  0xE0, 0x7E, 0x07, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0x80,
  0x7E, 0x07, 0x80, 0x3E, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x0F, 0x07, 0x00,
  0x0F, 0x07, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0E, 0x0F, 0x00,
  0x0E, 0x0F, 0x00, 0x1E, 0x0E, 0x00, 0x1E, 0x0E, 0x00, 0x1E, 0x1E, 0x00,
  0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1C, 0x1E, 0x00, 0x3C, 0x1E, 0x00,
  0x3C, 0x1C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00,
  0x38, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x38, 0x00, 0x78, 0x38, 0x00,
  0xF0, 0x78, 0x01, 0xF0, 0x78, 0x03, 0xE0, 0x78, 0x1F, 0xC0, 0x7F, 0xFF,
  0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE1, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFC, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xC0, 0x3E, 0x07, 0x80, 0x1E, 0x0F,
  0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0E, 0x00, 0x0E, 0x1E, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x1F, 0xFC, 0x38, 0x1F, 0xFC, 0x38, 0x3F, 0xF8, 0x78, 0x00, 0x38, 0x78,
  0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x70,
  0x00, 0x78, 0x70, 0x00, 0xF0, 0x70, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0x78,
  0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0x80, 0x0F, 0x07, 0x00, 0x0F, 0x07, 0x00, 0x0F, 0x0F,
  0x00, 0x0E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0E,
  0x00, 0x1E, 0x0E, 0x00, 0x1E, 0x1E, 0x00, 0x1C, 0x1E, 0x00, 0x1C, 0x1E,
  0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1C, 0x00, 0x3C, 0x3F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3C, 0x00, 0x78, 0x3C,
  0x00, 0x78, 0x38, 0x00, 0x78, 0x38, 0x00, 0x78, 0x78, 0x00, 0x70, 0x78,
  0x00, 0xF0, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x70, 0x00, 0xF0, 0x70,
  0x00, 0xF0, 0xF0, 0x00, 0xE0, 0xF0, 0x00, 0xE0, 0xF0, 0x01, 0xE0, 0xF0,
  0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xE0, 0x01, 0xE0, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x08, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1C, 0x1E, 0x00, 0x1E, 0x0F, 0x00,
  0x0F, 0x07, 0x80, 0x0F, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x1F, 0x80, 0x7F,
  0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0x03,
  0xE0, 0x70, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x07, 0x80, 0x78,
  0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x00, 0x78, 0x01, 0xE0, 0x1E, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0x80,
  0xF0, 0x00, 0xF0, 0x3E, 0x00, 0x1E, 0x07, 0x80, 0x03, 0x81, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x78, 0x1E,
  0x00, 0x0F, 0x03, 0xC0, 0x01, 0xC0, 0x78, 0x00, 0x78, 0x07, 0x80, 0x0F,
  0x00, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C,
  0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x00, 0xF0,
  0x01, 0xE0, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0xC0, 0x70, 0x00, 0x7C,
  0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x2F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x80, 0x07, 0xC0,
  0x0F, 0xC1, 0xF0, 0x03, 0xF0, 0x6E, 0x01, 0xF8, 0x1B, 0x80, 0x7E, 0x0E,
  0xE0, 0x3F, 0x83, 0xB8, 0x0E, 0xE0, 0xEE, 0x07, 0xB8, 0x3B, 0x81, 0xDE,
  0x0E, 0x70, 0xF7, 0x03, 0x9C, 0x39, 0xC1, 0xE7, 0x1E, 0x70, 0x79, 0xC7,
  0x1C, 0x1E, 0x71, 0xCF, 0x07, 0x0C, 0xE3, 0xC1, 0xC3, 0xB8, 0xE0, 0x70,
  0xFC, 0x38, 0x3C, 0x3F, 0x0E, 0x0F, 0x0F, 0x87, 0x83, 0xC3, 0xE1, 0xE0,
  0xF0, 0x00, 0x78, 0x38, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x07, 0x80, 0x01,
  0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80,
  0x03, 0xC1, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x3C, 0x00, 0x1E, 0x0F,
  0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x38, 0x00, 0x1C,
  0x00, 0x03, 0xE0, 0x07, 0x81, 0xF0, 0x03, 0xC1, 0xF8, 0x01, 0xE0, 0xFE,
  0x00, 0xF0, 0x77, 0x00, 0x70, 0x3B, 0x80, 0x38, 0x1D, 0xC0, 0x3C, 0x0E,
  0xE0, 0x1E, 0x0F, 0x78, 0x0F, 0x07, 0x9C, 0x07, 0x83, 0xCE, 0x03, 0x81,
  0xE7, 0x01, 0xC0, 0xE3, 0x81, 0xE0, 0x71, 0xE0, 0xF0, 0x78, 0x70, 0x78,
  0x3C, 0x38, 0x3C, 0x1E, 0x1C, 0x1C, 0x0F, 0x0F, 0x0E, 0x07, 0x07, 0x87,
  0x03, 0x81, 0xC7, 0x81, 0xC0, 0xE3, 0xC1, 0xE0, 0x71, 0xE0, 0xF0, 0x3C,
  0xF0, 0x78, 0x1E, 0x70, 0x3C, 0x07, 0x38, 0x1C, 0x03, 0xBC, 0x0E, 0x01,
  0xDE, 0x0F, 0x00, 0xFF, 0x07, 0x80, 0x3F, 0x83, 0xC0, 0x1F, 0x81, 0xE0,
  0x0F, 0xC0, 0xE0, 0x07, 0xE0, 0x70, 0x03, 0xF0, 0x78, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x7C, 0x07, 0xC0, 0xF0, 0x07, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0E,
  0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0,
  0x01, 0xC3, 0x80, 0x07, 0x87, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00,
  0x3C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x07,
  0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x70,
  0xF0, 0x00, 0xE1, 0xC0, 0x03, 0xC3, 0x80, 0x07, 0x87, 0x00, 0x0F, 0x0F,
  0x00, 0x3C, 0x1E, 0x00, 0xF8, 0x3F, 0x03, 0xE0, 0x3F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x1E, 0x00, 0x7E, 0x07, 0x80, 0x0F, 0x81, 0xE0, 0x01,
  0xE0, 0x78, 0x00, 0x7C, 0x1C, 0x00, 0x0F, 0x07, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83,
  0x80, 0x03, 0xC0, 0xE0, 0x01, 0xF0, 0x78, 0x01, 0xF8, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xC0, 0x7C, 0x07,
  0x80, 0x3E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E,
  0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1C, 0x00, 0x1E, 0x1C, 0x00, 0x1E, 0x3C,
  0x00, 0x1C, 0x3C, 0x00, 0x1C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C,
  0x00, 0x3C, 0x38, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x38, 0x78,
  0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x70, 0x00, 0x78, 0xF0,
  0x00, 0x78, 0xF0, 0x00, 0x70, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF8,
  0x01, 0xE0, 0x78, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0xF0, 0x07, 0xE0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0x3C,
  0x1E, 0x00, 0x1E, 0x0E, 0x00, 0x0F, 0x07, 0x00, 0x07, 0x87, 0x80, 0x03,
  0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x70, 0x00,
  0xF0, 0x38, 0x00, 0xF8, 0x3C, 0x01, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x03, 0xC0, 0xE0, 0x01, 0xC0, 0x78, 0x01, 0xE0,
  0x3C, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E,
  0x01, 0xE0, 0x0E, 0x00, 0x78, 0x07, 0x00, 0x3C, 0x07, 0x80, 0x1E, 0x03,
  0xC0, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x70, 0x00, 0x78,
  0x78, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3E, 0x01, 0xF0, 0x1E, 0x00, 0x78, 0x1E,
  0x00, 0x3C, 0x0F, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x07, 0x80, 0x04, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0x83, 0xC0,
  0x03, 0xC1, 0xF0, 0x03, 0xC0, 0x7C, 0x07, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x80, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x0F, 0x07, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F,
  0x0F, 0x00, 0x0E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0E, 0x00, 0x1E,
  0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1C, 0x1E, 0x00, 0x3C,
  0x1E, 0x00, 0x3C, 0x1C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C,
  0x3C, 0x00, 0x38, 0x3C, 0x00, 0x38, 0x3C, 0x00, 0x78, 0x38, 0x00, 0x78,
  0x38, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x70,
  0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x70, 0x00, 0xF0, 0x78, 0x00, 0xE0,
  0x78, 0x01, 0xE0, 0x78, 0x03, 0xC0, 0x7E, 0x07, 0xC0, 0x3F, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7B,
  0xC0, 0x00, 0xF7, 0x80, 0x01, 0xCF, 0x00, 0x07, 0x8E, 0x00, 0x0F, 0x1C,
  0x00, 0x3C, 0x38, 0x00, 0x78, 0x78, 0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xE0,
  0x07, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0xF0, 0x1E, 0x01,
  0xE0, 0x1C, 0x03, 0x80, 0x38, 0x0F, 0x00, 0x70, 0x1C, 0x00, 0xF0, 0x78,
  0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0E, 0x00,
  0x1E, 0x3C, 0x00, 0x1C, 0x78, 0x00, 0x39, 0xE0, 0x00, 0x73, 0xC0, 0x00,
  0xE7, 0x00, 0x01, 0xDE, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x70, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x38, 0x0F, 0x80, 0xE7,
  0x01, 0xF0, 0x3C, 0xE0, 0x3E, 0x07, 0x1C, 0x0F, 0x80, 0xE3, 0x81, 0xF0,
  0x3C, 0xF0, 0x36, 0x07, 0x9E, 0x06, 0xC0, 0xE3, 0xC1, 0xD8, 0x1C, 0x78,
  0x33, 0x07, 0x8F, 0x06, 0x60, 0xF1, 0xE1, 0xCC, 0x1C, 0x3C, 0x39, 0x83,
  0x87, 0x86, 0x30, 0xF0, 0xE1, 0xC6, 0x1C, 0x1C, 0x38, 0xC3, 0x83, 0x86,
  0x18, 0x70, 0x70, 0xC3, 0x1E, 0x0E, 0x38, 0x63, 0x81, 0xC7, 0x1C, 0x70,
  0x38, 0xC3, 0x9E, 0x07, 0x38, 0x73, 0x80, 0xE7, 0x0E, 0x70, 0x1C, 0xC1,
  0xCE, 0x03, 0x98, 0x3B, 0xC0, 0x77, 0x07, 0x70, 0x0E, 0xE0, 0xEE, 0x01,
  0xD8, 0x1D, 0xC0, 0x3F, 0x03, 0xF8, 0x07, 0xE0, 0x6E, 0x00, 0xF8, 0x0D,
  0xC0, 0x3F, 0x01, 0xB8, 0x07, 0xE0, 0x3E, 0x00, 0xFC, 0x07, 0xC0, 0x1F,
  0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x0F, 0x00, 0x0F, 0x80, 0x78,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x7C, 0x00, 0x78, 0x03,
  0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x38, 0x1E, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03,
  0xC3, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x03,
  0xC0, 0x01, 0xF0, 0x1E, 0x00, 0x0F, 0x00, 0x70, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x78, 0x07, 0x80, 0x03, 0xC0, 0x78,
  0x00, 0x1E, 0x07, 0xC0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x0F, 0xBC, 0x00,
  0x07, 0x9E, 0x00, 0x07, 0x8F, 0x00, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0,
  0x03, 0xC0, 0xF0, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0F,
  0x00, 0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x70, 0x00,
  0x3C, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xBC, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x21, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x0F, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x1F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0x38, 0x00, 0x79, 0xC0, 0x03, 0x8E, 0x00, 0x38,
  0x78, 0x03, 0xC1, 0xC0, 0x1C, 0x0E, 0x01, 0xE0, 0x70, 0x1E, 0x01, 0xC0,
  0xE0, 0x0E, 0x0F, 0x00, 0x70, 0x70, 0x03, 0xC7, 0x80, 0x0E, 0x78, 0x00,
  0x77, 0x80, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xF0, 0x78, 0x78, 0x3C, 0x1C, 0x1E, 0x0F, 0x00, 0xFF, 0x1E, 0x07,
  0xFF, 0x3C, 0x1F, 0xFF, 0x70, 0x7E, 0x0F, 0xE0, 0xF0, 0x07, 0xC3, 0xC0,
  0x0F, 0x87, 0x80, 0x1F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x38, 0x78, 0x00,
  0xF0, 0xE0, 0x01, 0xE1, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x0F,
  0x1E, 0x00, 0x1C, 0x3C, 0x00, 0x38, 0x78, 0x00, 0xF0, 0xE0, 0x01, 0xE1,
  0xC0, 0x03, 0xC3, 0x80, 0x0F, 0x87, 0x80, 0x1F, 0x0F, 0x00, 0x7C, 0x1F,
  0x01, 0xF8, 0x1F, 0xFE, 0xF0, 0x3F, 0xFD, 0xE0, 0x1F, 0xE3, 0xC0, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x0F,
  0xE0, 0x1E, 0x7F, 0xF0, 0x3D, 0xFF, 0xE0, 0x7F, 0x07, 0xE0, 0xF8, 0x03,
  0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x1E,
  0x3C, 0x00, 0x38, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xC0, 0x03, 0xC7,
  0x80, 0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x1C, 0x3C, 0x00, 0x38, 0x78,
  0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC7, 0xC0, 0x0F, 0x0F, 0x80,
  0x3E, 0x1F, 0xC0, 0xF8, 0x3F, 0xFF, 0xE0, 0x73, 0xFF, 0x81, 0xE3, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xF0, 0x7E,
  0x0F, 0x00, 0x7C, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0xCF, 0x00, 0x0F, 0x3C,
  0x00, 0x3C, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x0F, 0x1C, 0x00, 0x3C, 0x78, 0x01, 0xE1, 0xE0,
  0x0F, 0x87, 0xE0, 0x7C, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0xFF, 0x1E, 0x03, 0xFF, 0x9E, 0x07, 0xFF, 0xDC, 0x0F, 0xC1,
  0xFC, 0x0F, 0x00, 0x7C, 0x1E, 0x00, 0x7C, 0x1E, 0x00, 0x7C, 0x3C, 0x00,
  0x3C, 0x3C, 0x00, 0x38, 0x3C, 0x00, 0x78, 0x38, 0x00, 0x78, 0x38, 0x00,
  0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x70, 0x78, 0x00,
  0x70, 0x78, 0x00, 0xF0, 0x70, 0x00, 0xF0, 0x70, 0x00, 0xF0, 0x70, 0x01,
  0xF0, 0x78, 0x01, 0xF0, 0x78, 0x03, 0xE0, 0x7C, 0x07, 0xE0, 0x3F, 0xFD,
  0xE0, 0x3F, 0xFD, 0xE0, 0x0F, 0xF1, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xFF,
  0x80, 0x7F, 0xFF, 0x03, 0xE0, 0x3E, 0x0F, 0x00, 0x78, 0x78, 0x01, 0xE1,
  0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xE3, 0x80,
  0x03, 0x8F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x3C, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0xC0, 0x7C, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x1E, 0x07, 0xFF, 0x3C, 0x1F, 0xFF, 0x70, 0x7E,
  0x0F, 0xE0, 0xF0, 0x07, 0xC3, 0xC0, 0x0F, 0x87, 0x80, 0x0F, 0x1E, 0x00,
  0x1E, 0x3C, 0x00, 0x38, 0x78, 0x00, 0x70, 0xF0, 0x01, 0xE1, 0xC0, 0x03,
  0xC7, 0x80, 0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x1C, 0x3C, 0x00, 0x38,
  0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x07, 0xC3, 0xE0, 0x1F, 0x83,
  0xE0, 0x6F, 0x07, 0xFF, 0xDC, 0x07, 0xFF, 0x78, 0x07, 0xF8, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0xFF, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x1F, 0xE0, 0x1E, 0x7F, 0xF0, 0x3D, 0xFF, 0xE0,
  0x7F, 0x03, 0xE0, 0xF8, 0x03, 0xC1, 0xE0, 0x07, 0xC3, 0xC0, 0x07, 0x8F,
  0x00, 0x0F, 0x1E, 0x00, 0x1C, 0x3C, 0x00, 0x38, 0x78, 0x00, 0xF0, 0xF0,
  0x01, 0xE1, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00,
  0x1C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xE0, 0x01, 0xE1, 0xC0, 0x03,
  0xC7, 0x80, 0x07, 0x8F, 0x00, 0x0E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78,
  0x70, 0x00, 0xF1, 0xE0, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF8,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x0F,
  0x0E, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x7C, 0x1E, 0x00, 0xF8,
  0x1E, 0x01, 0xF0, 0x1C, 0x03, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x07, 0x80,
  0x3C, 0x0F, 0x00, 0x3C, 0x1F, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x78, 0x3E, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x1F, 0x00,
  0x78, 0x0F, 0x00, 0x78, 0x0F, 0x80, 0x70, 0x07, 0x80, 0xF0, 0x07, 0xC0,
  0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xF0,
  0xE0, 0x00, 0xF0, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xFC,
  0x0F, 0x7E, 0x3F, 0x03, 0xBF, 0x9F, 0xC0, 0xEF, 0xFF, 0xF8, 0x3C, 0x3E,
  0x1E, 0x0E, 0x07, 0x03, 0x87, 0x81, 0xC0, 0xE1, 0xE0, 0x70, 0x78, 0x78,
  0x3C, 0x1E, 0x1C, 0x0E, 0x07, 0x87, 0x03, 0x81, 0xC1, 0xC0, 0xE0, 0x70,
  0xF0, 0x38, 0x1C, 0x3C, 0x0E, 0x07, 0x0F, 0x07, 0x83, 0xC3, 0x81, 0xC0,
  0xF0, 0xE0, 0x70, 0x3C, 0x38, 0x1C, 0x0E, 0x0E, 0x07, 0x03, 0x87, 0x81,
  0xC0, 0xE1, 0xE0, 0xF0, 0x78, 0x78, 0x38, 0x1E, 0x1C, 0x0E, 0x07, 0x87,
  0x03, 0x81, 0xC1, 0xC0, 0xE0, 0x70, 0xF0, 0x38, 0x1C, 0x3C, 0x1E, 0x0F,
  0x00, 0x07, 0x1F, 0xE0, 0x1E, 0x7F, 0xF0, 0x3D, 0xFF, 0xE0, 0x7F, 0x03,
  0xE0, 0xF8, 0x03, 0xC1, 0xE0, 0x07, 0xC3, 0xC0, 0x07, 0x8F, 0x00, 0x0F,
  0x1E, 0x00, 0x1C, 0x3C, 0x00, 0x38, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE1,
  0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x1C, 0x3C,
  0x00, 0x78, 0x78, 0x00, 0xF0, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80,
  0x07, 0x8F, 0x00, 0x0E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x70, 0x00,
  0xF1, 0xE0, 0x01, 0xE0, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x80, 0x7F, 0xFF,
  0x03, 0xF0, 0x7E, 0x0F, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x03, 0xCF,
  0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xE3, 0x80, 0x07, 0x8E, 0x00,
  0x1E, 0x78, 0x00, 0x79, 0xE0, 0x01, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1C,
  0x78, 0x00, 0x71, 0xC0, 0x03, 0xC7, 0x00, 0x0F, 0x1C, 0x00, 0x3C, 0x78,
  0x01, 0xE1, 0xE0, 0x0F, 0x87, 0xC0, 0x7C, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0x87, 0xF0, 0x07, 0x9F, 0xFC, 0x07, 0xBF,
  0xFC, 0x07, 0xF0, 0x3E, 0x07, 0xC0, 0x1E, 0x07, 0x80, 0x1E, 0x07, 0x80,
  0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0E, 0x0F, 0x00,
  0x1E, 0x0F, 0x00, 0x1E, 0x0E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00,
  0x1E, 0x1E, 0x00, 0x1C, 0x1E, 0x00, 0x1C, 0x1E, 0x00, 0x3C, 0x1E, 0x00,
  0x3C, 0x3E, 0x00, 0x3C, 0x3E, 0x00, 0x78, 0x3F, 0x00, 0xF8, 0x3F, 0x81,
  0xF0, 0x3F, 0xFF, 0xE0, 0x39, 0xFF, 0xC0, 0x38, 0xFF, 0x80, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x1E, 0x07, 0xFF, 0x38, 0x1F, 0xFF, 0x70, 0x7E, 0x0F, 0xE0, 0xF0, 0x07,
  0xC3, 0xC0, 0x0F, 0x87, 0x80, 0x1F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x38,
  0x78, 0x00, 0xF0, 0xE0, 0x01, 0xE1, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8F,
  0x00, 0x0F, 0x1E, 0x00, 0x1C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xE0,
  0x01, 0xE1, 0xC0, 0x03, 0xC3, 0x80, 0x0F, 0x87, 0x80, 0x1E, 0x0F, 0x00,
  0x7C, 0x1F, 0x01, 0xF8, 0x1F, 0xFE, 0xF0, 0x3F, 0xF9, 0xE0, 0x1F, 0xE3,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x0F, 0x1F, 0xE0, 0x1E, 0x7F, 0xE0, 0x3D, 0xFF, 0xE0, 0x7F, 0x03, 0xE0,
  0xF8, 0x03, 0xC1, 0xE0, 0x07, 0xC7, 0xC0, 0x07, 0x8F, 0x00, 0x0F, 0x1E,
  0x00, 0x1E, 0x3C, 0x00, 0x38, 0x78, 0x00, 0xF0, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x83,
  0xE0, 0x3E, 0x1F, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0xF3, 0xC0, 0x07, 0x8F, 0xC0, 0x3E, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80,
  0x7F, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x1F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x1E, 0x00,
  0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x70, 0xF0, 0x00, 0xE1, 0xE0, 0x03,
  0xC3, 0x80, 0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x38,
  0x78, 0x00, 0x70, 0xF0, 0x01, 0xE1, 0xC0, 0x03, 0xC3, 0x80, 0x07, 0x8F,
  0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x38, 0x78, 0x00, 0xF0, 0xF0,
  0x01, 0xE1, 0xC0, 0x03, 0xC3, 0xC0, 0x07, 0x07, 0x80, 0x1E, 0x0F, 0x00,
  0x78, 0x1F, 0x81, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0x9C, 0x00, 0x1E,
  0x70, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x78,
  0x03, 0xC0, 0xE0, 0x0F, 0x03, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F,
  0x00, 0xF0, 0x3C, 0x01, 0xC1, 0xE0, 0x07, 0x07, 0x80, 0x1C, 0x1C, 0x00,
  0x78, 0xF0, 0x01, 0xE3, 0x80, 0x07, 0x9E, 0x00, 0x0E, 0x70, 0x00, 0x3B,
  0xC0, 0x00, 0xEE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xE0, 0x3C, 0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x7C, 0x0F, 0xE0, 0x7C,
  0x0E, 0xE0, 0x6C, 0x0E, 0xE0, 0xEC, 0x1E, 0xE0, 0xEC, 0x1C, 0xE0, 0xCC,
  0x1C, 0xE1, 0xCC, 0x1C, 0xE1, 0xCC, 0x38, 0xE1, 0x8C, 0x38, 0xE3, 0x8C,
  0x38, 0xE3, 0x8C, 0x70, 0xE3, 0x0C, 0x70, 0xE3, 0x0C, 0x70, 0xE7, 0x0C,
  0xE0, 0xE6, 0x0C, 0xE0, 0xE6, 0x0C, 0xE0, 0xEE, 0x0D, 0xC0, 0xEC, 0x0D,
  0xC0, 0xEC, 0x0D, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC1, 0xE0,
  0x03, 0xE0, 0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x3C, 0x00,
  0x78, 0x1F, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xC3, 0xC0, 0x00, 0x79, 0xE0,
  0x00, 0x1E, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x07, 0x80,
  0x0F, 0x81, 0xE0, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x01,
  0xE0, 0x78, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x3C,
  0x00, 0x38, 0x78, 0x00, 0x70, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0x80,
  0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x1C, 0x3C, 0x00, 0x38, 0x78, 0x00,
  0xF0, 0xF0, 0x01, 0xE1, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x0F,
  0x1E, 0x00, 0x1C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE1,
  0xE0, 0x07, 0xC3, 0xE0, 0x1F, 0x83, 0xE0, 0xEE, 0x07, 0xFF, 0x9C, 0x07,
  0xFE, 0x78, 0x03, 0xF8, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x0F, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x78, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x0E,
  0x3F, 0xE0, 0x3C, 0xFF, 0xC0, 0x7B, 0xC3, 0xC0, 0xF7, 0x83, 0xC1, 0xCE,
  0x07, 0xC7, 0x9C, 0x07, 0xFE, 0x78, 0x07, 0xF8, 0xF0, 0x07, 0xE0,
};

const GFXglyph JetBrainsMono_LightItalic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 11, 34, 28, 9, -34 },
  { 48, 15, 14, 28, 9, -34 },
  { 75, 27, 34, 28, 1, -34 },
  { 190, 25, 48, 28, 2, -41 },
  { 340, 32, 35, 28, -1, -35 },
  { 480, 26, 35, 28, 1, -35 },
  { 594, 6, 14, 28, 13, -34 },
  { 605, 19, 46, 28, 8, -40 },
  { 715, 19, 46, 28, 2, -40 },
  { 825, 24, 24, 28, 3, -29 },
  { 897, 23, 22, 28, 3, -27 },
  { 961, 12, 15, 28, 5, -7 },
  { 984, 15, 3, 28, 7, -17 },
  { 990, 9, 7, 28, 8, -7 },
  { 998, 28, 44, 28, 1, -39 },
  { 1152, 24, 35, 28, 3, -35 },
  { 1257, 22, 34, 28, 2, -34 },
  { 1351, 24, 35, 28, 2, -35 },
  { 1456, 24, 34, 28, 2, -34 },
  { 1558, 22, 34, 28, 3, -34 },
  { 1652, 23, 34, 28, 3, -34 },
  { 1750, 23, 34, 28, 2, -34 },
  { 1848, 22, 34, 28, 6, -34 },
  { 1942, 23, 35, 28, 3, -35 },
  { 2043, 22, 35, 28, 5, -35 },
  { 2140, 12, 26, 28, 8, -26 },
  { 2179, 15, 34, 28, 5, -26 },
  { 2243, 22, 25, 28, 4, -28 },
  { 2312, 23, 15, 28, 3, -23 },
  { 2356, 23, 25, 28, 2, -28 },
  { 2428, 19, 34, 28, 7, -34 },
  { 2509, 28, 43, 28, 0, -35 },
  { 2660, 23, 34, 28, 1, -34 },
  { 2758, 24, 34, 28, 3, -34 },
  { 2860, 24, 35, 28, 3, -35 },
  { 2965, 24, 34, 28, 2, -34 },
  { 3067, 25, 34, 28, 3, -34 },
  { 3174, 25, 34, 28, 3, -34 },
  { 3281, 24, 35, 28, 3, -35 },
  { 3386, 24, 34, 28, 3, -34 },
  { 3488, 23, 34, 28, 3, -34 },
  { 3586, 25, 34, 28, 1, -34 },
  { 3693, 27, 34, 28, 2, -34 },
  { 3808, 21, 34, 28, 3, -34 },
  { 3898, 26, 34, 28, 2, -34 },
  { 4009, 25, 34, 28, 2, -34 },
  { 4116, 23, 35, 28, 3, -35 },
  { 4217, 26, 34, 28, 2, -34 },
  { 4328, 24, 43, 28, 3, -35 },
  { 4457, 25, 34, 28, 2, -34 },
  { 4564, 25, 35, 28, 2, -35 },
  { 4674, 24, 34, 28, 5, -34 },
  { 4776, 24, 34, 28, 3, -34 },
  { 4878, 23, 34, 28, 6, -34 },
  { 4976, 27, 34, 28, 3, -34 },
  { 5091, 29, 34, 28, 0, -34 },
  { 5215, 25, 34, 28, 5, -34 },
  { 5322, 25, 34, 28, 2, -34 },
  { 5429, 18, 44, 28, 7, -39 },
  { 5528, 14, 44, 28, 8, -39 },
  { 5605, 18, 44, 28, 4, -39 },
  { 5704, 21, 18, 28, 4, -34 },
  { 5752, 23, 3, 28, 0, 1 },
  { 5761, 8, 7, 28, 13, -37 },
  { 5768, 23, 26, 28, 3, -26 },
  { 5843, 23, 34, 28, 2, -34 },
  { 5941, 22, 26, 28, 3, -26 },
  { 6013, 24, 34, 28, 3, -34 },
  { 6115, 22, 26, 28, 3, -26 },
  { 6187, 31, 42, 28, -2, -34 },
  { 6350, 23, 34, 28, 3, -26 },
  { 6448, 23, 34, 28, 2, -34 },
  { 6546, 22, 36, 28, 2, -36 },
  { 6645, 24, 44, 28, 1, -36 },
  { 6777, 24, 34, 28, 3, -34 },
  { 6879, 19, 34, 28, 5, -34 },
  { 6960, 26, 26, 28, 1, -26 },
  { 7045, 23, 26, 28, 2, -26 },
  { 7120, 22, 26, 28, 3, -26 },
  { 7192, 24, 34, 28, 1, -26 },
  { 7294, 23, 34, 28, 3, -26 },
  { 7392, 23, 26, 28, 3, -26 },
  { 7467, 22, 26, 28, 3, -26 },
  { 7539, 22, 33, 28, 4, -33 },
  { 7630, 23, 26, 28, 3, -26 },
  { 7705, 22, 26, 28, 5, -26 },
  { 7777, 24, 26, 28, 4, -26 },
  { 7855, 26, 26, 28, 1, -26 },
  { 7940, 23, 34, 28, 3, -26 },
  { 8038, 23, 26, 28, 2, -26 },
  { 8113, 23, 44, 28, 5, -39 },
  { 8240, 11, 44, 28, 9, -39 },
  { 8301, 24, 44, 28, 1, -39 },
  { 8433, 23, 9, 28, 3, -21 },
};

const GFXfont JetBrainsMono_LightItalic47pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_LightItalic47pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_LightItalic47pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _JETBRAINSMONO_LIGHTITALIC47PT7B_H_
