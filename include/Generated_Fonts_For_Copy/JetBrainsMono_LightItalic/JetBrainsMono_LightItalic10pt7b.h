#ifndef _JETBRAINSMONO_LIGHTITALIC10PT7B_H_
#define _JETBRAINSMONO_LIGHTITALIC10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-LightItalic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_LightItalic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x88, 0xB6, 0x80, 0x34, 0xA7, 0xD2, 0xF9, 0x49, 0x00, 0x10,
  0x43, 0x95, 0x70, 0x62, 0xAA, 0x70, 0x80, 0x77, 0x31, 0xC0, 0x83, 0xCA,
  0xA6, 0x00, 0x39, 0x02, 0x19, 0x9A, 0x46, 0x80, 0xE0, 0x34, 0x88, 0x88,
  0x88, 0x40, 0x62, 0x12, 0x22, 0x24, 0x80, 0x25, 0x5C, 0xC9, 0x00, 0x22,
  0xF4, 0x40, 0x6A, 0x40, 0xF0, 0xA0, 0x04, 0x20, 0x84, 0x10, 0x84, 0x10,
  0x80, 0x74, 0x63, 0x69, 0x4B, 0x80, 0x32, 0x84, 0x21, 0x0B, 0xE0, 0x39,
  0x10, 0x82, 0x31, 0x0F, 0x80, 0x79, 0x18, 0x21, 0x4B, 0x80, 0x12, 0x49,
  0x97, 0x10, 0x7C, 0x3D, 0x21, 0x4B, 0x80, 0x34, 0x69, 0x99, 0xE0, 0xFC,
  0x84, 0x42, 0x23, 0x00, 0x74, 0x54, 0xC9, 0x4B, 0x80, 0x74, 0x63, 0xA2,
  0x13, 0x00, 0x50, 0x20, 0x2C, 0x06, 0xA4, 0x0B, 0xA0, 0x83, 0x00, 0xF0,
  0xF0, 0x86, 0x12, 0xC0, 0x71, 0x16, 0x40, 0x40, 0x3D, 0x15, 0xE9, 0xA6,
  0xA9, 0x20, 0x60, 0x11, 0x4A, 0x97, 0xA6, 0x20, 0xF4, 0x65, 0xE9, 0x4B,
  0x80, 0x74, 0x61, 0x08, 0x4B, 0x80, 0xF4, 0x65, 0x29, 0x4B, 0x80, 0x7C,
  0x21, 0xE8, 0x43, 0xC0, 0xFC, 0x21, 0xE8, 0x42, 0x00, 0x74, 0x61, 0x69,
  0x4B, 0x80, 0x8C, 0x65, 0xE9, 0x4A, 0x40, 0x79, 0x08, 0x44, 0x23, 0xC0,
  0x1C, 0x20, 0x82, 0x0A, 0x27, 0x00, 0x8C, 0xA9, 0xCA, 0x4A, 0x40, 0x48,
  0x88, 0x88, 0xF0, 0x6D, 0xB7, 0x56, 0x4A, 0x28, 0x80, 0x4E, 0x75, 0x6B,
  0x5A, 0xC0, 0x74, 0x65, 0x29, 0x4B, 0x80, 0xFC, 0x63, 0xE8, 0x42, 0x00,
  0x74, 0x65, 0x29, 0x4B, 0x84, 0x20, 0xFC, 0x63, 0xEA, 0x4A, 0x40, 0x39,
  0x16, 0x06, 0x0A, 0x27, 0x00, 0xF9, 0x08, 0x44, 0x21, 0x00, 0x8C, 0x65,
  0x29, 0x4B, 0x80, 0x8C, 0xA4, 0xA6, 0x31, 0x00, 0xAD, 0x7B, 0xDB, 0x5A,
  0xC0, 0x64, 0xA3, 0x04, 0x31, 0x28, 0x80, 0x8A, 0x94, 0xC4, 0x21, 0x00,
  0x3C, 0x21, 0x08, 0x21, 0x0F, 0x80, 0x32, 0x44, 0x44, 0x44, 0xE0, 0x92,
  0x44, 0x92, 0x20, 0x71, 0x22, 0x22, 0x22, 0xC0, 0x25, 0x59, 0xF8, 0xC0,
  0x79, 0x99, 0x9F, 0x8A, 0xD9, 0x99, 0xE0, 0x69, 0x88, 0x9E, 0x0B, 0x65,
  0x29, 0x4B, 0xC0, 0x69, 0x9E, 0x9E, 0x1C, 0x47, 0xC8, 0x20, 0x82, 0x08,
  0xC0, 0x79, 0x99, 0x97, 0x1E, 0x8A, 0xD9, 0x99, 0x90, 0x18, 0x1C, 0x21,
  0x08, 0x9F, 0x08, 0x0E, 0x90, 0x88, 0x42, 0x17, 0x00, 0xC4, 0x65, 0x4E,
  0x52, 0x40, 0xE4, 0x44, 0x44, 0x70, 0x69, 0x55, 0x5A, 0xAA, 0xA0, 0xAD,
  0x99, 0x99, 0x69, 0x99, 0x9E, 0x53, 0x52, 0x94, 0xDA, 0x10, 0x79, 0x99,
  0x9F, 0x12, 0xA6, 0xA3, 0x08, 0x40, 0x69, 0x87, 0x1E, 0x27, 0xD0, 0x84,
  0x21, 0xC0, 0x99, 0x99, 0x9E, 0x8C, 0xA5, 0x46, 0x20, 0xAD, 0x7B, 0xEB,
  0x50, 0x44, 0xA3, 0x0C, 0x53, 0x20, 0x99, 0x99, 0xB5, 0x1E, 0x78, 0x44,
  0x44, 0x7C, 0x19, 0x08, 0x4C, 0x10, 0x88, 0x30, 0x55, 0x6A, 0x80, 0x30,
  0x84, 0x41, 0x90, 0x84, 0xC0, 0x45, 0xC0,
};

const GFXglyph JetBrainsMono_LightItalic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 7, 6, 2, -7 },
  { 3, 3, 3, 6, 2, -7 },
  { 5, 6, 7, 6, 0, -7 },
  { 11, 6, 10, 6, 0, -9 },
  { 19, 7, 7, 6, 0, -7 },
  { 26, 6, 7, 6, 0, -7 },
  { 32, 1, 3, 6, 3, -7 },
  { 33, 4, 9, 6, 2, -8 },
  { 38, 4, 9, 6, 1, -8 },
  { 43, 5, 5, 6, 1, -6 },
  { 47, 4, 5, 6, 1, -6 },
  { 50, 3, 4, 6, 1, -2 },
  { 52, 4, 1, 6, 1, -4 },
  { 53, 2, 2, 6, 2, -2 },
  { 54, 6, 9, 6, 0, -8 },
  { 61, 5, 7, 6, 1, -7 },
  { 66, 5, 7, 6, 0, -7 },
  { 71, 6, 7, 6, 0, -7 },
  { 77, 5, 7, 6, 1, -7 },
  { 82, 4, 7, 6, 1, -7 },
  { 86, 5, 7, 6, 1, -7 },
  { 91, 4, 7, 6, 1, -7 },
  { 95, 5, 7, 6, 1, -7 },
  { 100, 5, 7, 6, 1, -7 },
  { 105, 5, 7, 6, 1, -7 },
  { 110, 2, 6, 6, 2, -6 },
  { 112, 3, 8, 6, 1, -6 },
  { 115, 5, 5, 6, 1, -6 },
  { 119, 4, 3, 6, 1, -5 },
  { 121, 4, 5, 6, 1, -6 },
  { 124, 4, 7, 6, 1, -7 },
  { 128, 6, 9, 6, 0, -7 },
  { 135, 5, 7, 6, 0, -7 },
  { 140, 5, 7, 6, 1, -7 },
  { 145, 5, 7, 6, 1, -7 },
  { 150, 5, 7, 6, 1, -7 },
  { 155, 5, 7, 6, 1, -7 },
  { 160, 5, 7, 6, 1, -7 },
  { 165, 5, 7, 6, 1, -7 },
  { 170, 5, 7, 6, 1, -7 },
  { 175, 5, 7, 6, 1, -7 },
  { 180, 6, 7, 6, 0, -7 },
  { 186, 5, 7, 6, 1, -7 },
  { 191, 4, 7, 6, 1, -7 },
  { 195, 6, 7, 6, 0, -7 },
  { 201, 5, 7, 6, 1, -7 },
  { 206, 5, 7, 6, 1, -7 },
  { 211, 5, 7, 6, 1, -7 },
  { 216, 5, 9, 6, 1, -7 },
  { 222, 5, 7, 6, 1, -7 },
  { 227, 6, 7, 6, 0, -7 },
  { 233, 5, 7, 6, 1, -7 },
  { 238, 5, 7, 6, 1, -7 },
  { 243, 5, 7, 6, 1, -7 },
  { 248, 5, 7, 6, 1, -7 },
  { 253, 6, 7, 6, 0, -7 },
  { 259, 5, 7, 6, 1, -7 },
  { 264, 6, 7, 6, 0, -7 },
  { 270, 4, 9, 6, 1, -8 },
  { 275, 3, 9, 6, 2, -8 },
  { 279, 4, 9, 6, 1, -8 },
  { 284, 4, 4, 6, 1, -7 },
  { 286, 5, 1, 6, 0, 0 },
  { 287, 1, 2, 6, 3, -8 },
  { 288, 4, 6, 6, 1, -6 },
  { 291, 4, 7, 6, 1, -7 },
  { 295, 4, 6, 6, 1, -6 },
  { 298, 5, 7, 6, 1, -7 },
  { 303, 4, 6, 6, 1, -6 },
  { 306, 6, 9, 6, 0, -7 },
  { 313, 4, 8, 6, 1, -6 },
  { 317, 4, 7, 6, 1, -7 },
  { 321, 5, 8, 6, 0, -8 },
  { 326, 5, 10, 6, 0, -8 },
  { 333, 5, 7, 6, 1, -7 },
  { 338, 4, 7, 6, 1, -7 },
  { 342, 6, 6, 6, 0, -6 },
  { 347, 4, 6, 6, 1, -6 },
  { 350, 4, 6, 6, 1, -6 },
  { 353, 5, 8, 6, 0, -6 },
  { 358, 4, 8, 6, 1, -6 },
  { 362, 5, 6, 6, 1, -6 },
  { 366, 4, 6, 6, 1, -6 },
  { 369, 5, 7, 6, 1, -7 },
  { 374, 4, 6, 6, 1, -6 },
  { 377, 5, 6, 6, 1, -6 },
  { 381, 5, 6, 6, 1, -6 },
  { 385, 6, 6, 6, 0, -6 },
  { 390, 4, 8, 6, 1, -6 },
  { 394, 5, 6, 6, 0, -6 },
  { 398, 5, 9, 6, 1, -8 },
  { 404, 2, 9, 6, 2, -8 },
  { 407, 5, 9, 6, 0, -8 },
  { 413, 5, 2, 6, 1, -5 },
};

const GFXfont JetBrainsMono_LightItalic10pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_LightItalic10pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_LightItalic10pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _JETBRAINSMONO_LIGHTITALIC10PT7B_H_
