#ifndef _JETBRAINSMONO_LIGHTITALIC59PT7B_H_
#define _JETBRAINSMONO_LIGHTITALIC59PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-LightItalic.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_LightItalic59pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0xFF,
  0x81, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0xF3, 0xE0, 0x3E, 0x3E, 0x03,
  0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE7, 0xE0, 0x7E, 0x7C, 0x07, 0xC7, 0xC0,
  0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0x80, 0x78, 0x78,
  0x07, 0x87, 0x80, 0x78, 0x78, 0x0F, 0x8F, 0x80, 0xF8, 0xF0, 0x0F, 0x0F,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x1E, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x1C,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0xF0, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0xF0,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00,
  0xF0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x1E, 0x00,
  0x00, 0xF0, 0x07, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x3E, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x3C, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x3C, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xC7,
  0x1F, 0x80, 0x3F, 0x0E, 0x1F, 0x80, 0xFC, 0x1C, 0x1F, 0x01, 0xF0, 0x78,
  0x3E, 0x03, 0xC0, 0xE0, 0x7C, 0x0F, 0x81, 0xC0, 0xF8, 0x1F, 0x03, 0x81,
  0xF0, 0x3E, 0x07, 0x00, 0x00, 0x7C, 0x0E, 0x00, 0x00, 0xF8, 0x3C, 0x00,
  0x01, 0xF0, 0x78, 0x00, 0x03, 0xF0, 0xE0, 0x00, 0x03, 0xF1, 0xC0, 0x00,
  0x07, 0xF3, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0xBF, 0xC0, 0x00, 0x07, 0x1F, 0x80, 0x00,
  0x1E, 0x1F, 0x80, 0x00, 0x38, 0x1F, 0x00, 0x00, 0x70, 0x3E, 0x00, 0x00,
  0xE0, 0x7C, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x03, 0x81, 0xF0, 0xF8, 0x0F,
  0x03, 0xE1, 0xF0, 0x1E, 0x07, 0xC3, 0xE0, 0x38, 0x0F, 0x03, 0xE0, 0x70,
  0x3E, 0x07, 0xC0, 0xE0, 0xFC, 0x0F, 0xC1, 0xC3, 0xF0, 0x1F, 0xC7, 0x8F,
  0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0x80, 0x1F, 0xFC, 0x00, 0x0F, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0x80, 0x1F, 0x0F, 0x80, 0x07, 0x80, 0x1F, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0xF0, 0x07, 0x80,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x01, 0xE0,
  0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x07, 0x83,
  0xC0, 0x00, 0x38, 0x03, 0x83, 0xC0, 0x00, 0x3E, 0x03, 0xC3, 0xC0, 0x00,
  0x0F, 0x03, 0xE3, 0xC0, 0x00, 0x07, 0xC3, 0xE1, 0xE0, 0x00, 0x03, 0xFF,
  0xE1, 0xE0, 0x00, 0x00, 0xFF, 0xE1, 0xE0, 0x00, 0x00, 0x3F, 0xE1, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0xFF, 0x80, 0x00, 0x00, 0xF0, 0xFF,
  0xE0, 0x00, 0x00, 0xF0, 0xFF, 0xF8, 0x00, 0x00, 0xF0, 0xF8, 0x7C, 0x00,
  0x00, 0x78, 0xF8, 0x1E, 0x00, 0x00, 0x78, 0x78, 0x07, 0x80, 0x00, 0x78,
  0x38, 0x03, 0xC0, 0x00, 0x78, 0x3C, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x01,
  0xE0, 0x00, 0x78, 0x0F, 0x00, 0xF0, 0x00, 0x3C, 0x07, 0x80, 0x78, 0x00,
  0x3C, 0x03, 0xC0, 0x3C, 0x00, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0x3C, 0x00,
  0xF0, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x1F, 0x00, 0x3C, 0x00, 0x3F, 0x3F,
  0x00, 0x3C, 0x00, 0x0F, 0xFF, 0x00, 0x1E, 0x00, 0x07, 0xFF, 0x00, 0x3E,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0x9F,
  0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0x1F, 0x0F, 0x80, 0x3E, 0x3E, 0x0F, 0xC0, 0x3C, 0x3E, 0x07, 0xC0,
  0x7C, 0x3C, 0x07, 0xE0, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x7C, 0x01, 0xF1,
  0xF0, 0x7C, 0x01, 0xF3, 0xE0, 0x7C, 0x00, 0xFF, 0xC0, 0x78, 0x00, 0xFF,
  0x80, 0x78, 0x00, 0x7F, 0x80, 0xF8, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0xFF,
  0x80, 0xF8, 0x01, 0xFF, 0xC0, 0xFC, 0x07, 0xE7, 0xC0, 0x7F, 0xFF, 0xC3,
  0xE0, 0x7F, 0xFF, 0x83, 0xE0, 0x3F, 0xFF, 0x01, 0xF0, 0x0F, 0xFC, 0x01,
  0xF8, 0x01, 0x80, 0x00, 0x00, 0x3E, 0x7C, 0xF9, 0xF7, 0xEF, 0x9F, 0x3E,
  0x7C, 0xF9, 0xF7, 0xCF, 0x9F, 0x3E, 0x78, 0xF1, 0xE0, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x20, 0x03,
  0xE0, 0x02, 0x70, 0x07, 0x80, 0x3D, 0xFC, 0x0F, 0x03, 0xFB, 0xFE, 0x1E,
  0x1F, 0xFF, 0xFF, 0x38, 0xFF, 0xE7, 0xFF, 0x77, 0xFF, 0x83, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x00, 0xF8, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x80, 0x01, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xF8,
  0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0xF7,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x0F,
  0xE7, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFB, 0xFC, 0x7E, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFB, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0x80,
  0x07, 0xC0, 0xF8, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0xF1, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C, 0x7C, 0x0F, 0x03,
  0xE3, 0xE0, 0xFC, 0x1F, 0x1F, 0x0F, 0xE0, 0xF0, 0xF0, 0x7F, 0x07, 0x87,
  0x83, 0xF8, 0x7C, 0x7C, 0x0F, 0x83, 0xE3, 0xE0, 0x38, 0x1F, 0x1F, 0x00,
  0x00, 0xF8, 0xF8, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x01,
  0xE3, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0x3C, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x0F, 0x80,
  0x01, 0xF0, 0x7E, 0x00, 0x0F, 0x81, 0xF0, 0x01, 0xF8, 0x0F, 0xE0, 0x1F,
  0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFB,
  0xC0, 0x01, 0xFC, 0x78, 0x00, 0x7F, 0x1F, 0x00, 0x1F, 0x83, 0xE0, 0x07,
  0xE0, 0x7C, 0x00, 0xF0, 0x0F, 0x80, 0x1C, 0x01, 0xF0, 0x02, 0x00, 0x3C,
  0x00, 0x80, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0xFF, 0xDF, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x7C, 0x1E, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0x1F, 0x07, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x1F, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x0F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x3F,
  0x00, 0x3C, 0x07, 0xE0, 0x03, 0xC0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x07,
  0xC1, 0xF0, 0x00, 0x7C, 0x3F, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x78, 0x7C,
  0x00, 0x07, 0x87, 0xC0, 0x00, 0xF8, 0x78, 0x00, 0x0F, 0x87, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF1, 0xFF, 0x80, 0x0F, 0x1F, 0xFE,
  0x00, 0x7B, 0xFF, 0xF8, 0x07, 0xDF, 0xFF, 0xE0, 0x3F, 0xE0, 0x3F, 0x81,
  0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x03,
  0xF0, 0x3E, 0x00, 0x1F, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x20, 0x00, 0x3F, 0x7F, 0xE0, 0x03, 0xEF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFC, 0x7F, 0xC0, 0xFE, 0x00, 0xFE, 0x1F, 0x80, 0x07, 0xE1,
  0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x1F, 0x3C, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F,
  0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xE7, 0x80,
  0x00, 0x3E, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x0F,
  0x87, 0xE0, 0x01, 0xF0, 0x3F, 0x80, 0x7F, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xE7, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0xF1, 0xF0,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8, 0x78, 0x00, 0x07, 0xC3, 0xC0, 0x00,
  0x7C, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xDF, 0xF0, 0x03, 0xF0, 0x07, 0xE0,
  0x1F, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x0F,
  0x00, 0x01, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x1E, 0x07, 0xC0,
  0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x00, 0xF8, 0x00,
  0x7C, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x3F, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xF8, 0x7F, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x07, 0xE0, 0x01, 0xF0, 0x1F, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0xF8, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x3C,
  0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x07,
  0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0xFE, 0x01, 0xFC, 0x0F,
  0x80, 0x07, 0xE1, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x3E, 0x7C, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x1E, 0xF8, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x3C, 0xF8, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0xFC,
  0x7C, 0x00, 0x0F, 0x87, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x03, 0xFE,
  0x7F, 0xF0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xF7, 0xC0, 0x07, 0xFE, 0xFC,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x1F, 0xE0, 0x7F, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF,
  0x81, 0xFC, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x07, 0xF8, 0x1F,
  0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0x00, 0x60, 0x00,
  0x00, 0x0F, 0x80, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x02, 0x00, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x80,
  0x04, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03,
  0xFC, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x0F, 0x80, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00,
  0xF8, 0x0F, 0x00, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x00, 0x3C, 0x1F, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x18, 0x3E, 0x0F, 0x00, 0x3F, 0xE7, 0xC1, 0xE0, 0x0F, 0xFE, 0xF0,
  0x7C, 0x03, 0xFF, 0xFE, 0x0F, 0x00, 0xFC, 0x0F, 0xC1, 0xE0, 0x1F, 0x00,
  0xF8, 0x3C, 0x07, 0xC0, 0x1F, 0x07, 0x80, 0xF0, 0x03, 0xE0, 0xF0, 0x1E,
  0x00, 0x78, 0x3E, 0x03, 0xC0, 0x0F, 0x07, 0xC0, 0x78, 0x01, 0xE0, 0xF0,
  0x1F, 0x00, 0x3C, 0x1E, 0x03, 0xE0, 0x07, 0x83, 0xC0, 0x78, 0x01, 0xF0,
  0x78, 0x0F, 0x00, 0x3E, 0x1F, 0x01, 0xE0, 0x07, 0x83, 0xE0, 0x3C, 0x00,
  0xF0, 0x78, 0x0F, 0x80, 0x1E, 0x0F, 0x01, 0xF0, 0x07, 0xC1, 0xE0, 0x3E,
  0x00, 0xF8, 0x3C, 0x07, 0xC0, 0x3F, 0x07, 0x80, 0x7C, 0x0F, 0xC1, 0xF0,
  0x0F, 0xFF, 0xF8, 0x3C, 0x00, 0xFF, 0xEF, 0x07, 0x80, 0x0F, 0xF9, 0xE0,
  0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x03, 0xE7, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x0F,
  0x8F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x3C, 0x1F,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1E, 0x07, 0xC0, 0x01, 0xF0, 0x1E, 0x00,
  0x0F, 0x80, 0xF0, 0x00, 0x78, 0x07, 0x80, 0x07, 0xC0, 0x3C, 0x00, 0x3C,
  0x01, 0xE0, 0x03, 0xE0, 0x0F, 0x00, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x03,
  0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x78, 0x00, 0xF8, 0x07, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xF0,
  0x00, 0x3C, 0x0F, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x7C, 0x3E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xF8,
  0xF0, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0xF7, 0xC0,
  0x00, 0x07, 0xBE, 0x00, 0x00, 0x3E, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x0F,
  0xF8, 0x0F, 0x80, 0x07, 0xE0, 0x3E, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x3F,
  0x03, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xE0, 0x78,
  0x00, 0x0F, 0x81, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0x3E, 0x00,
  0x1F, 0x00, 0xF8, 0x07, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xC0, 0x07, 0xF0,
  0x1F, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x3E, 0x07,
  0x80, 0x00, 0x78, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0x1E, 0x0F, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xE0, 0xF0, 0x00,
  0x0F, 0x83, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0xFE, 0x07, 0x80, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x0F, 0xC0,
  0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3C, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x87,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC3,
  0xC0, 0x00, 0x3C, 0x3E, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x1F, 0x07, 0xC0,
  0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0xF8, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03,
  0xE0, 0x0F, 0xF0, 0x0F, 0x80, 0x0F, 0xC0, 0x3E, 0x00, 0x1F, 0x80, 0xF0,
  0x00, 0x3E, 0x03, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x07, 0x81, 0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0xF8, 0x1E, 0x00, 0x03,
  0xE0, 0x78, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8,
  0x3E, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x7C, 0x0F,
  0x00, 0x01, 0xF0, 0x3C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x78, 0x1F, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xE0, 0x00,
  0x3E, 0x07, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F,
  0x03, 0xE0, 0x00, 0x3C, 0x0F, 0x80, 0x01, 0xF0, 0x3C, 0x00, 0x07, 0xC0,
  0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xE0, 0x7C,
  0x00, 0x3F, 0x01, 0xF0, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0xC0, 0x1F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0xF8, 0x3C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x1F, 0xFF, 0x87, 0xC0, 0xFF, 0xFC, 0x3E, 0x07, 0xFF, 0xE1,
  0xE0, 0x3F, 0xFF, 0x0F, 0x01, 0xFF, 0xF8, 0xF8, 0x00, 0x07, 0x87, 0xC0,
  0x00, 0x3C, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00,
  0xF8, 0x78, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x3C, 0x3E, 0x00, 0x03, 0xE0,
  0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xF8,
  0x00, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x7C, 0x07, 0x80, 0x00,
  0xF0, 0x1F, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0xF0, 0x1F, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x3E, 0x03,
  0xC0, 0x00, 0x78, 0x0F, 0x80, 0x00, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x07, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00,
  0x03, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x0F, 0x80, 0xF0, 0x00,
  0x1E, 0x03, 0xE0, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x01,
  0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x0F,
  0x80, 0xF0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0xF8,
  0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x07, 0xC0,
  0x78, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0xC0,
  0x7E, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x7F, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0xF0, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x03,
  0xE0, 0x07, 0x80, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xF0, 0x03, 0xE0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x03,
  0xC0, 0x0F, 0x80, 0x03, 0xE0, 0x07, 0xC0, 0x01, 0xF0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3F, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x03, 0xF0,
  0x07, 0xC0, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0xF0, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03,
  0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x05, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xE0, 0x3F, 0xC0, 0x0F, 0x70, 0x1F,
  0xE0, 0x07, 0xF8, 0x0F, 0x70, 0x07, 0xBC, 0x07, 0x38, 0x03, 0xDE, 0x03,
  0x9E, 0x03, 0xCF, 0x03, 0xCF, 0x01, 0xE7, 0x01, 0xE7, 0x81, 0xE7, 0x80,
  0xF3, 0xC0, 0xF3, 0xC0, 0x78, 0xE0, 0xF1, 0xE0, 0x3C, 0x78, 0x78, 0xF0,
  0x1E, 0x3C, 0x78, 0xF8, 0x1F, 0x1E, 0x3C, 0x78, 0x0F, 0x8F, 0x1C, 0x3C,
  0x07, 0xC3, 0x9E, 0x1E, 0x03, 0xC1, 0xCE, 0x0F, 0x01, 0xE0, 0xEF, 0x0F,
  0x80, 0xF0, 0x7F, 0x07, 0xC0, 0x78, 0x3F, 0x83, 0xE0, 0x7C, 0x1F, 0x81,
  0xE0, 0x3E, 0x07, 0xC0, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00,
  0x7C, 0x07, 0x80, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x0F, 0x01, 0xF0, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x03, 0xE0, 0x3C, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0xF8, 0x1F, 0x00,
  0x00, 0x78, 0x0F, 0x80, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x1E, 0x03, 0xE0,
  0x00, 0x1F, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x07, 0xC0, 0x78,
  0x00, 0x03, 0xC0, 0x7C, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x7C, 0x0F, 0xF0, 0x00, 0xF8,
  0x1F, 0xE0, 0x01, 0xE0, 0x3F, 0xC0, 0x03, 0xC0, 0x7F, 0x80, 0x07, 0x80,
  0xFF, 0x00, 0x1F, 0x01, 0xEF, 0x00, 0x3E, 0x07, 0xDE, 0x00, 0x7C, 0x0F,
  0xBC, 0x00, 0xF8, 0x1F, 0x78, 0x01, 0xE0, 0x3C, 0xF8, 0x03, 0xC0, 0x78,
  0xF0, 0x07, 0x80, 0xF1, 0xE0, 0x1F, 0x01, 0xE3, 0xC0, 0x3E, 0x07, 0xC7,
  0x80, 0x7C, 0x0F, 0x8F, 0x80, 0xF0, 0x1F, 0x0F, 0x01, 0xE0, 0x3C, 0x1E,
  0x03, 0xC0, 0x78, 0x3C, 0x0F, 0x80, 0xF0, 0x78, 0x1F, 0x03, 0xE0, 0xF8,
  0x3E, 0x07, 0xC0, 0xF0, 0x78, 0x0F, 0x81, 0xE0, 0xF0, 0x1E, 0x03, 0xC1,
  0xE0, 0x3C, 0x07, 0x87, 0xC0, 0x78, 0x0F, 0x8F, 0x81, 0xF0, 0x0F, 0x1F,
  0x03, 0xE0, 0x1E, 0x3E, 0x07, 0xC0, 0x3C, 0x78, 0x0F, 0x80, 0x7C, 0xF0,
  0x1E, 0x00, 0x79, 0xE0, 0x3C, 0x00, 0xF7, 0xC0, 0x78, 0x01, 0xEF, 0x81,
  0xF0, 0x03, 0xDF, 0x03, 0xE0, 0x07, 0xFC, 0x07, 0xC0, 0x07, 0xF8, 0x0F,
  0x00, 0x0F, 0xF0, 0x1E, 0x00, 0x1F, 0xE0, 0x3C, 0x00, 0x3F, 0xC0, 0xF8,
  0x00, 0x7F, 0x81, 0xF0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x0F,
  0xC0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x78, 0x3C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x7C, 0x3E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x01,
  0xF0, 0x3E, 0x00, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x0F, 0xE0, 0x1F, 0x80,
  0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03,
  0xE0, 0x03, 0xFC, 0x03, 0xE0, 0x00, 0xFE, 0x03, 0xE0, 0x00, 0x7E, 0x03,
  0xC0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xFC, 0x0F, 0x80, 0x01, 0xF8, 0x0F,
  0x80, 0x03, 0xF8, 0x0F, 0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x07,
  0xC0, 0xF8, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x3E, 0x1E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x8F, 0x80,
  0x00, 0x7C, 0x7C, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x1E, 0x1F, 0x00, 0x01,
  0xF0, 0xF0, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0x80,
  0x00, 0x7C, 0x3C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00,
  0xF0, 0xF8, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x7C, 0x3C, 0x00, 0x03, 0xE1,
  0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0x87, 0xC0,
  0x00, 0x3C, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x01,
  0xF0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x0F, 0xE0, 0x1F, 0x80,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x03, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3E,
  0x00, 0x3F, 0x80, 0x7C, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x1F, 0x01, 0xE0,
  0x00, 0x3F, 0x03, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF0, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0xF8, 0x1F, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x7F,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x78, 0x03, 0xE0, 0x00, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x07,
  0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x78, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0xF8, 0x03, 0xE0,
  0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0x00,
  0x03, 0xE0, 0x3C, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0x3F, 0x01, 0xF0, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x1E, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x07,
  0xE0, 0x3F, 0x80, 0x1F, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x78, 0x1F, 0x00, 0x03, 0xE0,
  0x78, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3E,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x3C, 0x0F, 0x80,
  0x01, 0xF0, 0x3C, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x7C, 0x1F, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x3E,
  0x07, 0x80, 0x00, 0xF8, 0x1E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF0,
  0x00, 0x1F, 0x03, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x03,
  0xE0, 0x78, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x3E, 0x07, 0x80, 0x01, 0xF0,
  0x1F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x01, 0xF8, 0x01, 0xF8, 0x07,
  0xF0, 0x0F, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFB, 0xC0, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x1E, 0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3C, 0x0F, 0x00,
  0x03, 0xE0, 0x78, 0x00, 0x1F, 0x03, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x78, 0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x3C, 0x01,
  0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x01, 0xF0, 0x01, 0xE0,
  0x0F, 0x80, 0x0F, 0x00, 0x78, 0x00, 0x78, 0x07, 0xC0, 0x03, 0xC0, 0x3C,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF0, 0x00,
  0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x78, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x3C,
  0x3E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x03, 0xCF, 0x80, 0x00, 0x1F, 0x78, 0x00, 0x00, 0xFB, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3C, 0x01,
  0xF8, 0x07, 0xCF, 0x00, 0x7E, 0x01, 0xF3, 0xC0, 0x1F, 0x80, 0x78, 0xF0,
  0x0E, 0xC0, 0x1E, 0x3C, 0x03, 0xF0, 0x0F, 0x8F, 0x00, 0xFC, 0x03, 0xC3,
  0xC0, 0x3F, 0x00, 0xF0, 0xF0, 0x1D, 0xC0, 0x3C, 0x3C, 0x07, 0x70, 0x1F,
  0x0F, 0x01, 0xDC, 0x07, 0x87, 0xC0, 0xF7, 0x01, 0xE1, 0xF0, 0x39, 0xC0,
  0x78, 0x7C, 0x0E, 0x70, 0x3C, 0x1F, 0x03, 0x9C, 0x0F, 0x07, 0xC1, 0xC7,
  0x03, 0xC1, 0xE0, 0x71, 0xC1, 0xF0, 0x78, 0x1C, 0x70, 0x78, 0x1E, 0x0F,
  0x1C, 0x1E, 0x07, 0x83, 0x87, 0x07, 0x81, 0xE0, 0xE1, 0xC3, 0xE0, 0x78,
  0x38, 0x70, 0xF0, 0x1E, 0x1C, 0x1C, 0x3C, 0x07, 0x87, 0x07, 0x0F, 0x01,
  0xE1, 0xC1, 0xC7, 0x80, 0x78, 0xE0, 0x71, 0xE0, 0x1E, 0x38, 0x1C, 0x78,
  0x07, 0x8E, 0x07, 0x3E, 0x01, 0xE7, 0x81, 0xCF, 0x00, 0x79, 0xC0, 0xF3,
  0xC0, 0x1E, 0x70, 0x38, 0xF0, 0x07, 0x9C, 0x0E, 0x78, 0x01, 0xEE, 0x03,
  0x9E, 0x00, 0x7B, 0x80, 0xE7, 0x80, 0x1E, 0xE0, 0x39, 0xE0, 0x07, 0x78,
  0x0E, 0xF0, 0x03, 0xDC, 0x03, 0xBC, 0x00, 0xF7, 0x00, 0xEF, 0x00, 0x3D,
  0xC0, 0x3B, 0x80, 0x0F, 0xE0, 0x0F, 0xE0, 0x03, 0xF8, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x0F, 0xC0, 0x0F, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x07, 0x83, 0xE0, 0x00,
  0x00, 0x7C, 0x3E, 0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x00, 0x3E, 0xF8,
  0x00, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0x9F, 0x00, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0x3F, 0x0F, 0x00, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x3E, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x0F, 0x9E, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x0F, 0x83, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xE0, 0x3E, 0x00, 0x0F,
  0x80, 0x78, 0x00, 0x7C, 0x01, 0xF0, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80,
  0x0F, 0x00, 0x7C, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x01,
  0xE0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3C,
  0x7C, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x08, 0x03, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xEF, 0x00, 0x01, 0xF7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0xF9, 0xE0,
  0x00, 0x78, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x7C, 0x1E, 0x00, 0x3C, 0x07,
  0x80, 0x3C, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x1E, 0x00, 0xF8, 0x1F, 0x00,
  0x3C, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xC7, 0x80,
  0x01, 0xE7, 0xC0, 0x00, 0xF7, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x1E, 0x7F,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF8, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0xF8, 0x1F,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0x1F, 0x01, 0xFF, 0xF9, 0xF0, 0x3F,
  0xFF, 0xDF, 0x07, 0xF8, 0x3D, 0xF0, 0x7E, 0x00, 0xFE, 0x0F, 0x80, 0x07,
  0xE0, 0xF8, 0x00, 0x7E, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x1E,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xC3, 0xE0, 0x00,
  0x3C, 0x3E, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x7C, 0x3C, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x78, 0x7C, 0x00,
  0x0F, 0x87, 0x80, 0x00, 0xF8, 0x78, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8,
  0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x3F, 0x07, 0xE0,
  0x07, 0xF0, 0x7F, 0x00, 0xFF, 0x03, 0xFE, 0xFD, 0xF0, 0x3F, 0xFF, 0x9F,
  0x01, 0xFF, 0xF1, 0xE0, 0x07, 0xFE, 0x3E, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x7F, 0x80, 0x0F, 0x8F, 0xFE, 0x00, 0x7C, 0xFF, 0xFC, 0x03, 0xCF,
  0xFF, 0xE0, 0x1E, 0xF0, 0x3F, 0x81, 0xFE, 0x00, 0xFC, 0x0F, 0xE0, 0x03,
  0xF0, 0x7E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x1F, 0x07, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0x3C, 0x1F, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0x80, 0x00,
  0xF8, 0x3C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xE0,
  0xF8, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x78, 0x3E, 0x00, 0x07, 0xC1, 0xE0,
  0x00, 0x3E, 0x1F, 0x80, 0x01, 0xE0, 0xFC, 0x00, 0x1F, 0x07, 0xE0, 0x01,
  0xF8, 0x3F, 0x80, 0x1F, 0x81, 0xFE, 0x01, 0xF8, 0x0F, 0x7F, 0xFF, 0xC0,
  0x79, 0xFF, 0xFC, 0x07, 0xCF, 0xFF, 0x80, 0x3E, 0x1F, 0xF8, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xF8, 0x3F, 0xC0, 0x7E, 0x00, 0x7E,
  0x0F, 0xC0, 0x07, 0xE0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE1, 0xF0,
  0x00, 0x3E, 0x3E, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x20, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x07, 0x8F,
  0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0x7C, 0x00,
  0x1F, 0x07, 0xE0, 0x03, 0xE0, 0x7F, 0x00, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xC0, 0x01, 0xFC, 0x0F, 0x00, 0x1F, 0xFC, 0x7C, 0x01,
  0xFF, 0xF9, 0xF0, 0x0F, 0xFF, 0xF7, 0xC0, 0x7F, 0x83, 0xDF, 0x01, 0xF8,
  0x03, 0xFC, 0x0F, 0x80, 0x07, 0xE0, 0x3E, 0x00, 0x1F, 0x81, 0xF0, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x1E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0xF0, 0x3E, 0x00, 0x07, 0xC0,
  0xF0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x07, 0x81, 0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0xF8, 0x1E, 0x00,
  0x03, 0xE0, 0x78, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x01,
  0xF8, 0x1F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xFC,
  0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xFB, 0xF7, 0xC0, 0x3F, 0xFF, 0x9F, 0x00,
  0x7F, 0xFC, 0x78, 0x00, 0x7F, 0xE3, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x3F, 0x01, 0xFC, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C,
  0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x0F,
  0x9F, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0x8F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x8F,
  0x00, 0x01, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x07, 0xE0, 0x07,
  0xE0, 0x7F, 0x8F, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF,
  0x1F, 0x01, 0xFF, 0xF9, 0xF0, 0x3F, 0xFF, 0xDF, 0x07, 0xF8, 0x3D, 0xF0,
  0x7E, 0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xE0, 0xF8, 0x00, 0x7E, 0x1F, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3E,
  0x3E, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x3C, 0x3E, 0x00, 0x07, 0xC3, 0xC0,
  0x00, 0x7C, 0x3C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x07,
  0x87, 0xC0, 0x00, 0x78, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x7C,
  0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x06,
  0xF0, 0x3F, 0xC3, 0xEF, 0x01, 0xFF, 0xFD, 0xF0, 0x1F, 0xFF, 0x9F, 0x00,
  0x7F, 0xF1, 0xF0, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x03, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x7F, 0x00, 0x0F, 0x8F, 0xFF, 0x00,
  0x7C, 0xFF, 0xFC, 0x03, 0xCF, 0xFF, 0xE0, 0x1E, 0xF0, 0x3F, 0x81, 0xFE,
  0x00, 0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0xF8,
  0x7C, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x3C, 0x1F, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x1F, 0x07, 0x80, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x3E, 0x1F, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0xF8,
  0x3C, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x0F, 0x07, 0xC0, 0x00, 0x78, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x3E, 0x0F, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x78,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x0F, 0xC0, 0xF8, 0x00,
  0x3F, 0x01, 0xF0, 0x00, 0xFC, 0x03, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x07,
  0xC0, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x01, 0xF8,
  0x00, 0xF8, 0x07, 0xE0, 0x01, 0xE0, 0x1F, 0x80, 0x03, 0xC0, 0x7E, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x07,
  0xC0, 0x7E, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0x78, 0x01, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0,
  0x03, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x07, 0xE0, 0x1F, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x0F, 0xC0, 0x78, 0x00, 0x0F, 0x80, 0xF0, 0x00,
  0x1F, 0x83, 0xE0, 0x00, 0x1F, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0xC0, 0xF8, 0x07, 0xDF, 0xE3, 0xFC, 0x07,
  0xBF, 0xF7, 0xFE, 0x07, 0xBF, 0xF7, 0xFF, 0x07, 0xE1, 0xFC, 0x1F, 0x07,
  0xC0, 0xF8, 0x1F, 0x07, 0x80, 0xF0, 0x1F, 0x0F, 0x80, 0xF0, 0x1F, 0x0F,
  0x80, 0xF0, 0x1F, 0x0F, 0x80, 0xF0, 0x1E, 0x0F, 0x00, 0xF0, 0x1E, 0x0F,
  0x00, 0xE0, 0x1E, 0x0F, 0x01, 0xE0, 0x1E, 0x0F, 0x01, 0xE0, 0x3E, 0x1F,
  0x01, 0xE0, 0x3E, 0x1F, 0x01, 0xE0, 0x3C, 0x1E, 0x01, 0xE0, 0x3C, 0x1E,
  0x01, 0xE0, 0x3C, 0x1E, 0x03, 0xC0, 0x3C, 0x1E, 0x03, 0xC0, 0x7C, 0x3E,
  0x03, 0xC0, 0x7C, 0x3E, 0x03, 0xC0, 0x7C, 0x3E, 0x03, 0xC0, 0x78, 0x3C,
  0x03, 0xC0, 0x78, 0x3C, 0x07, 0x80, 0x78, 0x3C, 0x07, 0x80, 0x78, 0x7C,
  0x07, 0x80, 0xF8, 0x7C, 0x07, 0x80, 0xF8, 0x7C, 0x07, 0x80, 0xF0, 0x78,
  0x07, 0x80, 0xF0, 0x78, 0x07, 0x00, 0xF0, 0x78, 0x0F, 0x00, 0xF0, 0xF8,
  0x0F, 0x01, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x3E, 0x3F, 0xFC, 0x01, 0xF3,
  0xFF, 0xF0, 0x0F, 0x3F, 0xFF, 0x80, 0x7B, 0xC0, 0xFE, 0x07, 0xF8, 0x03,
  0xF0, 0x3F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0,
  0x7C, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x7C, 0x1E, 0x00, 0x03, 0xE1, 0xF0,
  0x00, 0x1E, 0x0F, 0x80, 0x00, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x7C, 0x1E, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8,
  0x7C, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x3C, 0x1F, 0x00, 0x03, 0xE0, 0xF0,
  0x00, 0x1F, 0x07, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x3C, 0x1F, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8,
  0x3C, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xE0, 0xF8,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0x83, 0xFC, 0x0F, 0xC0, 0x1F, 0x83,
  0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x7C, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0x7C,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x78, 0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C,
  0xF8, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0xFC, 0x3F, 0x00,
  0x3F, 0x07, 0xF0, 0x0F, 0xC0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x03, 0xE3, 0xFF, 0xC0, 0x07, 0xCF, 0xFF, 0xC0, 0x0F, 0x3F,
  0xFF, 0x80, 0x1E, 0xF0, 0x3F, 0x80, 0x7F, 0x80, 0x3F, 0x00, 0xFE, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x1E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x7C,
  0x07, 0x80, 0x00, 0xF8, 0x0F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x1E, 0x03,
  0xE0, 0x00, 0x7C, 0x07, 0x80, 0x00, 0xF8, 0x1F, 0x80, 0x01, 0xE0, 0x3F,
  0x00, 0x07, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x7E, 0x01, 0xEE,
  0x01, 0xF8, 0x03, 0xDF, 0xFF, 0xF0, 0x0F, 0x9F, 0xFF, 0xC0, 0x1F, 0x1F,
  0xFE, 0x00, 0x3E, 0x1F, 0xF8, 0x00, 0x7C, 0x06, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0x1F, 0x01, 0xFF, 0xF9, 0xF0,
  0x3F, 0xFF, 0xDF, 0x07, 0xF8, 0x3D, 0xF0, 0x7E, 0x00, 0xFE, 0x0F, 0x80,
  0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E,
  0x3E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3C, 0x3E, 0x00, 0x03, 0xC3, 0xE0,
  0x00, 0x7C, 0x3C, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x78, 0x7C,
  0x00, 0x0F, 0x87, 0x80, 0x00, 0xF8, 0x78, 0x00, 0x0F, 0x8F, 0x80, 0x00,
  0xF8, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x3F, 0x07,
  0xC0, 0x07, 0xF0, 0x7F, 0x00, 0xFF, 0x03, 0xFE, 0xFD, 0xF0, 0x3F, 0xFF,
  0x9E, 0x01, 0xFF, 0xF1, 0xE0, 0x07, 0xFC, 0x1E, 0x00, 0x0E, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x3E, 0x3F, 0xFC, 0x01, 0xF3, 0xFF, 0xF0, 0x0F, 0x3F,
  0xFF, 0xC0, 0x7B, 0xC0, 0xFE, 0x03, 0xF8, 0x01, 0xF8, 0x3F, 0x80, 0x0F,
  0xC1, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x7C, 0x1E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0xF8, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xE0, 0x7F, 0x00, 0xFE, 0x1F, 0x80, 0x0F, 0xC3, 0xE0, 0x00, 0xF8, 0xF8,
  0x00, 0x0F, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x9E,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3C, 0x7C, 0x00, 0x0F, 0x8F, 0xE0, 0x07,
  0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0xF8, 0x00,
  0x1F, 0x0F, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF1,
  0xF0, 0x00, 0x1E, 0x1F, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x3E, 0x1E, 0x00,
  0x03, 0xE1, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3C,
  0x3E, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x07, 0xC3, 0xC0,
  0x00, 0x7C, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x07,
  0x87, 0xC0, 0x00, 0x78, 0x7C, 0x00, 0x0F, 0x87, 0x80, 0x00, 0xF8, 0x78,
  0x00, 0x0F, 0x87, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x03,
  0xE0, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x3E, 0x78, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0x3C,
  0x00, 0x0F, 0x83, 0xC0, 0x01, 0xF0, 0x3C, 0x00, 0x1F, 0x03, 0xE0, 0x03,
  0xE0, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0x7C, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x00, 0x1F, 0x01,
  0xF0, 0x01, 0xF0, 0x1E, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0xF0, 0x3C, 0x00,
  0x0F, 0x07, 0xC0, 0x00, 0xF8, 0x78, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8,
  0xF0, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x07, 0xBE, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x3F, 0xE0, 0x1F,
  0x00, 0x7B, 0xC0, 0x3E, 0x00, 0xF7, 0x80, 0x7E, 0x03, 0xCF, 0x01, 0xDC,
  0x07, 0x9E, 0x03, 0xB8, 0x0F, 0x3C, 0x07, 0x70, 0x3C, 0x78, 0x1C, 0xE0,
  0x78, 0xF0, 0x39, 0xC0, 0xF1, 0xE0, 0x73, 0x83, 0xC3, 0xC1, 0xC7, 0x07,
  0x87, 0x83, 0x8E, 0x0F, 0x0F, 0x07, 0x1C, 0x1C, 0x1E, 0x1C, 0x38, 0x78,
  0x3C, 0x38, 0x70, 0xF0, 0x78, 0x70, 0xE1, 0xC0, 0xF1, 0xC1, 0xC7, 0x81,
  0xE3, 0x83, 0x8F, 0x03, 0xC7, 0x07, 0x1C, 0x07, 0x9C, 0x0E, 0x78, 0x0F,
  0x38, 0x1C, 0xF0, 0x1E, 0x70, 0x39, 0xC0, 0x3D, 0xC0, 0x77, 0x80, 0x7B,
  0x80, 0xEF, 0x00, 0xF7, 0x01, 0xDC, 0x01, 0xFC, 0x03, 0xB8, 0x03, 0xF8,
  0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80,
  0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0xF8, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0x80, 0x03, 0xE0, 0x1F, 0x80, 0x01,
  0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0x0F, 0x8F, 0xC0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x07, 0xE7, 0xC0,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x03, 0xF0, 0x1F, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x01, 0xF0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x7C, 0x01, 0xF8, 0x00,
  0x1F, 0x01, 0xF8, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x03, 0xE0, 0x0F, 0x80,
  0x01, 0xF0, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x1F,
  0x1F, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x1E, 0x1F, 0x00, 0x03, 0xE1, 0xF0,
  0x00, 0x3E, 0x1E, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x03,
  0xC3, 0xE0, 0x00, 0x3C, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3C,
  0x00, 0x07, 0xC3, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0x78, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x87,
  0xC0, 0x01, 0xF8, 0x7C, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0x3F, 0x00,
  0xEF, 0x03, 0xFC, 0x3F, 0xF0, 0x1F, 0xFF, 0xDF, 0x00, 0xFF, 0xF9, 0xF0,
  0x07, 0xFE, 0x1F, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x3F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x80, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xC7, 0xFF, 0x00, 0x3E, 0x7F, 0xFC,
  0x01, 0xE3, 0xE3, 0xF0, 0x0F, 0x3E, 0x0F, 0xC0, 0x79, 0xE0, 0x3E, 0x07,
  0xCF, 0x00, 0xF8, 0x7C, 0xF8, 0x07, 0xFF, 0xE7, 0xC0, 0x1F, 0xFE, 0x3E,
  0x00, 0x7F, 0xE1, 0xE0, 0x00, 0xFC, 0x00,
};

const GFXglyph JetBrainsMono_LightItalic59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 14, 43, 35, 11, -43 },
  { 77, 20, 18, 35, 11, -43 },
  { 122, 35, 43, 35, 1, -43 },
  { 311, 31, 59, 35, 3, -51 },
  { 540, 41, 43, 35, -2, -43 },
  { 761, 32, 45, 35, 2, -44 },
  { 941, 7, 18, 35, 17, -43 },
  { 957, 24, 57, 35, 10, -50 },
  { 1128, 24, 57, 35, 3, -50 },
  { 1299, 31, 30, 35, 3, -36 },
  { 1416, 28, 27, 35, 4, -33 },
  { 1511, 15, 18, 35, 6, -9 },
  { 1545, 20, 5, 35, 8, -22 },
  { 1558, 10, 10, 35, 11, -9 },
  { 1571, 35, 55, 35, 1, -49 },
  { 1812, 29, 45, 35, 4, -44 },
  { 1976, 27, 43, 35, 3, -43 },
  { 2122, 30, 44, 35, 3, -44 },
  { 2287, 30, 44, 35, 3, -43 },
  { 2452, 28, 43, 35, 4, -43 },
  { 2603, 29, 44, 35, 4, -43 },
  { 2763, 28, 44, 35, 3, -43 },
  { 2917, 29, 43, 35, 7, -43 },
  { 3073, 30, 45, 35, 3, -44 },
  { 3242, 28, 44, 35, 6, -44 },
  { 3396, 14, 34, 35, 11, -33 },
  { 3456, 19, 42, 35, 6, -33 },
  { 3556, 28, 31, 35, 5, -35 },
  { 3665, 28, 19, 35, 4, -29 },
  { 3732, 28, 31, 35, 3, -35 },
  { 3841, 23, 43, 35, 9, -43 },
  { 3965, 35, 55, 35, 1, -44 },
  { 4206, 29, 43, 35, 1, -43 },
  { 4362, 30, 43, 35, 3, -43 },
  { 4524, 29, 45, 35, 4, -44 },
  { 4688, 30, 43, 35, 3, -43 },
  { 4850, 31, 43, 35, 4, -43 },
  { 5017, 32, 43, 35, 3, -43 },
  { 5189, 29, 45, 35, 4, -44 },
  { 5353, 31, 43, 35, 3, -43 },
  { 5520, 29, 43, 35, 4, -43 },
  { 5676, 32, 44, 35, 1, -43 },
  { 5852, 33, 43, 35, 3, -43 },
  { 6030, 26, 43, 35, 4, -43 },
  { 6170, 33, 43, 35, 2, -43 },
  { 6348, 31, 43, 35, 3, -43 },
  { 6515, 29, 45, 35, 4, -44 },
  { 6679, 32, 43, 35, 3, -43 },
  { 6851, 29, 55, 35, 4, -44 },
  { 7051, 31, 43, 35, 3, -43 },
  { 7218, 31, 45, 35, 3, -44 },
  { 7393, 29, 43, 35, 7, -43 },
  { 7549, 30, 44, 35, 4, -43 },
  { 7714, 29, 43, 35, 7, -43 },
  { 7870, 34, 43, 35, 4, -43 },
  { 8053, 36, 43, 35, 0, -43 },
  { 8247, 30, 43, 35, 7, -43 },
  { 8409, 31, 43, 35, 3, -43 },
  { 8576, 23, 55, 35, 9, -49 },
  { 8735, 17, 55, 35, 10, -49 },
  { 8852, 23, 55, 35, 5, -49 },
  { 9011, 25, 23, 35, 6, -43 },
  { 9083, 29, 4, 35, 0, 1 },
  { 9098, 10, 8, 35, 16, -46 },
  { 9108, 28, 34, 35, 4, -33 },
  { 9227, 29, 44, 35, 3, -43 },
  { 9387, 28, 34, 35, 4, -33 },
  { 9506, 30, 44, 35, 4, -43 },
  { 9671, 27, 34, 35, 4, -33 },
  { 9786, 39, 54, 35, -2, -43 },
  { 10050, 28, 44, 35, 4, -33 },
  { 10204, 29, 43, 35, 3, -43 },
  { 10360, 28, 46, 35, 2, -46 },
  { 10521, 30, 57, 35, 1, -46 },
  { 10735, 31, 43, 35, 3, -43 },
  { 10902, 24, 43, 35, 6, -43 },
  { 11031, 32, 33, 35, 1, -33 },
  { 11163, 29, 33, 35, 3, -33 },
  { 11283, 27, 34, 35, 4, -33 },
  { 11398, 31, 44, 35, 1, -33 },
  { 11569, 28, 44, 35, 4, -33 },
  { 11723, 29, 33, 35, 4, -33 },
  { 11843, 27, 34, 35, 4, -33 },
  { 11958, 28, 41, 35, 5, -41 },
  { 12102, 28, 33, 35, 4, -32 },
  { 12218, 28, 32, 35, 6, -32 },
  { 12330, 31, 32, 35, 5, -32 },
  { 12454, 33, 32, 35, 1, -32 },
  { 12586, 28, 43, 35, 4, -32 },
  { 12737, 29, 32, 35, 3, -32 },
  { 12853, 29, 55, 35, 6, -49 },
  { 13053, 13, 55, 35, 12, -49 },
  { 13143, 29, 55, 35, 2, -49 },
  { 13343, 29, 12, 35, 4, -27 },
};

const GFXfont JetBrainsMono_LightItalic59pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_LightItalic59pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_LightItalic59pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _JETBRAINSMONO_LIGHTITALIC59PT7B_H_
