#ifndef _JETBRAINSMONO_LIGHTITALIC39PT7B_H_
#define _JETBRAINSMONO_LIGHTITALIC39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-LightItalic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_LightItalic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x0E, 0x0F, 0x07,
  0x83, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x3E, 0x1F, 0x0F, 0x00, 0x38, 0x39, 0xC3,
  0xDE, 0x1E, 0xF0, 0xE7, 0x07, 0x38, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0x63,
  0x07, 0x38, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x60, 0x30, 0x01, 0xC0, 0xE0,
  0x03, 0x81, 0xC0, 0x06, 0x03, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x1C, 0x0F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x06, 0x07, 0x00, 0x1C,
  0x0E, 0x00, 0x38, 0x18, 0x00, 0x60, 0x70, 0x01, 0xC0, 0xE0, 0x03, 0x01,
  0x80, 0x0E, 0x07, 0x00, 0x1C, 0x0E, 0x23, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0x01, 0xC0, 0xE0, 0x03, 0x01, 0x80, 0x0E, 0x07, 0x00, 0x1C, 0x0E, 0x00,
  0x30, 0x18, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0xE0, 0x03, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x03, 0xF0, 0x01, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0x99, 0xE0, 0xF1,
  0x8F, 0x0E, 0x18, 0x70, 0xE1, 0x87, 0x1E, 0x38, 0x71, 0xC3, 0x80, 0x1E,
  0x30, 0x01, 0xE3, 0x00, 0x0F, 0x30, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x67, 0x80, 0x06, 0x3C,
  0x00, 0x61, 0xC0, 0x0E, 0x1C, 0x10, 0xC1, 0xCE, 0x0C, 0x1C, 0xF0, 0xC3,
  0x8F, 0x0C, 0x38, 0x78, 0xC7, 0x07, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0xFF,
  0x80, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x20, 0x7F, 0x00, 0x38, 0x1F, 0xF0, 0x0E,
  0x07, 0x0E, 0x03, 0x80, 0xE0, 0xC0, 0x60, 0x18, 0x18, 0x18, 0x03, 0x03,
  0x07, 0x00, 0x60, 0xE1, 0xC0, 0x1C, 0x1C, 0x70, 0x03, 0x83, 0x9C, 0x00,
  0x78, 0xE3, 0x00, 0x07, 0xF8, 0xC0, 0x00, 0x7E, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0xF8, 0x00,
  0x06, 0x3F, 0x80, 0x01, 0x8F, 0xF8, 0x00, 0x73, 0x87, 0x00, 0x1C, 0x60,
  0x60, 0x07, 0x1C, 0x1C, 0x01, 0xC3, 0x83, 0x80, 0x30, 0x70, 0x70, 0x0C,
  0x0E, 0x0E, 0x03, 0x81, 0xC1, 0x80, 0xE0, 0x3C, 0xF0, 0x38, 0x03, 0xFC,
  0x0E, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0,
  0x07, 0x83, 0xC0, 0x78, 0x1E, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0x9E, 0x07, 0x38, 0x70,
  0x73, 0x83, 0xC7, 0x1C, 0x0E, 0x38, 0xE0, 0x7B, 0x87, 0x01, 0xF8, 0x38,
  0x07, 0xC1, 0xC0, 0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x1F, 0x87, 0x81, 0xFC,
  0x1F, 0x7E, 0xF0, 0xFF, 0xC3, 0x83, 0xFC, 0x0E, 0x00, 0x7B, 0xDE, 0xE7,
  0x39, 0xDE, 0xE7, 0x38, 0x00, 0x01, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x7C,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xE0, 0x00, 0x40, 0x02, 0x00, 0x03, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x01, 0xC1, 0xC0, 0xCF, 0x8E, 0x3E, 0xFF, 0x27, 0xF9,
  0xFD, 0xFE, 0x01, 0xFF, 0x80, 0x01, 0xC0, 0x00, 0x1F, 0x00, 0x01, 0xDC,
  0x00, 0x1C, 0x70, 0x01, 0xE3, 0xC0, 0x1E, 0x1E, 0x01, 0xE0, 0x78, 0x0E,
  0x03, 0xC0, 0x20, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x07, 0xC3,
  0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x1C, 0x07, 0x03,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0xFB, 0xFF, 0xFF, 0xCF, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x1F,
  0xF8, 0x03, 0xFF, 0xC0, 0x78, 0x1E, 0x0F, 0x00, 0xF0, 0xE0, 0x0F, 0x1C,
  0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00, 0x71, 0xC0, 0x0F, 0x3C, 0x00, 0xE3,
  0x80, 0x0E, 0x38, 0x20, 0xE3, 0x8F, 0x0E, 0x38, 0xF8, 0xE3, 0x8F, 0x1E,
  0x78, 0x71, 0xC7, 0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x01,
  0xC7, 0x00, 0x3C, 0x70, 0x03, 0x87, 0x00, 0x38, 0x70, 0x07, 0x87, 0x80,
  0xF0, 0x3F, 0x7E, 0x03, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x3F, 0x80, 0x1E, 0xE0, 0x1F, 0x38, 0x0F, 0x1E, 0x03, 0x87, 0x01, 0x81,
  0xC0, 0x40, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFE,
  0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x78, 0x1E, 0x0F, 0x00,
  0xE1, 0xE0, 0x0F, 0x1C, 0x00, 0x71, 0xC0, 0x07, 0x20, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x08, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x38, 0xF0, 0x03, 0x8E, 0x00, 0x38, 0xF0, 0x07, 0x8F, 0x00,
  0x70, 0x78, 0x0F, 0x07, 0xE7, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x0E, 0x03, 0x87, 0x80, 0xE3, 0xC0, 0x39, 0xE0, 0x0E, 0xF0,
  0x07, 0x38, 0x01, 0xCE, 0x00, 0x73, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF,
  0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x38, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07,
  0x0F, 0x00, 0xE7, 0xF8, 0x1D, 0xFF, 0x83, 0xE0, 0xF8, 0x78, 0x0F, 0x1E,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x70, 0xF0,
  0x1E, 0x0F, 0x9F, 0x81, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x40, 0x07,
  0x7F, 0x81, 0xFF, 0xF8, 0x3E, 0x0F, 0x8F, 0x00, 0xF1, 0xC0, 0x0E, 0x78,
  0x01, 0xCE, 0x00, 0x39, 0xC0, 0x07, 0x78, 0x00, 0xEE, 0x00, 0x1D, 0xC0,
  0x07, 0xBC, 0x00, 0xE3, 0x80, 0x3C, 0x78, 0x0F, 0x07, 0xEF, 0xC0, 0xFF,
  0xF0, 0x07, 0xF8, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFB, 0xC0, 0x07, 0x70,
  0x01, 0xEE, 0x00, 0x39, 0xC0, 0x0F, 0x38, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x78, 0x1E, 0x0F, 0x00, 0xE0,
  0xE0, 0x0F, 0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x1E, 0x00, 0xE0, 0xE0, 0x1E,
  0x0E, 0x01, 0xC0, 0xF0, 0x78, 0x07, 0xCF, 0x00, 0x1F, 0xC0, 0x01, 0xF8,
  0x00, 0x7F, 0xE0, 0x0F, 0x0F, 0x01, 0xC0, 0x78, 0x38, 0x03, 0x87, 0x80,
  0x3C, 0x70, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x03, 0x8F, 0x00, 0x38, 0x70,
  0x07, 0x87, 0x80, 0xF0, 0x7F, 0x7E, 0x03, 0xFF, 0xC0, 0x0F, 0xF8, 0x00,
  0x00, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x78, 0x1E, 0x3C, 0x03, 0xDE,
  0x00, 0x77, 0x00, 0x1D, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x0E, 0xF0, 0x03, 0xBC, 0x01, 0xE7, 0x80, 0xF1, 0xFF, 0xFC,
  0x3F, 0xEE, 0x07, 0xE7, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x07, 0xC7, 0xE3, 0xF1, 0xF8,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x1F, 0x1F, 0xCF, 0xC3, 0xC0, 0x00, 0xE0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x78, 0x0F, 0x00,
  0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x0E,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0x00,
  0x01, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x01,
  0x80, 0x3F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xEF,
  0xFF, 0xFB, 0xFF, 0xFC, 0x10, 0x00, 0x03, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x03, 0xE0, 0x01, 0xF8, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x03, 0xC0,
  0x00, 0x60, 0x00, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x07, 0xF0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0x70, 0x01, 0xC0, 0x0F, 0x83, 0xFE, 0x07, 0xF0, 0x0F, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0x01, 0xE0, 0x38, 0x01, 0xE0,
  0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x38,
  0x00, 0x1C, 0x70, 0x0F, 0x38, 0xE0, 0x7F, 0x71, 0xC1, 0xE7, 0xE3, 0x87,
  0x83, 0x86, 0x0E, 0x07, 0x1C, 0x1C, 0x0E, 0x38, 0x30, 0x1C, 0x70, 0xE0,
  0x38, 0xE1, 0xC0, 0x71, 0xC3, 0x80, 0xC3, 0x07, 0x03, 0x8E, 0x0E, 0x07,
  0x1C, 0x1C, 0x0E, 0x38, 0x38, 0x3C, 0x70, 0x7D, 0xF8, 0xE0, 0x7F, 0x71,
  0xC0, 0x78, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x3B, 0x80, 0x03, 0xB8, 0x00, 0x3B, 0x80, 0x07,
  0x18, 0x00, 0x71, 0xC0, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x1C, 0x1C, 0x01,
  0xC1, 0xC0, 0x1C, 0x1C, 0x03, 0x81, 0xC0, 0x38, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0E, 0x00, 0xE1, 0xC0, 0x0E,
  0x1C, 0x00, 0xE3, 0xC0, 0x0E, 0x38, 0x00, 0xE7, 0x80, 0x0E, 0x70, 0x00,
  0xEF, 0x00, 0x0F, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0E, 0x07, 0xE0, 0xE0,
  0x1E, 0x0E, 0x00, 0xF0, 0xE0, 0x0F, 0x0E, 0x00, 0xF1, 0xC0, 0x0E, 0x1C,
  0x00, 0xE1, 0xC0, 0x1E, 0x1C, 0x01, 0xC1, 0xC0, 0x78, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0x80, 0x78, 0x38, 0x03, 0xC3, 0x80, 0x1C,
  0x38, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x03,
  0x87, 0x00, 0x78, 0x70, 0x0F, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF,
  0x00, 0x00, 0x7C, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x07, 0xC1, 0xE1, 0xE0,
  0x1E, 0x38, 0x03, 0xC7, 0x00, 0x39, 0xC0, 0x07, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x0F, 0x38, 0x01, 0xC7, 0x00, 0x38, 0xF0, 0x0F,
  0x1E, 0x03, 0xC1, 0xFB, 0xF0, 0x1F, 0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0xFF, 0xF8, 0x0E, 0x0F, 0xC0, 0xE0, 0x1E, 0x0E, 0x00, 0xE0, 0xE0,
  0x0E, 0x1E, 0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x1C,
  0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x01, 0xE3, 0x80, 0x1C, 0x38, 0x01, 0xC3,
  0x80, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x03, 0xC7, 0x80, 0x38,
  0x70, 0x03, 0x87, 0x00, 0x38, 0x70, 0x07, 0x07, 0x00, 0xF0, 0x70, 0x1E,
  0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC3, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x07, 0xFF, 0xF8, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x07, 0xC1,
  0xE1, 0xE0, 0x1E, 0x38, 0x03, 0xC7, 0x00, 0x39, 0xC0, 0x07, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x87, 0xFE, 0x70, 0xFF, 0x8E, 0x1F, 0xF1, 0xC0, 0x0E,
  0x78, 0x01, 0xCE, 0x00, 0x39, 0xC0, 0x0F, 0x38, 0x01, 0xC7, 0x00, 0x38,
  0xF0, 0x0F, 0x1E, 0x03, 0xC1, 0xFB, 0xF0, 0x1F, 0xFC, 0x01, 0xFE, 0x00,
  0x0F, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00,
  0x70, 0xE0, 0x0E, 0x0E, 0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x00, 0xE1, 0xC0,
  0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x1C, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F,
  0xFF, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x3C, 0x38, 0x03, 0x87,
  0x80, 0x38, 0x70, 0x03, 0x87, 0x00, 0x38, 0x70, 0x03, 0x87, 0x00, 0x78,
  0x70, 0x07, 0x0F, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0x0F, 0xFF,
  0xE1, 0xFF, 0xFC, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x1F, 0xFF, 0xC3,
  0xFF, 0xF8, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x08,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x8F, 0x00, 0x3C,
  0x78, 0x01, 0xC3, 0xC0, 0x0E, 0x0E, 0x00, 0xF0, 0x78, 0x0F, 0x03, 0xFB,
  0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0x00, 0x3C, 0x38, 0x01,
  0xE0, 0xE0, 0x07, 0x03, 0x80, 0x38, 0x0E, 0x01, 0xE0, 0x38, 0x07, 0x01,
  0xE0, 0x38, 0x07, 0x01, 0xE0, 0x1C, 0x07, 0x00, 0x70, 0x38, 0x01, 0xC1,
  0xE0, 0x07, 0x07, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x0E, 0x0F, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x70, 0x03, 0x81, 0xE0, 0x1E,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3C, 0x07, 0x00, 0x70, 0x1C, 0x01,
  0xC0, 0x70, 0x07, 0x83, 0xC0, 0x0E, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xF0,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xE0,
  0x07, 0x80, 0x7C, 0x1E, 0x01, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3E, 0x0F,
  0xC1, 0xD8, 0x3B, 0x07, 0x60, 0xCC, 0x3B, 0x83, 0x30, 0xEE, 0x1C, 0xE3,
  0x38, 0x73, 0x9C, 0xE1, 0xCE, 0x67, 0x07, 0x1B, 0x9C, 0x1C, 0x6C, 0x70,
  0x71, 0xF1, 0xC1, 0xC7, 0x87, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0xE0, 0xE0,
  0x03, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xE1, 0xC0, 0x03,
  0x87, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x07,
  0x00, 0x1C, 0x3C, 0x00, 0x70, 0x0F, 0x80, 0x78, 0x7C, 0x03, 0x83, 0xE0,
  0x1C, 0x1F, 0x00, 0xE0, 0xFC, 0x07, 0x06, 0xE0, 0x38, 0x77, 0x03, 0x83,
  0x98, 0x1C, 0x1C, 0xE0, 0xE0, 0xE7, 0x07, 0x07, 0x38, 0x38, 0x39, 0xC1,
  0xC3, 0x86, 0x1C, 0x1C, 0x38, 0xE0, 0xE1, 0xC7, 0x07, 0x0E, 0x38, 0x38,
  0x71, 0xC1, 0xC1, 0x8E, 0x1E, 0x0E, 0xF0, 0xE0, 0x77, 0x07, 0x03, 0xB8,
  0x38, 0x1D, 0xC1, 0xC0, 0x6E, 0x0E, 0x03, 0xF0, 0x70, 0x1F, 0x87, 0x00,
  0xF8, 0x38, 0x03, 0xC1, 0xC0, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xE0,
  0x1F, 0xFE, 0x07, 0x81, 0xE1, 0xE0, 0x1C, 0x38, 0x03, 0x87, 0x00, 0x79,
  0xC0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x07, 0x1C, 0x00, 0xE7,
  0x80, 0x1C, 0xE0, 0x07, 0x9C, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x03, 0x8E,
  0x00, 0x71, 0xC0, 0x0E, 0x78, 0x03, 0xCE, 0x00, 0x71, 0xC0, 0x0E, 0x38,
  0x01, 0xC7, 0x00, 0x38, 0xE0, 0x0E, 0x1E, 0x03, 0xC1, 0xFB, 0xF0, 0x1F,
  0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0x80, 0xFC,
  0x1C, 0x01, 0xE0, 0xE0, 0x07, 0x87, 0x00, 0x1C, 0x78, 0x00, 0xE3, 0x80,
  0x07, 0x1C, 0x00, 0x78, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x01, 0xC1,
  0xC0, 0x3E, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0x80, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x03,
  0xFF, 0xC0, 0x78, 0x1E, 0x0F, 0x00, 0xE0, 0xE0, 0x0F, 0x1E, 0x00, 0x71,
  0xC0, 0x07, 0x1C, 0x00, 0xF1, 0xC0, 0x0E, 0x1C, 0x00, 0xE3, 0xC0, 0x0E,
  0x38, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x01, 0xE3, 0x80, 0x1C, 0x38, 0x01,
  0xC7, 0x80, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00,
  0x38, 0x70, 0x03, 0x87, 0x00, 0x38, 0x70, 0x07, 0x07, 0x80, 0xF0, 0x3F,
  0x7E, 0x03, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0x80, 0xF8, 0x1C, 0x01, 0xE0, 0xE0,
  0x07, 0x07, 0x00, 0x38, 0x78, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x70,
  0xE0, 0x03, 0x87, 0x00, 0x38, 0x38, 0x03, 0xC1, 0xC0, 0x7C, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x38, 0x38, 0x01, 0xC0, 0xE0, 0x0E,
  0x07, 0x00, 0xF0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38,
  0x0E, 0x01, 0xE0, 0x70, 0x07, 0x07, 0x80, 0x3C, 0x38, 0x01, 0xE1, 0xC0,
  0x07, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x78, 0x1E,
  0x0F, 0x00, 0xF0, 0xE0, 0x07, 0x0E, 0x00, 0x71, 0xE0, 0x07, 0x1C, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7F,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC1, 0x00, 0x1C, 0xE0, 0x01, 0xCE,
  0x00, 0x38, 0xF0, 0x03, 0x87, 0x80, 0x70, 0x7F, 0x7F, 0x03, 0xFF, 0xC0,
  0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0xF1, 0xC0, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x00,
  0xE1, 0xC0, 0x1E, 0x3C, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC3, 0x80,
  0x1C, 0x38, 0x01, 0xC3, 0x80, 0x3C, 0x78, 0x03, 0x87, 0x00, 0x38, 0x70,
  0x03, 0x87, 0x00, 0x38, 0x70, 0x03, 0x87, 0x00, 0x38, 0xF0, 0x07, 0x8E,
  0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x0F, 0x0F, 0x00, 0xE0,
  0xF0, 0x1E, 0x07, 0xEF, 0xC0, 0x3F, 0xF8, 0x01, 0xFE, 0x00, 0xE0, 0x01,
  0xFC, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x01, 0xCF, 0x00, 0x38, 0xE0, 0x0F,
  0x1C, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x0E, 0x0E, 0x01, 0xC1, 0xC0, 0x70,
  0x38, 0x0E, 0x07, 0x03, 0xC0, 0xE0, 0x70, 0x1E, 0x0E, 0x01, 0xC3, 0x80,
  0x38, 0x70, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x03, 0x9C, 0x00,
  0x73, 0x80, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x1B, 0x80, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x38, 0x1D, 0xC1, 0xE0, 0x77, 0x07,
  0x83, 0x9C, 0x1E, 0x0E, 0x70, 0xD8, 0x39, 0xC3, 0x60, 0xC6, 0x0D, 0x87,
  0x18, 0x36, 0x1C, 0x61, 0x98, 0x71, 0x86, 0x61, 0x8E, 0x19, 0x8E, 0x38,
  0xC6, 0x38, 0xE3, 0x18, 0xC3, 0x8C, 0x67, 0x0E, 0x31, 0x9C, 0x39, 0x86,
  0x70, 0xE6, 0x19, 0x83, 0x98, 0x6E, 0x0E, 0xC1, 0xB8, 0x3B, 0x0E, 0xE0,
  0xEC, 0x33, 0x03, 0xB0, 0xDC, 0x0F, 0x83, 0x70, 0x3E, 0x0D, 0x80, 0xD8,
  0x36, 0x03, 0xC0, 0xF8, 0x0F, 0x03, 0xE0, 0x3C, 0x0F, 0x00, 0x07, 0x80,
  0x0F, 0x03, 0x80, 0x1E, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x38, 0x01, 0xC0,
  0x70, 0x01, 0xE0, 0xF0, 0x00, 0xE0, 0xE0, 0x00, 0xE1, 0xC0, 0x00, 0x73,
  0xC0, 0x00, 0x73, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xE7, 0x00, 0x01, 0xC7, 0x00, 0x03, 0xC7, 0x80, 0x07, 0x83,
  0x80, 0x07, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x1E, 0x01, 0xC0, 0x3C, 0x01,
  0xE0, 0x38, 0x00, 0xE0, 0x78, 0x00, 0xE0, 0xF0, 0x00, 0xF0, 0xF0, 0x00,
  0x7B, 0x80, 0x07, 0x1C, 0x00, 0x78, 0x70, 0x03, 0x83, 0x80, 0x38, 0x1C,
  0x01, 0xC0, 0x70, 0x1C, 0x03, 0x81, 0xE0, 0x1C, 0x0E, 0x00, 0x70, 0xE0,
  0x03, 0x8F, 0x00, 0x1C, 0x70, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x1F,
  0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0x07, 0xFE,
  0x0F, 0xFC, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01,
  0xC0, 0x83, 0xFE, 0x07, 0xFC, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x07, 0xFE, 0x0F, 0xF8,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x03,
  0xFE, 0x07, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0x98,
  0x03, 0x98, 0x07, 0x1C, 0x07, 0x1C, 0x0E, 0x0C, 0x0E, 0x0E, 0x1C, 0x0E,
  0x38, 0x06, 0x38, 0x07, 0x70, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE3, 0xC7, 0x0E, 0x38, 0x70, 0x01,
  0xF0, 0x01, 0xFE, 0x70, 0xFF, 0xDC, 0x78, 0x3F, 0x3C, 0x07, 0xCE, 0x00,
  0xF7, 0x80, 0x39, 0xC0, 0x0E, 0x70, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0x39,
  0xC0, 0x1E, 0xF0, 0x07, 0x38, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x1C, 0xE0,
  0x0F, 0x38, 0x03, 0xCF, 0x01, 0xF1, 0xF1, 0xF8, 0x7F, 0xEE, 0x0F, 0xF3,
  0x80, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x07, 0x8F, 0x80, 0xE7, 0xFC, 0x1D, 0xFF, 0x83, 0xE0,
  0x78, 0x78, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x70, 0x03, 0x8E, 0x00,
  0x71, 0xC0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x0F, 0x3C, 0x01,
  0xC7, 0x00, 0x38, 0xE0, 0x07, 0x1C, 0x00, 0xE3, 0xC0, 0x38, 0x78, 0x0F,
  0x1F, 0xC7, 0xC3, 0xBF, 0xF0, 0x71, 0xFC, 0x00, 0x00, 0xF8, 0x01, 0xFF,
  0x80, 0xFF, 0xF0, 0x78, 0x1E, 0x3C, 0x03, 0x8E, 0x00, 0xF7, 0x80, 0x1D,
  0xC0, 0x07, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x1C, 0xE0, 0x07, 0x3C, 0x03,
  0xCF, 0x01, 0xE1, 0xFB, 0xF0, 0x3F, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x7C, 0x70, 0x3F, 0xCE, 0x0F, 0xFD, 0xC3, 0xC1, 0xF8, 0xF0, 0x1F,
  0x1C, 0x01, 0xE7, 0x80, 0x38, 0xE0, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x1C,
  0x70, 0x03, 0x8E, 0x00, 0xF3, 0xC0, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0x71,
  0xC0, 0x0E, 0x38, 0x03, 0xC7, 0x00, 0x78, 0xF0, 0x1F, 0x0F, 0x8F, 0xC1,
  0xFF, 0xB8, 0x1F, 0xE7, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xF0,
  0x78, 0x1E, 0x3C, 0x03, 0x8E, 0x00, 0xE7, 0x80, 0x39, 0xC0, 0x0E, 0x70,
  0x03, 0x9C, 0x00, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x03, 0x8F, 0x01, 0xE1,
  0xF1, 0xF0, 0x3F, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x01, 0xFF, 0x70, 0xFF, 0xDC, 0x78, 0x3F, 0x3C, 0x03,
  0xCE, 0x00, 0xF7, 0x80, 0x39, 0xC0, 0x0E, 0x70, 0x03, 0x9C, 0x00, 0xE7,
  0x00, 0x39, 0xC0, 0x0E, 0xF0, 0x07, 0x38, 0x01, 0xCE, 0x00, 0x73, 0xC0,
  0x3C, 0x70, 0x1F, 0x1E, 0x0D, 0xC7, 0xFE, 0xF0, 0xFF, 0x38, 0x06, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x07,
  0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x8F, 0x80,
  0xE7, 0xFC, 0x1D, 0xFF, 0x83, 0xE0, 0x78, 0x78, 0x07, 0x0E, 0x00, 0xE1,
  0xC0, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x01, 0xC7,
  0x00, 0x38, 0xE0, 0x0F, 0x3C, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x07, 0x1C,
  0x00, 0xE3, 0x80, 0x1C, 0x70, 0x07, 0x9E, 0x00, 0xE3, 0x80, 0x1C, 0x70,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0xFF, 0x80, 0x40, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x7F, 0xF8, 0x07,
  0xFF, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0xFF,
  0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x23, 0xC0, 0x1E, 0x1C, 0x01, 0xE0, 0xE0, 0x1E, 0x07, 0x00, 0xE0,
  0x38, 0x0E, 0x01, 0xC0, 0xF0, 0x1E, 0x0F, 0x00, 0xE0, 0xF0, 0x07, 0x0F,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0E, 0x1E, 0x00, 0x70, 0x70, 0x07,
  0x03, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x70, 0x0F,
  0x03, 0x80, 0x38, 0x3C, 0x01, 0xE1, 0xC0, 0x07, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F,
  0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xE0, 0xE0, 0xEF, 0xDF, 0x87, 0xFF,
  0xFC, 0x38, 0x78, 0xF1, 0xC3, 0x83, 0x8C, 0x1C, 0x1C, 0xE0, 0xE0, 0xC7,
  0x07, 0x0E, 0x38, 0x30, 0x71, 0xC1, 0x83, 0x8E, 0x1C, 0x1C, 0x70, 0xE0,
  0xE7, 0x07, 0x07, 0x38, 0x38, 0x71, 0xC1, 0x83, 0x8E, 0x0C, 0x1C, 0x70,
  0x60, 0xE3, 0x87, 0x07, 0x18, 0x38, 0x39, 0xC1, 0xC3, 0x8E, 0x0E, 0x1C,
  0x70, 0x60, 0xE0, 0x02, 0x3E, 0x03, 0x9F, 0xF0, 0x77, 0xFE, 0x0F, 0x81,
  0xE1, 0xE0, 0x1C, 0x38, 0x03, 0x8F, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x01,
  0xC7, 0x00, 0x38, 0xE0, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x3C, 0xF0, 0x07,
  0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x1E,
  0x78, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x0E, 0x00, 0x00, 0xF8, 0x01, 0xFF,
  0x80, 0xFF, 0xF0, 0x78, 0x1E, 0x3C, 0x03, 0x8E, 0x00, 0xE7, 0x80, 0x39,
  0xC0, 0x0E, 0x70, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x0E, 0xE0,
  0x07, 0xB8, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x03,
  0x8F, 0x01, 0xE1, 0xF3, 0xF0, 0x3F, 0xF8, 0x07, 0xF8, 0x00, 0x01, 0x1F,
  0x00, 0xE7, 0xFC, 0x0E, 0xFF, 0xC0, 0xF8, 0x1E, 0x0F, 0x00, 0xE0, 0xE0,
  0x0E, 0x1E, 0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x1C,
  0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x01, 0xE3, 0xC0, 0x1C, 0x38, 0x01, 0xC3,
  0x80, 0x1C, 0x38, 0x01, 0xC3, 0xC0, 0x38, 0x3C, 0x07, 0x87, 0xF1, 0xF0,
  0x73, 0xFE, 0x07, 0x1F, 0xC0, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x01, 0xFE, 0x70, 0xFF, 0xDC, 0x78, 0x37, 0x3C, 0x07, 0xCE, 0x00,
  0xF7, 0x80, 0x39, 0xC0, 0x0E, 0x70, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0x39,
  0xC0, 0x1E, 0xE0, 0x07, 0x38, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x1C, 0xE0,
  0x0F, 0x38, 0x03, 0xCF, 0x01, 0xE1, 0xF3, 0xF8, 0x7F, 0xEE, 0x0F, 0xF3,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x03, 0x9F, 0xE0, 0x77, 0xFE,
  0x0F, 0x81, 0xE1, 0xE0, 0x1C, 0x78, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x0E,
  0x38, 0x01, 0xC7, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0x07, 0x81, 0xE1, 0xC0, 0x1E, 0x38, 0x01,
  0xC7, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x9E, 0x00, 0x71, 0xC0, 0x1C, 0x3E, 0x1F, 0x83, 0xFF, 0xE0,
  0x3F, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0x3F, 0xC0, 0x38, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x1C, 0xE0,
  0x07, 0x38, 0x01, 0xDE, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x0E, 0x70, 0x03,
  0x9C, 0x00, 0xE7, 0x00, 0x3B, 0xC0, 0x1E, 0xE0, 0x07, 0x38, 0x01, 0xCE,
  0x00, 0x73, 0x80, 0x3C, 0xF0, 0x0E, 0x3C, 0x07, 0x87, 0xCF, 0xC0, 0xFF,
  0xE0, 0x1F, 0xE0, 0x00, 0xE0, 0x01, 0xEE, 0x00, 0x79, 0xC0, 0x0E, 0x38,
  0x03, 0xC7, 0x00, 0x70, 0xE0, 0x1E, 0x1C, 0x03, 0x81, 0xC0, 0x70, 0x38,
  0x1C, 0x07, 0x03, 0x80, 0xE0, 0xE0, 0x1C, 0x1C, 0x03, 0x87, 0x00, 0x38,
  0xE0, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0xE0, 0xF0, 0x3F, 0x07, 0x83, 0xB8,
  0x3C, 0x1D, 0xC1, 0xE0, 0xCE, 0x1B, 0x0E, 0x70, 0xD8, 0x73, 0x86, 0xC3,
  0x1C, 0x66, 0x38, 0xE3, 0x31, 0xC7, 0x19, 0x8C, 0x39, 0x8C, 0xE1, 0xCC,
  0x67, 0x0E, 0x63, 0x30, 0x76, 0x19, 0x83, 0xB0, 0xDC, 0x1D, 0x86, 0xC0,
  0xF8, 0x36, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x78, 0x78, 0x07, 0x81, 0xC0, 0x78, 0x07, 0x07,
  0x80, 0x38, 0x38, 0x00, 0xE3, 0x80, 0x07, 0x3C, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1D, 0xC0,
  0x01, 0xCE, 0x00, 0x1E, 0x38, 0x01, 0xE1, 0xC0, 0x1E, 0x07, 0x00, 0xE0,
  0x3C, 0x0E, 0x00, 0xE0, 0xF0, 0x07, 0x8F, 0x00, 0x1C, 0x00, 0x38, 0x01,
  0xCE, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x03, 0xDE, 0x00, 0xE7,
  0x00, 0x39, 0xC0, 0x0E, 0x70, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0x7B, 0xC0,
  0x1C, 0xE0, 0x07, 0x38, 0x01, 0xCF, 0x00, 0xF3, 0xC0, 0x7C, 0x7C, 0x7F,
  0x1F, 0xFB, 0x81, 0xFC, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x1F, 0xFE, 0x07, 0xFF, 0x01, 0xFF,
  0x00, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0xFC, 0x7F, 0xFF,
  0x8F, 0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x07, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x03, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x3C, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x3C, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0x04, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xC0,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x00, 0x0E, 0x00, 0xE7, 0xF0, 0x1D, 0xFF, 0x07, 0x38,
  0xE0, 0xEE, 0x0E, 0x1D, 0xC1, 0xFF, 0xB8, 0x1F, 0xE7, 0x01, 0xF0,
};

const GFXglyph JetBrainsMono_LightItalic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 9, 28, 23, 7, -28 },
  { 33, 13, 11, 23, 7, -28 },
  { 51, 23, 28, 23, 1, -28 },
  { 132, 20, 39, 23, 2, -34 },
  { 230, 27, 29, 23, -1, -29 },
  { 328, 21, 29, 23, 1, -29 },
  { 405, 5, 11, 23, 11, -28 },
  { 412, 16, 38, 23, 6, -33 },
  { 488, 16, 38, 23, 2, -33 },
  { 564, 21, 20, 23, 2, -24 },
  { 617, 18, 18, 23, 3, -22 },
  { 658, 10, 12, 23, 4, -6 },
  { 673, 12, 3, 23, 6, -14 },
  { 678, 7, 6, 23, 7, -6 },
  { 684, 23, 36, 23, 1, -32 },
  { 788, 20, 29, 23, 2, -29 },
  { 861, 18, 28, 23, 2, -28 },
  { 924, 20, 29, 23, 2, -29 },
  { 997, 20, 28, 23, 2, -28 },
  { 1067, 18, 28, 23, 3, -28 },
  { 1130, 19, 28, 23, 3, -28 },
  { 1197, 19, 28, 23, 2, -28 },
  { 1264, 19, 28, 23, 5, -28 },
  { 1331, 20, 29, 23, 2, -29 },
  { 1404, 18, 29, 23, 4, -29 },
  { 1470, 9, 22, 23, 7, -22 },
  { 1495, 12, 28, 23, 4, -22 },
  { 1537, 19, 20, 23, 3, -23 },
  { 1585, 18, 12, 23, 3, -19 },
  { 1612, 19, 20, 23, 2, -23 },
  { 1660, 15, 28, 23, 6, -28 },
  { 1713, 23, 36, 23, 0, -29 },
  { 1817, 20, 28, 23, 0, -28 },
  { 1887, 20, 28, 23, 2, -28 },
  { 1957, 19, 29, 23, 3, -29 },
  { 2026, 20, 28, 23, 2, -28 },
  { 2096, 21, 28, 23, 2, -28 },
  { 2170, 21, 29, 23, 2, -29 },
  { 2247, 19, 29, 23, 3, -29 },
  { 2316, 20, 28, 23, 2, -28 },
  { 2386, 19, 28, 23, 3, -28 },
  { 2453, 21, 28, 23, 1, -28 },
  { 2527, 22, 28, 23, 2, -28 },
  { 2604, 17, 28, 23, 3, -28 },
  { 2664, 22, 28, 23, 1, -28 },
  { 2741, 21, 28, 23, 2, -28 },
  { 2815, 19, 29, 23, 3, -29 },
  { 2884, 21, 28, 23, 2, -28 },
  { 2958, 20, 36, 23, 2, -29 },
  { 3048, 21, 28, 23, 2, -28 },
  { 3122, 20, 29, 23, 2, -29 },
  { 3195, 19, 29, 23, 5, -29 },
  { 3264, 20, 28, 23, 3, -28 },
  { 3334, 19, 28, 23, 5, -28 },
  { 3401, 22, 28, 23, 3, -28 },
  { 3478, 24, 28, 23, 0, -28 },
  { 3562, 21, 28, 23, 4, -28 },
  { 3636, 20, 28, 23, 2, -28 },
  { 3706, 15, 36, 23, 6, -32 },
  { 3774, 11, 36, 23, 7, -32 },
  { 3824, 15, 36, 23, 4, -32 },
  { 3892, 16, 15, 23, 4, -28 },
  { 3922, 19, 3, 23, 0, 1 },
  { 3930, 6, 6, 23, 11, -31 },
  { 3935, 18, 22, 23, 3, -22 },
  { 3985, 19, 28, 23, 2, -28 },
  { 4052, 18, 22, 23, 3, -22 },
  { 4102, 19, 28, 23, 3, -28 },
  { 4169, 18, 22, 23, 3, -22 },
  { 4219, 26, 35, 23, -2, -28 },
  { 4333, 18, 29, 23, 3, -22 },
  { 4399, 19, 28, 23, 2, -28 },
  { 4466, 18, 30, 23, 2, -30 },
  { 4534, 20, 37, 23, 1, -30 },
  { 4627, 21, 28, 23, 2, -28 },
  { 4701, 16, 28, 23, 4, -28 },
  { 4757, 21, 22, 23, 1, -22 },
  { 4815, 19, 22, 23, 2, -22 },
  { 4868, 18, 22, 23, 3, -22 },
  { 4918, 20, 29, 23, 1, -22 },
  { 4991, 18, 29, 23, 3, -22 },
  { 5057, 19, 22, 23, 3, -22 },
  { 5110, 19, 22, 23, 2, -22 },
  { 5163, 18, 27, 23, 4, -27 },
  { 5224, 18, 21, 23, 3, -21 },
  { 5272, 19, 21, 23, 4, -21 },
  { 5322, 21, 21, 23, 3, -21 },
  { 5378, 21, 21, 23, 1, -21 },
  { 5434, 18, 28, 23, 3, -21 },
  { 5497, 19, 21, 23, 2, -21 },
  { 5547, 19, 36, 23, 4, -32 },
  { 5633, 9, 36, 23, 8, -32 },
  { 5674, 20, 36, 23, 1, -32 },
  { 5764, 19, 8, 23, 3, -18 },
};

const GFXfont JetBrainsMono_LightItalic39pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_LightItalic39pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_LightItalic39pt7bGlyphs,
  0x20, 0x7E, 51
};

#endif // _JETBRAINSMONO_LIGHTITALIC39PT7B_H_
