#ifndef _JETBRAINSMONO_LIGHTITALIC36PT7B_H_
#define _JETBRAINSMONO_LIGHTITALIC36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-LightItalic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_LightItalic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x0F, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x20, 0x00, 0x00, 0x00, 0x78,
  0xF8, 0xF8, 0xF0, 0x70, 0xF7, 0x0E, 0x70, 0xE7, 0x0E, 0xE0, 0xEE, 0x0E,
  0xE0, 0xCE, 0x1C, 0xE1, 0xCC, 0x1C, 0xC1, 0xC0, 0x00, 0x70, 0x70, 0x03,
  0x03, 0x80, 0x18, 0x18, 0x01, 0xC1, 0xC0, 0x0C, 0x0E, 0x00, 0xE0, 0x60,
  0x07, 0x07, 0x03, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x1C, 0x1C, 0x00, 0xC0,
  0xC0, 0x0E, 0x06, 0x00, 0x60, 0x70, 0x03, 0x03, 0x00, 0x38, 0x18, 0x01,
  0x81, 0xC0, 0x0C, 0x0C, 0x07, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x30, 0x30,
  0x03, 0x81, 0x80, 0x18, 0x1C, 0x00, 0xC0, 0xC0, 0x0E, 0x06, 0x00, 0x60,
  0x70, 0x07, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x39, 0x9E,
  0x0E, 0x31, 0xC3, 0x86, 0x38, 0x70, 0xC7, 0x0E, 0x30, 0x01, 0xC6, 0x00,
  0x38, 0xC0, 0x07, 0x98, 0x00, 0x7B, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0C, 0xF0, 0x01, 0x8E, 0x00, 0x31, 0xC0,
  0x06, 0x18, 0xE1, 0x87, 0x1C, 0x30, 0xE3, 0x86, 0x1C, 0x78, 0xC7, 0x07,
  0xDB, 0xC0, 0x7F, 0xF0, 0x07, 0xFC, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x03, 0xF0, 0x07, 0x83, 0xFC,
  0x03, 0x03, 0x86, 0x03, 0x01, 0x83, 0x03, 0x00, 0xC1, 0x83, 0x80, 0xE0,
  0xC3, 0x80, 0x70, 0x63, 0x80, 0x38, 0x71, 0x80, 0x1C, 0x31, 0x80, 0x0F,
  0xF9, 0x80, 0x03, 0xF9, 0xC0, 0x00, 0x31, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC7, 0x80, 0x00, 0xCF, 0xF0, 0x00, 0xC7, 0x38,
  0x00, 0xE6, 0x0C, 0x00, 0xE3, 0x06, 0x00, 0xE1, 0x83, 0x00, 0x61, 0xC1,
  0x80, 0x60, 0xE0, 0xC0, 0x60, 0x70, 0xE0, 0x70, 0x38, 0xE0, 0x70, 0x0F,
  0xF0, 0x70, 0x03, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x1F, 0xF0, 0x03, 0xFF,
  0x80, 0x78, 0x78, 0x07, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x0F,
  0x80, 0x01, 0xFC, 0x00, 0x39, 0xE0, 0xF7, 0x0E, 0x0E, 0x70, 0x71, 0xC7,
  0x07, 0x38, 0x70, 0x3F, 0x07, 0x03, 0xF0, 0x60, 0x1E, 0x0E, 0x01, 0xE0,
  0xE0, 0x3E, 0x0E, 0x07, 0xF0, 0x78, 0xF7, 0x07, 0xFE, 0x38, 0x3F, 0x83,
  0xC0, 0x3B, 0xDC, 0xE7, 0x39, 0xCC, 0xE7, 0x38, 0x00, 0x0E, 0x00, 0x78,
  0x03, 0xF0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0xE0, 0x07, 0x80, 0x07, 0x00,
  0x01, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x03,
  0x80, 0x08, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x80, 0xC0, 0x9E, 0x18, 0x7F, 0xF2, 0x7F, 0x3F,
  0x5F, 0x81, 0xFF, 0x80, 0x03, 0x00, 0x01, 0xF0, 0x00, 0x77, 0x00, 0x1C,
  0x70, 0x07, 0x8E, 0x01, 0xE1, 0xE0, 0x78, 0x1E, 0x06, 0x01, 0x80, 0x40,
  0x20, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x00, 0x0F, 0x8F, 0x87, 0x83, 0x83, 0xC1, 0xC1, 0xE0, 0xE0,
  0x70, 0x70, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0x7B, 0xFF, 0xFE, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x7F, 0xC0, 0x7F, 0xF8,
  0x3C, 0x1E, 0x0E, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0xE0, 0x07, 0x38,
  0x01, 0xCE, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x06, 0x38, 0xE3, 0x8C, 0x78,
  0xE7, 0x1E, 0x39, 0xC3, 0x8E, 0x70, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0x31,
  0x80, 0x1C, 0xE0, 0x07, 0x38, 0x01, 0xC7, 0x00, 0xE1, 0xC0, 0x78, 0x7C,
  0x3C, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x7C, 0x01, 0xFC, 0x03, 0xDC,
  0x0F, 0x98, 0x1E, 0x38, 0x1C, 0x38, 0x10, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38,
  0x00, 0x7F, 0xC0, 0x7F, 0xF8, 0x3C, 0x1E, 0x1E, 0x01, 0xC7, 0x00, 0x71,
  0x80, 0x1C, 0xE0, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC3, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0xC0,
  0x07, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x0E, 0x38, 0x03,
  0x8F, 0x01, 0xC1, 0xE1, 0xF0, 0x3F, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x70,
  0xE0, 0x30, 0xE0, 0x38, 0xE0, 0x1C, 0xE0, 0x0E, 0x70, 0x07, 0x38, 0x03,
  0x9F, 0xFF, 0x9F, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x7F, 0x01, 0xBF, 0xE0, 0xFC, 0x7C, 0x3C, 0x07, 0x0E,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0xE0, 0x07, 0x1C, 0x03, 0x87, 0x01, 0xE1, 0xF1, 0xF0,
  0x3F, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x80, 0x03, 0xBF, 0x03, 0xFF, 0xC3, 0xF1, 0xF1, 0xE0, 0x39, 0xE0,
  0x1E, 0xE0, 0x07, 0x70, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xEE,
  0x00, 0x77, 0x00, 0x79, 0xC0, 0x78, 0xF8, 0xF8, 0x3F, 0xF8, 0x0F, 0xF0,
  0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xE7, 0x00, 0x39, 0xC0, 0x0E, 0x70, 0x07,
  0x1C, 0x01, 0xCE, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x7F, 0xC0, 0x7F, 0xF8, 0x3C, 0x0E, 0x0E, 0x01, 0xC7,
  0x00, 0x71, 0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x03, 0x87, 0x00, 0xE0, 0xE0,
  0x70, 0x3C, 0x78, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x78, 0x78,
  0x3C, 0x0E, 0x0E, 0x01, 0xC7, 0x00, 0x71, 0x80, 0x1C, 0xE0, 0x07, 0x38,
  0x01, 0xCE, 0x00, 0xF1, 0xC0, 0x38, 0x7C, 0x3C, 0x0F, 0xFE, 0x01, 0xFF,
  0x00, 0x00, 0xE0, 0x03, 0xFE, 0x07, 0xFF, 0x87, 0x83, 0xE3, 0x80, 0x73,
  0x80, 0x3B, 0x80, 0x1D, 0xC0, 0x06, 0xE0, 0x07, 0x70, 0x03, 0xB8, 0x01,
  0xDC, 0x01, 0xEE, 0x00, 0xE7, 0x80, 0xF1, 0xFF, 0xF0, 0x7F, 0xF0, 0x1F,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x3F, 0x3F, 0x3F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x78, 0xF8, 0xF8, 0xF8, 0xF8, 0x03, 0xC0, 0xFC, 0x1F, 0x83,
  0xF0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0x80,
  0x70, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x80, 0x03, 0xC0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x7F, 0xFF, 0xBF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF, 0x80,
  0x10, 0x00, 0x0E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0xE0, 0x07, 0xE0, 0x01,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0xE0, 0x07, 0x81, 0xFE, 0x03, 0xF8, 0x07, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x01, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0xF0, 0x1C, 0x07, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0xE0,
  0x01, 0x83, 0x00, 0x06, 0x1C, 0x00, 0x18, 0x70, 0x00, 0x61, 0x81, 0xF9,
  0x86, 0x0F, 0xF6, 0x38, 0x38, 0x78, 0xE1, 0xC0, 0xE3, 0x87, 0x03, 0x0E,
  0x1C, 0x0C, 0x30, 0x60, 0x70, 0xC1, 0x81, 0xC3, 0x0E, 0x07, 0x1C, 0x38,
  0x1C, 0x70, 0xE0, 0x61, 0xC3, 0x83, 0x87, 0x0F, 0x1E, 0x18, 0x1F, 0xD8,
  0x60, 0x3E, 0xE1, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x77,
  0x00, 0x1D, 0xC0, 0x06, 0x70, 0x03, 0x9C, 0x00, 0xE3, 0x00, 0x70, 0xC0,
  0x1C, 0x30, 0x06, 0x0E, 0x03, 0x83, 0x80, 0xE0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x70, 0x06, 0x1C, 0x01,
  0x8E, 0x00, 0x73, 0x80, 0x1D, 0xC0, 0x07, 0x70, 0x01, 0xFC, 0x00, 0x70,
  0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0xC0, 0xF8, 0x30, 0x0F, 0x1C, 0x01, 0xC7,
  0x00, 0x71, 0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x03, 0x86, 0x00, 0xE3, 0x80,
  0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0x80, 0xF0, 0xC0, 0x1C,
  0x70, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x1C, 0x70, 0x07, 0x18,
  0x03, 0xCE, 0x01, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xF8, 0x00, 0x00,
  0x70, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xE0, 0xF1, 0xC0, 0x39, 0xC0, 0x1C,
  0xE0, 0x0E, 0x70, 0x07, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x71,
  0xC0, 0x78, 0xF8, 0x78, 0x3F, 0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xFC, 0x03,
  0xFF, 0xC0, 0xC0, 0xF8, 0x70, 0x0E, 0x1C, 0x03, 0xC7, 0x00, 0x71, 0xC0,
  0x1C, 0x70, 0x07, 0x1C, 0x01, 0x86, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E,
  0x38, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x38, 0xC0, 0x1C, 0x70, 0x07, 0x1C,
  0x01, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x0E, 0x1C, 0x03, 0x8E, 0x03,
  0xC3, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0xE1, 0xFF,
  0xFC, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1F, 0xFF,
  0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE1, 0xFF, 0xFC, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x43, 0xFF, 0xF0, 0x7F, 0xFE, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xE0, 0xF1, 0xC0, 0x39, 0xC0,
  0x1C, 0xE0, 0x0E, 0x70, 0x07, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC3, 0xFC, 0xC3, 0xFE, 0xE0, 0x07,
  0x70, 0x03, 0xB8, 0x03, 0x9C, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0x73, 0x80,
  0x71, 0xC0, 0x78, 0xF8, 0x78, 0x3F, 0xF8, 0x0F, 0xF0, 0x00, 0x0E, 0x00,
  0xE1, 0xC0, 0x18, 0x38, 0x07, 0x06, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x03,
  0x87, 0x00, 0x70, 0xE0, 0x0C, 0x1C, 0x03, 0x83, 0x00, 0x70, 0xE0, 0x0E,
  0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFE, 0x0E, 0x01, 0xC1, 0x80, 0x38,
  0x70, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x03, 0x87, 0x00, 0xE0,
  0xE0, 0x1C, 0x38, 0x03, 0x87, 0x00, 0x70, 0xE0, 0x0E, 0x1C, 0x01, 0xC0,
  0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x38, 0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x70, 0x03, 0x8E, 0x00,
  0x71, 0xE0, 0x1C, 0x1C, 0x07, 0x83, 0xE3, 0xE0, 0x3F, 0xF8, 0x03, 0xFC,
  0x00, 0x0E, 0x00, 0xF0, 0xE0, 0x0E, 0x0C, 0x01, 0xC1, 0xC0, 0x3C, 0x1C,
  0x03, 0x81, 0xC0, 0x70, 0x1C, 0x0F, 0x01, 0xC0, 0xE0, 0x1C, 0x1C, 0x01,
  0x83, 0xC0, 0x38, 0x38, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00,
  0x38, 0x70, 0x03, 0x03, 0x80, 0x70, 0x38, 0x07, 0x03, 0x80, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1E, 0x06, 0x00, 0xE0, 0xE0, 0x0E, 0x0E, 0x00,
  0xF0, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x00, 0xF0, 0xF8, 0x0F,
  0x0F, 0x81, 0xB0, 0xD8, 0x1F, 0x0D, 0x83, 0x70, 0xD8, 0x36, 0x1D, 0x87,
  0x61, 0xDC, 0x66, 0x1C, 0xCE, 0xE1, 0xCC, 0xCE, 0x18, 0xDC, 0xE1, 0x8D,
  0x8C, 0x38, 0xF9, 0xC3, 0x8F, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x38,
  0x01, 0xC3, 0x00, 0x1C, 0x70, 0x01, 0x87, 0x00, 0x38, 0x70, 0x03, 0x87,
  0x00, 0x38, 0x70, 0x03, 0x87, 0x00, 0x38, 0x60, 0x03, 0x0E, 0x00, 0x70,
  0x0F, 0x00, 0xE1, 0xE0, 0x18, 0x3C, 0x03, 0x0F, 0xC0, 0xE1, 0xF8, 0x1C,
  0x3F, 0x03, 0x87, 0x60, 0x70, 0xEC, 0x0E, 0x19, 0xC1, 0x87, 0x38, 0x70,
  0xE3, 0x0E, 0x1C, 0x61, 0xC3, 0x8E, 0x38, 0x71, 0xC7, 0x0C, 0x38, 0xC3,
  0x83, 0x38, 0x70, 0x67, 0x0E, 0x0E, 0xE1, 0xC1, 0xDC, 0x38, 0x3B, 0x86,
  0x03, 0x60, 0xC0, 0x6C, 0x38, 0x0F, 0x87, 0x01, 0xF0, 0xE0, 0x3E, 0x1C,
  0x03, 0xC0, 0x00, 0x70, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xC1, 0xE1, 0xC0,
  0x79, 0xC0, 0x1C, 0xE0, 0x0E, 0x70, 0x07, 0x38, 0x03, 0xB8, 0x01, 0x9C,
  0x01, 0xCE, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x1C, 0xC0, 0x0E,
  0xE0, 0x0E, 0x70, 0x07, 0x38, 0x03, 0x9C, 0x01, 0xCE, 0x00, 0xE7, 0x00,
  0x63, 0x80, 0x71, 0xC0, 0x78, 0xF8, 0xF8, 0x3F, 0xF8, 0x0F, 0xF0, 0x00,
  0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x30, 0x1F, 0x0E, 0x00, 0xF1, 0xC0, 0x0E,
  0x38, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x07, 0x1C, 0x00, 0xE3, 0x00, 0x38,
  0xE0, 0x07, 0x1C, 0x01, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFE, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x7F, 0xC0, 0x7F, 0xF8, 0x3E, 0x1E, 0x0E,
  0x03, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x07, 0x38, 0x01, 0xCE, 0x00,
  0x73, 0x80, 0x1C, 0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0xE7, 0x00, 0x39,
  0xC0, 0x0E, 0x70, 0x03, 0x9C, 0x00, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0x60,
  0x07, 0x18, 0x01, 0xC7, 0x00, 0xE1, 0xC0, 0x78, 0x7C, 0x7C, 0x0F, 0xFE,
  0x01, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x30, 0x1F,
  0x0E, 0x00, 0xE1, 0xC0, 0x1E, 0x38, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x07,
  0x1C, 0x01, 0xC3, 0x00, 0x38, 0xE0, 0x0E, 0x1C, 0x03, 0xC3, 0xFF, 0xF0,
  0x7F, 0xF8, 0x0F, 0xFC, 0x01, 0x83, 0x80, 0x70, 0x38, 0x0E, 0x07, 0x01,
  0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0xC0, 0x38, 0x38, 0x03, 0x87,
  0x00, 0x70, 0xE0, 0x0E, 0x1C, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x3F, 0xE0,
  0x1F, 0xFE, 0x03, 0x81, 0xE0, 0xE0, 0x1C, 0x38, 0x03, 0x87, 0x00, 0x70,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x8E, 0x00, 0x71, 0xC0, 0x0E, 0x38,
  0x01, 0xC7, 0x80, 0x70, 0x7C, 0x3C, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0xE1, 0xC0, 0x18, 0x30, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x38,
  0x03, 0x87, 0x00, 0x70, 0xE0, 0x0E, 0x18, 0x01, 0x87, 0x00, 0x70, 0xE0,
  0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x07, 0x0E, 0x00, 0xC3, 0x80,
  0x38, 0x70, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x03, 0x87, 0x00,
  0xE0, 0xE0, 0x1C, 0x1C, 0x07, 0x03, 0xE3, 0xE0, 0x3F, 0xF8, 0x03, 0xFC,
  0x00, 0xE0, 0x03, 0xF0, 0x01, 0xB8, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0xE7,
  0x00, 0x73, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x1C, 0x30, 0x1C, 0x18, 0x0E,
  0x0E, 0x0E, 0x07, 0x07, 0x03, 0x83, 0x01, 0xC3, 0x80, 0xE1, 0xC0, 0x71,
  0xC0, 0x38, 0xE0, 0x0C, 0xE0, 0x06, 0x70, 0x03, 0x30, 0x01, 0xB8, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x00, 0x60, 0x70, 0x76,
  0x0F, 0x07, 0x60, 0xF0, 0x6E, 0x0F, 0x0E, 0xE1, 0xB0, 0xEE, 0x1B, 0x0E,
  0xE1, 0xB0, 0xCE, 0x1B, 0x1C, 0xE3, 0x31, 0xCE, 0x33, 0x18, 0xE3, 0x31,
  0x8E, 0x63, 0x38, 0xE6, 0x33, 0x8E, 0x62, 0x30, 0xE6, 0x23, 0x0E, 0xC2,
  0x70, 0xCC, 0x26, 0x0C, 0xC6, 0x60, 0xD8, 0x6E, 0x0D, 0x86, 0xE0, 0xD8,
  0x6C, 0x0D, 0x86, 0xC0, 0xF0, 0x7C, 0x0F, 0x07, 0xC0, 0xF0, 0x78, 0x0E,
  0x07, 0x80, 0x07, 0x00, 0x3C, 0x1C, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0,
  0x38, 0x01, 0xC0, 0xE0, 0x07, 0x07, 0x00, 0x1C, 0x38, 0x00, 0x38, 0xE0,
  0x00, 0xE7, 0x00, 0x01, 0xB8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xCE,
  0x00, 0x0E, 0x38, 0x00, 0x78, 0xE0, 0x01, 0xC1, 0xC0, 0x0E, 0x07, 0x00,
  0x70, 0x0E, 0x03, 0xC0, 0x38, 0x0E, 0x00, 0xE0, 0x70, 0x01, 0xC3, 0xC0,
  0x07, 0x00, 0xE0, 0x01, 0xEC, 0x00, 0x39, 0xC0, 0x0E, 0x38, 0x03, 0x83,
  0x00, 0x70, 0x70, 0x1C, 0x0E, 0x07, 0x00, 0xC0, 0xE0, 0x1C, 0x38, 0x03,
  0x8E, 0x00, 0x31, 0xC0, 0x07, 0x70, 0x00, 0xEE, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x40, 0x07, 0x00,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xFF,
  0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0x03, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1F, 0xE0, 0x7F, 0x83, 0xFE, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x60, 0x0E,
  0x01, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x1F,
  0xE0, 0xFF, 0x83, 0xFE, 0x00, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xF8, 0x01,
  0x98, 0x03, 0x98, 0x03, 0x18, 0x07, 0x1C, 0x0E, 0x0C, 0x0C, 0x0C, 0x1C,
  0x0E, 0x38, 0x0E, 0x38, 0x06, 0x70, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xE1, 0xC3, 0x0E, 0x1C, 0x03, 0xF1, 0xC1, 0xFE, 0x60, 0xF9,
  0xF8, 0x78, 0x1E, 0x1C, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E,
  0x30, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x07, 0x1C,
  0x01, 0xC7, 0x00, 0xE1, 0xC0, 0x38, 0x70, 0x1E, 0x1F, 0x0F, 0x83, 0xFE,
  0xE0, 0x7F, 0x38, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x73, 0xF0, 0x3B, 0xFE, 0x1B, 0x9F, 0x0F, 0x03,
  0xCF, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x1C, 0xE0, 0x0E, 0x60,
  0x0E, 0x70, 0x07, 0x38, 0x03, 0x9C, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0x63,
  0x80, 0x73, 0xC0, 0x79, 0xF8, 0x78, 0xEF, 0xF8, 0x73, 0xF8, 0x00, 0x03,
  0xF8, 0x0F, 0xFC, 0x1F, 0x3E, 0x3C, 0x0F, 0x38, 0x07, 0x70, 0x07, 0x70,
  0x07, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x0E, 0xE0, 0x1C, 0xE0, 0x3C, 0xF8, 0x78, 0x7F,
  0xF0, 0x3F, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0xFC, 0x70, 0x3F, 0xCE, 0x0F, 0x9F,
  0x83, 0xC0, 0xF0, 0x70, 0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x07,
  0x0C, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x1C,
  0x38, 0x03, 0x87, 0x00, 0xE0, 0xE0, 0x1C, 0x1C, 0x07, 0x83, 0xE1, 0xF0,
  0x3F, 0xEE, 0x03, 0xF9, 0xC0, 0x03, 0xF8, 0x0F, 0xFC, 0x1E, 0x1E, 0x38,
  0x0E, 0x38, 0x07, 0x70, 0x07, 0x70, 0x07, 0x70, 0x07, 0x60, 0x07, 0xFF,
  0xFE, 0xFF, 0xFE, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x1C, 0xE0, 0x1C, 0xF0, 0x78, 0x7F, 0xF0, 0x3F, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x0F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE3, 0x87,
  0xFD, 0x87, 0xCF, 0xC7, 0x81, 0xE3, 0x80, 0x73, 0x80, 0x39, 0xC0, 0x1C,
  0xE0, 0x0E, 0x60, 0x06, 0x70, 0x07, 0x38, 0x03, 0x9C, 0x01, 0xCE, 0x00,
  0xE7, 0x00, 0xF3, 0x80, 0x71, 0xE0, 0x78, 0x7F, 0xFC, 0x1F, 0xEE, 0x03,
  0x87, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0,
  0x7F, 0xF0, 0x7F, 0xE0, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x73, 0xF0, 0x3B, 0xFE, 0x1F, 0x9F,
  0x0F, 0x03, 0xCF, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x1C, 0xE0,
  0x0C, 0x60, 0x0E, 0x70, 0x07, 0x38, 0x03, 0x9C, 0x01, 0xCE, 0x00, 0xE7,
  0x00, 0x63, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x1C, 0xE0, 0x0E, 0x70, 0x07,
  0x00, 0x00, 0x0C, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFE,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x3F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x07,
  0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x78, 0xE0,
  0x1E, 0x1C, 0x03, 0x83, 0x80, 0xE0, 0xE0, 0x38, 0x1C, 0x0E, 0x03, 0x83,
  0xC0, 0x70, 0xF0, 0x0E, 0x3C, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0E, 0x1E,
  0x01, 0xC1, 0xC0, 0x38, 0x3C, 0x07, 0x03, 0x80, 0xE0, 0x78, 0x18, 0x07,
  0x07, 0x00, 0xF0, 0xE0, 0x0E, 0x1C, 0x01, 0xE0, 0xFF, 0x81, 0xFF, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0F, 0xFF, 0x0F, 0xFC, 0x0F, 0xF8, 0x1D, 0xE3, 0xC3,
  0x7E, 0xFC, 0x71, 0xE3, 0x9C, 0x38, 0x73, 0x87, 0x0E, 0x70, 0xE1, 0xCE,
  0x1C, 0x39, 0xC3, 0x06, 0x30, 0x60, 0xC6, 0x0C, 0x19, 0xC1, 0x87, 0x38,
  0x70, 0xE7, 0x0E, 0x1C, 0xE1, 0x83, 0x98, 0x30, 0x63, 0x06, 0x0C, 0xE0,
  0xC3, 0x9C, 0x38, 0x73, 0x87, 0x0E, 0x70, 0xC1, 0xC0, 0x1C, 0xFC, 0x0E,
  0xFF, 0x87, 0xE7, 0xC3, 0xC0, 0xF3, 0xC0, 0x39, 0xC0, 0x1C, 0xE0, 0x0E,
  0x70, 0x07, 0x38, 0x03, 0x18, 0x03, 0x9C, 0x01, 0xCE, 0x00, 0xE7, 0x00,
  0x73, 0x80, 0x39, 0xC0, 0x18, 0xC0, 0x1C, 0xE0, 0x0E, 0x70, 0x07, 0x38,
  0x03, 0x9C, 0x01, 0xC0, 0x03, 0xF8, 0x0F, 0xFC, 0x1F, 0x3E, 0x3C, 0x0E,
  0x38, 0x07, 0x70, 0x07, 0x70, 0x07, 0x70, 0x07, 0x60, 0x07, 0xE0, 0x0E,
  0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0C, 0xE0, 0x1C,
  0xE0, 0x3C, 0xF8, 0x78, 0x7F, 0xF0, 0x3F, 0xC0, 0x0E, 0x7E, 0x03, 0xBF,
  0xE0, 0xFC, 0xF8, 0x3C, 0x0F, 0x1E, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x1C,
  0x70, 0x07, 0x1C, 0x01, 0xC6, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x38,
  0x03, 0x8E, 0x00, 0xE3, 0x80, 0x30, 0xE0, 0x1C, 0x7C, 0x0F, 0x1F, 0x87,
  0x87, 0x7F, 0xC1, 0xCF, 0xE0, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x03, 0xF1, 0xC1, 0xFE, 0x60,
  0xF9, 0xF8, 0x78, 0x1E, 0x1C, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x38, 0xE0,
  0x0E, 0x30, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x07,
  0x1C, 0x01, 0xC7, 0x00, 0xE1, 0xC0, 0x38, 0x70, 0x1E, 0x1F, 0x1F, 0x83,
  0xFE, 0xE0, 0x7F, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x1C, 0xFC, 0x1D, 0xFF, 0x0E, 0xC7,
  0xC7, 0x80, 0xE3, 0x80, 0x79, 0xC0, 0x1C, 0xE0, 0x0E, 0x60, 0x06, 0x70,
  0x04, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0xFE, 0x07, 0xFF, 0x83, 0xE3, 0xE3, 0x80, 0x71, 0x80, 0x39,
  0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x80, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1D, 0xC0, 0x0E, 0xF0,
  0x0E, 0x3C, 0x1F, 0x1F, 0xFF, 0x03, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x03,
  0xFC, 0x00, 0x1C, 0x01, 0xC7, 0x00, 0x71, 0x80, 0x18, 0xE0, 0x0E, 0x38,
  0x03, 0x8E, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x0C, 0x01,
  0xC7, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0xE1,
  0xC0, 0x38, 0x70, 0x1C, 0x1F, 0x0F, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0xE0,
  0x03, 0xF0, 0x03, 0xB8, 0x01, 0xDC, 0x01, 0xC6, 0x00, 0xE3, 0x80, 0xE1,
  0xC0, 0x70, 0xE0, 0x70, 0x70, 0x38, 0x38, 0x38, 0x0C, 0x1C, 0x07, 0x1C,
  0x03, 0x8E, 0x01, 0xC6, 0x00, 0xE7, 0x00, 0x33, 0x00, 0x1B, 0x80, 0x0D,
  0x80, 0x07, 0xC0, 0x03, 0xC0, 0x00, 0xC0, 0xE0, 0xF8, 0x3C, 0x1B, 0x07,
  0x83, 0x60, 0xF0, 0xEC, 0x36, 0x19, 0x86, 0xC3, 0x30, 0xD8, 0xE6, 0x33,
  0x18, 0xC6, 0x63, 0x18, 0xCC, 0xE3, 0x11, 0x98, 0x66, 0x33, 0x0C, 0xC6,
  0xE1, 0x90, 0xD8, 0x36, 0x1B, 0x06, 0xC3, 0xE0, 0xD0, 0x78, 0x1E, 0x0F,
  0x03, 0xC1, 0xE0, 0x70, 0x38, 0x00, 0x1E, 0x00, 0xF0, 0xE0, 0x1E, 0x0F,
  0x03, 0xC0, 0x70, 0x38, 0x07, 0x07, 0x00, 0x38, 0xE0, 0x03, 0x9C, 0x00,
  0x1D, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xB8, 0x00, 0x73, 0x80, 0x0E, 0x1C, 0x01, 0xE1, 0xE0, 0x3C, 0x0E,
  0x03, 0x80, 0xF0, 0x70, 0x07, 0x0E, 0x00, 0x78, 0x38, 0x03, 0x9C, 0x01,
  0x8C, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x1C, 0xE0,
  0x0E, 0x70, 0x0E, 0x70, 0x07, 0x38, 0x03, 0x9C, 0x01, 0xCE, 0x00, 0xE7,
  0x00, 0xF3, 0x80, 0x71, 0xE0, 0xF8, 0x7F, 0xDC, 0x1F, 0xCE, 0x01, 0x07,
  0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x7F,
  0xF0, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xC0, 0x00,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x02, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1F, 0xE0, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x18, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x70, 0x70, 0x70,
  0x70, 0x70, 0x70, 0x60, 0xE0, 0xE0, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7F,
  0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x70, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x81, 0xCF, 0xF0, 0x77, 0x1C, 0x1D, 0xC3, 0x86, 0x60, 0xFF, 0x98, 0x1F,
  0xCE, 0x03, 0xE0,
};

const GFXglyph JetBrainsMono_LightItalic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 8, 26, 22, 7, -26 },
  { 27, 12, 11, 22, 7, -26 },
  { 44, 21, 26, 22, 1, -26 },
  { 113, 19, 36, 22, 2, -31 },
  { 199, 25, 26, 22, -1, -26 },
  { 281, 20, 27, 22, 1, -27 },
  { 349, 5, 11, 22, 10, -26 },
  { 356, 15, 35, 22, 6, -30 },
  { 422, 14, 35, 22, 2, -30 },
  { 484, 19, 19, 22, 2, -22 },
  { 530, 17, 17, 22, 3, -20 },
  { 567, 9, 11, 22, 4, -5 },
  { 580, 12, 2, 22, 5, -13 },
  { 583, 6, 5, 22, 7, -5 },
  { 587, 21, 34, 22, 1, -30 },
  { 677, 18, 27, 22, 2, -27 },
  { 738, 16, 26, 22, 2, -26 },
  { 790, 18, 27, 22, 2, -27 },
  { 851, 18, 26, 22, 2, -26 },
  { 910, 17, 26, 22, 2, -26 },
  { 966, 18, 26, 22, 2, -26 },
  { 1025, 17, 26, 22, 2, -26 },
  { 1081, 18, 26, 22, 4, -26 },
  { 1140, 18, 27, 22, 2, -27 },
  { 1201, 17, 27, 22, 4, -27 },
  { 1259, 8, 20, 22, 7, -20 },
  { 1279, 11, 26, 22, 4, -20 },
  { 1315, 17, 19, 22, 3, -21 },
  { 1356, 17, 11, 22, 3, -17 },
  { 1380, 17, 19, 22, 2, -21 },
  { 1421, 15, 26, 22, 5, -26 },
  { 1470, 22, 33, 22, 0, -27 },
  { 1561, 18, 26, 22, 0, -26 },
  { 1620, 18, 26, 22, 2, -26 },
  { 1679, 17, 27, 22, 3, -27 },
  { 1737, 18, 26, 22, 2, -26 },
  { 1796, 19, 26, 22, 2, -26 },
  { 1858, 19, 26, 22, 2, -26 },
  { 1920, 17, 27, 22, 3, -27 },
  { 1978, 19, 26, 22, 2, -26 },
  { 2040, 18, 26, 22, 2, -26 },
  { 2099, 19, 26, 22, 1, -26 },
  { 2161, 20, 26, 22, 2, -26 },
  { 2226, 15, 26, 22, 3, -26 },
  { 2275, 20, 26, 22, 1, -26 },
  { 2340, 19, 26, 22, 2, -26 },
  { 2402, 17, 27, 22, 3, -27 },
  { 2460, 19, 26, 22, 2, -26 },
  { 2522, 18, 33, 22, 2, -27 },
  { 2597, 19, 26, 22, 2, -26 },
  { 2659, 19, 27, 22, 2, -27 },
  { 2724, 18, 26, 22, 4, -26 },
  { 2783, 19, 26, 22, 2, -26 },
  { 2845, 17, 26, 22, 5, -26 },
  { 2901, 20, 26, 22, 3, -26 },
  { 2966, 22, 26, 22, 0, -26 },
  { 3038, 19, 26, 22, 4, -26 },
  { 3100, 19, 26, 22, 2, -26 },
  { 3162, 14, 34, 22, 5, -30 },
  { 3222, 11, 34, 22, 6, -30 },
  { 3269, 14, 34, 22, 3, -30 },
  { 3329, 16, 14, 22, 3, -26 },
  { 3357, 18, 2, 22, 0, 1 },
  { 3362, 6, 5, 22, 10, -28 },
  { 3366, 18, 20, 22, 2, -20 },
  { 3411, 17, 26, 22, 2, -26 },
  { 3467, 16, 20, 22, 3, -20 },
  { 3507, 19, 26, 22, 2, -26 },
  { 3569, 16, 20, 22, 3, -20 },
  { 3609, 24, 32, 22, -1, -26 },
  { 3705, 17, 26, 22, 3, -20 },
  { 3761, 17, 26, 22, 2, -26 },
  { 3817, 17, 28, 22, 1, -28 },
  { 3877, 18, 34, 22, 1, -28 },
  { 3954, 19, 26, 22, 2, -26 },
  { 4016, 15, 26, 22, 4, -26 },
  { 4065, 19, 20, 22, 1, -20 },
  { 4113, 17, 20, 22, 2, -20 },
  { 4156, 16, 20, 22, 3, -20 },
  { 4196, 18, 26, 22, 1, -20 },
  { 4255, 18, 26, 22, 2, -20 },
  { 4314, 17, 20, 22, 3, -20 },
  { 4357, 17, 20, 22, 2, -20 },
  { 4400, 17, 25, 22, 3, -25 },
  { 4454, 18, 20, 22, 2, -20 },
  { 4499, 17, 20, 22, 4, -20 },
  { 4542, 19, 20, 22, 3, -20 },
  { 4590, 20, 20, 22, 1, -20 },
  { 4640, 17, 26, 22, 3, -20 },
  { 4696, 17, 20, 22, 2, -20 },
  { 4739, 19, 34, 22, 3, -30 },
  { 4820, 8, 34, 22, 7, -30 },
  { 4854, 18, 34, 22, 1, -30 },
  { 4931, 18, 7, 22, 2, -16 },
};

const GFXfont JetBrainsMono_LightItalic36pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_LightItalic36pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_LightItalic36pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _JETBRAINSMONO_LIGHTITALIC36PT7B_H_
