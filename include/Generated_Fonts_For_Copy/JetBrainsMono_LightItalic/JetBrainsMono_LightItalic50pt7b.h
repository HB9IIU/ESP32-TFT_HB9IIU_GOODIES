#ifndef _JETBRAINSMONO_LIGHTITALIC50PT7B_H_
#define _JETBRAINSMONO_LIGHTITALIC50PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-LightItalic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_LightItalic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x7E, 0x1F, 0xC3,
  0xF8, 0x7E, 0x0F, 0xC0, 0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x03, 0xE7, 0x81,
  0xE3, 0xC0, 0xF1, 0xE0, 0x79, 0xF0, 0x3C, 0xF0, 0x3E, 0x78, 0x1E, 0x3C,
  0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x01, 0xE3, 0x80, 0xE1, 0xC0, 0x71,
  0xE0, 0x38, 0x00, 0x03, 0x80, 0x70, 0x00, 0x3C, 0x03, 0x80, 0x01, 0xC0,
  0x3C, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0xF0, 0x0E, 0x00, 0x07, 0x00, 0xF0,
  0x00, 0x78, 0x07, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x1C, 0x03, 0xC0, 0x01,
  0xE0, 0x1C, 0x00, 0x0E, 0x00, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x3C, 0x00, 0x1E, 0x01, 0xC0,
  0x00, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x78, 0x07, 0x00, 0x03,
  0x80, 0x78, 0x00, 0x1C, 0x03, 0xC0, 0x01, 0xE0, 0x1C, 0x00, 0x0E, 0x01,
  0xE0, 0x00, 0x70, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xE0, 0x1E, 0x01, 0xC0, 0x00, 0xE0, 0x1E, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x78, 0x07, 0x00, 0x03, 0x80, 0x78, 0x00, 0x1C, 0x03,
  0x80, 0x01, 0xE0, 0x1C, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x70, 0x0E, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xF8, 0xE7, 0xC0, 0x3E, 0x18,
  0x7C, 0x07, 0x87, 0x07, 0x81, 0xE0, 0xE0, 0xF0, 0x3C, 0x1C, 0x1E, 0x07,
  0x83, 0x83, 0xC0, 0xF0, 0x70, 0x00, 0x1E, 0x0C, 0x00, 0x03, 0xC1, 0x80,
  0x00, 0x7C, 0x70, 0x00, 0x0F, 0xCE, 0x00, 0x00, 0xFD, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xE7, 0xE0, 0x00, 0x1C, 0x7C, 0x00, 0x03,
  0x87, 0x80, 0x00, 0x60, 0xF8, 0x00, 0x1C, 0x0F, 0x00, 0x03, 0x81, 0xE0,
  0x00, 0x70, 0x3C, 0x3C, 0x0E, 0x0F, 0x07, 0x81, 0xC1, 0xE0, 0xF0, 0x30,
  0x3C, 0x1F, 0x06, 0x0F, 0x03, 0xF1, 0xC3, 0xE0, 0x3F, 0x39, 0xF8, 0x03,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x3F, 0xE0, 0x00, 0xE0, 0x1F, 0xF8, 0x00, 0x70, 0x0F,
  0x9F, 0x00, 0x38, 0x07, 0x83, 0xC0, 0x1C, 0x01, 0xC0, 0x70, 0x0F, 0x00,
  0x70, 0x1C, 0x07, 0x80, 0x1C, 0x07, 0x03, 0xC0, 0x0F, 0x01, 0xC0, 0xE0,
  0x03, 0xC0, 0xF0, 0x70, 0x00, 0xE0, 0x3C, 0x38, 0x00, 0x38, 0x0E, 0x1E,
  0x00, 0x0E, 0x03, 0x8F, 0x00, 0x03, 0xC3, 0xE7, 0x80, 0x00, 0x7F, 0xF1,
  0xC0, 0x00, 0x1F, 0xF8, 0xE0, 0x00, 0x01, 0xF8, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0x81, 0x00, 0x00, 0x01, 0xC7, 0xF8, 0x00, 0x00, 0xE3, 0xFF, 0x00,
  0x00, 0x71, 0xFF, 0xE0, 0x00, 0x3C, 0x70, 0x38, 0x00, 0x1E, 0x3C, 0x0E,
  0x00, 0x0F, 0x0E, 0x03, 0x80, 0x03, 0x83, 0x80, 0xE0, 0x01, 0xC0, 0xE0,
  0x38, 0x00, 0xE0, 0x78, 0x0E, 0x00, 0x70, 0x1E, 0x07, 0x80, 0x3C, 0x07,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x70, 0x07, 0x00, 0x78, 0x3C, 0x03, 0x80,
  0x0F, 0xFE, 0x01, 0xC0, 0x03, 0xFF, 0x00, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x00, 0xF0, 0x01, 0xE0, 0x0F,
  0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xF1, 0xE0, 0x1F, 0x1E, 0x1F,
  0x03, 0xC3, 0xC0, 0xF0, 0x3C, 0x3C, 0x0F, 0x87, 0x83, 0xC0, 0x78, 0xF0,
  0x3C, 0x07, 0xCF, 0x07, 0x80, 0x3D, 0xE0, 0x78, 0x01, 0xFC, 0x07, 0x80,
  0x1F, 0x80, 0x78, 0x00, 0xF8, 0x07, 0x80, 0x0F, 0x80, 0x78, 0x01, 0xF8,
  0x07, 0x80, 0x3F, 0xC0, 0x78, 0x07, 0xFC, 0x07, 0xE1, 0xF9, 0xE0, 0x3F,
  0xFF, 0x1F, 0x03, 0xFF, 0xC0, 0xF0, 0x0F, 0xF8, 0x0F, 0x80, 0x18, 0x00,
  0x00, 0x3E, 0x78, 0xF1, 0xE3, 0xCF, 0x9F, 0x3E, 0x78, 0xF1, 0xE3, 0xC7,
  0x1E, 0x3C, 0x78, 0x00, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xFC, 0x00,
  0x1F, 0xE0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0xFF,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x70,
  0x0E, 0x01, 0x9F, 0x03, 0x83, 0xFF, 0xF0, 0xC3, 0xFF, 0xFF, 0x33, 0xFF,
  0x1F, 0xEF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x1F,
  0x1F, 0x00, 0x0F, 0x83, 0xC0, 0x03, 0xC0, 0xF8, 0x01, 0xF0, 0x1E, 0x00,
  0xF8, 0x07, 0xC0, 0x3C, 0x00, 0xE0, 0x02, 0x00, 0x30, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x80, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0xF8,
  0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x0F,
  0x80, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xC0, 0x08, 0x1F, 0x9F, 0xCF, 0xEF, 0xF7, 0xFB, 0xFC,
  0xFC, 0x10, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3E, 0x01,
  0xF0, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x0F, 0x00,
  0x07, 0x8F, 0x00, 0x03, 0xC7, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0xF1, 0xE0,
  0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x3C,
  0x1E, 0x0F, 0x1E, 0x1F, 0x07, 0x8F, 0x0F, 0xC3, 0xC7, 0x87, 0xC3, 0xC3,
  0xC3, 0xE1, 0xE3, 0xC0, 0x40, 0xF1, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x3C,
  0x78, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x07,
  0x8F, 0x00, 0x03, 0xC7, 0x80, 0x03, 0xE3, 0xE0, 0x01, 0xE0, 0xF0, 0x01,
  0xF0, 0x7C, 0x01, 0xF0, 0x1F, 0x83, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xEF, 0x00, 0x3F,
  0x3C, 0x00, 0xFC, 0x78, 0x03, 0xE0, 0xF0, 0x07, 0x81, 0xE0, 0x0C, 0x03,
  0xC0, 0x10, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xF0, 0x0F, 0x80,
  0xF0, 0x01, 0xE0, 0x78, 0x00, 0x7C, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x8F,
  0x00, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x03, 0xE1, 0xF0, 0x01, 0xE0,
  0x78, 0x01, 0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x1E, 0x07, 0xC0,
  0x1E, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x1F, 0x00, 0x3C, 0x3E, 0x00,
  0x3C, 0x7C, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x7F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x03, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0xFE, 0x00, 0x3D, 0xFF, 0xC0, 0x3D, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFC, 0x0F, 0xC0, 0x3E, 0x07, 0xC0, 0x0F, 0x03, 0xC0, 0x07,
  0xC1, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x80, 0x03, 0xC7, 0x80, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0,
  0x01, 0xE0, 0x7C, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xC2, 0x00, 0x07, 0x9F, 0xE0, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x1F, 0x80, 0xFC, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0x3E,
  0x7C, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x1E,
  0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3C,
  0xF0, 0x00, 0x3C, 0xF8, 0x00, 0x78, 0xF8, 0x00, 0xF8, 0x7C, 0x01, 0xF0,
  0x7F, 0x07, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x00, 0x40, 0x00, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x3C,
  0x78, 0x00, 0x3C, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3E, 0x01, 0xF0, 0x3E, 0x00,
  0x78, 0x1E, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80,
  0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0x3C,
  0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x07, 0xC3, 0xE0, 0x01, 0xFF, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x3F, 0x00,
  0x7C, 0x07, 0xC0, 0x78, 0x01, 0xE0, 0x78, 0x00, 0xF8, 0x7C, 0x00, 0x3C,
  0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x8F, 0x00, 0x03,
  0xC7, 0x80, 0x01, 0xE3, 0xC0, 0x01, 0xE1, 0xF0, 0x01, 0xF0, 0x7C, 0x01,
  0xF0, 0x3F, 0x03, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0x3E, 0x3E,
  0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78,
  0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x3E, 0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0x7E,
  0x01, 0xF8, 0x7F, 0x8F, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFD, 0xE0, 0x07,
  0xF3, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x7E, 0x0F,
  0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x7F, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x07, 0xE0, 0x10, 0x00, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0xFF,
  0x01, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xF0,
  0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80,
  0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x10, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFA, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x00, 0x10, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x81, 0xFF,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x1F, 0xC0, 0xFC, 0x00, 0xF8, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xE0, 0x1E,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x38, 0x3C, 0x01, 0xFC, 0xE0, 0xE0, 0x1F, 0xFB, 0x83, 0x80, 0xFF, 0xEE,
  0x0E, 0x03, 0xC0, 0xF8, 0x78, 0x1E, 0x01, 0xE1, 0xE0, 0x78, 0x07, 0x87,
  0x81, 0xC0, 0x1C, 0x1E, 0x0F, 0x00, 0x70, 0x70, 0x3C, 0x03, 0xC1, 0xC0,
  0xF0, 0x0F, 0x0F, 0x03, 0xC0, 0x3C, 0x3C, 0x0E, 0x00, 0xF0, 0xF0, 0x38,
  0x03, 0x83, 0xC1, 0xE0, 0x0E, 0x0E, 0x07, 0x80, 0x78, 0x38, 0x1E, 0x01,
  0xE1, 0xE0, 0x78, 0x0F, 0x87, 0x80, 0xF0, 0x3E, 0x1E, 0x03, 0xFF, 0xF0,
  0x78, 0x0F, 0xFD, 0xC1, 0xE0, 0x0F, 0xC7, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0E, 0x78, 0x00, 0x1E, 0x38, 0x00,
  0x1E, 0x38, 0x00, 0x3C, 0x38, 0x00, 0x3C, 0x38, 0x00, 0x78, 0x3C, 0x00,
  0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x3C, 0x01,
  0xE0, 0x3C, 0x01, 0xE0, 0x3C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x1C, 0x03,
  0xC0, 0x1E, 0x07, 0x80, 0x1E, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x3C,
  0x00, 0x0E, 0x3C, 0x00, 0x0E, 0x7C, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x78, 0x03, 0xF0,
  0x3C, 0x00, 0xF8, 0x1C, 0x00, 0x3E, 0x1E, 0x00, 0x1F, 0x0F, 0x00, 0x07,
  0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xC1, 0xE0, 0x01, 0xE0, 0xE0, 0x00,
  0xF0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0xF8, 0x3C, 0x00, 0xF8, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x03, 0xC0,
  0x0F, 0xC1, 0xE0, 0x03, 0xE0, 0xF0, 0x00, 0xF8, 0x78, 0x00, 0x3C, 0x3C,
  0x00, 0x1E, 0x1C, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xC7,
  0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x01, 0xF0, 0xE0, 0x01, 0xF0,
  0xF0, 0x01, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3E, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x1E,
  0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC3,
  0xC0, 0x01, 0xE3, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0,
  0x01, 0xE1, 0xE0, 0x01, 0xE0, 0xF0, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x1F,
  0x83, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0x02, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x78, 0x07, 0xE0, 0x3C, 0x00, 0xF8, 0x3C, 0x00,
  0x7C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0,
  0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78,
  0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07,
  0x80, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0,
  0xF0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x1E,
  0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x07, 0x83, 0xC0, 0x03,
  0xC1, 0xE0, 0x03, 0xC0, 0xF0, 0x03, 0xE0, 0xF0, 0x07, 0xE0, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xE0, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3E, 0x01, 0xF0, 0x3E, 0x00, 0x7C,
  0x1E, 0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03,
  0xC3, 0xC0, 0x01, 0xE3, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x47, 0x81, 0xFF, 0xC3, 0xC1, 0xFF, 0xE1, 0xE0,
  0xFF, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x3C,
  0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC3,
  0xC0, 0x01, 0xE1, 0xE0, 0x01, 0xE0, 0xF0, 0x01, 0xF0, 0x7C, 0x01, 0xF0,
  0x1F, 0x83, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0x02, 0x00, 0x00, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x78,
  0x00, 0x78, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x01, 0xE0,
  0x78, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x03,
  0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x07, 0x80,
  0x03, 0xC1, 0xE0, 0x00, 0xE0, 0x78, 0x00, 0x78, 0x1F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3C, 0x00, 0x1E,
  0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x00,
  0x3C, 0x0E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0x78,
  0x00, 0x78, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x01, 0xE0,
  0xF0, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x03,
  0xC0, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07,
  0x80, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x03, 0xE0, 0x03,
  0xC0, 0x7C, 0x00, 0xF8, 0x07, 0xE0, 0x7E, 0x00, 0x7F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xE0, 0x78, 0x00, 0x7C,
  0x07, 0x80, 0x07, 0x80, 0x78, 0x00, 0xF8, 0x0F, 0x00, 0x1F, 0x00, 0xF0,
  0x01, 0xE0, 0x0F, 0x00, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x78,
  0x00, 0xF0, 0x0F, 0x80, 0x0F, 0x01, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x1E,
  0x03, 0xE0, 0x01, 0xE0, 0x7C, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3C, 0x07, 0x80, 0x03,
  0xC0, 0x78, 0x00, 0x3C, 0x07, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x3C, 0x03,
  0xC0, 0x07, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xF0, 0x07, 0x80, 0x0F, 0x00, 0x78, 0x00, 0xF0, 0x07, 0x00,
  0x0F, 0x80, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x7C,
  0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xE0,
  0x03, 0xF0, 0x7E, 0x00, 0x3E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E,
  0x07, 0xF0, 0x0F, 0xE0, 0x77, 0x00, 0xEE, 0x07, 0x70, 0x1E, 0xE0, 0xF7,
  0x01, 0xDC, 0x0F, 0x70, 0x3D, 0xC0, 0xF7, 0x03, 0x9C, 0x0E, 0x78, 0x79,
  0xC0, 0xE3, 0x87, 0x3C, 0x0E, 0x38, 0xF3, 0xC0, 0xE3, 0x8E, 0x3C, 0x1E,
  0x39, 0xE3, 0x81, 0xE3, 0x9C, 0x78, 0x1E, 0x3D, 0xC7, 0x81, 0xE1, 0xF8,
  0x78, 0x1E, 0x1F, 0x87, 0x81, 0xC1, 0xF0, 0x78, 0x3C, 0x1F, 0x07, 0x03,
  0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x0E, 0x07, 0x80, 0x01, 0xE0,
  0x78, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80,
  0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C,
  0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x03, 0xC1,
  0xF8, 0x00, 0xF0, 0x7E, 0x00, 0x3C, 0x1F, 0x80, 0x0E, 0x07, 0xE0, 0x07,
  0x81, 0xFC, 0x01, 0xE0, 0xFF, 0x00, 0x78, 0x3D, 0xC0, 0x1E, 0x0F, 0x70,
  0x07, 0x83, 0xDE, 0x01, 0xC0, 0xF7, 0x80, 0xF0, 0x39, 0xE0, 0x3C, 0x1E,
  0x38, 0x0F, 0x07, 0x8E, 0x03, 0xC1, 0xE3, 0xC0, 0xF0, 0x78, 0xF0, 0x38,
  0x1E, 0x3C, 0x1E, 0x07, 0x07, 0x07, 0x83, 0xC1, 0xC1, 0xE0, 0xF0, 0x78,
  0x78, 0x3C, 0x1E, 0x1E, 0x0F, 0x03, 0x87, 0x83, 0xC0, 0xE1, 0xC0, 0xF0,
  0x38, 0xF0, 0x38, 0x0F, 0x3C, 0x1E, 0x03, 0xCF, 0x07, 0x80, 0x73, 0xC1,
  0xE0, 0x1C, 0xF0, 0x78, 0x07, 0xB8, 0x1E, 0x01, 0xEE, 0x07, 0x00, 0x7F,
  0x83, 0xC0, 0x0F, 0xE0, 0xF0, 0x03, 0xF8, 0x3C, 0x00, 0xFE, 0x0F, 0x00,
  0x3F, 0x03, 0xC0, 0x0F, 0xC0, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3E, 0x01,
  0xF0, 0x3E, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x1F, 0x0F, 0x00,
  0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0,
  0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1E,
  0x00, 0x1E, 0x0E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC3,
  0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x70, 0x78, 0x00, 0x78,
  0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07,
  0x87, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x01,
  0xE0, 0x7C, 0x01, 0xF0, 0x1F, 0x83, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x78, 0x01,
  0xF8, 0x0F, 0x00, 0x0F, 0x83, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x1E, 0x0F,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x01,
  0xE0, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x87, 0x80, 0x01, 0xE0, 0xF0,
  0x00, 0x7C, 0x1E, 0x00, 0x1F, 0x03, 0xC0, 0x0F, 0xC0, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x3E, 0x01, 0xF0, 0x3E, 0x00, 0x78, 0x1E, 0x00, 0x3E, 0x1E,
  0x00, 0x0F, 0x0F, 0x00, 0x07, 0x8F, 0x80, 0x03, 0xC7, 0x80, 0x01, 0xE3,
  0xC0, 0x00, 0xF1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C,
  0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x8F, 0x00, 0x07,
  0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF1, 0xE0, 0x00,
  0x78, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x00,
  0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x03, 0xC1, 0xE0,
  0x01, 0xE0, 0xF0, 0x01, 0xE0, 0x7C, 0x01, 0xF0, 0x1F, 0x83, 0xF0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x02, 0xF8, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFC, 0x07, 0x80, 0x3F, 0x81, 0xE0, 0x03, 0xE0, 0xF0, 0x00, 0x78,
  0x3C, 0x00, 0x1F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00,
  0x7C, 0x3C, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0,
  0x00, 0xF0, 0x78, 0x00, 0x7C, 0x1E, 0x00, 0x3E, 0x07, 0x80, 0x7F, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0x03, 0xE0,
  0x03, 0xC0, 0x78, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x07, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x78, 0x01, 0xE0, 0x1E,
  0x00, 0x78, 0x07, 0x80, 0x1F, 0x01, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xF0,
  0x3C, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0xF0,
  0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x87, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0xE0,
  0x01, 0xE0, 0x7E, 0x00, 0x7C, 0x07, 0xE0, 0x3F, 0x00, 0x7F, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE0,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x03, 0xC1, 0xE0,
  0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x81,
  0xE0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07,
  0x83, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x1E, 0x00,
  0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1E,
  0x00, 0x1E, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78,
  0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x03, 0xC0, 0xF0, 0x00,
  0xF0, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0,
  0x00, 0xF0, 0x78, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x81,
  0xE0, 0x03, 0xC0, 0x7C, 0x01, 0xF0, 0x0F, 0xC1, 0xF8, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x10, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xCF, 0x00, 0x03, 0xE7,
  0x80, 0x01, 0xE3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78,
  0x78, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x1E,
  0x03, 0x80, 0x0F, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x01, 0xE0, 0x07, 0x80,
  0xF0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0x70, 0x3C, 0x00, 0x3C,
  0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x8F, 0x00, 0x03,
  0xC7, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x7B, 0xC0, 0x00,
  0x1D, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x78, 0x0F, 0x80, 0xF7, 0x80,
  0xF8, 0x0F, 0x78, 0x0F, 0x80, 0xF7, 0x80, 0xF8, 0x0E, 0x78, 0x1F, 0x81,
  0xE7, 0x01, 0xF8, 0x1E, 0x70, 0x1B, 0x81, 0xE7, 0x03, 0xB8, 0x1C, 0x70,
  0x3B, 0x83, 0xC7, 0x03, 0xB8, 0x3C, 0x70, 0x33, 0x03, 0x87, 0x07, 0x30,
  0x38, 0x70, 0x73, 0x07, 0x8F, 0x06, 0x30, 0x78, 0xF0, 0xE3, 0x07, 0x0F,
  0x0E, 0x30, 0xF0, 0xF0, 0xE3, 0x0F, 0x0F, 0x0C, 0x30, 0xE0, 0xF1, 0xC3,
  0x0E, 0x0F, 0x1C, 0x31, 0xE0, 0xF1, 0x83, 0x1E, 0x0F, 0x38, 0x71, 0xC0,
  0xF3, 0x87, 0x1C, 0x0F, 0x38, 0x73, 0xC0, 0xF3, 0x07, 0x38, 0x0E, 0x70,
  0x73, 0x80, 0xE7, 0x07, 0x38, 0x0E, 0x60, 0x77, 0x80, 0xEE, 0x07, 0x70,
  0x0E, 0xE0, 0x77, 0x00, 0xEC, 0x07, 0xF0, 0x0E, 0xC0, 0x7F, 0x00, 0xFC,
  0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x7C,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xC0, 0x00,
  0x78, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x07, 0xC0, 0x0F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x3C, 0x03, 0xE0,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x7C, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0xF8, 0x07,
  0xC0, 0x01, 0xE0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3C,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x0F,
  0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x3C, 0x00, 0xF8, 0x0F, 0x80,
  0x3C, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x0F, 0x80, 0x1E, 0x03, 0xC0, 0x03,
  0xC1, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x9E, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0xF0,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF,
  0xF0, 0x1F, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x80,
  0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xB8, 0x00, 0x39, 0xC0, 0x03, 0xCE, 0x00,
  0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x1E, 0x0E, 0x00, 0xE0, 0x70, 0x0F, 0x03,
  0xC0, 0xF0, 0x0E, 0x07, 0x80, 0x70, 0x78, 0x03, 0xC3, 0x80, 0x1E, 0x3C,
  0x00, 0x73, 0xC0, 0x03, 0xDE, 0x00, 0x1F, 0xE0, 0x00, 0x70, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE0, 0xF8,
  0x1E, 0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x00, 0x3F, 0x0F, 0x00, 0xFF,
  0xCF, 0x03, 0xFF, 0xEF, 0x07, 0xFB, 0xEF, 0x0F, 0xC0, 0x6F, 0x0F, 0x00,
  0x3F, 0x1F, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x3C, 0x00,
  0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x3C, 0x00,
  0x3C, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00,
  0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00,
  0xF8, 0x78, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x3E, 0x07, 0x78, 0x3F, 0xFE,
  0xF0, 0x1F, 0xFC, 0xF0, 0x0F, 0xF8, 0xF0, 0x00, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x0F, 0xE0, 0x0F, 0x3F, 0xF8, 0x0F, 0x7F, 0xFC, 0x0E, 0xFF,
  0xFC, 0x1E, 0xC0, 0x7E, 0x1F, 0x80, 0x3E, 0x1F, 0x00, 0x1E, 0x1E, 0x00,
  0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00,
  0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00,
  0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00,
  0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x7C, 0x00, 0xF0, 0xFC, 0x01,
  0xF0, 0xF7, 0x07, 0xE0, 0xF7, 0xFF, 0xC0, 0xF3, 0xFF, 0x80, 0xF1, 0xFF,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x1E, 0x1F, 0x00,
  0x1E, 0x1E, 0x00, 0x1F, 0x1E, 0x00, 0x1F, 0x3C, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x7C, 0x78, 0x00, 0x78, 0x78, 0x00,
  0xF8, 0x7C, 0x01, 0xF0, 0x3F, 0x07, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x0F, 0xC3, 0xC0, 0x0F, 0xFC, 0xF0, 0x0F, 0xFF, 0xBC, 0x07, 0xFB,
  0xEF, 0x03, 0xF0, 0x1B, 0xC0, 0xF0, 0x03, 0xF0, 0x7C, 0x00, 0x78, 0x1E,
  0x00, 0x1E, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78,
  0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00,
  0xF0, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0,
  0x00, 0xF0, 0x78, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x81,
  0xE0, 0x03, 0xE0, 0x7C, 0x01, 0xF8, 0x0F, 0x81, 0xDE, 0x03, 0xFF, 0xEF,
  0x00, 0x7F, 0xF3, 0xC0, 0x0F, 0xF8, 0xF0, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x07, 0xF9, 0xFC, 0x07,
  0xC0, 0x3C, 0x0F, 0x00, 0x3E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E,
  0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x78, 0x78, 0x00, 0xF8, 0x7C, 0x00, 0xF0, 0x3E,
  0x03, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x1E, 0x03, 0xFF, 0x3C, 0x1F, 0xFF, 0x78, 0x7F, 0xBE, 0xF1,
  0xF8, 0x0F, 0xE3, 0xC0, 0x0F, 0xCF, 0x80, 0x0F, 0x1E, 0x00, 0x1E, 0x3C,
  0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xE7, 0x80,
  0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF0, 0x00,
  0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x03, 0xE7, 0xC0, 0x07, 0x8F, 0x80, 0x1F,
  0x0F, 0x80, 0x7E, 0x1F, 0xC7, 0xBC, 0x1F, 0xFF, 0x78, 0x1F, 0xFC, 0xF0,
  0x1F, 0xE3, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0xFF,
  0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x0F, 0xE0, 0x0F, 0x3F, 0xF8, 0x0F, 0x7F, 0xFC, 0x0E,
  0xF9, 0xFC, 0x1E, 0xC0, 0x7E, 0x1F, 0x80, 0x3E, 0x1F, 0x00, 0x1E, 0x1E,
  0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C,
  0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C,
  0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78,
  0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x70, 0x00, 0x78, 0xF0,
  0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0,
  0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x01, 0xF0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x1F, 0x03,
  0xC0, 0x0F, 0x81, 0xE0, 0x07, 0xC0, 0x78, 0x03, 0xE0, 0x1E, 0x01, 0xF0,
  0x07, 0x80, 0x78, 0x01, 0xE0, 0x3C, 0x00, 0x78, 0x1F, 0x00, 0x3C, 0x0F,
  0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x0F, 0x03, 0xC0, 0x07, 0x80, 0xF8, 0x01, 0xE0, 0x1E, 0x00,
  0x78, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x01, 0xE0, 0x07,
  0x80, 0xF0, 0x01, 0xF0, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x83, 0xC0,
  0x01, 0xE0, 0xF0, 0x00, 0x7C, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F,
  0xFE, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x07, 0x1E, 0x0F, 0x81,
  0xEF, 0xE3, 0xF8, 0x3F, 0xFE, 0xFF, 0x07, 0xC7, 0xF1, 0xF0, 0xF0, 0x7C,
  0x1E, 0x1E, 0x07, 0x03, 0xC3, 0x80, 0xE0, 0x78, 0xF0, 0x3C, 0x0F, 0x1E,
  0x07, 0x81, 0xC3, 0xC0, 0xE0, 0x38, 0x78, 0x1C, 0x0F, 0x0F, 0x03, 0x81,
  0xE1, 0xC0, 0x70, 0x3C, 0x38, 0x1E, 0x07, 0x8F, 0x03, 0xC0, 0xE1, 0xE0,
  0x70, 0x1C, 0x3C, 0x0E, 0x07, 0x87, 0x81, 0xC0, 0xF0, 0xE0, 0x38, 0x1E,
  0x1C, 0x0F, 0x03, 0xC7, 0x81, 0xE0, 0x78, 0xF0, 0x38, 0x0E, 0x1E, 0x07,
  0x01, 0xC3, 0xC0, 0xE0, 0x78, 0x78, 0x1C, 0x0F, 0x0E, 0x03, 0x81, 0xE3,
  0xC0, 0xF0, 0x3C, 0x78, 0x1E, 0x07, 0x00, 0x0F, 0x0F, 0xE0, 0x0F, 0x3F,
  0xF8, 0x0F, 0x7F, 0xFC, 0x0E, 0xF9, 0xFC, 0x1E, 0xC0, 0x7E, 0x1F, 0x80,
  0x3E, 0x1F, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00,
  0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00,
  0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00,
  0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00,
  0x78, 0x70, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00,
  0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xC0, 0x7C, 0x0F, 0x00,
  0x3E, 0x1F, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x3C, 0x00,
  0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00,
  0x3E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00,
  0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00,
  0x78, 0x78, 0x00, 0xF0, 0x7C, 0x01, 0xF0, 0x3F, 0x07, 0xE0, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x03, 0xC3,
  0xF8, 0x00, 0xF3, 0xFF, 0x80, 0x3D, 0xFF, 0xF0, 0x0E, 0xFF, 0xFC, 0x07,
  0xB0, 0x1F, 0x81, 0xF8, 0x03, 0xE0, 0x7C, 0x00, 0x78, 0x1E, 0x00, 0x1E,
  0x07, 0x80, 0x07, 0x81, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00,
  0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x3C,
  0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0,
  0x78, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x83, 0xF0, 0x03,
  0xC0, 0xFC, 0x01, 0xF0, 0x3D, 0xC1, 0xF8, 0x0F, 0x7F, 0xFC, 0x03, 0xCF,
  0xFE, 0x00, 0xF1, 0xFF, 0x00, 0x3C, 0x0C, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x0F, 0x01, 0xFF, 0xCF, 0x03, 0xFF, 0xEF, 0x07, 0xFB, 0xEF, 0x0F,
  0xC0, 0x6F, 0x0F, 0x00, 0x3F, 0x1F, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E,
  0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C,
  0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78,
  0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78,
  0x00, 0x78, 0x78, 0x00, 0xF8, 0x78, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7E,
  0x07, 0x78, 0x3F, 0xFE, 0xF0, 0x1F, 0xFC, 0xF0, 0x0F, 0xF8, 0xF0, 0x00,
  0x80, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x0F, 0x0F, 0xE0, 0x0F, 0x3F, 0xF0, 0x0E, 0x7F, 0xFC, 0x1E,
  0xF9, 0xFC, 0x1F, 0xC0, 0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x00, 0x1E, 0x1E,
  0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x3E, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C,
  0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x0F, 0x80, 0x3E, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x1F, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF8,
  0x00, 0xF8, 0x7E, 0x03, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0x00,
  0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00,
  0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x0E, 0x1E, 0x00, 0x1E, 0x1E, 0x00,
  0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00,
  0x1E, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x78, 0x00,
  0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x78, 0x78, 0x00,
  0x78, 0x78, 0x00, 0xF8, 0x7C, 0x00, 0xF0, 0x7C, 0x01, 0xF0, 0x3F, 0x07,
  0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x40,
  0x00, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00,
  0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x7C, 0x78, 0x00, 0x78, 0x38, 0x00,
  0xF8, 0x3C, 0x00, 0xF0, 0x3C, 0x01, 0xF0, 0x3C, 0x01, 0xE0, 0x3C, 0x01,
  0xE0, 0x3C, 0x03, 0xC0, 0x1C, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x1E, 0x07,
  0x80, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x0E, 0x1E,
  0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0xF0, 0x1E, 0x01, 0xFC, 0x07, 0x80, 0xFF, 0x03, 0xE0, 0x3F, 0xC0,
  0xF8, 0x0E, 0xF0, 0x36, 0x03, 0xB8, 0x1D, 0x81, 0xEE, 0x07, 0x60, 0x73,
  0x81, 0x98, 0x1C, 0xE0, 0x66, 0x0F, 0x38, 0x39, 0x83, 0x8E, 0x0C, 0x60,
  0xE3, 0x83, 0x18, 0x78, 0xE1, 0xC6, 0x1C, 0x38, 0x61, 0x87, 0x0E, 0x18,
  0x63, 0xC3, 0x8E, 0x18, 0xE0, 0xE3, 0x86, 0x38, 0x38, 0xC1, 0x9E, 0x0E,
  0x70, 0x67, 0x03, 0x9C, 0x19, 0xC0, 0xE6, 0x06, 0x70, 0x3B, 0x81, 0xB8,
  0x0E, 0xE0, 0x6E, 0x03, 0xB0, 0x1B, 0x80, 0xFC, 0x07, 0xC0, 0x3F, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x7C, 0x00, 0x3E, 0x03, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x01, 0xE0,
  0x0F, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF0, 0x3E, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x78, 0x78, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x7C, 0x0F,
  0x00, 0x0F, 0x80, 0x78, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x03,
  0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x1E, 0x0F, 0x80, 0x01, 0xF0, 0x1E, 0x00,
  0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x01,
  0xE7, 0x80, 0x03, 0xCF, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x3C,
  0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xE7, 0x80, 0x07, 0x8F,
  0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x7C, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0,
  0x01, 0xF3, 0xC0, 0x03, 0xC7, 0xC0, 0x07, 0x8F, 0x80, 0x1F, 0x0F, 0x80,
  0x7E, 0x1F, 0xEF, 0xBC, 0x1F, 0xFE, 0x78, 0x1F, 0xF9, 0xE0, 0x0F, 0xC3,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x07,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x07, 0xF8,
  0x03, 0xC7, 0xFE, 0x01, 0xE7, 0xFF, 0x80, 0xE3, 0xC3, 0xC0, 0xF3, 0xC1,
  0xF0, 0x79, 0xE0, 0x7C, 0x7C, 0xF0, 0x1F, 0xFC, 0x70, 0x07, 0xFC, 0x78,
  0x01, 0xFC, 0x00,
};

const GFXglyph JetBrainsMono_LightItalic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 30, 0, -1 },
  { 1, 11, 37, 30, 10, -37 },
  { 52, 17, 16, 30, 9, -37 },
  { 86, 29, 37, 30, 1, -37 },
  { 221, 27, 51, 30, 2, -44 },
  { 394, 34, 37, 30, -1, -37 },
  { 552, 28, 38, 30, 1, -37 },
  { 685, 7, 16, 30, 14, -37 },
  { 699, 21, 48, 30, 8, -42 },
  { 825, 20, 48, 30, 3, -42 },
  { 945, 26, 26, 30, 3, -31 },
  { 1030, 24, 23, 30, 3, -28 },
  { 1099, 13, 16, 30, 5, -8 },
  { 1125, 17, 3, 30, 7, -18 },
  { 1132, 9, 9, 30, 9, -8 },
  { 1143, 29, 48, 30, 1, -42 },
  { 1317, 25, 38, 30, 3, -37 },
  { 1436, 23, 37, 30, 2, -37 },
  { 1543, 26, 37, 30, 2, -37 },
  { 1664, 25, 38, 30, 3, -37 },
  { 1783, 24, 37, 30, 3, -37 },
  { 1894, 25, 38, 30, 3, -37 },
  { 2013, 24, 38, 30, 3, -37 },
  { 2127, 24, 37, 30, 6, -37 },
  { 2238, 25, 38, 30, 3, -37 },
  { 2357, 24, 37, 30, 5, -37 },
  { 2468, 12, 29, 30, 9, -28 },
  { 2512, 16, 36, 30, 5, -28 },
  { 2584, 24, 27, 30, 4, -30 },
  { 2665, 23, 15, 30, 4, -24 },
  { 2709, 23, 27, 30, 3, -30 },
  { 2787, 20, 37, 30, 7, -37 },
  { 2880, 30, 46, 30, 0, -37 },
  { 3053, 24, 37, 30, 1, -37 },
  { 3164, 25, 37, 30, 3, -37 },
  { 3280, 25, 38, 30, 3, -37 },
  { 3399, 25, 37, 30, 3, -37 },
  { 3515, 26, 37, 30, 3, -37 },
  { 3636, 27, 37, 30, 3, -37 },
  { 3761, 25, 38, 30, 3, -37 },
  { 3880, 26, 37, 30, 3, -37 },
  { 4001, 25, 37, 30, 3, -37 },
  { 4117, 27, 38, 30, 1, -37 },
  { 4246, 28, 37, 30, 3, -37 },
  { 4376, 21, 37, 30, 4, -37 },
  { 4474, 28, 37, 30, 2, -37 },
  { 4604, 26, 37, 30, 3, -37 },
  { 4725, 25, 38, 30, 3, -37 },
  { 4844, 27, 37, 30, 3, -37 },
  { 4969, 25, 46, 30, 3, -37 },
  { 5113, 26, 37, 30, 3, -37 },
  { 5234, 27, 38, 30, 2, -37 },
  { 5363, 25, 37, 30, 6, -37 },
  { 5479, 26, 38, 30, 3, -37 },
  { 5603, 25, 37, 30, 6, -37 },
  { 5719, 28, 37, 30, 4, -37 },
  { 5849, 31, 37, 30, 0, -37 },
  { 5993, 26, 37, 30, 6, -37 },
  { 6114, 27, 37, 30, 2, -37 },
  { 6239, 20, 48, 30, 7, -42 },
  { 6359, 15, 48, 30, 8, -42 },
  { 6449, 20, 48, 30, 4, -42 },
  { 6569, 21, 20, 30, 5, -37 },
  { 6622, 25, 4, 30, 0, 1 },
  { 6635, 9, 7, 30, 13, -39 },
  { 6643, 24, 29, 30, 3, -28 },
  { 6730, 24, 38, 30, 3, -37 },
  { 6844, 24, 29, 30, 3, -28 },
  { 6931, 26, 38, 30, 3, -37 },
  { 7055, 24, 29, 30, 3, -28 },
  { 7142, 33, 46, 30, -2, -37 },
  { 7332, 23, 37, 30, 4, -28 },
  { 7439, 24, 37, 30, 3, -37 },
  { 7550, 24, 39, 30, 2, -39 },
  { 7667, 25, 48, 30, 1, -39 },
  { 7817, 26, 37, 30, 3, -37 },
  { 7938, 21, 37, 30, 5, -37 },
  { 8036, 27, 28, 30, 1, -28 },
  { 8131, 24, 28, 30, 3, -28 },
  { 8215, 24, 29, 30, 3, -28 },
  { 8302, 26, 37, 30, 1, -28 },
  { 8423, 24, 37, 30, 3, -28 },
  { 8534, 24, 28, 30, 4, -28 },
  { 8618, 24, 29, 30, 3, -28 },
  { 8705, 23, 35, 30, 5, -35 },
  { 8806, 24, 29, 30, 3, -28 },
  { 8893, 24, 28, 30, 5, -28 },
  { 8977, 26, 28, 30, 4, -28 },
  { 9068, 28, 28, 30, 1, -28 },
  { 9166, 23, 37, 30, 4, -28 },
  { 9273, 25, 28, 30, 2, -28 },
  { 9361, 25, 48, 30, 5, -42 },
  { 9511, 11, 48, 30, 10, -42 },
  { 9577, 25, 48, 30, 1, -42 },
  { 9727, 25, 10, 30, 3, -23 },
};

const GFXfont JetBrainsMono_LightItalic50pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_LightItalic50pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_LightItalic50pt7bGlyphs,
  0x20, 0x7E, 66
};

#endif // _JETBRAINSMONO_LIGHTITALIC50PT7B_H_
