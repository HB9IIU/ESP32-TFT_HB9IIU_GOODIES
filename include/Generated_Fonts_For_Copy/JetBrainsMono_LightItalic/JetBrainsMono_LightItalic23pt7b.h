#ifndef _JETBRAINSMONO_LIGHTITALIC23PT7B_H_
#define _JETBRAINSMONO_LIGHTITALIC23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-LightItalic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_LightItalic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x61, 0x86, 0x18, 0x61, 0x04, 0x30, 0xC3, 0x08, 0x00, 0x02,
  0x1C, 0xE0, 0x63, 0x63, 0x67, 0x66, 0x46, 0x46, 0xC6, 0x02, 0x18, 0x30,
  0x81, 0x0C, 0x08, 0x40, 0xC2, 0x3F, 0xFC, 0x21, 0x03, 0x18, 0x10, 0xC1,
  0x84, 0x0C, 0x61, 0xFF, 0xC6, 0x10, 0x31, 0x81, 0x0C, 0x18, 0x40, 0xC6,
  0x00, 0x01, 0x80, 0x18, 0x01, 0x00, 0x7C, 0x0F, 0xE1, 0x93, 0x31, 0x33,
  0x30, 0x32, 0x03, 0xA0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x6E, 0x04, 0x60,
  0x46, 0xC4, 0x6E, 0x4C, 0x77, 0x83, 0xF0, 0x0C, 0x00, 0x80, 0x08, 0x00,
  0x0F, 0x03, 0x1F, 0x86, 0x11, 0x84, 0x11, 0x88, 0x31, 0x90, 0x31, 0x30,
  0x1F, 0x60, 0x0E, 0xC0, 0x00, 0x80, 0x01, 0x30, 0x02, 0x7C, 0x06, 0xCC,
  0x0C, 0x8C, 0x18, 0x8C, 0x30, 0x8C, 0x20, 0xD8, 0xC0, 0xF0, 0x07, 0x81,
  0xFC, 0x18, 0x63, 0x06, 0x30, 0x01, 0x00, 0x18, 0x01, 0xC0, 0x7C, 0x06,
  0x63, 0xC6, 0x6C, 0x3C, 0xC3, 0x8C, 0x18, 0xC3, 0xCE, 0xEC, 0x7C, 0x60,
  0xFF, 0xF8, 0x01, 0x83, 0x83, 0x03, 0x03, 0x01, 0x80, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x07,
  0x01, 0xC0, 0x20, 0x0C, 0x0F, 0x00, 0xC0, 0x70, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x18, 0x0C, 0x06, 0x06, 0x03, 0x03,
  0x07, 0x0F, 0x04, 0x00, 0x03, 0x00, 0x30, 0x03, 0x04, 0x21, 0xF2, 0x73,
  0xFE, 0x06, 0x00, 0xF0, 0x1B, 0x03, 0x18, 0x71, 0xC2, 0x08, 0x06, 0x00,
  0xC0, 0x10, 0x06, 0x00, 0xC3, 0xFF, 0x83, 0x00, 0x60, 0x08, 0x01, 0x00,
  0x60, 0x00, 0x1C, 0xE3, 0x0C, 0x61, 0x8C, 0x00, 0xFF, 0x7F, 0xE0, 0x00,
  0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x00, 0x07, 0xC0, 0xFE, 0x18, 0x73, 0x03, 0x30, 0x33, 0x03, 0x20,
  0x36, 0x62, 0x67, 0x66, 0x66, 0x60, 0x66, 0x06, 0x40, 0x64, 0x0C, 0x60,
  0xC7, 0x38, 0x3F, 0x00, 0x03, 0x80, 0xF0, 0x76, 0x18, 0xC2, 0x18, 0x02,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01,
  0x87, 0xFF, 0xFF, 0xC0, 0x07, 0xC1, 0xFE, 0x18, 0x73, 0x03, 0x30, 0x30,
  0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x60, 0x0F, 0xFC, 0xFF, 0xC0, 0x1F, 0xF1, 0xFF, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x07, 0x00, 0x7C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x04,
  0xC0, 0xCC, 0x0C, 0x60, 0xC7, 0x38, 0x3F, 0x00, 0x00, 0xC0, 0x60, 0x30,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC3, 0x70, 0xD8, 0x3C, 0x0B, 0x06, 0xFF,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0x3F, 0xE7, 0xFC, 0xC0, 0x10, 0x06,
  0x00, 0xC0, 0x1B, 0xC3, 0xFC, 0x60, 0xC8, 0x18, 0x03, 0x00, 0x60, 0x09,
  0x03, 0x30, 0x67, 0x38, 0x7E, 0x00, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0x60, 0x18, 0x06, 0x01, 0xBE, 0x38, 0xEC, 0x0D, 0x81, 0xA0, 0x3C, 0x07,
  0x80, 0x98, 0x33, 0x9C, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0x03, 0x60, 0x6C,
  0x18, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x80,
  0x60, 0x0C, 0x03, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0xFE, 0x18, 0x33, 0x03,
  0x30, 0x33, 0x06, 0x18, 0xC0, 0xF8, 0x0F, 0x01, 0x9C, 0x30, 0xC6, 0x06,
  0x40, 0x6C, 0x04, 0x60, 0xC7, 0x38, 0x3F, 0x00, 0x0F, 0x83, 0xF8, 0xC1,
  0xB0, 0x36, 0x07, 0x80, 0xF0, 0x1F, 0x06, 0x61, 0xCF, 0xF0, 0x64, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x00, 0xC0, 0x70, 0x00, 0x18, 0xF3, 0x84, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x3C, 0xF0, 0x06, 0x0F, 0x0E, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x18, 0x30, 0x30, 0x60, 0x60, 0xC0, 0x00,
  0x20, 0x0C, 0x07, 0x07, 0x83, 0xC1, 0xE0, 0x30, 0x07, 0x80, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0xC0, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xBF, 0xE0, 0x20, 0x06, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x18,
  0x0F, 0x07, 0x83, 0x81, 0xC0, 0x60, 0x00, 0x3E, 0x0F, 0xC0, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x0C, 0x3E, 0x0E, 0x03, 0x00, 0xC0, 0x00, 0x00,
  0x02, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0xE0, 0x3C, 0xE0, 0xC1, 0x86, 0x03,
  0x30, 0x0C, 0xC0, 0x32, 0x1E, 0x88, 0xC6, 0x63, 0x19, 0x88, 0x66, 0x21,
  0x99, 0x86, 0x66, 0x11, 0x18, 0xC4, 0x7D, 0x30, 0x64, 0xC0, 0x01, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C,
  0x02, 0x40, 0x64, 0x04, 0x40, 0xC6, 0x0C, 0x61, 0x86, 0x18, 0x61, 0xFE,
  0x30, 0x63, 0x06, 0x60, 0x26, 0x02, 0xC0, 0x30, 0x1F, 0xC1, 0xFE, 0x10,
  0x73, 0x03, 0x30, 0x33, 0x02, 0x30, 0x63, 0xFC, 0x3F, 0x86, 0x0C, 0x60,
  0x66, 0x06, 0x60, 0x66, 0x06, 0x40, 0xCF, 0xF8, 0xFF, 0x00, 0x0F, 0x83,
  0xF8, 0xC1, 0xB0, 0x36, 0x06, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x0D, 0x83, 0x30, 0x67, 0x38, 0x7E, 0x00, 0x1F, 0x81,
  0xFE, 0x10, 0x63, 0x03, 0x30, 0x33, 0x02, 0x30, 0x63, 0x06, 0x20, 0x66,
  0x06, 0x60, 0x66, 0x06, 0x60, 0x46, 0x0C, 0x41, 0x8F, 0xF8, 0xFE, 0x00,
  0x1F, 0xF8, 0xFF, 0x86, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07,
  0xFC, 0x3F, 0xC1, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0F, 0xF8, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF, 0xC4, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x3F, 0xE3, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x00, 0x0F, 0x83, 0xF8, 0xC1,
  0xB0, 0x36, 0x06, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18, 0xFB, 0x03, 0x60,
  0x6C, 0x0D, 0x83, 0x30, 0x67, 0x38, 0x7E, 0x00, 0x18, 0x31, 0x83, 0x10,
  0x33, 0x03, 0x30, 0x33, 0x02, 0x30, 0x63, 0xFE, 0x3F, 0xE6, 0x06, 0x60,
  0x66, 0x04, 0x60, 0xC6, 0x0C, 0x40, 0xCC, 0x0C, 0xC0, 0xC0, 0x1F, 0xF1,
  0xFF, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x07, 0xFC, 0xFF, 0x80,
  0x03, 0xF0, 0x3F, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0xC0, 0xCC, 0x0C, 0xC1, 0x8F, 0x78,
  0x7E, 0x00, 0x18, 0x18, 0x81, 0x84, 0x0C, 0x60, 0xC3, 0x0C, 0x18, 0x60,
  0xC6, 0x07, 0xE0, 0x3F, 0x03, 0x18, 0x18, 0x60, 0xC3, 0x06, 0x18, 0x30,
  0x61, 0x03, 0x18, 0x18, 0xC0, 0x60, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0xFF, 0xFF, 0x80, 0x38, 0x39, 0xC3, 0x8E, 0x1C, 0x50, 0xA2, 0xCF,
  0x16, 0x59, 0x96, 0xCC, 0xA4, 0x67, 0x23, 0x33, 0x18, 0x18, 0x80, 0xC4,
  0x06, 0x60, 0x33, 0x01, 0x18, 0x18, 0xC0, 0xC0, 0x18, 0x31, 0xC3, 0x3C,
  0x33, 0xC3, 0x34, 0x33, 0x42, 0x36, 0x22, 0x66, 0x26, 0x66, 0x26, 0x62,
  0x66, 0x34, 0x63, 0x44, 0x3C, 0x41, 0xCC, 0x1C, 0xC1, 0xC0, 0x0F, 0x83,
  0xF8, 0xC3, 0xB0, 0x36, 0x06, 0xC0, 0x98, 0x12, 0x06, 0xC0, 0xD8, 0x1B,
  0x03, 0x60, 0x6C, 0x09, 0x83, 0x30, 0x67, 0x38, 0x7E, 0x00, 0x1F, 0xC0,
  0xFF, 0x84, 0x0C, 0x60, 0x63, 0x01, 0x98, 0x18, 0xC0, 0xC6, 0x0E, 0x3F,
  0xE3, 0xFC, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x07, 0xC0, 0xFE, 0x18, 0x73, 0x03, 0x30, 0x33, 0x03, 0x20,
  0x26, 0x06, 0x60, 0x66, 0x06, 0x60, 0x66, 0x06, 0x40, 0x44, 0x0C, 0x60,
  0xC7, 0x38, 0x3F, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x1F, 0xC1,
  0xFE, 0x10, 0x33, 0x03, 0x30, 0x33, 0x03, 0x30, 0x33, 0x06, 0x3F, 0xC7,
  0xF0, 0x63, 0x06, 0x18, 0x61, 0x86, 0x18, 0x40, 0xCC, 0x0C, 0xC0, 0xC0,
  0x07, 0xC0, 0xFE, 0x18, 0x33, 0x03, 0x30, 0x03, 0x00, 0x38, 0x01, 0xC0,
  0x0F, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x6C, 0x06, 0xE0, 0xC7, 0x38,
  0x3F, 0x00, 0xFF, 0xFF, 0xFC, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80,
  0x30, 0x00, 0x30, 0x64, 0x0D, 0x81, 0xB0, 0x36, 0x06, 0xC0, 0x98, 0x33,
  0x06, 0x40, 0xD8, 0x1B, 0x03, 0x60, 0x4C, 0x19, 0x83, 0x30, 0x67, 0x38,
  0x7E, 0x00, 0xC0, 0x78, 0x0F, 0x03, 0x60, 0x6C, 0x09, 0x83, 0x10, 0x62,
  0x18, 0x63, 0x0C, 0xC1, 0x98, 0x32, 0x06, 0xC0, 0xD8, 0x1E, 0x03, 0xC0,
  0x30, 0x00, 0xC3, 0x1E, 0x38, 0xB1, 0xCD, 0x8C, 0x6C, 0xE3, 0x65, 0x13,
  0x29, 0x9B, 0x4C, 0xD2, 0x46, 0x92, 0x24, 0xB1, 0x65, 0x8A, 0x28, 0x51,
  0x43, 0x8E, 0x18, 0x70, 0xC3, 0x00, 0x18, 0x0C, 0x60, 0x60, 0xC3, 0x83,
  0x0C, 0x06, 0x60, 0x1B, 0x00, 0x6C, 0x00, 0xE0, 0x03, 0x00, 0x1E, 0x00,
  0x78, 0x03, 0x30, 0x18, 0xC0, 0x63, 0x03, 0x06, 0x18, 0x18, 0xC0, 0x30,
  0x80, 0x7C, 0x06, 0xC0, 0xC4, 0x08, 0x61, 0x86, 0x30, 0x22, 0x03, 0x60,
  0x3C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60,
  0x0F, 0xFC, 0xFF, 0xC0, 0x0F, 0x87, 0xC6, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x20, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x07, 0xC7, 0xE0, 0xC1, 0x83, 0x02, 0x06, 0x0C, 0x18, 0x10,
  0x30, 0x60, 0xC1, 0x81, 0x83, 0x06, 0x0C, 0x08, 0x18, 0x30, 0x60, 0xC0,
  0xC0, 0x1F, 0x8F, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x06, 0x03, 0x01, 0x8F,
  0xC7, 0xE0, 0x03, 0x01, 0xC0, 0xD0, 0x24, 0x19, 0x8C, 0x63, 0x09, 0x83,
  0xC0, 0xC0, 0xFF, 0xE0, 0xC6, 0x30, 0x0F, 0x31, 0xFA, 0x30, 0x63, 0x06,
  0x60, 0x66, 0x06, 0x60, 0x66, 0x04, 0x60, 0xC6, 0x0C, 0x60, 0xC7, 0x3C,
  0x3E, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03, 0x38, 0x7F, 0x8E, 0x19,
  0x83, 0x20, 0x6C, 0x0D, 0x81, 0xB0, 0x36, 0x04, 0xC1, 0x98, 0x36, 0x9C,
  0xDF, 0x00, 0x0F, 0x0F, 0xE6, 0x0D, 0x83, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x6C, 0x1B, 0x9C, 0x7E, 0x00, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x0F, 0x31, 0xFA, 0x30, 0x63, 0x06, 0x60, 0x66, 0x06, 0x60, 0x66,
  0x04, 0x60, 0xC6, 0x0C, 0x60, 0xC7, 0x3C, 0x3E, 0xC0, 0x0F, 0x0F, 0xE6,
  0x0D, 0x83, 0xC0, 0xF0, 0x3F, 0xFF, 0x00, 0xC0, 0x30, 0x0C, 0x1B, 0x9C,
  0x7E, 0x00, 0x00, 0x3E, 0x01, 0xFC, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x07, 0xFF, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0x1E, 0x67, 0xE9, 0x83, 0x30, 0x6C,
  0x0D, 0x81, 0xB0, 0x36, 0x04, 0xC1, 0x98, 0x33, 0x9E, 0x3E, 0xC0, 0x18,
  0x03, 0x00, 0xC7, 0xF8, 0xFE, 0x00, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03,
  0x38, 0x7F, 0x8E, 0x19, 0x83, 0x20, 0x6C, 0x0D, 0x81, 0xB0, 0x26, 0x0C,
  0xC1, 0x90, 0x36, 0x06, 0xC0, 0xC0, 0x01, 0x80, 0x70, 0x0E, 0x00, 0x00,
  0x00, 0x7E, 0x0F, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x07, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x30, 0x7F, 0x0F, 0xC0, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x33,
  0x06, 0x30, 0xE3, 0x0C, 0x21, 0x86, 0x30, 0x7E, 0x06, 0x30, 0x63, 0x06,
  0x18, 0x61, 0x84, 0x0C, 0xC0, 0xC0, 0x7C, 0x3F, 0x00, 0xC0, 0x30, 0x0C,
  0x02, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x03,
  0x00, 0x7F, 0x1F, 0xC0, 0x2E, 0xE7, 0xEF, 0x63, 0x36, 0x23, 0x66, 0x34,
  0x62, 0x46, 0x2C, 0x66, 0xC4, 0x6C, 0x46, 0xC4, 0x6C, 0xC4, 0x8C, 0xC0,
  0x33, 0x87, 0xF8, 0xE1, 0x98, 0x32, 0x06, 0xC0, 0xD8, 0x1B, 0x02, 0x60,
  0xCC, 0x19, 0x03, 0x60, 0x6C, 0x0C, 0x0F, 0x0F, 0xE6, 0x0D, 0x83, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xB0, 0x6C, 0x1B, 0x9C, 0x7E, 0x00, 0x33,
  0x87, 0xF8, 0xE1, 0x98, 0x32, 0x06, 0xC0, 0xD8, 0x1B, 0x03, 0x60, 0x4C,
  0x19, 0x83, 0x69, 0xCD, 0xF1, 0x80, 0x30, 0x06, 0x00, 0x80, 0x00, 0x0F,
  0x31, 0xFA, 0x30, 0x63, 0x06, 0x60, 0x66, 0x06, 0x60, 0x66, 0x04, 0x60,
  0xC6, 0x0C, 0x60, 0xC7, 0x3C, 0x3E, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x27, 0x8D, 0xF9, 0xC3, 0x30, 0x36, 0x06, 0xC1, 0x90, 0x02, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x0F, 0x83, 0xFC, 0xC1, 0x98,
  0x03, 0x00, 0x70, 0x07, 0xE0, 0x0E, 0x00, 0xC0, 0x0B, 0x03, 0x38, 0xE3,
  0xF0, 0x0C, 0x01, 0x80, 0x30, 0x7F, 0xFF, 0xFE, 0x10, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x07, 0xE0, 0xFC, 0x60,
  0x6C, 0x09, 0x83, 0x20, 0x64, 0x0D, 0x81, 0xB0, 0x36, 0x04, 0xC0, 0x98,
  0x33, 0x06, 0x73, 0x87, 0xE0, 0xC0, 0x68, 0x0D, 0x83, 0x30, 0x66, 0x18,
  0xC3, 0x08, 0xC1, 0x18, 0x32, 0x06, 0xC0, 0xD0, 0x1E, 0x01, 0x80, 0x86,
  0x38, 0x63, 0x8A, 0x28, 0xA6, 0x8A, 0x69, 0x24, 0x92, 0xC9, 0x2C, 0xA2,
  0x8A, 0x38, 0xA3, 0x8E, 0x30, 0xC3, 0x00, 0x18, 0x18, 0xC1, 0x83, 0x18,
  0x19, 0xC0, 0x6C, 0x03, 0xC0, 0x0C, 0x00, 0xF0, 0x0D, 0x80, 0xC6, 0x0E,
  0x30, 0x60, 0xCE, 0x06, 0x00, 0x60, 0x6C, 0x09, 0x83, 0x20, 0x64, 0x0D,
  0x81, 0xB0, 0x36, 0x04, 0xC1, 0x98, 0x33, 0xDE, 0x3E, 0xC0, 0x18, 0x02,
  0x00, 0xC7, 0xF8, 0xFE, 0x00, 0x3F, 0xE7, 0xFC, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x7F, 0xEF, 0xFC, 0x00,
  0xF0, 0x1F, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x06,
  0x00, 0x60, 0xFC, 0x0F, 0xC0, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0x80, 0x10, 0x18, 0xC4, 0x63, 0x18,
  0xC6, 0x23, 0x18, 0xC6, 0x31, 0x88, 0xC6, 0x31, 0x8C, 0x40, 0x1E, 0x03,
  0xC0, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x0F, 0x83, 0xF0, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60,
  0x0C, 0x0F, 0x01, 0x00, 0x00, 0x78, 0x79, 0x8F, 0x1B, 0x43, 0xC0,
};

const GFXglyph JetBrainsMono_LightItalic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 6, 17, 14, 4, -17 },
  { 14, 8, 7, 14, 4, -17 },
  { 21, 13, 17, 14, 1, -17 },
  { 49, 12, 23, 14, 1, -20 },
  { 84, 16, 17, 14, -1, -17 },
  { 118, 12, 17, 14, 1, -17 },
  { 144, 2, 7, 14, 7, -17 },
  { 146, 9, 22, 14, 4, -19 },
  { 171, 9, 22, 14, 1, -19 },
  { 196, 12, 12, 14, 1, -14 },
  { 214, 11, 11, 14, 2, -13 },
  { 230, 6, 7, 14, 2, -3 },
  { 236, 8, 1, 14, 3, -8 },
  { 237, 4, 3, 14, 4, -3 },
  { 239, 14, 22, 14, 0, -19 },
  { 278, 12, 17, 14, 1, -17 },
  { 304, 11, 17, 14, 1, -17 },
  { 328, 12, 17, 14, 1, -17 },
  { 354, 12, 17, 14, 1, -17 },
  { 380, 10, 17, 14, 2, -17 },
  { 402, 11, 17, 14, 2, -17 },
  { 426, 11, 17, 14, 1, -17 },
  { 450, 11, 17, 14, 3, -17 },
  { 474, 12, 17, 14, 1, -17 },
  { 500, 11, 17, 14, 2, -17 },
  { 524, 6, 13, 14, 4, -13 },
  { 534, 8, 17, 14, 2, -13 },
  { 551, 11, 12, 14, 2, -14 },
  { 568, 11, 7, 14, 2, -11 },
  { 578, 11, 12, 14, 1, -14 },
  { 595, 10, 17, 14, 3, -17 },
  { 617, 14, 21, 14, 0, -17 },
  { 654, 12, 17, 14, 0, -17 },
  { 680, 12, 17, 14, 1, -17 },
  { 706, 11, 17, 14, 2, -17 },
  { 730, 12, 17, 14, 1, -17 },
  { 756, 13, 17, 14, 1, -17 },
  { 784, 13, 17, 14, 1, -17 },
  { 812, 11, 17, 14, 2, -17 },
  { 836, 12, 17, 14, 1, -17 },
  { 862, 12, 17, 14, 1, -17 },
  { 888, 12, 17, 14, 1, -17 },
  { 914, 13, 17, 14, 1, -17 },
  { 942, 10, 17, 14, 2, -17 },
  { 964, 13, 17, 14, 1, -17 },
  { 992, 12, 17, 14, 1, -17 },
  { 1018, 11, 17, 14, 2, -17 },
  { 1042, 13, 17, 14, 1, -17 },
  { 1070, 12, 21, 14, 1, -17 },
  { 1102, 12, 17, 14, 1, -17 },
  { 1128, 12, 17, 14, 1, -17 },
  { 1154, 11, 17, 14, 3, -17 },
  { 1178, 11, 17, 14, 2, -17 },
  { 1202, 11, 17, 14, 3, -17 },
  { 1226, 13, 17, 14, 2, -17 },
  { 1254, 14, 17, 14, 0, -17 },
  { 1284, 12, 17, 14, 3, -17 },
  { 1310, 12, 17, 14, 1, -17 },
  { 1336, 9, 22, 14, 3, -19 },
  { 1361, 7, 22, 14, 4, -19 },
  { 1381, 9, 22, 14, 2, -19 },
  { 1406, 10, 9, 14, 2, -17 },
  { 1418, 11, 1, 14, 0, 1 },
  { 1420, 4, 3, 14, 6, -18 },
  { 1422, 12, 13, 14, 1, -13 },
  { 1442, 11, 17, 14, 1, -17 },
  { 1466, 10, 13, 14, 2, -13 },
  { 1483, 12, 17, 14, 1, -17 },
  { 1509, 10, 13, 14, 2, -13 },
  { 1526, 15, 21, 14, -1, -17 },
  { 1566, 11, 17, 14, 2, -13 },
  { 1590, 11, 17, 14, 1, -17 },
  { 1614, 11, 18, 14, 1, -18 },
  { 1639, 12, 22, 14, 0, -18 },
  { 1672, 12, 17, 14, 1, -17 },
  { 1698, 10, 17, 14, 2, -17 },
  { 1720, 12, 13, 14, 1, -13 },
  { 1740, 11, 13, 14, 1, -13 },
  { 1758, 10, 13, 14, 2, -13 },
  { 1775, 11, 17, 14, 1, -13 },
  { 1799, 12, 17, 14, 1, -13 },
  { 1825, 11, 13, 14, 2, -13 },
  { 1843, 11, 13, 14, 1, -13 },
  { 1861, 11, 16, 14, 2, -16 },
  { 1883, 11, 13, 14, 2, -13 },
  { 1901, 11, 13, 14, 2, -13 },
  { 1919, 12, 13, 14, 2, -13 },
  { 1939, 13, 13, 14, 0, -13 },
  { 1961, 11, 17, 14, 2, -13 },
  { 1985, 11, 13, 14, 1, -13 },
  { 2003, 12, 22, 14, 2, -19 },
  { 2036, 5, 22, 14, 5, -19 },
  { 2050, 11, 22, 14, 1, -19 },
  { 2081, 11, 4, 14, 2, -10 },
};

const GFXfont JetBrainsMono_LightItalic23pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_LightItalic23pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_LightItalic23pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _JETBRAINSMONO_LIGHTITALIC23PT7B_H_
