#ifndef _JETBRAINSMONO_LIGHTITALIC8PT7B_H_
#define _JETBRAINSMONO_LIGHTITALIC8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-LightItalic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_LightItalic8pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xFC, 0x29, 0x96, 0xAE, 0x50, 0x11, 0x9A, 0xC3, 0x59, 0xC4,
  0x6D, 0x98, 0x66, 0xD8, 0x32, 0x11, 0x79, 0x78, 0xE0, 0x16, 0x44, 0x88,
  0x84, 0x42, 0x11, 0x22, 0x2C, 0x27, 0xC8, 0xA0, 0x4B, 0xA0, 0xE0, 0xE0,
  0xC0, 0x08, 0x84, 0x42, 0x21, 0x10, 0x32, 0x52, 0xE9, 0x30, 0x35, 0x22,
  0x2F, 0x32, 0x44, 0x44, 0x78, 0x71, 0x21, 0x96, 0x29, 0x5E, 0x40, 0xF3,
  0x93, 0x80, 0x12, 0x65, 0x97, 0xF9, 0x24, 0x48, 0x35, 0x75, 0x97, 0x69,
  0x9E, 0x48, 0x43, 0x43, 0x80, 0x16, 0x86, 0xE3, 0x80, 0x42, 0x1E, 0x64,
  0xA1, 0x00, 0x32, 0x6F, 0x5A, 0xDB, 0x80, 0x23, 0x55, 0x79, 0x72, 0x5C,
  0xA9, 0x78, 0x69, 0x88, 0xAE, 0x75, 0x55, 0x9E, 0x7A, 0x1C, 0x84, 0x78,
  0x7A, 0x10, 0xE8, 0x40, 0x69, 0x8E, 0xAE, 0x4A, 0x5C, 0xA9, 0x48, 0xF4,
  0x44, 0x4E, 0x38, 0x84, 0x29, 0x70, 0x4A, 0x94, 0xC9, 0x48, 0x92, 0x49,
  0xC0, 0x4A, 0xDB, 0x29, 0x48, 0x4A, 0x5C, 0xE9, 0x48, 0x76, 0xDB, 0x80,
  0x72, 0x52, 0xE8, 0x40, 0x69, 0xAA, 0xAC, 0x60, 0x72, 0x54, 0xC9, 0x48,
  0x32, 0x50, 0x69, 0x38, 0xF4, 0x44, 0x44, 0x99, 0xAA, 0xAC, 0x99, 0xAA,
  0xC4, 0xDD, 0xAE, 0xAA, 0x4A, 0x88, 0x45, 0x48, 0x9A, 0xA4, 0x44, 0x78,
  0x88, 0x44, 0x78, 0x69, 0x25, 0x26, 0x91, 0x24, 0x89, 0x64, 0x94, 0x96,
  0x4E, 0x80, 0xF0, 0xC0, 0xF6, 0xF0, 0x46, 0x55, 0x9F, 0xF2, 0x70, 0x15,
  0xAA, 0xAE, 0xFE, 0x70, 0x19, 0x1E, 0x44, 0x23, 0x00, 0xF6, 0xFE, 0x46,
  0x55, 0x99, 0x14, 0x22, 0x2F, 0x16, 0x11, 0x12, 0xE0, 0x42, 0x54, 0xCA,
  0x48, 0xC9, 0x28, 0xC0, 0x7D, 0xAD, 0x60, 0x75, 0x99, 0xF6, 0xE0, 0x75,
  0x9F, 0x80, 0xF6, 0xF2, 0xF2, 0x40, 0x76, 0x17, 0x5D, 0x28, 0xC0, 0xB6,
  0xE0, 0xBA, 0xC4, 0xDE, 0xAA, 0x59, 0x19, 0x20, 0xB6, 0xFE, 0x72, 0x4F,
  0x12, 0x24, 0xC4, 0x46, 0xFF, 0x62, 0x22, 0x34, 0x4C, 0xBC,
};

const GFXglyph JetBrainsMono_LightItalic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 6, 5, 2, -6 },
  { 2, 2, 3, 5, 2, -6 },
  { 3, 5, 6, 5, 0, -6 },
  { 7, 5, 8, 5, 0, -7 },
  { 12, 5, 6, 5, 0, -6 },
  { 16, 5, 6, 5, 0, -6 },
  { 20, 1, 3, 5, 2, -6 },
  { 21, 4, 8, 5, 1, -7 },
  { 25, 4, 8, 5, 0, -7 },
  { 29, 5, 4, 5, 0, -5 },
  { 32, 3, 4, 5, 1, -5 },
  { 34, 2, 2, 5, 1, -1 },
  { 35, 3, 1, 5, 1, -3 },
  { 36, 2, 1, 5, 1, -1 },
  { 37, 5, 8, 5, 0, -7 },
  { 42, 5, 6, 5, 0, -6 },
  { 46, 4, 6, 5, 0, -6 },
  { 49, 5, 6, 5, 0, -6 },
  { 53, 4, 6, 5, 0, -6 },
  { 56, 3, 6, 5, 1, -6 },
  { 59, 3, 6, 5, 1, -6 },
  { 62, 4, 6, 5, 0, -6 },
  { 65, 4, 6, 5, 1, -6 },
  { 68, 4, 6, 5, 0, -6 },
  { 71, 4, 6, 5, 1, -6 },
  { 74, 2, 4, 5, 1, -4 },
  { 75, 2, 5, 5, 1, -4 },
  { 77, 4, 4, 5, 1, -5 },
  { 79, 3, 3, 5, 1, -4 },
  { 81, 4, 4, 5, 0, -5 },
  { 83, 3, 6, 5, 1, -6 },
  { 86, 5, 7, 5, 0, -6 },
  { 91, 4, 6, 5, 0, -6 },
  { 94, 5, 6, 5, 0, -6 },
  { 98, 4, 6, 5, 1, -6 },
  { 101, 4, 6, 5, 0, -6 },
  { 104, 5, 6, 5, 0, -6 },
  { 108, 5, 6, 5, 0, -6 },
  { 112, 4, 6, 5, 1, -6 },
  { 115, 5, 6, 5, 0, -6 },
  { 119, 4, 6, 5, 1, -6 },
  { 122, 5, 6, 5, 0, -6 },
  { 126, 5, 6, 5, 0, -6 },
  { 130, 3, 6, 5, 1, -6 },
  { 133, 5, 6, 5, 0, -6 },
  { 137, 5, 6, 5, 0, -6 },
  { 141, 3, 6, 5, 1, -6 },
  { 144, 5, 6, 5, 0, -6 },
  { 148, 4, 7, 5, 1, -6 },
  { 152, 5, 6, 5, 0, -6 },
  { 156, 5, 6, 5, 0, -6 },
  { 160, 4, 6, 5, 1, -6 },
  { 163, 4, 6, 5, 1, -6 },
  { 166, 4, 6, 5, 1, -6 },
  { 169, 4, 6, 5, 1, -6 },
  { 172, 5, 6, 5, 0, -6 },
  { 176, 4, 6, 5, 1, -6 },
  { 179, 5, 6, 5, 0, -6 },
  { 183, 3, 8, 5, 1, -7 },
  { 186, 3, 8, 5, 1, -7 },
  { 189, 3, 8, 5, 1, -7 },
  { 192, 3, 3, 5, 1, -6 },
  { 194, 4, 1, 5, 0, 0 },
  { 195, 2, 1, 5, 2, -6 },
  { 196, 3, 4, 5, 1, -4 },
  { 198, 4, 6, 5, 0, -6 },
  { 201, 3, 4, 5, 1, -4 },
  { 203, 4, 6, 5, 1, -6 },
  { 206, 3, 4, 5, 1, -4 },
  { 208, 5, 7, 5, 0, -6 },
  { 213, 3, 5, 5, 1, -4 },
  { 215, 4, 6, 5, 0, -6 },
  { 218, 4, 6, 5, 0, -6 },
  { 221, 4, 7, 5, 0, -6 },
  { 225, 5, 6, 5, 0, -6 },
  { 229, 3, 6, 5, 1, -6 },
  { 232, 5, 4, 5, 0, -4 },
  { 235, 4, 4, 5, 0, -4 },
  { 237, 3, 4, 5, 1, -4 },
  { 239, 4, 5, 5, 0, -4 },
  { 242, 3, 5, 5, 1, -4 },
  { 244, 3, 4, 5, 1, -4 },
  { 246, 4, 4, 5, 0, -4 },
  { 248, 3, 6, 5, 1, -6 },
  { 251, 3, 4, 5, 1, -4 },
  { 253, 4, 4, 5, 1, -4 },
  { 255, 4, 4, 5, 1, -4 },
  { 257, 5, 4, 5, 0, -4 },
  { 260, 3, 5, 5, 1, -4 },
  { 262, 4, 4, 5, 0, -4 },
  { 264, 4, 8, 5, 1, -7 },
  { 268, 1, 8, 5, 2, -7 },
  { 269, 4, 8, 5, 0, -7 },
  { 273, 3, 2, 5, 1, -4 },
};

const GFXfont JetBrainsMono_LightItalic8pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_LightItalic8pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_LightItalic8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _JETBRAINSMONO_LIGHTITALIC8PT7B_H_
