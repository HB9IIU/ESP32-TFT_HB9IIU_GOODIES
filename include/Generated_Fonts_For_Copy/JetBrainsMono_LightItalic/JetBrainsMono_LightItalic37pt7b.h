#ifndef _JETBRAINSMONO_LIGHTITALIC37PT7B_H_
#define _JETBRAINSMONO_LIGHTITALIC37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-LightItalic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_LightItalic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0x81, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x0C, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0xF8, 0x7C, 0x1E, 0x00, 0x78, 0x77, 0x07, 0x70,
  0xF7, 0x0F, 0x70, 0xE7, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x0C, 0xE1,
  0xC0, 0x00, 0x30, 0x38, 0x03, 0x81, 0x80, 0x18, 0x1C, 0x00, 0xC0, 0xE0,
  0x0E, 0x06, 0x00, 0x60, 0x70, 0x03, 0x03, 0x83, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xC0, 0xE0, 0x60, 0x06, 0x07, 0x00, 0x70, 0x30, 0x03,
  0x81, 0x80, 0x18, 0x1C, 0x01, 0xC0, 0xC0, 0x0E, 0x06, 0x07, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF0, 0x38, 0x18, 0x01, 0x81, 0xC0, 0x1C, 0x0C, 0x00, 0xE0,
  0xE0, 0x06, 0x07, 0x00, 0x70, 0x30, 0x03, 0x03, 0x80, 0x38, 0x1C, 0x00,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x01, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0x31, 0xC1, 0xC6, 0x1C,
  0x70, 0xC3, 0x8E, 0x18, 0x71, 0xC3, 0x00, 0x38, 0x60, 0x07, 0x98, 0x00,
  0xFB, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0x0C, 0xF0, 0x01, 0x8F, 0x00, 0x30, 0xE0, 0x06, 0x1C, 0x00, 0xC3, 0x9C,
  0x18, 0x73, 0x87, 0x0E, 0x70, 0xC3, 0x87, 0x18, 0xF0, 0xFB, 0x7C, 0x0F,
  0xFF, 0x00, 0xFF, 0x80, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x01, 0xF0, 0x03, 0x83, 0xFC, 0x03, 0x83, 0x87,
  0x01, 0x81, 0xC3, 0x81, 0x80, 0xC1, 0xC1, 0x80, 0x60, 0xE1, 0xC0, 0x70,
  0x61, 0xC0, 0x38, 0x31, 0xC0, 0x1C, 0x38, 0xC0, 0x0E, 0x1C, 0xC0, 0x03,
  0xFC, 0xC0, 0x00, 0xF8, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x63, 0xE0, 0x00, 0x67, 0xF8, 0x00, 0x73, 0x8E,
  0x00, 0x73, 0x87, 0x00, 0x71, 0x81, 0x80, 0x70, 0xC1, 0xC0, 0x30, 0x60,
  0xE0, 0x30, 0x70, 0x70, 0x30, 0x38, 0x30, 0x38, 0x0E, 0x38, 0x38, 0x07,
  0xF8, 0x38, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xC7,
  0x80, 0x70, 0x3C, 0x07, 0x01, 0xC0, 0x60, 0x1C, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x0F,
  0xC0, 0x01, 0xFE, 0x00, 0x38, 0xE0, 0xF7, 0x0F, 0x0E, 0x70, 0x71, 0xC7,
  0x03, 0xB8, 0x70, 0x3B, 0x87, 0x01, 0xF0, 0x60, 0x1E, 0x0E, 0x00, 0xE0,
  0xE0, 0x1F, 0x0F, 0x03, 0xF0, 0x78, 0xF3, 0x87, 0xFE, 0x38, 0x3F, 0x81,
  0xC0, 0x77, 0x7F, 0xFE, 0xEE, 0xEC, 0xC0, 0x00, 0x06, 0x00, 0x3C, 0x01,
  0xF8, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07,
  0x00, 0x02, 0x00, 0x07, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x07,
  0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x03, 0x80, 0x04, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x60, 0x60, 0x67, 0xC6, 0x3E, 0xFF, 0x6F, 0xF1, 0xFF, 0xF8,
  0x03, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xB0, 0x00, 0x73, 0x80, 0x0F, 0x38,
  0x01, 0xE3, 0xC0, 0x3C, 0x1E, 0x07, 0x81, 0xE0, 0x30, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x07, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x70, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x87, 0x83, 0xC3, 0xC1, 0xE1, 0xE0, 0xF0, 0x70, 0x70, 0x38, 0x38,
  0x1C, 0x00, 0x7F, 0xFB, 0xFF, 0xBF, 0xFC, 0x11, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x7F,
  0xF0, 0x1F, 0x1F, 0x07, 0x80, 0xE1, 0xE0, 0x1E, 0x38, 0x01, 0xC7, 0x00,
  0x38, 0xC0, 0x07, 0x38, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x07, 0x1C, 0x30,
  0xE3, 0x8F, 0x1C, 0x71, 0xE3, 0x9C, 0x38, 0x63, 0x82, 0x1C, 0x70, 0x03,
  0x8E, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x01, 0xCE, 0x00, 0x31, 0xE0, 0x0E,
  0x1C, 0x03, 0xC3, 0xC0, 0x70, 0x7C, 0x3C, 0x07, 0xFF, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0xFB, 0x80, 0xF1, 0xC0,
  0xF0, 0xE0, 0x60, 0xE0, 0x20, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0x00, 0x7F, 0xF0, 0x1E, 0x1F, 0x07, 0x00, 0xE1, 0xC0, 0x1C, 0x38,
  0x01, 0xCE, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0x1F, 0xFF,
  0xE3, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFF, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x03, 0x83, 0x80,
  0xF0, 0x7C, 0x7C, 0x07, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x0E,
  0x0F, 0x03, 0x87, 0x80, 0xE1, 0xC0, 0x38, 0xE0, 0x0E, 0x70, 0x07, 0x1C,
  0x01, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0xFF, 0xFF, 0x00, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x07, 0xFF,
  0xE1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x8F, 0x00, 0x77, 0xF8,
  0x0F, 0xFF, 0x81, 0xE0, 0xF8, 0x78, 0x0F, 0x0E, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70,
  0xE0, 0x0E, 0x1C, 0x03, 0xC3, 0x80, 0x70, 0x7C, 0x7C, 0x07, 0xFF, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xF3, 0x80, 0x3F, 0xF8, 0x1F, 0xFF, 0x0F, 0x83, 0xE3, 0x80,
  0x79, 0xE0, 0x0E, 0x70, 0x03, 0x9C, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x0E,
  0xE0, 0x03, 0xB8, 0x01, 0xCF, 0x00, 0x71, 0xC0, 0x38, 0x7E, 0x7C, 0x0F,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xFE, 0x00, 0x77, 0x00, 0x7B, 0x80, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x1E, 0x1F, 0x07, 0x80, 0xE0,
  0xE0, 0x1C, 0x38, 0x03, 0x87, 0x00, 0x70, 0xE0, 0x0E, 0x1C, 0x01, 0xC1,
  0xC0, 0x70, 0x3C, 0x3C, 0x03, 0xCF, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x03,
  0xEF, 0x00, 0xF0, 0x70, 0x38, 0x07, 0x0F, 0x00, 0xF1, 0xC0, 0x0E, 0x38,
  0x01, 0xCE, 0x00, 0x39, 0xC0, 0x0E, 0x3C, 0x01, 0xC3, 0x80, 0x70, 0x7C,
  0x3E, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x07, 0xFF, 0x07,
  0xC7, 0xC7, 0x80, 0xE7, 0x80, 0x3B, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xDC, 0x00, 0xEF, 0x00, 0xE3, 0xC1,
  0xF1, 0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x1F, 0x3F, 0x3F, 0x1F, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0xFC, 0xFC,
  0xFC, 0xF8, 0x01, 0xC0, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x38,
  0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x80,
  0x00, 0x60, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xBF,
  0xFF, 0xC0, 0x10, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x60, 0x00, 0x78, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xE0, 0x3F,
  0xF0, 0x7F, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x01, 0xFC, 0x07,
  0xF0, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xC0, 0x1E, 0x07, 0x80, 0xE0, 0x0E, 0x07,
  0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x00, 0x07, 0x1C, 0x00,
  0x1C, 0x70, 0x1E, 0x71, 0xC1, 0xFD, 0xC6, 0x0F, 0x1E, 0x18, 0x38, 0x38,
  0xE1, 0xC0, 0xE3, 0x87, 0x03, 0x8E, 0x1C, 0x0E, 0x38, 0x70, 0x38, 0xC1,
  0x80, 0xC3, 0x06, 0x03, 0x1C, 0x38, 0x1C, 0x70, 0xE0, 0x71, 0xC3, 0x81,
  0xC7, 0x07, 0x1F, 0x18, 0x1F, 0xDC, 0x60, 0x3E, 0x61, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1D, 0x80, 0x03, 0xB0, 0x00, 0x66,
  0x00, 0x1C, 0xC0, 0x03, 0x98, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x07, 0x0E,
  0x00, 0xE1, 0xC0, 0x18, 0x38, 0x07, 0x07, 0x00, 0xE0, 0xE0, 0x38, 0x0C,
  0x07, 0x01, 0x81, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE1, 0xC0, 0x1C,
  0x38, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x0E, 0x78, 0x01, 0xCE, 0x00, 0x1B,
  0xC0, 0x03, 0x80, 0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0x01,
  0xE0, 0xC0, 0x1C, 0x38, 0x03, 0xC7, 0x00, 0x70, 0xE0, 0x0E, 0x1C, 0x01,
  0xC3, 0x80, 0x38, 0x60, 0x0E, 0x1C, 0x0F, 0x83, 0xFF, 0xC0, 0x7F, 0xFC,
  0x0E, 0x07, 0xC1, 0xC0, 0x3C, 0x38, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x0E,
  0x38, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x0E, 0x1C, 0x01, 0xC3, 0x00, 0xF0,
  0xFF, 0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x01, 0xFF,
  0xC0, 0xF8, 0xF8, 0x78, 0x0E, 0x1C, 0x03, 0xCE, 0x00, 0x73, 0x80, 0x1C,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x04, 0xE0, 0x06, 0x38, 0x03, 0x8E, 0x00, 0xE3,
  0xC0, 0x70, 0x7C, 0x78, 0x1F, 0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x01,
  0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0x01, 0xE0, 0xC0, 0x1C, 0x38, 0x03, 0x87,
  0x00, 0x70, 0xE0, 0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x07, 0x1C,
  0x00, 0xE3, 0x80, 0x38, 0x70, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x38,
  0x03, 0x8E, 0x00, 0x71, 0xC0, 0x0C, 0x38, 0x03, 0x87, 0x00, 0x70, 0xE0,
  0x0E, 0x1C, 0x03, 0x83, 0x00, 0xE0, 0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xFF, 0x83, 0xFF,
  0xF0, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x83,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0xC0, 0xF8,
  0xF8, 0x78, 0x0E, 0x1C, 0x03, 0xCE, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x3F, 0xE7, 0x0F, 0xF1, 0xC3, 0xFC, 0xE0, 0x07, 0x38, 0x01, 0xCE, 0x00,
  0x73, 0x80, 0x1C, 0xE0, 0x06, 0x38, 0x03, 0x8E, 0x00, 0xE3, 0xC0, 0x70,
  0x7C, 0x78, 0x1F, 0xFC, 0x01, 0xFE, 0x00, 0x0E, 0x00, 0xE1, 0xC0, 0x1C,
  0x38, 0x03, 0x87, 0x00, 0x70, 0xE0, 0x0E, 0x38, 0x03, 0x87, 0x00, 0x70,
  0xE0, 0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x07, 0x1C, 0x01, 0xC3,
  0xFF, 0xF8, 0x7F, 0xFF, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x03, 0x8E,
  0x00, 0x61, 0xC0, 0x1C, 0x38, 0x03, 0x87, 0x00, 0x70, 0xE0, 0x0E, 0x1C,
  0x01, 0xC3, 0x00, 0x38, 0xE0, 0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x00,
  0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x7F, 0xFE, 0x0F,
  0xFF, 0xC3, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x70,
  0xF0, 0x07, 0x07, 0x00, 0xE0, 0x7C, 0x7C, 0x03, 0xFF, 0x80, 0x1F, 0xF0,
  0x00, 0x0E, 0x00, 0x78, 0x70, 0x07, 0x83, 0x80, 0x38, 0x1C, 0x03, 0xC0,
  0xC0, 0x3C, 0x0E, 0x01, 0xC0, 0x70, 0x1E, 0x03, 0x81, 0xE0, 0x1C, 0x0E,
  0x00, 0xE0, 0xF0, 0x07, 0x0F, 0x00, 0x70, 0x70, 0x03, 0xFF, 0x80, 0x1F,
  0xF8, 0x00, 0xE1, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x38, 0x03, 0x81, 0xE0,
  0x1C, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xC0,
  0x38, 0x0C, 0x01, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x38, 0x01, 0xE0,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x07, 0x80, 0x78, 0x7C, 0x07, 0xC3,
  0x60, 0x3E, 0x1B, 0x03, 0xE0, 0xD8, 0x1B, 0x06, 0xC1, 0xD8, 0x37, 0x0D,
  0xC3, 0xB8, 0xEE, 0x1C, 0xC6, 0x70, 0xE6, 0x73, 0x07, 0x33, 0x38, 0x39,
  0xB9, 0xC1, 0x8F, 0x8E, 0x1C, 0x3C, 0x70, 0xE1, 0xC3, 0x87, 0x00, 0x18,
  0x38, 0x01, 0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0x60, 0x03, 0x87, 0x00,
  0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0x70, 0x03, 0x83,
  0x00, 0x1C, 0x38, 0x00, 0xE0, 0x0F, 0x00, 0xE1, 0xE0, 0x1C, 0x3E, 0x03,
  0x87, 0xC0, 0x71, 0xF8, 0x0E, 0x3B, 0x01, 0x87, 0x60, 0x70, 0xEE, 0x0E,
  0x1D, 0xC1, 0xC3, 0x38, 0x38, 0xE3, 0x07, 0x1C, 0x70, 0xE3, 0x8E, 0x18,
  0x71, 0xC7, 0x0E, 0x18, 0xE1, 0xC3, 0x1C, 0x30, 0x73, 0x8E, 0x0E, 0x71,
  0xC1, 0xCC, 0x38, 0x1B, 0x87, 0x03, 0x70, 0xE0, 0x7E, 0x18, 0x0F, 0xC7,
  0x01, 0xF8, 0xE0, 0x1E, 0x1C, 0x03, 0xC3, 0x80, 0x78, 0x00, 0x01, 0xFE,
  0x01, 0xFF, 0xC0, 0xF8, 0xF8, 0x78, 0x0E, 0x1C, 0x03, 0x8E, 0x00, 0xE3,
  0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0xE7, 0x00, 0x39, 0xC0,
  0x0E, 0x70, 0x03, 0x1C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0xE0, 0x07,
  0x38, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x8E,
  0x01, 0xC3, 0xC0, 0xF0, 0x78, 0xF8, 0x1F, 0xFC, 0x01, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xE0, 0x1E, 0x0C, 0x00, 0xF1,
  0xC0, 0x07, 0x1C, 0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00, 0xE1, 0xC0, 0x0E,
  0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x38, 0x07, 0xC3, 0xFF, 0xF8, 0x3F, 0xFE,
  0x03, 0xFF, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xF0,
  0x1F, 0x1F, 0x07, 0x80, 0xE0, 0xE0, 0x1C, 0x38, 0x01, 0xC7, 0x00, 0x38,
  0xE0, 0x06, 0x38, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x07, 0x1C, 0x00, 0xE3,
  0x80, 0x1C, 0x70, 0x03, 0x8C, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x03, 0x8E,
  0x00, 0x71, 0xC0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x70, 0xE0, 0x0E, 0x1C,
  0x03, 0xC3, 0xC0, 0xF0, 0x7C, 0x7C, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0xE0, 0x1E, 0x0C, 0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x0E,
  0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x18, 0x01, 0xC3, 0x80, 0x3C, 0x38, 0x1F,
  0x83, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0x87, 0x00, 0x38, 0x38, 0x07, 0x03,
  0x80, 0x70, 0x38, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xE0, 0x70,
  0x0E, 0x06, 0x00, 0xE0, 0xE0, 0x0F, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x00,
  0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0x1F, 0x07, 0x80, 0xE0, 0xE0, 0x0E,
  0x38, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xCE,
  0x00, 0x39, 0xC0, 0x07, 0x38, 0x01, 0xC3, 0x80, 0x78, 0x7C, 0x3E, 0x07,
  0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0xE1, 0xC0, 0x1C, 0x38, 0x03, 0x87, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x01,
  0x87, 0x00, 0x70, 0xE0, 0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0xE0, 0x07,
  0x1C, 0x00, 0xE3, 0x80, 0x38, 0x70, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x1C,
  0x38, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x1C, 0x38, 0x03, 0x87, 0x00, 0x70,
  0xE0, 0x0E, 0x1C, 0x03, 0x83, 0xC0, 0xF0, 0x3C, 0x7C, 0x07, 0xFF, 0x00,
  0x7F, 0xC0, 0x00, 0xE0, 0x01, 0xF8, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x1C,
  0xE0, 0x07, 0x38, 0x01, 0xCE, 0x00, 0xE3, 0x80, 0x38, 0x60, 0x1C, 0x1C,
  0x07, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x1C, 0x07, 0x07,
  0x01, 0xC3, 0x80, 0x70, 0xE0, 0x0C, 0x30, 0x03, 0x1C, 0x00, 0xE7, 0x00,
  0x3B, 0x80, 0x0E, 0xE0, 0x03, 0xB0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0x60, 0x70, 0x3B, 0x03, 0x81, 0x98, 0x3C, 0x1C,
  0xC1, 0xE0, 0xE6, 0x0F, 0x07, 0x70, 0x78, 0x33, 0x86, 0xC3, 0x9C, 0x36,
  0x1C, 0xE1, 0xB0, 0xC7, 0x19, 0x86, 0x38, 0xCC, 0x71, 0xC6, 0x63, 0x8E,
  0x33, 0x18, 0x73, 0x19, 0xC3, 0x98, 0xCE, 0x1C, 0xC6, 0x60, 0xEC, 0x33,
  0x07, 0x61, 0xB8, 0x3B, 0x0D, 0xC1, 0x98, 0x6C, 0x0D, 0x83, 0x60, 0x6C,
  0x1F, 0x03, 0x60, 0xF8, 0x1E, 0x07, 0x80, 0xF0, 0x2C, 0x07, 0x81, 0xE0,
  0x3C, 0x1E, 0x00, 0x07, 0x00, 0x1E, 0x0F, 0x00, 0x78, 0x0E, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x1C, 0x0F, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x70, 0x00,
  0x71, 0xC0, 0x00, 0xE3, 0x80, 0x00, 0xEE, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xEE, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x3C, 0x00, 0x3C, 0x38,
  0x00, 0x70, 0x70, 0x01, 0xC0, 0x70, 0x07, 0x80, 0xE0, 0x1E, 0x01, 0xE0,
  0x38, 0x01, 0xC0, 0xE0, 0x03, 0x83, 0xC0, 0x03, 0x80, 0xE0, 0x00, 0xEE,
  0x00, 0x39, 0xC0, 0x07, 0x38, 0x01, 0xC3, 0x80, 0x78, 0x70, 0x0E, 0x0E,
  0x03, 0x80, 0xE0, 0xF0, 0x1C, 0x1C, 0x03, 0x87, 0x00, 0x38, 0xE0, 0x07,
  0x38, 0x00, 0xEE, 0x00, 0x0D, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xFF,
  0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xF8, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x7F, 0xC0, 0xFF, 0x83, 0xFE,
  0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x1C,
  0x03, 0x80, 0x03, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x7F, 0xC0, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0xE0, 0x03, 0xE0,
  0x06, 0xC0, 0x1D, 0x80, 0x33, 0x80, 0xE7, 0x03, 0x86, 0x07, 0x0C, 0x1C,
  0x1C, 0x30, 0x38, 0xE0, 0x33, 0x80, 0x77, 0x00, 0xFC, 0x00, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xE1, 0xC3, 0x8E, 0x1C, 0x00, 0xE0, 0x00, 0xFE,
  0x70, 0xFF, 0xDC, 0x3C, 0x1F, 0x1C, 0x03, 0xC7, 0x00, 0xE3, 0x80, 0x38,
  0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x0E, 0x70,
  0x07, 0x1C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x0F, 0x1E, 0x07,
  0xC7, 0xC3, 0xE0, 0xFF, 0xB8, 0x1F, 0xCE, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC3, 0xC0,
  0x73, 0xFC, 0x1D, 0xFF, 0x07, 0xC1, 0xE1, 0xE0, 0x38, 0xF0, 0x0E, 0x38,
  0x03, 0x8E, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x9C, 0x00,
  0xE7, 0x00, 0x39, 0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0xF1,
  0xE0, 0x78, 0xEC, 0x3C, 0x3B, 0xFE, 0x0E, 0x7F, 0x00, 0x00, 0xE0, 0x03,
  0xFE, 0x03, 0xFF, 0x83, 0xC1, 0xE3, 0x80, 0x71, 0xC0, 0x1D, 0xC0, 0x0E,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x39, 0xC0, 0x1C, 0xE0, 0x0E, 0x78, 0x0E, 0x1F,
  0x1E, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x38, 0x70, 0x1F,
  0xCE, 0x0F, 0xFD, 0xC1, 0xE0, 0xF8, 0x70, 0x0F, 0x0E, 0x01, 0xE3, 0x80,
  0x38, 0x70, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x70, 0x03, 0x8E, 0x00,
  0x71, 0xC0, 0x1C, 0x38, 0x03, 0x87, 0x00, 0x70, 0xE0, 0x0E, 0x1C, 0x03,
  0xC3, 0xC0, 0xF8, 0x7C, 0x3E, 0x07, 0xFD, 0xC0, 0x7F, 0x38, 0x00, 0x00,
  0xF0, 0x03, 0xFE, 0x03, 0xFF, 0x83, 0x81, 0xE3, 0x80, 0x71, 0xC0, 0x39,
  0xC0, 0x1C, 0xE0, 0x0E, 0x70, 0x07, 0x3F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF,
  0xEE, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x0E, 0x70,
  0x0E, 0x1E, 0x1E, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x03, 0xFD, 0xC7,
  0xFE, 0xE3, 0xC1, 0xF3, 0x80, 0x79, 0xC0, 0x39, 0xC0, 0x1C, 0xE0, 0x0E,
  0x70, 0x07, 0x38, 0x03, 0xB8, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0xE7, 0x00,
  0x73, 0x80, 0x39, 0xE0, 0x3C, 0x78, 0x3E, 0x3F, 0xF7, 0x0F, 0xF7, 0x01,
  0xC3, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78,
  0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xE0, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC3, 0xC0, 0x73,
  0xFC, 0x1D, 0xFF, 0x07, 0xC1, 0xE1, 0xC0, 0x38, 0xF0, 0x0E, 0x38, 0x03,
  0x8E, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x9C, 0x00, 0xE7,
  0x00, 0x71, 0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x71, 0x80,
  0x1C, 0xE0, 0x06, 0x38, 0x03, 0x8E, 0x00, 0xE0, 0x00, 0x04, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x07, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80,
  0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xF0, 0x1F, 0xFC, 0x03, 0xFE,
  0x00, 0x7E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x11, 0xC0, 0x1E,
  0x1C, 0x03, 0xC1, 0xC0, 0x38, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x1E,
  0x03, 0x83, 0xC0, 0x38, 0x78, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFF,
  0x00, 0x70, 0x70, 0x07, 0x07, 0x80, 0x70, 0x38, 0x07, 0x03, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xE0, 0xE0, 0x0E, 0x0E, 0x00, 0xF0, 0xE0, 0x07, 0x00,
  0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1F, 0xFE, 0x1F,
  0xFC, 0x1F, 0xF8, 0x00, 0xC1, 0x81, 0xFF, 0x7E, 0x1B, 0xF7, 0xE1, 0xC3,
  0x8F, 0x18, 0x30, 0x73, 0x83, 0x06, 0x38, 0x30, 0x63, 0x87, 0x0E, 0x38,
  0x70, 0xE3, 0x87, 0x0E, 0x30, 0x60, 0xE7, 0x06, 0x0E, 0x70, 0x60, 0xC7,
  0x0E, 0x1C, 0x70, 0xE1, 0xC7, 0x0E, 0x1C, 0x60, 0xC1, 0xCE, 0x0C, 0x1C,
  0xE0, 0xC1, 0x8E, 0x1C, 0x18, 0xE1, 0xC3, 0x80, 0x00, 0x3C, 0x07, 0x3F,
  0xC1, 0xDF, 0xF0, 0x7C, 0x1E, 0x1C, 0x03, 0x8F, 0x00, 0xE3, 0x80, 0x38,
  0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x39, 0xC0, 0x0E, 0x70,
  0x07, 0x1C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x07, 0x18, 0x01,
  0xCE, 0x00, 0x63, 0x80, 0x38, 0xE0, 0x0E, 0x00, 0x00, 0xF0, 0x03, 0xFE,
  0x03, 0xFF, 0x83, 0xC1, 0xE3, 0x80, 0x71, 0xC0, 0x39, 0xC0, 0x1C, 0xE0,
  0x0E, 0x70, 0x07, 0x38, 0x03, 0xB8, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0x77,
  0x00, 0x73, 0x80, 0x39, 0xC0, 0x1C, 0xE0, 0x1C, 0x78, 0x1E, 0x1E, 0x1E,
  0x0F, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x1E, 0x01, 0xCF, 0xF0, 0x3B, 0xFE,
  0x07, 0xC1, 0xE0, 0xF0, 0x1C, 0x3C, 0x03, 0x87, 0x00, 0x70, 0xE0, 0x0E,
  0x1C, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x1C,
  0x70, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x07, 0x8F, 0x80, 0xE1,
  0xD8, 0x78, 0x3B, 0xFE, 0x07, 0x3F, 0x80, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0xFE, 0x70, 0xFF, 0xDC, 0x3C, 0x1F, 0x1C, 0x03, 0xCF,
  0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0xE7, 0x00,
  0x39, 0xC0, 0x0C, 0x70, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x1C,
  0x70, 0x0F, 0x1E, 0x07, 0xC7, 0xC3, 0xE0, 0xFF, 0xB8, 0x1F, 0xCE, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x38, 0x07, 0x7F, 0x81, 0xBF, 0xF0, 0xF8, 0x1E,
  0x3C, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x9C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x78, 0x0E,
  0x1C, 0x03, 0xC7, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0xE0, 0x07, 0x3C, 0x03, 0xC7, 0x81, 0xE1, 0xFF, 0xF0,
  0x1F, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3F, 0xF8, 0x07, 0xFC, 0x00,
  0xFF, 0x00, 0x1C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0xE0, 0x07, 0x38,
  0x01, 0xCE, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x00,
  0xE7, 0x00, 0x39, 0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x71,
  0xC0, 0x38, 0x78, 0x1E, 0x0F, 0x1F, 0x03, 0xFF, 0x80, 0x3F, 0x80, 0xE0,
  0x03, 0xF0, 0x03, 0xF8, 0x01, 0xCE, 0x01, 0xE7, 0x00, 0xE3, 0x80, 0x71,
  0xC0, 0x70, 0xE0, 0x38, 0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x1C, 0x07, 0x0E,
  0x03, 0x8E, 0x01, 0xC7, 0x00, 0x67, 0x00, 0x33, 0x80, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xE0, 0xE0, 0x7C, 0x1C, 0x1F, 0x87,
  0x83, 0x70, 0xF0, 0x6E, 0x1E, 0x1D, 0xC6, 0xC3, 0x38, 0xD8, 0x67, 0x1B,
  0x1C, 0xC6, 0x63, 0x18, 0xCC, 0x63, 0x19, 0x9C, 0x66, 0x33, 0x0C, 0xC6,
  0x61, 0x98, 0xCC, 0x36, 0x1B, 0x06, 0xC3, 0x60, 0xD8, 0x6C, 0x1E, 0x0F,
  0x83, 0xC1, 0xE0, 0x78, 0x3C, 0x00, 0x1E, 0x00, 0xF0, 0xF0, 0x1E, 0x07,
  0x03, 0xC0, 0x70, 0x38, 0x03, 0x87, 0x00, 0x38, 0xE0, 0x01, 0xDE, 0x00,
  0x1D, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x03, 0xB8, 0x00, 0x71, 0xC0, 0x0F, 0x1C, 0x01, 0xE0, 0xE0, 0x3C, 0x0F,
  0x03, 0x80, 0x70, 0x70, 0x07, 0x8F, 0x00, 0x38, 0x38, 0x03, 0x9C, 0x01,
  0xCE, 0x00, 0xEE, 0x00, 0x77, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x1C, 0xE0,
  0x0E, 0x70, 0x07, 0x30, 0x03, 0xB8, 0x01, 0x9C, 0x01, 0xCE, 0x00, 0xE7,
  0x00, 0x73, 0xC0, 0x78, 0xF0, 0xDC, 0x7F, 0xEE, 0x1F, 0xEE, 0x01, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x7F,
  0xF0, 0x3F, 0xF0, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0xC7, 0xFF, 0xF0, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3F, 0xFF, 0xCF, 0xFF,
  0xE3, 0xFF, 0xF8, 0x00, 0x03, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0xFF, 0x80, 0x3F, 0x80, 0x0F, 0xF8, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0x81,
  0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x38, 0x00, 0x07, 0x80, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xE0, 0x03, 0xF8, 0x01, 0xFF, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xE0,
  0x00, 0x00, 0x06, 0x00, 0xE3, 0xF0, 0x18, 0xFF, 0x07, 0x38, 0xF0, 0xE7,
  0x0F, 0x1C, 0xE0, 0xFF, 0x18, 0x0F, 0xC7, 0x00, 0x60,
};

const GFXglyph JetBrainsMono_LightItalic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 9, 27, 22, 7, -27 },
  { 32, 12, 11, 22, 7, -27 },
  { 49, 21, 27, 22, 1, -27 },
  { 120, 19, 37, 22, 2, -32 },
  { 208, 25, 27, 22, -1, -27 },
  { 293, 20, 27, 22, 1, -27 },
  { 361, 4, 11, 22, 11, -27 },
  { 367, 15, 36, 22, 6, -31 },
  { 435, 15, 36, 22, 2, -31 },
  { 503, 20, 19, 22, 2, -23 },
  { 551, 17, 17, 22, 3, -21 },
  { 588, 9, 12, 22, 4, -6 },
  { 602, 13, 3, 22, 5, -14 },
  { 607, 6, 6, 22, 7, -6 },
  { 612, 21, 35, 22, 1, -31 },
  { 704, 19, 27, 22, 2, -27 },
  { 769, 17, 27, 22, 2, -27 },
  { 827, 19, 27, 22, 2, -27 },
  { 892, 19, 27, 22, 2, -27 },
  { 957, 18, 27, 22, 2, -27 },
  { 1018, 19, 27, 22, 2, -27 },
  { 1083, 18, 27, 22, 2, -27 },
  { 1144, 17, 27, 22, 5, -27 },
  { 1202, 19, 27, 22, 2, -27 },
  { 1267, 17, 27, 22, 4, -27 },
  { 1325, 8, 21, 22, 7, -21 },
  { 1346, 12, 27, 22, 4, -21 },
  { 1387, 18, 19, 22, 3, -22 },
  { 1430, 17, 11, 22, 3, -18 },
  { 1454, 18, 19, 22, 2, -22 },
  { 1497, 15, 27, 22, 5, -27 },
  { 1548, 22, 34, 22, 0, -27 },
  { 1642, 19, 27, 22, 0, -27 },
  { 1707, 19, 27, 22, 2, -27 },
  { 1772, 18, 27, 22, 3, -27 },
  { 1833, 19, 27, 22, 2, -27 },
  { 1898, 20, 27, 22, 2, -27 },
  { 1966, 20, 27, 22, 2, -27 },
  { 2034, 18, 27, 22, 3, -27 },
  { 2095, 19, 27, 22, 2, -27 },
  { 2160, 19, 27, 22, 2, -27 },
  { 2225, 20, 27, 22, 1, -27 },
  { 2293, 21, 27, 22, 2, -27 },
  { 2364, 16, 27, 22, 3, -27 },
  { 2418, 21, 27, 22, 1, -27 },
  { 2489, 19, 27, 22, 2, -27 },
  { 2554, 18, 27, 22, 3, -27 },
  { 2615, 20, 27, 22, 2, -27 },
  { 2683, 19, 34, 22, 2, -27 },
  { 2764, 20, 27, 22, 2, -27 },
  { 2832, 19, 27, 22, 2, -27 },
  { 2897, 19, 27, 22, 4, -27 },
  { 2962, 19, 27, 22, 2, -27 },
  { 3027, 18, 27, 22, 5, -27 },
  { 3088, 21, 27, 22, 3, -27 },
  { 3159, 23, 27, 22, 0, -27 },
  { 3237, 19, 27, 22, 4, -27 },
  { 3302, 19, 27, 22, 2, -27 },
  { 3367, 15, 35, 22, 5, -31 },
  { 3433, 11, 35, 22, 6, -31 },
  { 3482, 15, 35, 22, 3, -31 },
  { 3548, 15, 14, 22, 4, -27 },
  { 3575, 18, 2, 22, 0, 1 },
  { 3580, 6, 5, 22, 10, -29 },
  { 3584, 18, 21, 22, 2, -21 },
  { 3632, 18, 27, 22, 2, -27 },
  { 3693, 17, 21, 22, 3, -21 },
  { 3738, 19, 27, 22, 2, -27 },
  { 3803, 17, 21, 22, 3, -21 },
  { 3848, 25, 34, 22, -2, -27 },
  { 3955, 17, 28, 22, 3, -21 },
  { 4015, 18, 27, 22, 2, -27 },
  { 4076, 18, 29, 22, 1, -29 },
  { 4142, 19, 36, 22, 1, -29 },
  { 4228, 20, 27, 22, 2, -27 },
  { 4296, 15, 27, 22, 4, -27 },
  { 4347, 20, 21, 22, 1, -21 },
  { 4400, 18, 21, 22, 2, -21 },
  { 4448, 17, 21, 22, 3, -21 },
  { 4493, 19, 28, 22, 1, -21 },
  { 4560, 18, 28, 22, 2, -21 },
  { 4623, 18, 21, 22, 3, -21 },
  { 4671, 18, 21, 22, 2, -21 },
  { 4719, 18, 26, 22, 3, -26 },
  { 4778, 18, 20, 22, 2, -20 },
  { 4823, 17, 20, 22, 4, -20 },
  { 4866, 19, 20, 22, 3, -20 },
  { 4914, 20, 20, 22, 1, -20 },
  { 4964, 17, 27, 22, 3, -20 },
  { 5022, 18, 20, 22, 2, -20 },
  { 5067, 18, 35, 22, 4, -31 },
  { 5146, 9, 35, 22, 7, -31 },
  { 5186, 19, 35, 22, 1, -31 },
  { 5270, 19, 8, 22, 2, -17 },
};

const GFXfont JetBrainsMono_LightItalic37pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_LightItalic37pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_LightItalic37pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _JETBRAINSMONO_LIGHTITALIC37PT7B_H_
