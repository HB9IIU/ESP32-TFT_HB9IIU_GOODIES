#ifndef _JETBRAINSMONO_LIGHTITALIC61PT7B_H_
#define _JETBRAINSMONO_LIGHTITALIC61PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-LightItalic.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_LightItalic61pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0xC0, 0xFF,
  0x83, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0x7E, 0x00, 0x3E, 0x03, 0xF3, 0xE0,
  0x3E, 0x7E, 0x03, 0xE7, 0xE0, 0x3E, 0x7E, 0x07, 0xE7, 0xC0, 0x7E, 0x7C,
  0x07, 0xE7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0xF8, 0x07, 0xCF,
  0x80, 0x7C, 0xF8, 0x07, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x00, 0xF8,
  0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x78,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00,
  0x78, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0xF8, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x78, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x78, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x0F,
  0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xBB, 0xFC, 0x00,
  0xFC, 0x78, 0xFC, 0x01, 0xF8, 0x78, 0x7E, 0x01, 0xF0, 0x78, 0x3E, 0x03,
  0xE0, 0x70, 0x3E, 0x03, 0xE0, 0x70, 0x3E, 0x03, 0xC0, 0x70, 0x3E, 0x07,
  0xC0, 0x70, 0x3E, 0x07, 0xC0, 0xF0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x07,
  0xC0, 0xE0, 0x00, 0x07, 0xE0, 0xE0, 0x00, 0x03, 0xE0, 0xE0, 0x00, 0x03,
  0xF0, 0xE0, 0x00, 0x03, 0xFD, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x03, 0xCF, 0xE0, 0x00, 0x03, 0x83, 0xF0, 0x00, 0x03, 0x83, 0xF0, 0x00,
  0x03, 0x81, 0xF0, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x07, 0x81, 0xF0, 0x00,
  0x07, 0x81, 0xF0, 0x7C, 0x07, 0x01, 0xF0, 0x78, 0x07, 0x01, 0xF0, 0x78,
  0x07, 0x01, 0xF0, 0x7C, 0x07, 0x03, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x7E,
  0x0F, 0x07, 0xC0, 0x7F, 0x0E, 0x0F, 0xC0, 0x3F, 0x8E, 0x3F, 0x80, 0x3F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x07, 0xFE, 0x00,
  0x01, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x78,
  0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x01, 0xE0, 0x07, 0x80, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x03, 0xC0, 0x1E,
  0x01, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0xF0, 0x00, 0x3C, 0x01, 0xE0, 0x7C,
  0x00, 0x0F, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0x00,
  0xF0, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x01,
  0xE1, 0xE0, 0x00, 0x03, 0xE1, 0xF8, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x7C,
  0x00, 0x00, 0x1F, 0xFE, 0x1E, 0x00, 0x00, 0x03, 0xFE, 0x0F, 0x00, 0x00,
  0x00, 0x1C, 0x07, 0x80, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0x0F, 0xFE,
  0x00, 0x00, 0x07, 0x87, 0xFF, 0xC0, 0x00, 0x03, 0xC3, 0xFF, 0xF0, 0x00,
  0x01, 0xF1, 0xF0, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x0F, 0x80, 0x00, 0x3C,
  0x3C, 0x01, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0x03, 0xC0,
  0x3C, 0x00, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x00, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x00, 0x1F,
  0x03, 0xE0, 0x07, 0x80, 0x03, 0xFF, 0xF0, 0x03, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xE0, 0x0F,
  0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0x1F, 0x00, 0x3F, 0x1F, 0x07, 0xC0, 0x1F, 0x1F, 0x03, 0xF0, 0x1F, 0x0F,
  0x80, 0xF8, 0x1F, 0x07, 0x80, 0x7E, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x83,
  0xE0, 0x07, 0xCF, 0x81, 0xF0, 0x03, 0xE7, 0x80, 0xF8, 0x00, 0xFF, 0xC0,
  0x7C, 0x00, 0x7F, 0xC0, 0x3E, 0x00, 0x1F, 0xC0, 0x1E, 0x00, 0x0F, 0xE0,
  0x1F, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x03, 0xF8, 0x07, 0xC0, 0x03, 0xFC,
  0x03, 0xE0, 0x03, 0xFF, 0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x7E, 0x07, 0xF3,
  0xE0, 0x3F, 0xFF, 0xF1, 0xF8, 0x0F, 0xFF, 0xF0, 0x7C, 0x07, 0xFF, 0xE0,
  0x1F, 0x00, 0xFF, 0xC0, 0x0F, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x1F, 0x1F,
  0x3F, 0x3F, 0x3F, 0x3E, 0x3E, 0x3E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C,
  0x7C, 0x78, 0x78, 0x78, 0xF8, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x3F, 0x01, 0xE0, 0x3F, 0x7F, 0xC1, 0xC1, 0xFF, 0xFF, 0xF1, 0xC7,
  0xFF, 0x7F, 0xF9, 0xDF, 0xFE, 0x0F, 0xFF, 0xBF, 0xF0, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0x7C, 0xF8,
  0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x00, 0x0F, 0x80, 0x0E, 0x00, 0x0F, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0,
  0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x1F, 0x87, 0xF9, 0xFF, 0x3F, 0xEF, 0xFD,
  0xFF, 0xBF, 0xF3, 0xFC, 0x7F, 0x01, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xE0, 0x7F, 0x80,
  0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7E, 0x07,
  0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x78, 0x3E, 0x00,
  0x01, 0xF0, 0x78, 0x00, 0x03, 0xE1, 0xF0, 0x3C, 0x07, 0xC3, 0xE0, 0xFC,
  0x0F, 0x87, 0xC1, 0xFC, 0x1F, 0x0F, 0x83, 0xF8, 0x3C, 0x1F, 0x07, 0xF0,
  0xF8, 0x3C, 0x0F, 0xC1, 0xF0, 0xF8, 0x0F, 0x03, 0xE1, 0xF0, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x7C,
  0x1E, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x7C, 0x1F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFB, 0xE0,
  0x00, 0xFF, 0x3E, 0x00, 0x1F, 0xC3, 0xE0, 0x03, 0xF8, 0x3E, 0x00, 0x3E,
  0x03, 0xE0, 0x03, 0xC0, 0x3E, 0x00, 0x70, 0x07, 0xC0, 0x06, 0x00, 0x7C,
  0x00, 0x40, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0x3F,
  0xC0, 0x3F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3F,
  0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0xF8,
  0x7C, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x0F,
  0x80, 0x01, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x1F, 0x80, 0x3F,
  0x80, 0x7F, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x03, 0xE0,
  0x1F, 0x00, 0x1E, 0x01, 0xF8, 0x01, 0xF0, 0x1F, 0x80, 0x0F, 0x81, 0xF8,
  0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x00,
  0xF8, 0xFC, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x1F, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF8, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x87, 0xFC, 0x00, 0x3E,
  0x7F, 0xFC, 0x00, 0xFB, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0x78,
  0x1F, 0xC0, 0x7F, 0x80, 0x1F, 0x81, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x80, 0x0F,
  0xC0, 0x7F, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0xFF, 0xC0, 0x07, 0xDF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0x3F, 0xC1,
  0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0xCF, 0x80,
  0x00, 0x3E, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00,
  0x7D, 0xF0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0xF3,
  0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xE7, 0xC0,
  0x00, 0x3E, 0x3E, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x03,
  0xF0, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x17, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0xF0, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x1F, 0x1F, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x3F, 0xC0, 0x1F, 0x80, 0x1F, 0x80,
  0x7E, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x1E, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x07, 0xC0, 0x78, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0x7C, 0x03, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0,
  0x3F, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFE, 0x7F,
  0x00, 0x07, 0xF0, 0x3F, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0x3F,
  0x01, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x7C,
  0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF0, 0x3F, 0x80, 0x0F, 0xC0, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x80, 0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x3E, 0x3F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0xCF,
  0x80, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0xBE, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0xC7,
  0xC0, 0x00, 0x7C, 0x3F, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0xFE, 0x07, 0xF8,
  0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xCF,
  0x80, 0x03, 0xF8, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0xFF, 0xC1, 0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x03, 0xFE, 0x07,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0x80, 0xFE, 0x00, 0x20,
  0x00, 0x00, 0x0F, 0xC0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x10, 0x1F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF0, 0x04, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x07, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x1E, 0x0F, 0x80,
  0x00, 0x01, 0xE0, 0xF8, 0x00, 0x10, 0x1E, 0x0F, 0x00, 0x1F, 0xF3, 0xE0,
  0xF0, 0x03, 0xFF, 0xBE, 0x0F, 0x00, 0x7F, 0xFF, 0xC1, 0xF0, 0x0F, 0xC1,
  0xFC, 0x1F, 0x00, 0xF8, 0x07, 0xC1, 0xE0, 0x1F, 0x00, 0x7C, 0x1E, 0x01,
  0xE0, 0x07, 0xC1, 0xE0, 0x3E, 0x00, 0x7C, 0x1E, 0x03, 0xE0, 0x07, 0x83,
  0xE0, 0x3E, 0x00, 0x78, 0x3E, 0x03, 0xC0, 0x07, 0x83, 0xE0, 0x3C, 0x00,
  0x78, 0x3C, 0x03, 0xC0, 0x0F, 0x83, 0xC0, 0x7C, 0x00, 0xF8, 0x3C, 0x07,
  0xC0, 0x0F, 0x83, 0xC0, 0x7C, 0x00, 0xF0, 0x7C, 0x07, 0x80, 0x0F, 0x07,
  0xC0, 0x78, 0x00, 0xF0, 0x78, 0x07, 0x80, 0x1F, 0x07, 0x80, 0x7C, 0x01,
  0xF0, 0x78, 0x07, 0xC0, 0x3F, 0x07, 0x80, 0x7E, 0x07, 0xE0, 0xF8, 0x03,
  0xFF, 0xDE, 0x0F, 0x80, 0x3F, 0xFD, 0xE0, 0xF8, 0x01, 0xFF, 0x1E, 0x0F,
  0x80, 0x03, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x3D,
  0xF0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x3E, 0x3C,
  0x00, 0x00, 0xF8, 0xF0, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x1F, 0x0F, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x0F, 0x03, 0xE0, 0x00,
  0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0x07, 0xC0, 0x1E, 0x00, 0x1F, 0x00,
  0x78, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x1F,
  0x00, 0x7C, 0x00, 0x7C, 0x01, 0xF0, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F,
  0x00, 0x03, 0xC0, 0xF8, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x3E, 0x1F, 0x00,
  0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F, 0x8F, 0x80, 0x00,
  0x3E, 0x3E, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x07,
  0xBE, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x7C, 0x01, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0x80, 0x3C, 0x00, 0x3F, 0x80, 0xF8, 0x00, 0x3F, 0x01,
  0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x7C, 0x0F,
  0x80, 0x00, 0xF8, 0x1E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0xF8, 0x0F, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0xC0, 0x7C, 0x00,
  0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x1F, 0xE0, 0x3E, 0x00, 0x0F,
  0xC0, 0x7C, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F,
  0x03, 0xC0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7C,
  0x3E, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xFC, 0x1F,
  0x00, 0x03, 0xF0, 0x3E, 0x00, 0x0F, 0xE0, 0x7C, 0x01, 0xFF, 0x80, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x3F,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x1E, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x1F, 0x80, 0x3F, 0x80, 0x7E, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7C, 0x00,
  0xFF, 0x00, 0xF8, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x7E, 0x03, 0xE0, 0x00,
  0x7C, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x1E, 0x00, 0x01,
  0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0x80,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x03, 0xC0, 0x00,
  0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x3F,
  0x80, 0x7C, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x3F,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x1E, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x01, 0xFF, 0xF8,
  0x3E, 0x03, 0xFF, 0xF0, 0x7C, 0x07, 0xFF, 0xE0, 0xF8, 0x1F, 0xFF, 0xC1,
  0xF0, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x1F, 0x80, 0x3F, 0x80, 0x7E, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x78, 0x07, 0x80,
  0x00, 0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x01, 0xE0, 0x1E, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x03, 0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x0F, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x3F, 0xC0, 0x3F, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x01, 0xF8, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x03, 0xF0, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x07, 0xE0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x0F,
  0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x1F, 0x80, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x3F, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x3E, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x0F, 0x80, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x1F,
  0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x0F, 0x80, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x01,
  0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x2F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFC, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xF0, 0x1F,
  0xC0, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0xF7, 0x80, 0x1E, 0xE0, 0x3D, 0xE0, 0x07, 0xF8, 0x0F, 0x78, 0x03, 0xDE,
  0x03, 0xDE, 0x00, 0xF7, 0x80, 0xF7, 0x80, 0x79, 0xE0, 0x3C, 0xE0, 0x1E,
  0xF8, 0x1F, 0x3C, 0x0F, 0x3C, 0x07, 0xCF, 0x03, 0xCF, 0x01, 0xE3, 0xC1,
  0xE3, 0xC0, 0x78, 0xF0, 0x78, 0xF0, 0x1E, 0x3C, 0x3C, 0x7C, 0x07, 0x87,
  0x0F, 0x1F, 0x01, 0xE1, 0xE7, 0x87, 0x80, 0xF8, 0x79, 0xE1, 0xE0, 0x3E,
  0x1E, 0xF0, 0xF8, 0x0F, 0x87, 0xBC, 0x3E, 0x03, 0xE0, 0xEE, 0x0F, 0x80,
  0xF0, 0x3F, 0x83, 0xE0, 0x3C, 0x0F, 0xC0, 0xF0, 0x1F, 0x03, 0xF0, 0x3C,
  0x07, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x01,
  0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x07, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x0F, 0x80,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x03, 0xE0, 0x3C,
  0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7C,
  0x07, 0x80, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0x01, 0xFC, 0x00, 0x1F, 0x01, 0xFC,
  0x00, 0x1F, 0x01, 0xFC, 0x00, 0x1F, 0x01, 0xFC, 0x00, 0x1F, 0x03, 0xFE,
  0x00, 0x1E, 0x03, 0xFE, 0x00, 0x1E, 0x03, 0xDE, 0x00, 0x3E, 0x03, 0xDE,
  0x00, 0x3E, 0x03, 0xDE, 0x00, 0x3E, 0x03, 0xDF, 0x00, 0x3E, 0x07, 0xCF,
  0x00, 0x3C, 0x07, 0xCF, 0x00, 0x3C, 0x07, 0xCF, 0x00, 0x7C, 0x07, 0xCF,
  0x80, 0x7C, 0x07, 0x87, 0x80, 0x7C, 0x07, 0x87, 0x80, 0x7C, 0x0F, 0x87,
  0x80, 0x7C, 0x0F, 0x87, 0x80, 0x78, 0x0F, 0x87, 0xC0, 0xF8, 0x0F, 0x83,
  0xC0, 0xF8, 0x0F, 0x83, 0xC0, 0xF8, 0x0F, 0x03, 0xC0, 0xF8, 0x0F, 0x03,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0xF0, 0x1F, 0x01, 0xE0, 0xF0, 0x1F, 0x01,
  0xE1, 0xF0, 0x1F, 0x01, 0xE1, 0xF0, 0x1E, 0x01, 0xF1, 0xF0, 0x1E, 0x01,
  0xF1, 0xF0, 0x3E, 0x00, 0xF1, 0xE0, 0x3E, 0x00, 0xF1, 0xE0, 0x3E, 0x00,
  0xF3, 0xE0, 0x3E, 0x00, 0xFB, 0xE0, 0x3C, 0x00, 0xFB, 0xE0, 0x3C, 0x00,
  0x7B, 0xE0, 0x7C, 0x00, 0x7B, 0xC0, 0x7C, 0x00, 0x7B, 0xC0, 0x7C, 0x00,
  0x7F, 0xC0, 0x7C, 0x00, 0x3F, 0xC0, 0x7C, 0x00, 0x3F, 0xC0, 0x78, 0x00,
  0x3F, 0xC0, 0xF8, 0x00, 0x3F, 0xC0, 0xF8, 0x00, 0x3F, 0x80, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x3F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C,
  0x1F, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x78, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xC0,
  0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x0F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07,
  0xC1, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3C,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x1F, 0x00,
  0x00, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E,
  0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x07, 0xF8, 0x0F, 0x80, 0x00, 0xFC,
  0x07, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00,
  0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x1F, 0x81, 0xF0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x1F, 0xC0, 0x7C, 0x00,
  0x3F, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0x0F, 0xF8, 0x07, 0xE0, 0x07, 0xE0,
  0x3F, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x7C, 0x3F,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x7C, 0x3C, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07, 0x87, 0xC0, 0x00,
  0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F,
  0x87, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x78, 0x7C, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0xF8, 0x78, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x7C,
  0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3E, 0x07,
  0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0x7F, 0x80, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x01, 0xFE, 0x03, 0xE0, 0x00, 0x7E, 0x03,
  0xE0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0xFC, 0x0F,
  0x80, 0x01, 0xF8, 0x0F, 0x80, 0x03, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x7C, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x07, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x7E, 0x01,
  0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x03,
  0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x78,
  0x00, 0x01, 0xF0, 0x78, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x03, 0xE0, 0x7E, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x3C, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x1E, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0x80,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x3C, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x07,
  0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0xF8, 0x78,
  0x00, 0x07, 0xC1, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x01,
  0xF0, 0x1F, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0xF0,
  0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x00,
  0xF8, 0x03, 0xE0, 0x03, 0xE0, 0x0F, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0x81,
  0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7C, 0x7C, 0x00,
  0x01, 0xF1, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x1F, 0x3C, 0x00, 0x00,
  0x3D, 0xF0, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xE7, 0xC0,
  0x1F, 0x00, 0x7C, 0xF8, 0x03, 0xE0, 0x0F, 0x9E, 0x00, 0xFC, 0x01, 0xE3,
  0xC0, 0x1F, 0x80, 0x3C, 0x78, 0x03, 0xF0, 0x0F, 0x8F, 0x00, 0xFE, 0x01,
  0xF1, 0xE0, 0x1D, 0xC0, 0x3C, 0x3C, 0x03, 0xB8, 0x07, 0x87, 0x80, 0x77,
  0x01, 0xF0, 0xF0, 0x1C, 0xE0, 0x3C, 0x1E, 0x03, 0x9C, 0x07, 0x83, 0xC0,
  0x73, 0x80, 0xF0, 0x78, 0x1E, 0x70, 0x3E, 0x0F, 0x03, 0x8E, 0x07, 0x81,
  0xE0, 0x71, 0xC0, 0xF0, 0x7C, 0x1E, 0x38, 0x3E, 0x0F, 0x83, 0x87, 0x07,
  0x81, 0xF0, 0x70, 0xE0, 0xF0, 0x3E, 0x0E, 0x1C, 0x1E, 0x07, 0xC3, 0xC3,
  0x87, 0xC0, 0xF8, 0x70, 0x70, 0xF0, 0x1F, 0x0E, 0x1E, 0x1E, 0x03, 0xC3,
  0xC3, 0xC3, 0xC0, 0x78, 0x70, 0x78, 0xF8, 0x0F, 0x0E, 0x0E, 0x1E, 0x01,
  0xE1, 0xC1, 0xC3, 0xC0, 0x3C, 0x78, 0x38, 0xF8, 0x07, 0x8E, 0x07, 0x1E,
  0x00, 0xF1, 0xC0, 0xE3, 0xC0, 0x1E, 0x78, 0x1C, 0x78, 0x03, 0xCE, 0x03,
  0x9F, 0x00, 0x79, 0xC0, 0x73, 0xC0, 0x0F, 0x38, 0x0E, 0x78, 0x01, 0xEF,
  0x01, 0xCF, 0x00, 0x3D, 0xC0, 0x3B, 0xC0, 0x07, 0xB8, 0x07, 0x78, 0x00,
  0xFF, 0x00, 0xEF, 0x00, 0x1F, 0xC0, 0x1D, 0xE0, 0x03, 0xF8, 0x03, 0xF8,
  0x00, 0xF7, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0xF8, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x03, 0xF0,
  0xF8, 0x00, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0x03, 0xF0, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00,
  0x7C, 0x7C, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x07,
  0xC0, 0x1F, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x1F,
  0x00, 0x0F, 0x80, 0x3E, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xE1, 0xF0,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xDE, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF9, 0xE0, 0x00, 0x3C,
  0x78, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x83, 0xC0, 0x03, 0xC0, 0xF0, 0x01,
  0xF0, 0x3E, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0x78,
  0x07, 0x80, 0x0F, 0x03, 0xE0, 0x03, 0xC1, 0xF0, 0x00, 0xF0, 0x78, 0x00,
  0x3E, 0x3E, 0x00, 0x07, 0x9F, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF0,
  0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0xE0, 0x78, 0x03, 0xFF,
  0xC7, 0xC0, 0x3F, 0xFF, 0x3E, 0x03, 0xFF, 0xFD, 0xF0, 0x3F, 0x81, 0xEF,
  0x83, 0xF0, 0x03, 0x7C, 0x3F, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x7E, 0x1F,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x3C, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x1E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x1F, 0x1F,
  0x00, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x0F,
  0xC3, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x3F, 0x07,
  0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0xC0, 0xFF, 0xFF, 0xBE, 0x03, 0xFF,
  0xF9, 0xE0, 0x0F, 0xFF, 0x9F, 0x00, 0x3F, 0xF0, 0xF8, 0x00, 0x18, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x3F, 0xC0, 0x07, 0xC3,
  0xFF, 0x80, 0x1F, 0x3F, 0xFF, 0x80, 0x7D, 0xFF, 0xFE, 0x01, 0xFF, 0x83,
  0xFC, 0x07, 0xB0, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x0F,
  0x83, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x7C,
  0x00, 0x03, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00,
  0x78, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x1F, 0x07,
  0xF0, 0x00, 0xF8, 0x1F, 0xC0, 0x07, 0xE0, 0x7F, 0xC0, 0x7F, 0x01, 0xF7,
  0xFF, 0xF8, 0x07, 0x9F, 0xFF, 0xC0, 0x3E, 0x3F, 0xFE, 0x00, 0xF8, 0x7F,
  0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xC1, 0xFE,
  0x03, 0xF0, 0x03, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x3E, 0x1F,
  0x80, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x3C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x3F, 0x07,
  0xE0, 0x03, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0x07, 0xC0,
  0x07, 0xFF, 0x8F, 0x80, 0x1F, 0xFF, 0x9F, 0x00, 0x7F, 0xFF, 0xBE, 0x01,
  0xFC, 0x0F, 0x7C, 0x07, 0xE0, 0x06, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x3E,
  0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x3E, 0x07, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x1F, 0x03, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0xF8,
  0x0F, 0x80, 0x03, 0xF0, 0x1F, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xDF, 0x00, 0x7F, 0xFF, 0x3C, 0x00,
  0x7F, 0xFC, 0xF8, 0x00, 0x7F, 0xE1, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xC0, 0x03,
  0xE0, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x1F,
  0x00, 0x01, 0xF1, 0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x1F, 0x3E, 0x00, 0x01, 0xE3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFE, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x10, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x78, 0x03, 0xFF, 0xC7, 0xC0, 0x3F, 0xFF,
  0x3E, 0x03, 0xFF, 0xFD, 0xF0, 0x3F, 0x81, 0xEF, 0x83, 0xF0, 0x03, 0xFC,
  0x3F, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF0, 0xF8,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x3C, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x1E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C,
  0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xF8, 0xF8,
  0x00, 0x07, 0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x1F, 0x0F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0xC1, 0xF0, 0x01, 0xBC,
  0x0F, 0xC0, 0x1F, 0xE0, 0x7F, 0xC7, 0xDF, 0x01, 0xFF, 0xFE, 0xF8, 0x07,
  0xFF, 0xE7, 0xC0, 0x1F, 0xFC, 0x3E, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF0, 0x7F, 0xC0, 0x07, 0xC7, 0xFF, 0xC0, 0x1F,
  0x3F, 0xFF, 0x80, 0x7D, 0xFF, 0xFE, 0x01, 0xFF, 0x01, 0xFC, 0x07, 0xF0,
  0x03, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F,
  0x83, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x07, 0xC1, 0xE0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0xF8, 0x3C, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C,
  0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07,
  0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x3C, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x03,
  0xF0, 0x0F, 0x80, 0x03, 0xF0, 0x07, 0xC0, 0x03, 0xF0, 0x03, 0xE0, 0x01,
  0xF0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x01,
  0xF8, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x1F, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3C, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x07,
  0xC0, 0x0F, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF8, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x3E, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0xFC,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x03,
  0xFF, 0xF8, 0x07, 0x8F, 0xC0, 0xF8, 0x07, 0x9F, 0xE3, 0xFE, 0x0F, 0xBF,
  0xE7, 0xFE, 0x0F, 0xFF, 0xF7, 0xFF, 0x0F, 0xC1, 0xFC, 0x3F, 0x0F, 0x80,
  0xF8, 0x1F, 0x0F, 0x80, 0xF0, 0x1F, 0x0F, 0x00, 0xF0, 0x1F, 0x0F, 0x00,
  0xF0, 0x1F, 0x1F, 0x01, 0xF0, 0x1F, 0x1F, 0x01, 0xE0, 0x1E, 0x1F, 0x01,
  0xE0, 0x1E, 0x1E, 0x01, 0xE0, 0x1E, 0x1E, 0x01, 0xE0, 0x3E, 0x1E, 0x01,
  0xE0, 0x3E, 0x3E, 0x03, 0xE0, 0x3E, 0x3E, 0x03, 0xC0, 0x3C, 0x3E, 0x03,
  0xC0, 0x3C, 0x3E, 0x03, 0xC0, 0x3C, 0x3C, 0x03, 0xC0, 0x7C, 0x3C, 0x03,
  0xC0, 0x7C, 0x7C, 0x03, 0xC0, 0x7C, 0x7C, 0x07, 0x80, 0x7C, 0x7C, 0x07,
  0x80, 0x78, 0x7C, 0x07, 0x80, 0x78, 0x78, 0x07, 0x80, 0x78, 0x78, 0x07,
  0x80, 0xF8, 0x78, 0x07, 0x80, 0xF8, 0xF8, 0x0F, 0x80, 0xF8, 0xF8, 0x0F,
  0x00, 0xF0, 0xF8, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x00, 0xF0, 0xF0, 0x0F,
  0x01, 0xF0, 0xF0, 0x0F, 0x01, 0xF0, 0x03, 0xC1, 0xFF, 0x00, 0x1F, 0x1F,
  0xFF, 0x00, 0x7C, 0xFF, 0xFE, 0x01, 0xF7, 0xFF, 0xF8, 0x07, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xC1, 0xF0,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x78, 0x3E, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8,
  0x3E, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x7C, 0x1F,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x7C, 0x1E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0x83, 0xE0, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x7E, 0x00, 0x7E, 0x0F,
  0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x1F, 0x80, 0x01, 0xF1, 0xF0, 0x00,
  0x1F, 0x1F, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x3E, 0x3E, 0x00,
  0x03, 0xE3, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E,
  0x7C, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0x7C, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x0F,
  0x87, 0xC0, 0x01, 0xF0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x0F, 0xE0, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x3F, 0xC0, 0x01, 0xF1, 0xFF,
  0xF0, 0x01, 0xF3, 0xFF, 0xF8, 0x01, 0xF7, 0xFF, 0xF8, 0x01, 0xFF, 0x83,
  0xFC, 0x01, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x3E, 0x03, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0x80, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0x78, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x01,
  0xF0, 0x1F, 0x80, 0x01, 0xF0, 0x1F, 0xC0, 0x03, 0xE0, 0x1F, 0xC0, 0x07,
  0xE0, 0x1F, 0xF0, 0x1F, 0xC0, 0x1F, 0x7F, 0xFF, 0x80, 0x1E, 0x7F, 0xFF,
  0x80, 0x3E, 0x3F, 0xFE, 0x00, 0x3E, 0x1F, 0xFC, 0x00, 0x3E, 0x01, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0xF8, 0x03, 0xFF, 0xC7,
  0xC0, 0x3F, 0xFF, 0x3E, 0x07, 0xFF, 0xFD, 0xF0, 0x3F, 0x81, 0xEF, 0x83,
  0xF0, 0x03, 0x7C, 0x3F, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x7E, 0x1F, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x3C, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x1E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x1F, 0x1F, 0x00,
  0x00, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0xC3,
  0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x3F, 0x07, 0xE0,
  0x03, 0xF8, 0x3F, 0x80, 0x77, 0xC0, 0xFF, 0xFF, 0xBE, 0x03, 0xFF, 0xF9,
  0xE0, 0x1F, 0xFF, 0x9F, 0x00, 0x3F, 0xF0, 0xF8, 0x00, 0x18, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xC1, 0xFF, 0x00, 0x1F, 0x1F, 0xFF, 0x00, 0x7C, 0xFF, 0xFE,
  0x01, 0xF7, 0xFF, 0xFC, 0x07, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x0F, 0xE0,
  0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0xF8, 0x3E,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0xF8, 0x3C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x07,
  0xF8, 0x0F, 0xF0, 0x7C, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00,
  0x1F, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF8, 0xFC,
  0x00, 0x1F, 0x8F, 0xE0, 0x03, 0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x7C,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x0F, 0x87, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3E,
  0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x3E,
  0x00, 0x03, 0xE1, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xF0, 0xF8, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F,
  0x0F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x7C, 0x3E,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00,
  0x07, 0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x3E,
  0x07, 0xE0, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x7C, 0x78,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01,
  0xF0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x3C, 0x00, 0x7C, 0x03,
  0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF0, 0x01, 0xE0, 0x1F, 0x00, 0x1E, 0x01, 0xE0, 0x01, 0xE0, 0x3E, 0x00,
  0x1F, 0x03, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF0,
  0xF8, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF1, 0xF0, 0x00, 0x0F, 0x9F, 0x00,
  0x00, 0xFB, 0xE0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xF0, 0x07, 0xC0, 0x0F, 0xF0, 0x07, 0xC0, 0x1F, 0xF0, 0x07, 0xC0,
  0x1E, 0xF0, 0x0F, 0xC0, 0x1E, 0xF0, 0x0F, 0xC0, 0x3E, 0xF0, 0x0F, 0xC0,
  0x3C, 0xF0, 0x1F, 0xC0, 0x3C, 0xF0, 0x1D, 0xC0, 0x7C, 0xF0, 0x1D, 0xC0,
  0x78, 0xF0, 0x3D, 0xC0, 0x78, 0xF0, 0x39, 0xC0, 0x78, 0xF0, 0x39, 0xC0,
  0xF0, 0xF0, 0x39, 0xC0, 0xF0, 0xF0, 0x71, 0xC0, 0xF0, 0xF0, 0x71, 0xC1,
  0xE0, 0xF0, 0x71, 0xC1, 0xE0, 0xF0, 0xE1, 0xC1, 0xE0, 0xF0, 0xE1, 0xC3,
  0xC0, 0xF0, 0xE1, 0xC3, 0xC0, 0xF1, 0xC1, 0xC3, 0xC0, 0xF1, 0xC1, 0xC7,
  0x80, 0xF1, 0xC1, 0xC7, 0x80, 0xF3, 0x81, 0xC7, 0x80, 0xF3, 0x81, 0xCF,
  0x00, 0xF3, 0x81, 0xCF, 0x00, 0xF7, 0x01, 0xCF, 0x00, 0xF7, 0x01, 0xCE,
  0x00, 0xF7, 0x01, 0xDE, 0x00, 0xFE, 0x01, 0xDE, 0x00, 0xFE, 0x01, 0xDC,
  0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0xFC, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7C, 0x00,
  0x07, 0xE0, 0x1F, 0x80, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x00,
  0xF8, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x01, 0xF0, 0xFC, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x0F, 0x9F, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x0F,
  0xCF, 0x80, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00,
  0xF8, 0x1F, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x1F, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01,
  0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F,
  0x87, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x1E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x0F,
  0x00, 0x00, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x1F,
  0x83, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F, 0xFF, 0xDF, 0x01,
  0xFF, 0xFC, 0xF8, 0x07, 0xFF, 0xC7, 0xC0, 0x1F, 0xFC, 0x3E, 0x00, 0x04,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x01, 0xF0, 0xFF, 0xE0, 0x07, 0xC7, 0xFF, 0xC0, 0x1E, 0x3F,
  0xFF, 0x00, 0x79, 0xF0, 0x7E, 0x01, 0xE7, 0xC0, 0xFC, 0x0F, 0x9E, 0x01,
  0xF8, 0x3E, 0x78, 0x03, 0xFF, 0xF1, 0xE0, 0x0F, 0xFF, 0x8F, 0x80, 0x1F,
  0xFC, 0x3E, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x08, 0x00,
};

const GFXglyph JetBrainsMono_LightItalic61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 37, 0, -1 },
  { 1, 14, 45, 37, 12, -45 },
  { 80, 20, 19, 37, 12, -45 },
  { 128, 36, 45, 37, 1, -45 },
  { 331, 32, 62, 37, 3, -53 },
  { 579, 42, 45, 37, -2, -45 },
  { 816, 33, 46, 37, 2, -45 },
  { 1006, 8, 19, 37, 17, -45 },
  { 1025, 25, 60, 37, 10, -52 },
  { 1213, 25, 60, 37, 3, -52 },
  { 1401, 32, 31, 37, 3, -37 },
  { 1525, 29, 28, 37, 4, -34 },
  { 1627, 15, 19, 37, 6, -9 },
  { 1663, 20, 4, 37, 9, -22 },
  { 1673, 11, 10, 37, 11, -9 },
  { 1687, 36, 58, 37, 1, -51 },
  { 1948, 31, 46, 37, 4, -45 },
  { 2127, 28, 45, 37, 3, -45 },
  { 2285, 31, 45, 37, 3, -45 },
  { 2460, 31, 46, 37, 3, -45 },
  { 2639, 29, 45, 37, 4, -45 },
  { 2803, 30, 46, 37, 4, -45 },
  { 2976, 29, 46, 37, 3, -45 },
  { 3143, 30, 45, 37, 7, -45 },
  { 3312, 31, 46, 37, 3, -45 },
  { 3491, 29, 45, 37, 6, -45 },
  { 3655, 15, 35, 37, 11, -34 },
  { 3721, 20, 44, 37, 6, -34 },
  { 3831, 29, 32, 37, 5, -36 },
  { 3947, 29, 19, 37, 4, -30 },
  { 4016, 29, 32, 37, 3, -36 },
  { 4132, 24, 45, 37, 9, -45 },
  { 4267, 36, 56, 37, 1, -45 },
  { 4519, 30, 45, 37, 1, -45 },
  { 4688, 31, 45, 37, 3, -45 },
  { 4863, 31, 46, 37, 4, -45 },
  { 5042, 31, 45, 37, 3, -45 },
  { 5217, 32, 45, 37, 4, -45 },
  { 5397, 33, 45, 37, 3, -45 },
  { 5583, 31, 46, 37, 4, -45 },
  { 5762, 32, 45, 37, 3, -45 },
  { 5942, 30, 45, 37, 4, -45 },
  { 6111, 33, 46, 37, 1, -45 },
  { 6301, 35, 45, 37, 3, -45 },
  { 6498, 27, 45, 37, 4, -45 },
  { 6650, 34, 45, 37, 2, -45 },
  { 6842, 32, 45, 37, 3, -45 },
  { 7022, 30, 46, 37, 4, -45 },
  { 7195, 33, 45, 37, 3, -45 },
  { 7381, 30, 56, 37, 4, -45 },
  { 7591, 32, 45, 37, 3, -45 },
  { 7771, 32, 46, 37, 3, -45 },
  { 7955, 31, 45, 37, 7, -45 },
  { 8130, 31, 46, 37, 4, -45 },
  { 8309, 30, 45, 37, 8, -45 },
  { 8478, 35, 45, 37, 4, -45 },
  { 8675, 38, 45, 37, 0, -45 },
  { 8889, 32, 45, 37, 7, -45 },
  { 9069, 32, 45, 37, 3, -45 },
  { 9249, 24, 58, 37, 9, -51 },
  { 9423, 18, 58, 37, 10, -51 },
  { 9554, 24, 58, 37, 5, -51 },
  { 9728, 26, 24, 37, 6, -45 },
  { 9806, 30, 4, 37, 0, 2 },
  { 9821, 11, 9, 37, 16, -48 },
  { 9834, 29, 35, 37, 4, -34 },
  { 9961, 30, 46, 37, 3, -45 },
  { 10134, 29, 35, 37, 4, -34 },
  { 10261, 31, 46, 37, 4, -45 },
  { 10440, 28, 35, 37, 4, -34 },
  { 10563, 41, 56, 37, -3, -45 },
  { 10850, 29, 45, 37, 4, -34 },
  { 11014, 30, 45, 37, 3, -45 },
  { 11183, 29, 47, 37, 2, -47 },
  { 11354, 31, 58, 37, 1, -47 },
  { 11579, 33, 45, 37, 3, -45 },
  { 11765, 25, 45, 37, 6, -45 },
  { 11906, 32, 34, 37, 2, -34 },
  { 12042, 30, 34, 37, 3, -34 },
  { 12170, 28, 35, 37, 4, -34 },
  { 12293, 32, 45, 37, 1, -34 },
  { 12473, 29, 45, 37, 4, -34 },
  { 12637, 30, 34, 37, 4, -34 },
  { 12765, 28, 35, 37, 4, -34 },
  { 12888, 28, 43, 37, 6, -43 },
  { 13039, 29, 35, 37, 4, -34 },
  { 13166, 28, 34, 37, 7, -34 },
  { 13285, 32, 34, 37, 5, -34 },
  { 13421, 34, 34, 37, 1, -34 },
  { 13566, 29, 45, 37, 4, -34 },
  { 13730, 30, 34, 37, 3, -34 },
  { 13858, 30, 58, 37, 6, -51 },
  { 14076, 14, 58, 37, 12, -51 },
  { 14178, 30, 58, 37, 2, -51 },
  { 14396, 30, 13, 37, 4, -28 },
};

const GFXfont JetBrainsMono_LightItalic61pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_LightItalic61pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_LightItalic61pt7bGlyphs,
  0x20, 0x7E, 81
};

#endif // _JETBRAINSMONO_LIGHTITALIC61PT7B_H_
