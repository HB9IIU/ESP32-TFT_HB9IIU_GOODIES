#ifndef _JETBRAINSMONO_LIGHTITALIC33PT7B_H_
#define _JETBRAINSMONO_LIGHTITALIC33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-LightItalic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_LightItalic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0C, 0x0C, 0x1C, 0x1C,
  0x1C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x00, 0x00, 0x00, 0x30, 0x78, 0xF8,
  0x70, 0x70, 0xEE, 0x1D, 0xC3, 0xB8, 0x67, 0x1C, 0xC3, 0x98, 0x77, 0x0E,
  0xE1, 0x9C, 0x30, 0x00, 0xE0, 0xC0, 0x18, 0x18, 0x03, 0x07, 0x00, 0xE0,
  0xC0, 0x18, 0x18, 0x03, 0x07, 0x00, 0xE0, 0xC1, 0xFF, 0xFF, 0x3F, 0xFF,
  0xE0, 0xE0, 0xC0, 0x18, 0x18, 0x03, 0x06, 0x00, 0xC0, 0xC0, 0x18, 0x38,
  0x03, 0x06, 0x07, 0xFF, 0xF8, 0xFF, 0xFF, 0x03, 0x06, 0x00, 0xC0, 0xC0,
  0x18, 0x38, 0x03, 0x06, 0x00, 0xC0, 0xC0, 0x18, 0x38, 0x07, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x1F,
  0xE0, 0x1F, 0xF8, 0x1C, 0xCE, 0x1C, 0x67, 0x0E, 0x31, 0x86, 0x10, 0xC7,
  0x18, 0x03, 0x8C, 0x00, 0xE6, 0x00, 0x7B, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0x6F, 0x00, 0x33, 0xC0, 0x18, 0xE0, 0x0C, 0x70, 0x06,
  0x39, 0xC2, 0x1C, 0xE3, 0x0C, 0x71, 0x8E, 0x1C, 0xDE, 0x0F, 0xFE, 0x01,
  0xFE, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0x03, 0xE0, 0x0E, 0x0F, 0xE0, 0x30, 0x30, 0xC0, 0xC0, 0x61, 0x83,
  0x81, 0xC3, 0x06, 0x03, 0x06, 0x18, 0x06, 0x0C, 0x60, 0x0C, 0x39, 0x80,
  0x1C, 0xE6, 0x00, 0x1F, 0x9C, 0x00, 0x1E, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x78, 0x00, 0x33, 0xF8, 0x00, 0xEE, 0x38, 0x03,
  0x98, 0x30, 0x06, 0x30, 0xE0, 0x18, 0x61, 0xC0, 0x61, 0xC3, 0x01, 0x83,
  0x86, 0x06, 0x07, 0x1C, 0x1C, 0x07, 0xF0, 0x70, 0x07, 0xC0, 0x01, 0xFC,
  0x00, 0xFF, 0x80, 0x70, 0xF0, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x7E,
  0x00, 0x39, 0xC1, 0xDC, 0x70, 0xE7, 0x0E, 0x71, 0x83, 0x98, 0x60, 0x7E,
  0x38, 0x0F, 0x0E, 0x03, 0x83, 0x80, 0xF0, 0xE0, 0x7C, 0x3C, 0x7B, 0x87,
  0xFC, 0xE0, 0xFC, 0x1C, 0x3B, 0x9C, 0xE7, 0x39, 0x8C, 0x67, 0x00, 0x00,
  0x04, 0x00, 0xF0, 0x07, 0xC0, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0x70, 0x03,
  0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x60, 0x04, 0x00, 0x38, 0x03, 0xE0,
  0x07, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x7C, 0x03, 0xC0, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x03, 0x06, 0x1F,
  0xF2, 0x7E, 0xFD, 0x7E, 0x0F, 0xF8, 0x00, 0xC0, 0x00, 0xF0, 0x01, 0xDC,
  0x01, 0xC7, 0x00, 0xE3, 0x80, 0xE0, 0xE0, 0xE0, 0x70, 0x20, 0x10, 0x00,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x0F, 0x87, 0x83, 0x83,
  0xC1, 0xC1, 0xC0, 0xE0, 0xE0, 0x70, 0x70, 0x00, 0xFF, 0xFF, 0xF8, 0x39,
  0xEF, 0xFE, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0x03, 0x83, 0xC3,
  0x80, 0xE1, 0x80, 0x31, 0xC0, 0x18, 0xE0, 0x0C, 0x70, 0x06, 0x30, 0x07,
  0x18, 0x03, 0x9C, 0x71, 0xCE, 0x78, 0xE7, 0x1C, 0x63, 0x8E, 0x31, 0x80,
  0x38, 0xC0, 0x1C, 0xE0, 0x0E, 0x70, 0x07, 0x38, 0x03, 0x1C, 0x03, 0x8E,
  0x03, 0xC3, 0xC3, 0xC0, 0xFF, 0xC0, 0x3F, 0x80, 0x00, 0xF8, 0x03, 0xE0,
  0x1E, 0xC0, 0x7B, 0x81, 0xC7, 0x03, 0x0E, 0x08, 0x1C, 0x00, 0x30, 0x00,
  0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x30, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFC, 0x03, 0xFF, 0x03, 0x83, 0xC3,
  0x80, 0xE3, 0x80, 0x31, 0xC0, 0x18, 0xC0, 0x0C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x03, 0xFF, 0xF1, 0xFF, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF,
  0x10, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0,
  0x03, 0x80, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0xE0, 0x0C, 0xE0, 0x1C, 0xE0, 0x1C,
  0xE0, 0x38, 0x70, 0x70, 0x7F, 0xE0, 0x3F, 0xC0, 0x00, 0x0F, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x0E, 0x1C, 0x0E, 0x38, 0x0E, 0x38, 0x0E,
  0x70, 0x0C, 0x60, 0x0C, 0x7F, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x0F, 0xFF, 0x0F, 0xFF,
  0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x38, 0xF0, 0x3B, 0xFC, 0x3F, 0x7C, 0x3C, 0x1E, 0x38, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0xE0, 0x1C,
  0xE0, 0x38, 0x70, 0x78, 0x3F, 0xF0, 0x1F, 0xC0, 0x00, 0x3C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x39, 0xE0, 0x7F, 0xF1, 0xF3, 0xE7, 0x81, 0xEE, 0x01, 0xD8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xEE, 0x01, 0xCF,
  0x0F, 0x0F, 0xFC, 0x0F, 0xE0, 0x7F, 0xFF, 0x7F, 0xFF, 0x60, 0x07, 0xE0,
  0x0E, 0xE0, 0x0C, 0xE0, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x03, 0xFC, 0x07, 0xFE, 0x0E, 0x0F, 0x1C,
  0x07, 0x1C, 0x03, 0x18, 0x03, 0x18, 0x07, 0x18, 0x06, 0x1C, 0x0E, 0x0E,
  0x1C, 0x07, 0xF0, 0x03, 0xE0, 0x0F, 0xF0, 0x1C, 0x38, 0x38, 0x1C, 0x70,
  0x0C, 0x60, 0x0E, 0xE0, 0x0E, 0xE0, 0x0C, 0xE0, 0x1C, 0xE0, 0x1C, 0x70,
  0x78, 0x7F, 0xF0, 0x1F, 0xC0, 0x07, 0xF8, 0x0F, 0xFC, 0x1E, 0x1E, 0x38,
  0x0E, 0x70, 0x07, 0x70, 0x07, 0x60, 0x07, 0x60, 0x07, 0xE0, 0x06, 0xE0,
  0x0E, 0x70, 0x0E, 0x70, 0x1C, 0x7E, 0xFC, 0x3F, 0xF8, 0x0F, 0x70, 0x00,
  0x60, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x1E, 0x3F, 0x3F, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x78, 0xF8, 0xF8, 0xF8, 0x03,
  0xC0, 0xFC, 0x1F, 0x81, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0x80,
  0xF0, 0x1C, 0x03, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x01, 0x00, 0x06, 0x00,
  0x1E, 0x00, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF0,
  0x00, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x18, 0x00, 0x08, 0x3F, 0xFF, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0xFF, 0xFE, 0x20, 0x00, 0x60, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0x78, 0x00, 0xC0, 0x01, 0x00,
  0x00, 0x3F, 0x81, 0xFF, 0x00, 0x7C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x38, 0x3F, 0x81, 0xF8, 0x1E, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x7C,
  0x03, 0xE0, 0x1E, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0x80, 0xE0,
  0x70, 0x0E, 0x0E, 0x00, 0x60, 0xC0, 0x07, 0x1C, 0x00, 0x71, 0x80, 0x07,
  0x18, 0x1F, 0x63, 0x83, 0xF6, 0x38, 0x70, 0xE3, 0x86, 0x0E, 0x30, 0xE0,
  0xE3, 0x0E, 0x0E, 0x30, 0xC0, 0xC3, 0x0C, 0x0C, 0x70, 0xC0, 0xC7, 0x0C,
  0x1C, 0x61, 0xC1, 0xC6, 0x0C, 0x3C, 0x60, 0xFF, 0x86, 0x07, 0xD8, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x0D, 0x80, 0x06, 0xE0, 0x07, 0x70, 0x03, 0x38, 0x03, 0x9C,
  0x01, 0x8E, 0x01, 0xC3, 0x00, 0xE1, 0x80, 0x60, 0xC0, 0x70, 0x60, 0x30,
  0x30, 0x38, 0x1C, 0x1F, 0xFE, 0x0F, 0xFF, 0x0E, 0x03, 0x86, 0x01, 0xC7,
  0x00, 0x63, 0x80, 0x33, 0x80, 0x19, 0xC0, 0x0D, 0xC0, 0x07, 0x1F, 0xFC,
  0x0F, 0xFF, 0x07, 0x07, 0xC3, 0x80, 0xE1, 0x80, 0x70, 0xC0, 0x18, 0x60,
  0x0C, 0x70, 0x0E, 0x38, 0x06, 0x1C, 0x07, 0x0F, 0xFF, 0x07, 0xFE, 0x03,
  0xFF, 0xC3, 0x80, 0xF1, 0xC0, 0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x30, 0x07,
  0x18, 0x03, 0x9C, 0x03, 0x8E, 0x01, 0xC7, 0x07, 0xC3, 0xFF, 0xC1, 0xFF,
  0x80, 0x03, 0xFC, 0x03, 0xFF, 0x03, 0xC3, 0xC3, 0x80, 0xE1, 0xC0, 0x30,
  0xC0, 0x18, 0xE0, 0x0C, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x30, 0x07, 0x18, 0x03, 0x0C, 0x03, 0x87, 0x01, 0xC3, 0xC3, 0xC0,
  0xFF, 0xC0, 0x3F, 0x80, 0x1F, 0xF8, 0x1F, 0xFC, 0x1C, 0x1E, 0x1C, 0x0F,
  0x18, 0x07, 0x18, 0x07, 0x18, 0x07, 0x38, 0x07, 0x38, 0x07, 0x38, 0x07,
  0x38, 0x06, 0x30, 0x06, 0x30, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E,
  0x70, 0x0C, 0x60, 0x0C, 0x60, 0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0xE1, 0xF0,
  0xFF, 0xE0, 0xFF, 0x80, 0x0F, 0xFF, 0x87, 0xFF, 0xC7, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0F, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0xC1, 0x80, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x03, 0xFF, 0xF1, 0xFF, 0xF8, 0x0F, 0xFF, 0xC7, 0xFF, 0xE1,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xF8, 0x3F, 0xFE,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0x03, 0xFC, 0x03, 0xFF, 0x03, 0xC3, 0xC3, 0x80, 0xE1, 0xC0, 0x30,
  0xC0, 0x18, 0xE0, 0x0C, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x07, 0x0F, 0xE3, 0x8F, 0xF1, 0xC0, 0x38, 0xE0, 0x1C, 0x60,
  0x0E, 0x30, 0x07, 0x18, 0x03, 0x0C, 0x03, 0x87, 0x01, 0xC3, 0xC3, 0xC0,
  0xFF, 0xC0, 0x3F, 0x80, 0x1C, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x80,
  0x61, 0x80, 0x30, 0xC0, 0x38, 0x60, 0x1C, 0x70, 0x0E, 0x38, 0x07, 0x1C,
  0x03, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE3, 0x80, 0x71, 0xC0, 0x38,
  0xE0, 0x18, 0x70, 0x0C, 0x30, 0x06, 0x18, 0x07, 0x1C, 0x03, 0x8E, 0x01,
  0xC7, 0x00, 0xE3, 0x80, 0x61, 0x80, 0x70, 0x0F, 0xFF, 0x87, 0xFF, 0x80,
  0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x38, 0x03, 0xFF, 0xE1, 0xFF, 0xF0, 0x00, 0x7F,
  0xC0, 0x1F, 0xE0, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E,
  0x38, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x70, 0xE0, 0x1C, 0x1E, 0x1E, 0x07,
  0xFF, 0x00, 0x7F, 0x00, 0x1C, 0x01, 0xC7, 0x00, 0xE1, 0xC0, 0x38, 0x70,
  0x1C, 0x18, 0x0E, 0x06, 0x03, 0x81, 0x81, 0xC0, 0xE0, 0xE0, 0x38, 0x38,
  0x0E, 0x1C, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1C, 0x38, 0x07,
  0x07, 0x01, 0xC1, 0xC0, 0x70, 0x70, 0x18, 0x0E, 0x06, 0x03, 0x83, 0x80,
  0xE0, 0xE0, 0x1C, 0x38, 0x07, 0x0E, 0x01, 0xC3, 0x00, 0x38, 0x0E, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0C, 0x00, 0x5F, 0xFF, 0x7F, 0xFE, 0x0F, 0x01, 0xE1, 0xE0, 0x78,
  0x3C, 0x0F, 0x0D, 0x83, 0x61, 0xB0, 0x6C, 0x36, 0x1B, 0x86, 0x63, 0x60,
  0xCC, 0xCC, 0x19, 0x99, 0x87, 0x36, 0x30, 0xE6, 0xCE, 0x1C, 0xF9, 0xC3,
  0x8E, 0x38, 0x60, 0x06, 0x0C, 0x00, 0xC1, 0x80, 0x38, 0x70, 0x07, 0x0E,
  0x00, 0xE1, 0xC0, 0x1C, 0x30, 0x03, 0x06, 0x00, 0x60, 0xC0, 0x0C, 0x38,
  0x03, 0x87, 0x00, 0x70, 0x1E, 0x03, 0x8F, 0x01, 0xC7, 0xC0, 0xE3, 0xE0,
  0x61, 0xB0, 0x30, 0xD8, 0x18, 0xEC, 0x1C, 0x77, 0x0E, 0x3B, 0x87, 0x1C,
  0xC3, 0x8C, 0x61, 0x86, 0x30, 0xC7, 0x1C, 0x63, 0x86, 0x71, 0xC3, 0x38,
  0xE1, 0x9C, 0x60, 0xCC, 0x30, 0x76, 0x18, 0x1B, 0x1C, 0x0D, 0x8E, 0x07,
  0xC7, 0x03, 0xE3, 0x01, 0xE1, 0x80, 0x70, 0x03, 0xFC, 0x07, 0xFE, 0x0F,
  0x0F, 0x1C, 0x07, 0x1C, 0x07, 0x18, 0x03, 0x38, 0x07, 0x38, 0x07, 0x38,
  0x07, 0x38, 0x07, 0x30, 0x06, 0x30, 0x06, 0x70, 0x06, 0x70, 0x0E, 0x70,
  0x0E, 0x70, 0x0E, 0x60, 0x0E, 0x60, 0x0C, 0x60, 0x1C, 0xE0, 0x1C, 0x70,
  0x38, 0x78, 0x78, 0x3F, 0xF0, 0x1F, 0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0xC1,
  0xC0, 0xF8, 0x70, 0x0E, 0x18, 0x03, 0x86, 0x00, 0x61, 0x80, 0x18, 0xE0,
  0x0E, 0x38, 0x03, 0x8E, 0x01, 0xC3, 0x80, 0x70, 0xC1, 0xF8, 0x3F, 0xFC,
  0x1F, 0xFC, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x00, 0x03, 0xFC, 0x03, 0xFF, 0x03, 0xC3, 0xC3, 0x80, 0xE1, 0x80, 0x31,
  0xC0, 0x18, 0xE0, 0x0C, 0x70, 0x0E, 0x30, 0x07, 0x18, 0x03, 0x8C, 0x01,
  0xCE, 0x00, 0xC7, 0x00, 0x63, 0x80, 0x31, 0xC0, 0x38, 0xC0, 0x1C, 0x60,
  0x0E, 0x70, 0x07, 0x38, 0x03, 0x1C, 0x03, 0x87, 0x03, 0x83, 0xC3, 0xC0,
  0xFF, 0xC0, 0x3F, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x1F, 0xFC, 0x0F, 0xFF, 0x07, 0x03, 0xC3,
  0x80, 0xF1, 0x80, 0x38, 0xC0, 0x1C, 0x60, 0x0E, 0x70, 0x07, 0x38, 0x03,
  0x1C, 0x03, 0x8E, 0x03, 0x87, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x01, 0xC3,
  0x80, 0xE0, 0xE0, 0x70, 0x70, 0x30, 0x38, 0x18, 0x0E, 0x1C, 0x07, 0x0E,
  0x03, 0x87, 0x00, 0xE3, 0x80, 0x71, 0x80, 0x38, 0x03, 0xFC, 0x03, 0xFF,
  0x03, 0x83, 0xC3, 0x80, 0xE1, 0xC0, 0x30, 0xC0, 0x18, 0xE0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x38, 0x03,
  0x9C, 0x01, 0x8E, 0x01, 0xC7, 0x83, 0xC1, 0xFF, 0xC0, 0x3F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x61, 0x80, 0x30, 0xC0, 0x18,
  0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x07, 0x1C, 0x03, 0x8C, 0x01, 0x86, 0x00,
  0xC7, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x1C, 0x70, 0x0C, 0x30,
  0x06, 0x18, 0x07, 0x0C, 0x03, 0x87, 0x03, 0x83, 0xC3, 0xC0, 0xFF, 0xC0,
  0x3F, 0x80, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x06, 0x60, 0x0E, 0x60, 0x0C,
  0x60, 0x1C, 0x60, 0x1C, 0x70, 0x38, 0x70, 0x38, 0x70, 0x30, 0x70, 0x70,
  0x70, 0x60, 0x70, 0xE0, 0x30, 0xE0, 0x30, 0xC0, 0x31, 0xC0, 0x31, 0x80,
  0x3B, 0x80, 0x3B, 0x80, 0x3B, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x70, 0x70, 0x6E, 0x1E, 0x1D, 0xC3, 0xC3, 0xB8, 0x78, 0x67,
  0x0B, 0x0C, 0xC3, 0x63, 0x98, 0x6C, 0x63, 0x09, 0x0C, 0x63, 0x23, 0x8C,
  0x64, 0x71, 0x8C, 0x8C, 0x31, 0x11, 0x86, 0x62, 0x70, 0xCC, 0x4C, 0x19,
  0x09, 0x83, 0x63, 0x30, 0x6C, 0x6E, 0x0D, 0x8D, 0x81, 0xA1, 0xB0, 0x3C,
  0x36, 0x0F, 0x87, 0x81, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0x0E,
  0x00, 0x70, 0x70, 0x0E, 0x07, 0x00, 0xC0, 0x30, 0x1C, 0x03, 0x83, 0x80,
  0x38, 0x70, 0x01, 0xC7, 0x00, 0x1C, 0xE0, 0x00, 0xDC, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x01, 0xF8,
  0x00, 0x39, 0x80, 0x07, 0x1C, 0x00, 0x70, 0xC0, 0x0E, 0x0E, 0x01, 0xC0,
  0xE0, 0x38, 0x06, 0x03, 0x80, 0x70, 0x70, 0x07, 0x0E, 0x00, 0x38, 0xC0,
  0x03, 0xF0, 0x03, 0x98, 0x03, 0x8C, 0x01, 0xC7, 0x01, 0xC3, 0x80, 0xC0,
  0xC0, 0xE0, 0x70, 0xE0, 0x38, 0x60, 0x0C, 0x70, 0x07, 0x70, 0x03, 0xB0,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0xFF, 0xE3, 0xFF, 0xF8, 0x07, 0xF8, 0x7F, 0x83,
  0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x01, 0xC0, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x00, 0xC0,
  0x70, 0x38, 0x1C, 0x06, 0x03, 0x01, 0xC0, 0xE0, 0x30, 0x18, 0x0E, 0x07,
  0x03, 0x80, 0xC0, 0x70, 0x38, 0x1C, 0x06, 0x03, 0x01, 0xC0, 0xE0, 0x70,
  0x18, 0x0E, 0x07, 0x03, 0x80, 0xC0, 0x60, 0x38, 0x1C, 0x0E, 0x07, 0xF8,
  0x3F, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x00, 0x00, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xDC, 0x07, 0x30, 0x18, 0xC0,
  0xE3, 0x07, 0x06, 0x18, 0x18, 0xE0, 0x63, 0x01, 0xD8, 0x03, 0xE0, 0x0C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xC7, 0x0E, 0x1C, 0x07, 0xF7, 0x0F, 0xFF,
  0x1C, 0x1F, 0x38, 0x0E, 0x38, 0x0E, 0x30, 0x0E, 0x70, 0x0E, 0x70, 0x0E,
  0x70, 0x0E, 0x70, 0x0E, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x1C, 0xE0, 0x1C,
  0x70, 0x3C, 0x78, 0x7C, 0x7F, 0xD8, 0x3F, 0x98, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x19, 0xFC, 0x3B, 0xFC,
  0x3C, 0x1E, 0x38, 0x0E, 0x38, 0x06, 0x30, 0x06, 0x30, 0x0E, 0x70, 0x0E,
  0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0C, 0x60, 0x0C, 0x60, 0x1C, 0xE0, 0x1C,
  0xF0, 0x38, 0xF8, 0x78, 0xFF, 0xF0, 0xCF, 0xE0, 0x07, 0xF8, 0x0F, 0xFC,
  0x1E, 0x0E, 0x38, 0x0E, 0x38, 0x06, 0x30, 0x06, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x0C, 0xE0, 0x1C,
  0x70, 0x1C, 0x78, 0x78, 0x3F, 0xF0, 0x1F, 0xC0, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x1F, 0xDC, 0x1F,
  0xFE, 0x1C, 0x1F, 0x1C, 0x07, 0x8E, 0x03, 0x86, 0x01, 0xC7, 0x00, 0xE3,
  0x80, 0x71, 0xC0, 0x38, 0xE0, 0x1C, 0x60, 0x0C, 0x30, 0x06, 0x18, 0x07,
  0x1C, 0x03, 0x87, 0x03, 0xC3, 0xC3, 0xE1, 0xFF, 0x60, 0x7F, 0x30, 0x07,
  0xF8, 0x1F, 0xF8, 0x70, 0x39, 0xC0, 0x73, 0x80, 0x66, 0x00, 0xDC, 0x01,
  0xBF, 0xFF, 0x7F, 0xFE, 0xFF, 0xFD, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x0C,
  0x03, 0x9C, 0x07, 0x38, 0x1C, 0x3F, 0xF0, 0x3F, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0x80, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF7, 0x0F, 0xFF,
  0x1C, 0x1F, 0x38, 0x0E, 0x38, 0x0E, 0x30, 0x0E, 0x70, 0x0E, 0x70, 0x0E,
  0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0C, 0x60, 0x1C, 0x70, 0x1C, 0x70, 0x3C,
  0x7F, 0xFC, 0x3F, 0xDC, 0x0F, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x01, 0xF0, 0x7F, 0xE0, 0x7F, 0x80, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x19, 0xFC, 0x3B, 0xFC,
  0x3C, 0x0E, 0x38, 0x0E, 0x38, 0x06, 0x30, 0x06, 0x30, 0x0E, 0x70, 0x0E,
  0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0C, 0x60, 0x0C, 0x60, 0x1C, 0xE0, 0x1C,
  0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x18, 0xC0, 0x18, 0x00, 0x10, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF,
  0x00, 0x01, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x3F, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x0E, 0x70,
  0x0E, 0x38, 0x0E, 0x1C, 0x0E, 0x0E, 0x0E, 0x06, 0x0E, 0x03, 0x0F, 0x03,
  0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x70, 0xE0, 0x38, 0x70, 0x18, 0x1C,
  0x0C, 0x0E, 0x0E, 0x03, 0x87, 0x01, 0xC3, 0x80, 0x71, 0xC0, 0x38, 0x7F,
  0x81, 0xFE, 0x08, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0xFF, 0xC1, 0xFF, 0x1B, 0xCF, 0x8F, 0xFF, 0xE3, 0x8E, 0x18,
  0xE1, 0x86, 0x30, 0xE1, 0x8C, 0x38, 0x63, 0x0C, 0x39, 0xC3, 0x0E, 0x70,
  0xC3, 0x9C, 0x30, 0xC6, 0x0C, 0x31, 0x87, 0x0C, 0x61, 0x87, 0x18, 0x61,
  0xCE, 0x18, 0x73, 0x86, 0x18, 0xE1, 0x86, 0x30, 0xE1, 0x80, 0x19, 0xFC,
  0x3B, 0xFC, 0x3C, 0x0E, 0x38, 0x0E, 0x38, 0x06, 0x30, 0x06, 0x30, 0x0E,
  0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0C, 0x60, 0x0C, 0x60, 0x1C,
  0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x18, 0xC0, 0x18, 0x07, 0xF8,
  0x1F, 0xF8, 0x70, 0x79, 0xC0, 0x73, 0x80, 0x66, 0x00, 0xDC, 0x03, 0xB8,
  0x07, 0x70, 0x0E, 0xE0, 0x1D, 0x80, 0x33, 0x00, 0x66, 0x01, 0xDC, 0x03,
  0x9C, 0x0E, 0x3C, 0x3C, 0x3F, 0xF0, 0x3F, 0x80, 0x1C, 0xFE, 0x0E, 0xFF,
  0x07, 0xC3, 0xC3, 0x80, 0xE1, 0xC0, 0x30, 0xC0, 0x18, 0x60, 0x1C, 0x70,
  0x0E, 0x38, 0x07, 0x1C, 0x03, 0x8E, 0x01, 0x86, 0x00, 0xC3, 0x00, 0xE3,
  0x80, 0x71, 0xE0, 0x70, 0xF8, 0x78, 0x7F, 0xF8, 0x33, 0xF8, 0x18, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0x07,
  0xF7, 0x0F, 0xF7, 0x1C, 0x1F, 0x38, 0x0E, 0x38, 0x0E, 0x30, 0x0E, 0x70,
  0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0xE0,
  0x1C, 0xE0, 0x1C, 0x70, 0x3C, 0x78, 0x7C, 0x7F, 0xD8, 0x3F, 0x98, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x1D,
  0xFC, 0x1F, 0xFE, 0x1A, 0x0F, 0x1C, 0x07, 0x38, 0x07, 0x38, 0x07, 0x38,
  0x07, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x07,
  0xFC, 0x3F, 0xFC, 0x70, 0x39, 0xC0, 0x33, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1F, 0x80, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xC0,
  0x01, 0xB8, 0x07, 0x78, 0x1C, 0x7F, 0xF8, 0x7F, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x1F, 0xFF, 0xFF, 0xFF, 0x83, 0x80,
  0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0,
  0x81, 0xFE, 0x01, 0xFC, 0x00, 0x38, 0x07, 0x38, 0x07, 0x38, 0x07, 0x38,
  0x07, 0x30, 0x06, 0x30, 0x06, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70,
  0x0E, 0x70, 0x0C, 0x60, 0x0C, 0x60, 0x1C, 0x60, 0x1C, 0x70, 0x38, 0x78,
  0x78, 0x3F, 0xF0, 0x1F, 0xC0, 0xC0, 0x0F, 0x80, 0x1B, 0x80, 0x77, 0x00,
  0xCE, 0x03, 0x8C, 0x06, 0x18, 0x1C, 0x30, 0x30, 0x70, 0xE0, 0xE1, 0x81,
  0xC7, 0x01, 0x8C, 0x03, 0x38, 0x06, 0x60, 0x0F, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0x38, 0x00, 0xC1, 0xC3, 0xE1, 0xE1, 0xB0, 0xF0, 0xD8, 0x78, 0x6C,
  0x6C, 0x66, 0x36, 0x33, 0x1B, 0x19, 0x99, 0x98, 0xCC, 0xCC, 0x66, 0x66,
  0x36, 0x36, 0x1B, 0x1B, 0x0D, 0x8D, 0x87, 0x87, 0x83, 0xC3, 0xC1, 0xE1,
  0xE0, 0xE0, 0xE0, 0x70, 0x70, 0x00, 0x1C, 0x03, 0xC3, 0x81, 0xE0, 0xE0,
  0x70, 0x1C, 0x38, 0x07, 0x1C, 0x00, 0xEE, 0x00, 0x3B, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1D, 0xC0, 0x0E, 0x38, 0x07,
  0x0E, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x70, 0x0E, 0x38, 0x03, 0x80, 0x38,
  0x07, 0x38, 0x07, 0x38, 0x07, 0x38, 0x06, 0x30, 0x06, 0x30, 0x0E, 0x70,
  0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0C, 0x70, 0x0C, 0x60, 0x1C, 0x70,
  0x1C, 0x70, 0x3C, 0x7F, 0xFC, 0x3F, 0xDC, 0x06, 0x18, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x30, 0x01, 0xF0, 0x7F, 0xE0, 0x7F, 0x80, 0x1F,
  0xFF, 0x3F, 0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xFF, 0xFC, 0xFF, 0xF8, 0x00,
  0x1F, 0x80, 0x1F, 0x80, 0x1E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0E, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x07, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x01, 0xC0, 0x0E, 0x1C, 0x38, 0x60, 0xC1, 0x87, 0x0E,
  0x1C, 0x38, 0x60, 0xC3, 0x87, 0x0E, 0x1C, 0x30, 0x61, 0xC3, 0x87, 0x0E,
  0x18, 0x30, 0x61, 0xC3, 0x87, 0x0E, 0x18, 0x30, 0x00, 0x07, 0xC0, 0x0F,
  0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0xFF, 0x00, 0x7F, 0x01, 0xE0, 0x01, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x0F, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xE0, 0x00, 0x1E,
  0x03, 0x3F, 0x03, 0x73, 0x83, 0x61, 0xC7, 0x60, 0xFE, 0xE0, 0xFC, 0xE0,
  0x10,
};

const GFXglyph JetBrainsMono_LightItalic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 8, 24, 20, 6, -24 },
  { 25, 11, 10, 20, 6, -24 },
  { 39, 19, 24, 20, 1, -24 },
  { 96, 17, 34, 20, 2, -29 },
  { 169, 23, 24, 20, -1, -24 },
  { 238, 18, 24, 20, 1, -24 },
  { 292, 5, 10, 20, 9, -24 },
  { 299, 14, 32, 20, 5, -28 },
  { 355, 13, 32, 20, 2, -28 },
  { 407, 17, 17, 20, 2, -20 },
  { 444, 16, 16, 20, 2, -19 },
  { 476, 9, 10, 20, 3, -5 },
  { 488, 11, 2, 20, 5, -12 },
  { 491, 6, 5, 20, 6, -5 },
  { 495, 19, 31, 20, 1, -27 },
  { 569, 17, 24, 20, 2, -24 },
  { 620, 15, 24, 20, 2, -24 },
  { 665, 17, 24, 20, 2, -24 },
  { 716, 16, 24, 20, 2, -24 },
  { 764, 16, 24, 20, 2, -24 },
  { 812, 16, 24, 20, 2, -24 },
  { 860, 15, 24, 20, 2, -24 },
  { 905, 16, 24, 20, 4, -24 },
  { 953, 16, 24, 20, 2, -24 },
  { 1001, 16, 24, 20, 3, -24 },
  { 1049, 8, 18, 20, 6, -18 },
  { 1067, 11, 23, 20, 3, -18 },
  { 1099, 16, 18, 20, 3, -20 },
  { 1135, 16, 10, 20, 2, -16 },
  { 1155, 15, 18, 20, 2, -20 },
  { 1189, 13, 24, 20, 5, -24 },
  { 1228, 20, 30, 20, 0, -24 },
  { 1303, 17, 24, 20, 0, -24 },
  { 1354, 17, 24, 20, 2, -24 },
  { 1405, 17, 24, 20, 2, -24 },
  { 1456, 16, 24, 20, 2, -24 },
  { 1504, 17, 24, 20, 2, -24 },
  { 1555, 18, 24, 20, 2, -24 },
  { 1609, 17, 24, 20, 2, -24 },
  { 1660, 17, 24, 20, 2, -24 },
  { 1711, 17, 24, 20, 2, -24 },
  { 1762, 18, 24, 20, 1, -24 },
  { 1816, 18, 24, 20, 2, -24 },
  { 1870, 15, 24, 20, 2, -24 },
  { 1915, 19, 24, 20, 1, -24 },
  { 1972, 17, 24, 20, 2, -24 },
  { 2023, 16, 24, 20, 2, -24 },
  { 2071, 18, 24, 20, 2, -24 },
  { 2125, 17, 30, 20, 2, -24 },
  { 2189, 17, 24, 20, 2, -24 },
  { 2240, 17, 24, 20, 2, -24 },
  { 2291, 16, 24, 20, 4, -24 },
  { 2339, 17, 24, 20, 2, -24 },
  { 2390, 16, 24, 20, 4, -24 },
  { 2438, 19, 24, 20, 2, -24 },
  { 2495, 20, 24, 20, 0, -24 },
  { 2555, 17, 24, 20, 4, -24 },
  { 2606, 18, 24, 20, 1, -24 },
  { 2660, 13, 31, 20, 5, -27 },
  { 2711, 9, 31, 20, 6, -27 },
  { 2746, 13, 31, 20, 3, -27 },
  { 2797, 14, 13, 20, 3, -24 },
  { 2820, 16, 2, 20, 0, 1 },
  { 2824, 6, 5, 20, 9, -26 },
  { 2828, 16, 18, 20, 2, -18 },
  { 2864, 16, 24, 20, 2, -24 },
  { 2912, 16, 18, 20, 2, -18 },
  { 2948, 17, 24, 20, 2, -24 },
  { 2999, 15, 18, 20, 2, -18 },
  { 3033, 22, 30, 20, -1, -24 },
  { 3116, 16, 24, 20, 2, -18 },
  { 3164, 16, 24, 20, 2, -24 },
  { 3212, 16, 26, 20, 1, -26 },
  { 3264, 17, 32, 20, 0, -26 },
  { 3332, 17, 24, 20, 2, -24 },
  { 3383, 14, 24, 20, 3, -24 },
  { 3425, 18, 18, 20, 1, -18 },
  { 3466, 16, 18, 20, 2, -18 },
  { 3502, 15, 18, 20, 2, -18 },
  { 3536, 17, 24, 20, 1, -18 },
  { 3587, 16, 24, 20, 2, -18 },
  { 3635, 16, 18, 20, 2, -18 },
  { 3671, 15, 18, 20, 2, -18 },
  { 3705, 15, 23, 20, 3, -23 },
  { 3749, 16, 18, 20, 2, -18 },
  { 3785, 15, 18, 20, 4, -18 },
  { 3819, 17, 18, 20, 3, -18 },
  { 3858, 18, 18, 20, 1, -18 },
  { 3899, 16, 24, 20, 2, -18 },
  { 3947, 16, 18, 20, 2, -18 },
  { 3983, 17, 31, 20, 3, -27 },
  { 4049, 7, 31, 20, 7, -27 },
  { 4077, 16, 31, 20, 1, -27 },
  { 4139, 16, 7, 20, 2, -15 },
};

const GFXfont JetBrainsMono_LightItalic33pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_LightItalic33pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_LightItalic33pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _JETBRAINSMONO_LIGHTITALIC33PT7B_H_
