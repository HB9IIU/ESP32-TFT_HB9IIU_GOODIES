#ifndef _JETBRAINSMONO_LIGHTITALIC64PT7B_H_
#define _JETBRAINSMONO_LIGHTITALIC64PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-LightItalic.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_LightItalic64pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0xFF, 0x01, 0xFF, 0x07, 0xFE, 0x0F,
  0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF,
  0xC0, 0x7E, 0x7E, 0x03, 0xF3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x0F,
  0xCF, 0xC0, 0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8,
  0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xE0, 0x0F, 0x0F, 0x00, 0x78,
  0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x07,
  0x80, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x0F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0x07,
  0x80, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x01, 0xF0,
  0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFC,
  0xEF, 0xF8, 0x03, 0xF8, 0xF1, 0xFC, 0x01, 0xF8, 0x78, 0x3E, 0x01, 0xF8,
  0x3C, 0x1F, 0x80, 0xF8, 0x1E, 0x07, 0xC0, 0xFC, 0x0E, 0x03, 0xE0, 0x7C,
  0x07, 0x01, 0xF0, 0x3E, 0x03, 0x80, 0xF8, 0x1F, 0x03, 0xC0, 0x00, 0x0F,
  0x81, 0xE0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x03, 0xE0, 0x70, 0x00, 0x01,
  0xF8, 0x38, 0x00, 0x00, 0xFC, 0x1C, 0x00, 0x00, 0x7F, 0x1E, 0x00, 0x00,
  0x1F, 0xEF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1E, 0x7F,
  0x80, 0x00, 0x0E, 0x0F, 0xC0, 0x00, 0x07, 0x07, 0xE0, 0x00, 0x03, 0x81,
  0xF8, 0x00, 0x03, 0xC0, 0xFC, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0xF0,
  0x1F, 0x00, 0x00, 0x70, 0x0F, 0x87, 0xC0, 0x38, 0x0F, 0xC3, 0xE0, 0x1C,
  0x07, 0xC1, 0xF0, 0x1E, 0x03, 0xE0, 0xF8, 0x0F, 0x03, 0xF0, 0x7E, 0x07,
  0x81, 0xF0, 0x3F, 0x03, 0x81, 0xF8, 0x0F, 0xC1, 0xC3, 0xF8, 0x07, 0xF8,
  0xE7, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x78, 0x00, 0xF8, 0x1F, 0x00, 0x0F,
  0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x0F, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0xF0, 0x0F, 0x00, 0x03, 0xE0, 0x1F, 0x01, 0xE0, 0x00, 0x3C, 0x01,
  0xF0, 0x3E, 0x00, 0x03, 0xC0, 0x1E, 0x07, 0xC0, 0x00, 0x3C, 0x01, 0xE0,
  0xF8, 0x00, 0x03, 0xC0, 0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x03, 0xE1, 0xE0,
  0x00, 0x03, 0xE0, 0x7C, 0x3C, 0x00, 0x00, 0x3F, 0xFF, 0x87, 0x80, 0x00,
  0x01, 0xFF, 0xF8, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x1F, 0x00, 0x00, 0x00,
  0x7F, 0xC1, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0x87, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0xFF, 0xF8,
  0x00, 0x00, 0x1E, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xC3, 0xE0, 0x7C, 0x00,
  0x00, 0x7C, 0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x87, 0xC0, 0x3C, 0x00, 0x00,
  0xF0, 0x78, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x3C, 0x00, 0x03, 0xC0,
  0x78, 0x03, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x00, 0x0F, 0x80, 0xF8,
  0x03, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x00, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x0F, 0x80,
  0x0F, 0x00, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x3E,
  0x00, 0x07, 0xFF, 0xE0, 0x07, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xF8,
  0x3F, 0xC0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0x1F, 0xC7, 0xC0, 0x07, 0xC3, 0xE0, 0xFC, 0x01, 0xF0, 0xFC, 0x0F,
  0xC0, 0x7E, 0x1F, 0x01, 0xF8, 0x0F, 0x83, 0xE0, 0x1F, 0x83, 0xE0, 0x7C,
  0x01, 0xF0, 0xFC, 0x1F, 0x80, 0x3F, 0x1F, 0x03, 0xE0, 0x03, 0xE7, 0xC0,
  0x7C, 0x00, 0x7F, 0xF0, 0x0F, 0x80, 0x07, 0xFE, 0x01, 0xF0, 0x00, 0x7F,
  0x80, 0x3E, 0x00, 0x0F, 0xE0, 0x07, 0xC0, 0x00, 0xFC, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0x3E, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x01, 0xFF, 0x00, 0xFC,
  0x00, 0x7F, 0xF0, 0x1F, 0x80, 0x1F, 0xBE, 0x01, 0xFC, 0x0F, 0xE7, 0xE0,
  0x3F, 0xFF, 0xF8, 0x7C, 0x03, 0xFF, 0xFE, 0x0F, 0xC0, 0x3F, 0xFF, 0x00,
  0xF8, 0x03, 0xFF, 0x80, 0x1F, 0x80, 0x07, 0x00, 0x00, 0x00, 0x1F, 0x1F,
  0x3F, 0x3F, 0x3F, 0x3F, 0x3E, 0x3E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C,
  0x7C, 0x7C, 0x78, 0x78, 0xF8, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x10, 0x00,
  0xF0, 0x00, 0x9F, 0x00, 0x78, 0x03, 0xCF, 0xE0, 0x3C, 0x0F, 0xFF, 0xFC,
  0x1C, 0x1F, 0xFF, 0xFF, 0x8E, 0x3F, 0xFD, 0xFF, 0xE7, 0x7F, 0xFC, 0x1F,
  0xFB, 0x7F, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x03, 0xF0, 0xF8, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xC0,
  0x01, 0xF8, 0x07, 0xE0, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFE,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFD, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x07, 0xF1, 0xFF, 0x3F, 0xEF, 0xFD,
  0xFF, 0xBF, 0xF7, 0xFE, 0xFF, 0x8F, 0xE0, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF,
  0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7E, 0x03, 0xE0,
  0x00, 0x3E, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x00,
  0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3E, 0x1F, 0x00,
  0x00, 0x3E, 0x1F, 0x03, 0xC0, 0x7C, 0x1F, 0x07, 0xE0, 0x7C, 0x3E, 0x07,
  0xF0, 0x7C, 0x3E, 0x0F, 0xF0, 0x7C, 0x3E, 0x07, 0xF0, 0x7C, 0x3E, 0x07,
  0xE0, 0x7C, 0x3E, 0x03, 0xC0, 0xFC, 0x3E, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x00, 0xF8, 0x7C, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x01, 0xF0, 0xFC, 0x00,
  0x03, 0xE0, 0xFC, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x0F, 0xC0, 0x7F, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xFE, 0x7C, 0x00, 0x1F, 0xC3, 0xE0, 0x03,
  0xFC, 0x1F, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0x00,
  0x3E, 0x00, 0x30, 0x03, 0xF0, 0x02, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xE0, 0x03, 0xF8, 0x07, 0xE0,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xF0,
  0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x0F,
  0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x81,
  0xF0, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0xC0,
  0x1F, 0x80, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0xF8,
  0x07, 0xE0, 0x03, 0xE0, 0x3F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3E, 0x07,
  0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x1F, 0x0F, 0xC0,
  0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0x3F, 0x1F, 0x00, 0x00, 0xF8, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0xC7,
  0xFF, 0x80, 0x0F, 0x9F, 0xFF, 0xC0, 0x0F, 0xBF, 0xFF, 0xE0, 0x0F, 0xBF,
  0xFF, 0xF0, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x03, 0xF0, 0x0F, 0xC0,
  0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x07, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x1F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x0F, 0xDF, 0xFE, 0x00, 0x3F, 0x7F, 0xFE, 0x00,
  0x7D, 0xFF, 0xFE, 0x01, 0xFF, 0xCF, 0xFE, 0x07, 0xFC, 0x01, 0xFC, 0x0F,
  0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x03, 0xE3, 0xF0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x0F, 0x8F, 0x80,
  0x00, 0x1F, 0x3E, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x7C, 0xF8, 0x00,
  0x00, 0xF9, 0xF0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x07, 0xE7, 0xC0, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x7C, 0x3F, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x1F, 0x80, 0x7F, 0x80, 0xFF,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xCF, 0x80, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x3E, 0x3E,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07, 0xE3, 0xE0,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFC, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00,
  0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x03, 0xFB,
  0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x7E,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x0F, 0xC1,
  0xF0, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE0,
  0x1F, 0x80, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xE0, 0xFF,
  0x00, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x01, 0xF1,
  0xF0, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x0F, 0x9F,
  0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x7C, 0xF8,
  0x00, 0x01, 0xF1, 0xF0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0xC0, 0x01, 0xF8, 0x1F, 0xC0,
  0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xBE, 0x00, 0x3F, 0xFC, 0xF8, 0x00, 0x1F, 0xE3, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x07, 0xF8,
  0x1F, 0xF0, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x07,
  0xF0, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x03, 0xF8, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83,
  0xFE, 0x03, 0xF8, 0x01, 0x80, 0x00, 0x00, 0x07, 0x80, 0x01, 0xFE, 0x00,
  0x3F, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8,
  0x04, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0xC0, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x00,
  0x3E, 0x0F, 0x80, 0x03, 0xF0, 0xF8, 0x3E, 0x00, 0x3F, 0xF3, 0xC0, 0xF8,
  0x03, 0xFF, 0xEF, 0x03, 0xC0, 0x1F, 0xFF, 0xBC, 0x0F, 0x00, 0x7E, 0x07,
  0xF0, 0x7C, 0x03, 0xE0, 0x0F, 0xC1, 0xF0, 0x0F, 0x80, 0x1F, 0x07, 0xC0,
  0x7C, 0x00, 0x7C, 0x1F, 0x01, 0xF0, 0x01, 0xE0, 0x78, 0x07, 0xC0, 0x07,
  0x81, 0xE0, 0x1E, 0x00, 0x3E, 0x0F, 0x80, 0x78, 0x00, 0xF8, 0x3E, 0x01,
  0xE0, 0x03, 0xE0, 0xF8, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x3E, 0x00, 0x3C,
  0x0F, 0x00, 0xF8, 0x00, 0xF0, 0x3C, 0x03, 0xE0, 0x07, 0xC0, 0xF0, 0x0F,
  0x00, 0x1F, 0x07, 0xC0, 0x3C, 0x00, 0x7C, 0x1F, 0x01, 0xF0, 0x01, 0xF0,
  0x7C, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x0F, 0x80, 0x3E, 0x07, 0x80, 0x3E,
  0x01, 0xF8, 0x1E, 0x00, 0xFE, 0x3D, 0xE0, 0xF8, 0x03, 0xFF, 0xF7, 0x83,
  0xE0, 0x07, 0xFF, 0xBE, 0x0F, 0x80, 0x0F, 0xF8, 0xF0, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0xFB,
  0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x0F, 0x8F,
  0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x00,
  0x07, 0xE0, 0x1E, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x1F, 0x00, 0x7F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00,
  0x3E, 0x3F, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xE0, 0x0F, 0x80, 0x07, 0xF0, 0x07, 0xC0, 0x01, 0xFC, 0x03, 0xE0,
  0x00, 0x7E, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x1F,
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0xF8, 0x00, 0x7F, 0x00, 0x7C, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0,
  0x07, 0xC0, 0x07, 0xF8, 0x03, 0xE0, 0x00, 0xFE, 0x01, 0xF0, 0x00, 0x3F,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xE0, 0x7C, 0x00,
  0x07, 0xE0, 0x7C, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x0F, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0xFF, 0x83, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x1F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0x0F, 0xE0, 0x07, 0xC0, 0x03, 0xF8,
  0x03, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x1F,
  0x80, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01,
  0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x7E, 0x00,
  0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x80,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xF0,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x1F, 0x80,
  0x7C, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x1F, 0xC0, 0x3E, 0x00, 0x1F, 0xC0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0xFC, 0x00,
  0xFE, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x01, 0xFF,
  0xFC, 0x1F, 0x01, 0xFF, 0xFC, 0x1F, 0x01, 0xFF, 0xFC, 0x3E, 0x03, 0xFF,
  0xF8, 0x3E, 0x03, 0xFF, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00,
  0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01,
  0xF8, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03,
  0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x1F,
  0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0xF0, 0x0F, 0x80,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x01, 0xF0,
  0x0F, 0x80, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x1F, 0x00,
  0x00, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x03, 0xE0,
  0x1F, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00,
  0x7C, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x3E, 0x00,
  0x01, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x07,
  0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x03, 0xE0,
  0x1F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xE0, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x1F,
  0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0x80,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x7C, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x00, 0x7C, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xF8, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFE, 0x01, 0xFE,
  0x00, 0x1E, 0xE0, 0x1F, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x3D, 0xE0,
  0x1E, 0xF0, 0x07, 0xDE, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x3C, 0xF0, 0x0F,
  0xBC, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x1F, 0x3C, 0x03, 0xC7,
  0x81, 0xE3, 0xC0, 0x3C, 0x78, 0x1E, 0x7C, 0x07, 0xC7, 0x83, 0xC7, 0xC0,
  0x7C, 0x78, 0x3C, 0x78, 0x07, 0xC7, 0x87, 0x87, 0x80, 0x7C, 0x78, 0x78,
  0xF8, 0x07, 0xC3, 0xCF, 0x0F, 0x80, 0x78, 0x3C, 0xF0, 0xF8, 0x0F, 0x83,
  0xDE, 0x0F, 0x80, 0xF8, 0x3D, 0xE0, 0xF8, 0x0F, 0x83, 0xFC, 0x1F, 0x00,
  0xF8, 0x1F, 0xC1, 0xF0, 0x0F, 0x81, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x81,
  0xF0, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x3E, 0x00,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x7C, 0x00,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x7F, 0x80, 0x01, 0xF0, 0x1F, 0xE0, 0x00,
  0x7C, 0x07, 0xF8, 0x00, 0x3E, 0x01, 0xFE, 0x00, 0x0F, 0x80, 0x7F, 0xC0,
  0x03, 0xE0, 0x1F, 0xF0, 0x00, 0xF8, 0x07, 0xFC, 0x00, 0x3E, 0x03, 0xEF,
  0x00, 0x0F, 0x80, 0xFB, 0xC0, 0x03, 0xC0, 0x3E, 0xF8, 0x01, 0xF0, 0x0F,
  0xBE, 0x00, 0x7C, 0x03, 0xE7, 0x80, 0x1F, 0x00, 0xF1, 0xE0, 0x07, 0xC0,
  0x7C, 0x78, 0x01, 0xF0, 0x1F, 0x1F, 0x00, 0x7C, 0x07, 0xC7, 0xC0, 0x3E,
  0x01, 0xF0, 0xF0, 0x0F, 0x80, 0x7C, 0x3C, 0x03, 0xE0, 0x1F, 0x0F, 0x00,
  0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x80, 0xF8, 0x1E,
  0x07, 0xC0, 0x3E, 0x07, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x7C, 0x03, 0xE0,
  0x7C, 0x1F, 0x00, 0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x03, 0xC1, 0xF0, 0x1F,
  0x00, 0xF0, 0x78, 0x07, 0xC0, 0x3E, 0x3E, 0x01, 0xF0, 0x0F, 0x8F, 0x80,
  0x7C, 0x03, 0xE3, 0xE0, 0x1E, 0x00, 0x78, 0xF8, 0x0F, 0x80, 0x1E, 0x3E,
  0x03, 0xE0, 0x07, 0xCF, 0x80, 0xF8, 0x01, 0xF3, 0xC0, 0x3E, 0x00, 0x3D,
  0xF0, 0x0F, 0x80, 0x0F, 0x7C, 0x03, 0xE0, 0x03, 0xDF, 0x01, 0xF0, 0x00,
  0xFF, 0xC0, 0x7C, 0x00, 0x3F, 0xF0, 0x1F, 0x00, 0x07, 0xF8, 0x07, 0xC0,
  0x01, 0xFE, 0x01, 0xF0, 0x00, 0x7F, 0x80, 0x7C, 0x00, 0x1F, 0xE0, 0x3E,
  0x00, 0x07, 0xF8, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0xFF, 0x83, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C,
  0x1F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C,
  0x1F, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8,
  0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF0,
  0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0,
  0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xC0,
  0x7E, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x7F, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x00, 0xFF, 0x00, 0x7C,
  0x00, 0x07, 0xF0, 0x0F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x03,
  0xF0, 0x3E, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x01, 0xF0, 0x3E, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0xF8,
  0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x7C, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xFC, 0x03, 0xE0, 0x01, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0xFF, 0x83, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xF8,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xC0,
  0x00, 0x3F, 0x07, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0x80,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3E, 0x1F, 0x00,
  0x00, 0x7E, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x7C, 0x3E, 0x00,
  0x00, 0xFC, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0xFC, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xE0, 0x7C, 0x00,
  0x07, 0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x1F, 0x80, 0x3F, 0xC0,
  0x7F, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x1F, 0xC0, 0x1F, 0x00, 0x03, 0xF8,
  0x07, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x03,
  0xF0, 0x3E, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x3F, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0xF8, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x03, 0xF0, 0x1F, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0xFE, 0x03,
  0xE0, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x7E, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x1F,
  0x80, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x03, 0xF0, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x1F, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x7C, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x7E,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xF0, 0x7C,
  0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF8,
  0x03, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x81, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0xF8,
  0x1F, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01,
  0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0xC0, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x01, 0xF0, 0x3F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xFC, 0x0F, 0x80,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F, 0x80, 0x1F,
  0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x1F, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x0F, 0xCF,
  0x80, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0xF8, 0x7C,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0xF8, 0x0F, 0x80,
  0x03, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0x7C, 0x00,
  0x3E, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x0F, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x1E, 0x1F, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00,
  0xF9, 0xF0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x07,
  0xDF, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF7,
  0xC0, 0x0F, 0xC0, 0x1F, 0x7C, 0x01, 0xFC, 0x01, 0xF7, 0xC0, 0x1F, 0xC0,
  0x1E, 0x7C, 0x01, 0xFC, 0x03, 0xE7, 0xC0, 0x1F, 0x80, 0x3E, 0x7C, 0x03,
  0xF8, 0x03, 0xC7, 0xC0, 0x3B, 0x80, 0x3C, 0x7C, 0x03, 0xB8, 0x07, 0xC7,
  0xC0, 0x7B, 0x80, 0x7C, 0x7C, 0x07, 0xB8, 0x07, 0x87, 0xC0, 0x73, 0x80,
  0xF8, 0x7C, 0x07, 0x38, 0x0F, 0x87, 0x80, 0xF3, 0x80, 0xF0, 0x78, 0x0E,
  0x38, 0x0F, 0x07, 0x80, 0xE3, 0x81, 0xF0, 0x78, 0x1E, 0x38, 0x1F, 0x07,
  0x81, 0xE3, 0x81, 0xE0, 0x78, 0x1C, 0x38, 0x1E, 0x07, 0x81, 0xC3, 0x83,
  0xE0, 0x78, 0x3C, 0x38, 0x3E, 0x07, 0x83, 0x83, 0x83, 0xC0, 0x78, 0x38,
  0x38, 0x3C, 0x0F, 0x87, 0x83, 0x87, 0xC0, 0xF8, 0x78, 0x78, 0x78, 0x0F,
  0x87, 0x07, 0x87, 0x80, 0xF8, 0x70, 0x78, 0xF8, 0x0F, 0x8F, 0x07, 0x8F,
  0x80, 0xF8, 0xE0, 0x78, 0xF0, 0x0F, 0x8E, 0x07, 0x8F, 0x00, 0xF9, 0xE0,
  0x79, 0xF0, 0x0F, 0x9C, 0x07, 0x1E, 0x00, 0xF9, 0xC0, 0x71, 0xE0, 0x0F,
  0x1C, 0x07, 0x1E, 0x00, 0xF3, 0xC0, 0x73, 0xE0, 0x0F, 0x38, 0x07, 0x3C,
  0x00, 0xF3, 0x80, 0x73, 0xC0, 0x0F, 0x78, 0x07, 0x3C, 0x00, 0xF7, 0x00,
  0x77, 0xC0, 0x0F, 0x70, 0x07, 0x78, 0x00, 0xF7, 0x00, 0x77, 0x80, 0x0F,
  0xF0, 0x07, 0x78, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x01, 0xF3,
  0xF0, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0xF8, 0x00,
  0x00, 0x00, 0xF9, 0xF8, 0x00, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x01,
  0xF0, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xDF, 0x00, 0x00,
  0x07, 0xE7, 0xC0, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0xF8, 0x7E, 0x00,
  0x00, 0x7E, 0x0F, 0x80, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x03, 0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0xFC, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0,
  0x03, 0xF0, 0x03, 0xE0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3E, 0x0F,
  0xC0, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0x7C,
  0x7C, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x01,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFB,
  0xC0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x3E, 0x3E, 0x00,
  0x03, 0xE1, 0xE0, 0x00, 0x7C, 0x1E, 0x00, 0x07, 0x81, 0xF0, 0x00, 0xF8,
  0x1F, 0x00, 0x1F, 0x00, 0xF0, 0x01, 0xF0, 0x0F, 0x00, 0x3E, 0x00, 0xF8,
  0x07, 0xC0, 0x07, 0x80, 0x7C, 0x00, 0x78, 0x0F, 0x80, 0x07, 0xC0, 0xF8,
  0x00, 0x7C, 0x1F, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x1E, 0xFC, 0x00, 0x01, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x7C, 0x01, 0xFF, 0xF8,
  0xF8, 0x07, 0xFF, 0xF9, 0xF0, 0x1F, 0xFF, 0xF7, 0xC0, 0x7F, 0x00, 0xFF,
  0x81, 0xF8, 0x00, 0xFF, 0x03, 0xE0, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0xFC,
  0x1F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x1F,
  0x00, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x0F, 0xC0,
  0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x83, 0xE0, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0xFE, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0xC0, 0x0F,
  0xF0, 0x1F, 0xC0, 0x3F, 0xE0, 0x3F, 0xFF, 0xF7, 0xC0, 0x3F, 0xFF, 0xCF,
  0x80, 0x3F, 0xFF, 0x1F, 0x00, 0x3F, 0xF8, 0x7E, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x01, 0xF8, 0x00,
  0x3E, 0x1F, 0xFC, 0x00, 0x7C, 0xFF, 0xFE, 0x00, 0xFB, 0xFF, 0xFE, 0x03,
  0xEF, 0xFF, 0xFC, 0x07, 0xDC, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xF8, 0x1F,
  0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC1, 0xF8,
  0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0xFC, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF0,
  0x7F, 0x00, 0x07, 0xE0, 0xFB, 0x00, 0x1F, 0x81, 0xF7, 0x80, 0xFE, 0x03,
  0xEF, 0xFF, 0xFC, 0x07, 0xCF, 0xFF, 0xF0, 0x0F, 0x9F, 0xFF, 0x80, 0x3F,
  0x0F, 0xFE, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7E, 0x03, 0xE0,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0xF8, 0x7E, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x7E, 0x0F,
  0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x1F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xFF, 0xC3,
  0xE0, 0x03, 0xFF, 0xF1, 0xF0, 0x03, 0xFF, 0xFD, 0xF8, 0x03, 0xFF, 0xFE,
  0xF8, 0x03, 0xF8, 0x07, 0xFC, 0x03, 0xF0, 0x01, 0xFE, 0x01, 0xF0, 0x00,
  0x7F, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x07, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x3F, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x1F, 0xE0,
  0x0F, 0xE0, 0x1F, 0xF0, 0x07, 0xFF, 0xFE, 0xF8, 0x01, 0xFF, 0xFE, 0x7C,
  0x00, 0x7F, 0xFE, 0x3E, 0x00, 0x1F, 0xFC, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xBF, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0,
  0x7E, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3E,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x1F, 0x00,
  0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00,
  0x3E, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFC, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x07, 0xC1, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xE0, 0x0F,
  0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xE1, 0xF0, 0x0F, 0xFF,
  0xC7, 0xC0, 0x7F, 0xFF, 0x9F, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xC0, 0x3F,
  0xE0, 0xFC, 0x00, 0x7F, 0x83, 0xE0, 0x00, 0xFE, 0x1F, 0x80, 0x01, 0xF8,
  0x7C, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x3E,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x1F, 0x80,
  0x00, 0x7C, 0x7C, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x0F,
  0x8F, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x07, 0xC3,
  0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xFC, 0x1F, 0x80, 0x0F, 0xF0, 0x7F,
  0x80, 0xF7, 0xC0, 0xFF, 0xFF, 0xBE, 0x01, 0xFF, 0xFE, 0xF8, 0x03, 0xFF,
  0xE3, 0xE0, 0x07, 0xFF, 0x0F, 0x80, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x01, 0xF8,
  0x00, 0x3E, 0x1F, 0xFC, 0x00, 0x7C, 0xFF, 0xFE, 0x00, 0xFB, 0xFF, 0xFE,
  0x03, 0xEF, 0xEF, 0xFC, 0x07, 0xDC, 0x01, 0xFC, 0x0F, 0xF0, 0x01, 0xF8,
  0x1F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0xFC,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00,
  0xF8, 0x7C, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x3E,
  0x00, 0x01, 0xF8, 0x1F, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x01, 0xF8, 0x0F,
  0xC0, 0x01, 0xF8, 0x07, 0xC0, 0x01, 0xF8, 0x03, 0xE0, 0x01, 0xFC, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0xFE, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x7C, 0x07, 0xE0, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x3F, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x07, 0xC0, 0x07,
  0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x3E, 0x00,
  0x03, 0xF0, 0x1F, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x7E, 0x07, 0xC0,
  0x00, 0x3F, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xC0, 0x3C, 0x01, 0xF3, 0xFC, 0x3F,
  0xC0, 0x79, 0xFF, 0x1F, 0xF8, 0x1E, 0xFF, 0xEF, 0xFE, 0x07, 0xB1, 0xFF,
  0x1F, 0x83, 0xF0, 0x3F, 0x03, 0xF0, 0xF8, 0x07, 0xC0, 0x7C, 0x3E, 0x01,
  0xE0, 0x1F, 0x0F, 0x80, 0x78, 0x07, 0x83, 0xE0, 0x3E, 0x01, 0xE0, 0xF0,
  0x0F, 0x80, 0xF8, 0x7C, 0x03, 0xC0, 0x3E, 0x1F, 0x00, 0xF0, 0x0F, 0x87,
  0xC0, 0x3C, 0x03, 0xE1, 0xF0, 0x0F, 0x00, 0xF8, 0x7C, 0x07, 0xC0, 0x3C,
  0x1E, 0x01, 0xF0, 0x1F, 0x07, 0x80, 0x78, 0x07, 0xC3, 0xE0, 0x1E, 0x01,
  0xF0, 0xF8, 0x07, 0x80, 0x7C, 0x3E, 0x01, 0xE0, 0x1F, 0x0F, 0x80, 0x78,
  0x07, 0x83, 0xE0, 0x3E, 0x01, 0xE0, 0xF0, 0x0F, 0x80, 0xF8, 0x7C, 0x03,
  0xC0, 0x3E, 0x1F, 0x00, 0xF0, 0x0F, 0x87, 0xC0, 0x3C, 0x03, 0xE1, 0xF0,
  0x0F, 0x00, 0xF8, 0x7C, 0x07, 0xC0, 0x3C, 0x1E, 0x01, 0xF0, 0x1F, 0x0F,
  0x80, 0x78, 0x07, 0xC3, 0xE0, 0x1E, 0x01, 0xF0, 0xF8, 0x07, 0x80, 0x7C,
  0x3E, 0x01, 0xE0, 0x1F, 0x0F, 0x80, 0xF8, 0x07, 0x83, 0xC0, 0x3E, 0x03,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xC3, 0xFF, 0x80, 0x0F, 0x9F, 0xFF,
  0xC0, 0x1F, 0x7F, 0xFF, 0xC0, 0x7D, 0xFD, 0xFF, 0x80, 0xFB, 0x80, 0x3F,
  0x81, 0xFE, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xFC, 0x3E, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7E, 0x1F, 0x00, 0x00,
  0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0x81,
  0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE1, 0xF8,
  0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x03, 0xE3, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x00,
  0xF8, 0xF8, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C,
  0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x1F, 0x1F,
  0x00, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x07, 0xC1, 0xF8, 0x00,
  0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0xFF, 0xE0,
  0x01, 0xF3, 0xFF, 0xF8, 0x01, 0xF7, 0xFF, 0xFC, 0x03, 0xEF, 0xFF, 0xFC,
  0x03, 0xEE, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x3E,
  0x03, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x3F,
  0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x7C,
  0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8,
  0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF0,
  0x3F, 0x80, 0x03, 0xF0, 0x3E, 0xC0, 0x07, 0xE0, 0x3E, 0xF0, 0x1F, 0xC0,
  0x3E, 0xFF, 0xFF, 0xC0, 0x3E, 0x7F, 0xFF, 0x80, 0x3E, 0x3F, 0xFE, 0x00,
  0x7E, 0x1F, 0xF8, 0x00, 0x7C, 0x03, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x7C,
  0x01, 0xFF, 0xF8, 0xF8, 0x07, 0xFF, 0xFB, 0xF0, 0x1F, 0xFF, 0xF7, 0xC0,
  0x7F, 0x00, 0xFF, 0x81, 0xF8, 0x00, 0xFF, 0x07, 0xE0, 0x00, 0xFE, 0x0F,
  0xC0, 0x00, 0xFC, 0x1F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x0F, 0xC0,
  0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F,
  0x83, 0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0xFE, 0x0F, 0xC0, 0x01, 0xF8,
  0x1F, 0xC0, 0x0F, 0xF0, 0x1F, 0xC0, 0x3B, 0xE0, 0x3F, 0xFF, 0xF7, 0xC0,
  0x3F, 0xFF, 0xCF, 0x80, 0x3F, 0xFF, 0x1F, 0x00, 0x3F, 0xF8, 0x7C, 0x00,
  0x07, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x0F, 0x87, 0xFF, 0x00, 0x1F, 0x3F, 0xFF, 0x80, 0x3E, 0xFF,
  0xFF, 0x80, 0x7F, 0xFB, 0xFF, 0x81, 0xF7, 0x00, 0x7F, 0x03, 0xFC, 0x00,
  0x7E, 0x07, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x00, 0x00,
  0xF8, 0x3E, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF8, 0x1F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F,
  0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x3E,
  0x00, 0x00, 0xF8, 0xF8, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x1F, 0x8F, 0xE0,
  0x00, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00,
  0x00, 0xF8, 0x7C, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x1F, 0x80, 0x00,
  0x7C, 0x3E, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E,
  0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x0F,
  0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x03, 0xF0,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0xF8, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xF0,
  0x1F, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0x7C, 0x7C, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E,
  0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x3E, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0xF8, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x7C, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x7C,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x00,
  0xF8, 0xF8, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x1F,
  0x78, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xF8, 0x03,
  0xE0, 0x07, 0xFE, 0x00, 0xF8, 0x01, 0xEF, 0x80, 0x7E, 0x00, 0xFB, 0xE0,
  0x1F, 0x80, 0x3C, 0xF8, 0x07, 0xE0, 0x0F, 0x3E, 0x03, 0xF8, 0x07, 0xCF,
  0x80, 0xEE, 0x01, 0xE3, 0xE0, 0x3B, 0x80, 0x78, 0xF8, 0x0E, 0xE0, 0x1E,
  0x3E, 0x07, 0xB8, 0x0F, 0x0F, 0x81, 0xCE, 0x03, 0xC3, 0xE0, 0x73, 0x80,
  0xF0, 0xF8, 0x3C, 0xE0, 0x7C, 0x3C, 0x0E, 0x38, 0x1E, 0x0F, 0x03, 0x8E,
  0x07, 0x83, 0xC1, 0xE3, 0xC3, 0xE0, 0xF0, 0x70, 0xF0, 0xF0, 0x3C, 0x1C,
  0x3C, 0x3C, 0x0F, 0x0F, 0x0F, 0x1F, 0x03, 0xC3, 0x83, 0xC7, 0x80, 0xF0,
  0xE0, 0xF1, 0xE0, 0x3C, 0x78, 0x3C, 0x78, 0x0F, 0x1C, 0x0F, 0x3C, 0x03,
  0xC7, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0xF3, 0xC0, 0x3C, 0xE0, 0x3D, 0xE0,
  0x0F, 0x38, 0x0F, 0x78, 0x03, 0xDE, 0x03, 0xDE, 0x00, 0xF7, 0x00, 0xFF,
  0x00, 0x3D, 0xC0, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0, 0x03, 0xF8, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x0F, 0xC0,
  0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x00, 0x0F, 0x87, 0xE0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xBE,
  0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x03,
  0xE1, 0xF8, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x01, 0xF8, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x7E, 0x00, 0x01,
  0xF1, 0xF0, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8,
  0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x3F,
  0x00, 0x01, 0xF8, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC7, 0xE0, 0x00,
  0x1F, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x03, 0xE3,
  0xF0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x7C, 0x3F, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x03, 0x7C, 0x1F, 0xE0,
  0x3F, 0xF0, 0x3F, 0xFF, 0xEF, 0x80, 0x7F, 0xFF, 0x3E, 0x00, 0xFF, 0xF8,
  0xF8, 0x01, 0xFF, 0x83, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x07, 0xFE, 0x00, 0x1E, 0x0F,
  0xFF, 0x00, 0x3E, 0x1F, 0xFF, 0x80, 0x3E, 0x3F, 0x1F, 0xC0, 0x3E, 0x3E,
  0x0F, 0xC0, 0x3E, 0x7C, 0x07, 0xE0, 0x3E, 0x7C, 0x03, 0xF0, 0x7C, 0x7C,
  0x03, 0xFD, 0xFC, 0x7C, 0x01, 0xFF, 0xF8, 0x78, 0x00, 0xFF, 0xF0, 0xF8,
  0x00, 0x7F, 0xE0, 0xF8, 0x00, 0x1F, 0x00,
};

const GFXglyph JetBrainsMono_LightItalic64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 15, 47, 38, 12, -47 },
  { 90, 21, 19, 38, 12, -47 },
  { 140, 38, 47, 38, 1, -47 },
  { 364, 33, 65, 38, 3, -56 },
  { 633, 44, 47, 38, -2, -47 },
  { 892, 35, 48, 38, 2, -47 },
  { 1102, 8, 19, 38, 18, -47 },
  { 1121, 27, 62, 38, 10, -54 },
  { 1331, 26, 62, 38, 3, -54 },
  { 1533, 33, 33, 38, 4, -39 },
  { 1670, 31, 30, 38, 4, -36 },
  { 1787, 17, 20, 38, 6, -10 },
  { 1830, 21, 4, 38, 9, -23 },
  { 1841, 11, 11, 38, 12, -10 },
  { 1857, 38, 60, 38, 1, -53 },
  { 2142, 32, 48, 38, 4, -47 },
  { 2334, 29, 47, 38, 3, -47 },
  { 2505, 33, 47, 38, 3, -47 },
  { 2699, 33, 48, 38, 3, -47 },
  { 2897, 30, 47, 38, 4, -47 },
  { 3074, 32, 48, 38, 4, -47 },
  { 3266, 31, 48, 38, 3, -47 },
  { 3452, 31, 47, 38, 8, -47 },
  { 3635, 33, 48, 38, 3, -47 },
  { 3833, 31, 47, 38, 6, -47 },
  { 4016, 15, 37, 38, 12, -36 },
  { 4086, 20, 46, 38, 7, -36 },
  { 4201, 30, 34, 38, 6, -38 },
  { 4329, 30, 20, 38, 5, -31 },
  { 4404, 31, 34, 38, 3, -38 },
  { 4536, 26, 47, 38, 9, -47 },
  { 4689, 38, 59, 38, 1, -47 },
  { 4970, 31, 47, 38, 1, -47 },
  { 5153, 33, 47, 38, 3, -47 },
  { 5347, 32, 48, 38, 4, -47 },
  { 5539, 33, 47, 38, 3, -47 },
  { 5733, 34, 47, 38, 4, -47 },
  { 5933, 34, 47, 38, 4, -47 },
  { 6133, 32, 48, 38, 4, -47 },
  { 6325, 34, 47, 38, 3, -47 },
  { 6525, 32, 47, 38, 4, -47 },
  { 6713, 34, 48, 38, 2, -47 },
  { 6917, 36, 47, 38, 3, -47 },
  { 7129, 27, 47, 38, 5, -47 },
  { 7288, 36, 47, 38, 2, -47 },
  { 7500, 34, 47, 38, 3, -47 },
  { 7700, 32, 48, 38, 4, -47 },
  { 7892, 35, 47, 38, 3, -47 },
  { 8098, 32, 59, 38, 4, -47 },
  { 8334, 34, 47, 38, 3, -47 },
  { 8534, 34, 48, 38, 3, -47 },
  { 8738, 32, 47, 38, 7, -47 },
  { 8926, 33, 48, 38, 4, -47 },
  { 9124, 31, 47, 38, 8, -47 },
  { 9307, 36, 47, 38, 5, -47 },
  { 9519, 39, 47, 38, 0, -47 },
  { 9749, 34, 47, 38, 7, -47 },
  { 9949, 34, 47, 38, 3, -47 },
  { 10149, 25, 60, 38, 9, -53 },
  { 10337, 18, 60, 38, 11, -53 },
  { 10472, 25, 60, 38, 6, -53 },
  { 10660, 28, 25, 38, 6, -47 },
  { 10748, 31, 4, 38, 0, 2 },
  { 10764, 11, 9, 38, 17, -50 },
  { 10777, 31, 37, 38, 4, -36 },
  { 10921, 31, 48, 38, 3, -47 },
  { 11107, 31, 37, 38, 4, -36 },
  { 11251, 33, 48, 38, 4, -47 },
  { 11449, 30, 37, 38, 4, -36 },
  { 11588, 43, 59, 38, -3, -47 },
  { 11906, 30, 48, 38, 5, -36 },
  { 12086, 31, 47, 38, 3, -47 },
  { 12269, 30, 50, 38, 3, -50 },
  { 12457, 33, 62, 38, 1, -50 },
  { 12713, 33, 47, 38, 4, -47 },
  { 12907, 26, 47, 38, 7, -47 },
  { 13060, 34, 36, 38, 2, -36 },
  { 13213, 31, 36, 38, 3, -36 },
  { 13353, 30, 37, 38, 4, -36 },
  { 13492, 32, 48, 38, 2, -36 },
  { 13684, 31, 48, 38, 4, -36 },
  { 13870, 31, 36, 38, 5, -36 },
  { 14010, 30, 37, 38, 4, -36 },
  { 14149, 30, 45, 38, 6, -45 },
  { 14318, 31, 36, 38, 4, -35 },
  { 14458, 30, 35, 38, 7, -35 },
  { 14590, 34, 35, 38, 5, -35 },
  { 14739, 36, 35, 38, 1, -35 },
  { 14897, 30, 47, 38, 5, -35 },
  { 15074, 31, 35, 38, 3, -35 },
  { 15210, 32, 60, 38, 6, -53 },
  { 15450, 14, 60, 38, 13, -53 },
  { 15555, 32, 60, 38, 2, -53 },
  { 15795, 32, 13, 38, 4, -29 },
};

const GFXfont JetBrainsMono_LightItalic64pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_LightItalic64pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_LightItalic64pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _JETBRAINSMONO_LIGHTITALIC64PT7B_H_
