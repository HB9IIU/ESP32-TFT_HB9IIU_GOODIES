#ifndef _JETBRAINSMONO_LIGHTITALIC67PT7B_H_
#define _JETBRAINSMONO_LIGHTITALIC67PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-LightItalic.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_LightItalic67pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0,
  0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0xFE, 0x03, 0xFC, 0x0F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0x00, 0x3F, 0x00, 0xFC,
  0xFC, 0x03, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x7E, 0x01, 0xF9, 0xF8,
  0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0x7C, 0x7E, 0x03, 0xF1, 0xF0, 0x0F,
  0xC7, 0xC0, 0x3F, 0x1F, 0x00, 0xFC, 0x7C, 0x03, 0xE3, 0xF0, 0x0F, 0x8F,
  0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x0F, 0x80,
  0x7C, 0x3C, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x01, 0xF0,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x01, 0xF0,
  0x00, 0x03, 0xC0, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x0F, 0x00,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xDD, 0xFF, 0x00, 0x1F,
  0xC3, 0x87, 0xF0, 0x07, 0xF0, 0xF0, 0x7E, 0x00, 0xFC, 0x1E, 0x0F, 0xC0,
  0x3F, 0x03, 0xC0, 0xF8, 0x07, 0xC0, 0x78, 0x1F, 0x80, 0xF8, 0x0E, 0x03,
  0xF0, 0x3F, 0x01, 0xC0, 0x7C, 0x07, 0xE0, 0x78, 0x00, 0x00, 0xFC, 0x0F,
  0x00, 0x00, 0x1F, 0x81, 0xE0, 0x00, 0x03, 0xF0, 0x3C, 0x00, 0x00, 0x7E,
  0x07, 0x80, 0x00, 0x0F, 0xE0, 0xE0, 0x00, 0x00, 0xFE, 0x3C, 0x00, 0x00,
  0x1F, 0xE7, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xE7, 0xF8, 0x00, 0x00, 0x38, 0x3F, 0x80,
  0x00, 0x07, 0x03, 0xF0, 0x00, 0x01, 0xE0, 0x7E, 0x00, 0x00, 0x3C, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x1C,
  0x03, 0xE0, 0xF8, 0x03, 0x80, 0x7C, 0x1F, 0x00, 0xF0, 0x0F, 0x83, 0xE0,
  0x1E, 0x03, 0xF0, 0x7C, 0x03, 0xC0, 0x7C, 0x0F, 0xC0, 0x78, 0x1F, 0x81,
  0xF8, 0x0F, 0x03, 0xF0, 0x3F, 0x81, 0xC0, 0xFC, 0x03, 0xF8, 0x78, 0x7F,
  0x00, 0x7F, 0xEF, 0x3F, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x78, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x3E, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0xE0, 0x07,
  0xC0, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0x07, 0x80, 0x3E, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0xF8, 0x07, 0x80, 0x00, 0xF8, 0x03, 0xE0, 0x3C, 0x00,
  0x03, 0xE0, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x3C, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x07, 0xC3, 0xE0, 0x00, 0x03,
  0xE0, 0x1E, 0x0F, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x78, 0x00, 0x00, 0x1F,
  0xFF, 0xC3, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x1F, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x83, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x3F,
  0xFC, 0x00, 0x00, 0x01, 0xE1, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x78, 0x7E, 0x0F, 0xC0, 0x00, 0x03, 0xE1, 0xF0, 0x1F,
  0x00, 0x00, 0x1F, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x1F, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x00,
  0x3E, 0x01, 0xF0, 0x07, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x0F,
  0x80, 0x1E, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x78, 0x03, 0xE0, 0x01, 0xE0,
  0x01, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x7C, 0x00,
  0x0F, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xE0,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8,
  0x3F, 0x00, 0x3E, 0x1F, 0x01, 0xF8, 0x07, 0xC3, 0xF0, 0x1F, 0x80, 0xFC,
  0x3E, 0x00, 0xFC, 0x1F, 0x83, 0xE0, 0x0F, 0xC1, 0xF0, 0x3E, 0x00, 0x7E,
  0x3F, 0x03, 0xE0, 0x03, 0xE7, 0xE0, 0x7E, 0x00, 0x3F, 0x7C, 0x07, 0xE0,
  0x01, 0xFF, 0x80, 0x7C, 0x00, 0x1F, 0xF8, 0x07, 0xC0, 0x00, 0xFF, 0x00,
  0x7C, 0x00, 0x0F, 0xE0, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x0F,
  0xE0, 0x0F, 0xC0, 0x01, 0xFF, 0x00, 0xFC, 0x00, 0x1F, 0xF8, 0x0F, 0xC0,
  0x07, 0xFF, 0x80, 0x7E, 0x00, 0xFE, 0xFC, 0x07, 0xF8, 0x3F, 0xCF, 0xC0,
  0x7F, 0xFF, 0xF8, 0x7E, 0x03, 0xFF, 0xFE, 0x03, 0xE0, 0x1F, 0xFF, 0xC0,
  0x3F, 0x00, 0x7F, 0xF0, 0x01, 0xF8, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x9F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xE1, 0xF0, 0xF8, 0x7C, 0x7C, 0x3E, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xC0, 0x03,
  0xC0, 0x03, 0x3F, 0x00, 0x78, 0x03, 0xE7, 0xF8, 0x0F, 0x03, 0xFD, 0xFF,
  0xC1, 0xC1, 0xFF, 0xFF, 0xFE, 0x38, 0xFF, 0xF9, 0xFF, 0xE7, 0x7F, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3E,
  0xF0, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0xFC, 0x00,
  0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x7F,
  0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFE, 0x0F, 0x83, 0xFE, 0x3F, 0xE7, 0xFE, 0x7F, 0xEF,
  0xFE, 0xFF, 0xEF, 0xFE, 0x7F, 0xC3, 0xF8, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xE0,
  0x7F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0xFE, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x03, 0xE0,
  0xFC, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00,
  0x7E, 0x1F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x3F,
  0x01, 0xF0, 0x7C, 0x0F, 0xE0, 0x7C, 0x1F, 0x07, 0xF8, 0x3F, 0x0F, 0xC1,
  0xFE, 0x0F, 0xC3, 0xF0, 0x7F, 0x83, 0xE0, 0xF8, 0x0F, 0xC0, 0xF8, 0x3E,
  0x01, 0xF0, 0x3E, 0x0F, 0x80, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00,
  0xFC, 0x1F, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0xE0,
  0x00, 0x3F, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFC, 0xF8,
  0x00, 0x0F, 0xF3, 0xF0, 0x00, 0x7F, 0x87, 0xE0, 0x01, 0xFE, 0x0F, 0x80,
  0x03, 0xF0, 0x1F, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x1E, 0x00, 0x7C, 0x00,
  0x38, 0x01, 0xF8, 0x00, 0x40, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x81,
  0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0xFE, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x80, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x1F, 0x87, 0xC0,
  0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x0F,
  0xE0, 0x03, 0xF8, 0x03, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x2E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x7C, 0x07, 0xE0, 0x00,
  0x7C, 0x0F, 0xC0, 0x00, 0x7C, 0x1F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00,
  0xF8, 0x7E, 0x00, 0x00, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xF0, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0xFF, 0x80, 0x01,
  0xF1, 0xFF, 0xF8, 0x00, 0xF9, 0xFF, 0xFE, 0x00, 0x7D, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xF8,
  0x0F, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F,
  0x02, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x07, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x01, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF8, 0x03, 0xFE,
  0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0xFF, 0x00, 0x03, 0xF3, 0xFF, 0xC0,
  0x03, 0xEF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFE, 0x1F, 0xF8,
  0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0xFE,
  0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E,
  0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x7C,
  0xF8, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC,
  0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x07, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0,
  0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E,
  0x7C, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0xF8,
  0x7C, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFC, 0x0F,
  0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x7F, 0x01, 0xF8, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F,
  0xC0, 0x3F, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F,
  0x0F, 0x80, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00,
  0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0x0F, 0xF8, 0x07, 0xF0, 0x03, 0xFC, 0x0F,
  0xC0, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x3F,
  0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3E, 0xFC,
  0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x7C, 0xF8,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x01, 0xF8, 0xFE, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7F,
  0x80, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xEF, 0xC0, 0x07, 0xFF, 0xDF, 0x80, 0x01, 0xFF, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x10, 0x01, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x07,
  0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF,
  0xE0, 0xFF, 0xE0, 0x7F, 0xC0, 0x3F, 0x80, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x40, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0x04, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x03,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x0F,
  0x00, 0x00, 0x40, 0x78, 0x3E, 0x00, 0x0F, 0xF8, 0xF0, 0x7C, 0x00, 0x7F,
  0xF9, 0xE0, 0xF8, 0x01, 0xFF, 0xF3, 0xC1, 0xF0, 0x07, 0xFD, 0xF7, 0x83,
  0xE0, 0x1F, 0x80, 0x7F, 0x07, 0x80, 0x3E, 0x00, 0x7E, 0x1F, 0x00, 0x7C,
  0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x03, 0xE0,
  0xF8, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x0F, 0x00, 0x0F, 0x83, 0xC0, 0x3E,
  0x00, 0x1F, 0x0F, 0x80, 0x7C, 0x00, 0x3C, 0x1F, 0x00, 0xF8, 0x00, 0xF8,
  0x3E, 0x01, 0xF0, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x03, 0xE0, 0xF8, 0x07,
  0x80, 0x07, 0xC1, 0xF0, 0x1F, 0x00, 0x0F, 0x83, 0xC0, 0x3E, 0x00, 0x1E,
  0x0F, 0x80, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x00, 0xF8, 0x3E, 0x01,
  0xF0, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0x07, 0xE0, 0xF8, 0x07, 0xF0, 0x1F,
  0xC1, 0xE0, 0x07, 0xFF, 0xEF, 0x07, 0xC0, 0x0F, 0xFF, 0xDE, 0x0F, 0x80,
  0x0F, 0xFF, 0x3C, 0x1F, 0x00, 0x07, 0xF8, 0x78, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xF9, 0xE0,
  0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x7E, 0x78, 0x00, 0x00, 0x3E, 0x3E,
  0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07, 0xE0,
  0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF0,
  0x0F, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x7C,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0xF8, 0x03,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7C, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x07,
  0xC7, 0xE0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x00,
  0xF9, 0xF0, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x7C, 0x00, 0x3F, 0xC0, 0x3F, 0x00, 0x03, 0xF8, 0x0F, 0x80, 0x00, 0xFE,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x3F, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x03, 0xF0, 0x0F, 0x80, 0x03, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xF0, 0x00, 0x7F, 0x80, 0x7C, 0x00, 0x07,
  0xE0, 0x1F, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x3F, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x7E, 0x0F, 0x80,
  0x00, 0x1F, 0x83, 0xE0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0xC1,
  0xF0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0xFC,
  0x07, 0xC0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xF0, 0x03, 0xF8,
  0x07, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF0,
  0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xF0, 0x01, 0xF8,
  0x01, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F,
  0x80, 0x0F, 0xF0, 0x0F, 0xC0, 0x03, 0xFC, 0x07, 0xC0, 0x00, 0x7E, 0x03,
  0xE0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0xFC,
  0x1F, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x07,
  0xE0, 0xF8, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00,
  0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x3E, 0x0F, 0xC0, 0x00,
  0x3F, 0x07, 0xC0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x01, 0xF0, 0x7E, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x7E, 0x0F, 0x80,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x83, 0xF0,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xE0, 0x7C,
  0x00, 0x07, 0xE0, 0x3E, 0x00, 0x07, 0xF0, 0x1F, 0x00, 0x07, 0xF0, 0x1F,
  0x80, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x07, 0xF0,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0xFF, 0xFF, 0x0F, 0x80, 0x7F, 0xFF, 0x07, 0xC0, 0x7F, 0xFF,
  0x83, 0xE0, 0x3F, 0xFF, 0xC3, 0xF0, 0x1F, 0xFF, 0xE1, 0xF8, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00,
  0x7C, 0x1F, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1F, 0x0F, 0xC0, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x03, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF0, 0x3F, 0x00,
  0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xF0, 0x01, 0xF8, 0x01, 0xFE,
  0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00,
  0x7C, 0x07, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x7C, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x1F,
  0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01,
  0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x7C, 0x00,
  0x01, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x07,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x1F, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x7C,
  0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x3B, 0xC0, 0x01, 0xFE, 0x01,
  0xEF, 0x00, 0x0F, 0xF8, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x1E, 0xF0, 0x01,
  0xF7, 0x80, 0x7B, 0xE0, 0x07, 0xBC, 0x01, 0xEF, 0x80, 0x3E, 0xF0, 0x07,
  0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x07, 0xCF, 0x00, 0xF9, 0xE0, 0x1E,
  0x7C, 0x03, 0xE7, 0x80, 0xF9, 0xF0, 0x0F, 0x9F, 0x03, 0xC7, 0xC0, 0x3E,
  0x7C, 0x1F, 0x1E, 0x00, 0xF0, 0xF0, 0x78, 0xF8, 0x03, 0xC3, 0xC3, 0xE3,
  0xE0, 0x1F, 0x0F, 0x0F, 0x0F, 0x80, 0x7C, 0x3C, 0x3C, 0x3E, 0x01, 0xF0,
  0xF9, 0xE0, 0xF8, 0x07, 0xC1, 0xE7, 0x87, 0xC0, 0x1F, 0x07, 0xBC, 0x1F,
  0x00, 0x7C, 0x1E, 0xF0, 0x7C, 0x03, 0xF0, 0x7F, 0x81, 0xF0, 0x0F, 0x81,
  0xFE, 0x07, 0xC0, 0x3E, 0x07, 0xF0, 0x3F, 0x00, 0xF8, 0x0F, 0xC0, 0xF8,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x7E, 0x00,
  0x00, 0x3E, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x1F, 0x00, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00,
  0x7E, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x0F, 0xF0, 0x00, 0x3E, 0x00, 0xFF, 0x00, 0x03, 0xE0, 0x0F,
  0xF0, 0x00, 0x3E, 0x01, 0xFF, 0x00, 0x03, 0xE0, 0x1F, 0xF0, 0x00, 0x3E,
  0x01, 0xFF, 0x80, 0x07, 0xE0, 0x1F, 0xF8, 0x00, 0x7C, 0x01, 0xFF, 0x80,
  0x07, 0xC0, 0x1F, 0x78, 0x00, 0x7C, 0x01, 0xE7, 0x80, 0x07, 0xC0, 0x3E,
  0x7C, 0x00, 0x7C, 0x03, 0xE7, 0xC0, 0x07, 0xC0, 0x3E, 0x7C, 0x00, 0xFC,
  0x03, 0xE3, 0xC0, 0x0F, 0x80, 0x3E, 0x3C, 0x00, 0xF8, 0x03, 0xE3, 0xE0,
  0x0F, 0x80, 0x7E, 0x3E, 0x00, 0xF8, 0x07, 0xC3, 0xE0, 0x0F, 0x80, 0x7C,
  0x1E, 0x01, 0xF8, 0x07, 0xC1, 0xF0, 0x1F, 0x00, 0x7C, 0x1F, 0x01, 0xF0,
  0x07, 0xC1, 0xF0, 0x1F, 0x00, 0xFC, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF0,
  0x1F, 0x00, 0xF8, 0x0F, 0x83, 0xF0, 0x0F, 0x80, 0xF8, 0x3E, 0x00, 0xF8,
  0x0F, 0x83, 0xE0, 0x0F, 0x80, 0x78, 0x3E, 0x00, 0xF8, 0x07, 0x83, 0xE0,
  0x1F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0x07, 0xC3, 0xE0, 0x1F, 0x00, 0x7C,
  0x7E, 0x01, 0xF0, 0x03, 0xC7, 0xC0, 0x1F, 0x00, 0x3E, 0x7C, 0x01, 0xF0,
  0x03, 0xE7, 0xC0, 0x3F, 0x00, 0x3E, 0x7C, 0x03, 0xE0, 0x03, 0xE7, 0xC0,
  0x3E, 0x00, 0x1E, 0x7C, 0x03, 0xE0, 0x01, 0xF7, 0x80, 0x3E, 0x00, 0x1F,
  0xF8, 0x03, 0xE0, 0x01, 0xFF, 0x80, 0x7E, 0x00, 0x1F, 0xF8, 0x07, 0xC0,
  0x00, 0xFF, 0x80, 0x7C, 0x00, 0x0F, 0xF8, 0x07, 0xC0, 0x00, 0xFF, 0x00,
  0x7C, 0x00, 0x0F, 0xF0, 0x07, 0xC0, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF,
  0x83, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x3F, 0x07, 0xC0,
  0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3F, 0x0F, 0x80,
  0x00, 0x3F, 0x0F, 0x80, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x80,
  0x00, 0x3E, 0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3E, 0x1F, 0x00,
  0x00, 0x7E, 0x1F, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x7C, 0x3F, 0x00,
  0x00, 0x7C, 0x3F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00,
  0x00, 0xFC, 0x3E, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0xF8, 0x7E, 0x00,
  0x00, 0xF8, 0x7E, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x01, 0xF8, 0x7C, 0x00,
  0x01, 0xF0, 0xFC, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x03, 0xF0, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xE0, 0xFC, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0x7F, 0x00,
  0x3F, 0x80, 0x7F, 0xC0, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0x00, 0x07, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x3E, 0x00,
  0x00, 0xFE, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0x7E, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x00, 0x7E, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0x7C, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x1F,
  0x80, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0xFF, 0x00, 0xF8, 0x00,
  0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x07, 0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0xF8, 0x3F,
  0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x07, 0xE0,
  0xF8, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x1F,
  0x07, 0xE0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00,
  0xFC, 0x1F, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x03, 0xE0, 0xFC, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0x80,
  0x00, 0x1F, 0x83, 0xE0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x01,
  0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xF8, 0x1F, 0xE0, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xE0, 0x00, 0xFF, 0x00, 0xFC, 0x00,
  0x0F, 0xF0, 0x1F, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x7C,
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x7E, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0xF8, 0x00,
  0x01, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0xF8,
  0x00, 0x07, 0xF0, 0x1F, 0x00, 0x01, 0xFC, 0x03, 0xE0, 0x00, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xF0, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x01, 0xF8,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0xFC, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x0F,
  0xC0, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x03,
  0xF0, 0x7C, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x03, 0xE0, 0x3F, 0x80, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x7F,
  0xE0, 0x7F, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x7C, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x7E,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00,
  0x3E, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0x80,
  0x00, 0x3F, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x07,
  0xC0, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0xFC,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x01, 0xF0, 0x1F, 0x80,
  0x00, 0x7E, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x01, 0xF8, 0x0F,
  0x80, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0xF8,
  0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00,
  0xFC, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x00,
  0x00, 0x7C, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x03, 0xF0,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x7C,
  0xF8, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xF8,
  0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0,
  0x7C, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xE0,
  0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x0F, 0x80,
  0x7E, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF0, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x1F, 0x07, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x1F, 0x1F, 0x80, 0x00,
  0x1F, 0x9F, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00,
  0x0F, 0xBE, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0x7C, 0xF8, 0x01, 0xF8, 0x01, 0xF3, 0xE0, 0x0F, 0xE0, 0x07, 0x8F, 0x80,
  0x3F, 0x80, 0x3E, 0x3C, 0x00, 0xFE, 0x00, 0xF8, 0xF0, 0x03, 0xF8, 0x03,
  0xE7, 0xC0, 0x1F, 0xE0, 0x1F, 0x1F, 0x00, 0x77, 0x80, 0x7C, 0x7C, 0x01,
  0xDE, 0x01, 0xF1, 0xF0, 0x0F, 0x78, 0x07, 0x87, 0xC0, 0x3D, 0xE0, 0x3E,
  0x1F, 0x00, 0xE7, 0x80, 0xF8, 0x7C, 0x03, 0x9C, 0x03, 0xE1, 0xF0, 0x1E,
  0x70, 0x0F, 0x07, 0xC0, 0x71, 0xC0, 0x7C, 0x1F, 0x01, 0xC7, 0x01, 0xF0,
  0x7C, 0x0F, 0x1C, 0x07, 0xC1, 0xF0, 0x3C, 0x70, 0x3E, 0x07, 0xC0, 0xE1,
  0xC0, 0xF8, 0x1F, 0x07, 0x87, 0x03, 0xE0, 0x7C, 0x1E, 0x1C, 0x0F, 0x01,
  0xF0, 0x70, 0x70, 0x7C, 0x07, 0xC1, 0xC1, 0xC1, 0xF0, 0x1F, 0x0F, 0x07,
  0x07, 0xC0, 0x78, 0x3C, 0x1C, 0x1E, 0x01, 0xE0, 0xE0, 0x70, 0xF8, 0x07,
  0x87, 0x83, 0xC3, 0xE0, 0x1E, 0x1E, 0x0F, 0x0F, 0x00, 0x78, 0x70, 0x3C,
  0x3C, 0x01, 0xE1, 0xC0, 0xF1, 0xF0, 0x0F, 0x8F, 0x03, 0xC7, 0xC0, 0x3E,
  0x3C, 0x0F, 0x1E, 0x00, 0xF8, 0xE0, 0x3C, 0xF8, 0x03, 0xE7, 0x80, 0xF3,
  0xE0, 0x0F, 0x9E, 0x03, 0xCF, 0x80, 0x3E, 0x70, 0x0F, 0x3C, 0x00, 0xF9,
  0xC0, 0x3D, 0xF0, 0x03, 0xEF, 0x00, 0xE7, 0xC0, 0x0F, 0xBC, 0x03, 0x9E,
  0x00, 0x3E, 0xE0, 0x0E, 0x78, 0x00, 0xFF, 0x80, 0x3B, 0xE0, 0x03, 0xDE,
  0x00, 0xEF, 0x80, 0x0F, 0x70, 0x03, 0xBC, 0x00, 0x3D, 0xC0, 0x0E, 0xF0,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0x00, 0x3E,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0x07,
  0xE0, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x00, 0x3F, 0x1F, 0x00, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xF0,
  0x1F, 0x80, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x0F, 0xC0, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x1F, 0x80, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x00, 0xF8, 0x3F, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF8, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x03, 0xEF,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x1F, 0x00,
  0x00, 0xF8, 0x78, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x07,
  0xC0, 0x78, 0x00, 0x7C, 0x03, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x03, 0xC0, 0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF8,
  0x1F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x7C,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0x1E, 0x7E, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x07, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3F, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x07, 0xFE, 0x0F, 0xC0, 0x0F, 0xFF, 0xC7, 0xC0, 0x0F,
  0xFF, 0xF3, 0xE0, 0x0F, 0xFF, 0xF9, 0xF0, 0x0F, 0xF0, 0x3E, 0xF8, 0x0F,
  0xE0, 0x07, 0x7C, 0x0F, 0xE0, 0x01, 0xFE, 0x07, 0xE0, 0x00, 0x7F, 0x07,
  0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x01, 0xF8,
  0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3E,
  0x0F, 0xC0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x0F,
  0xC1, 0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01,
  0xF0, 0x7E, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x03, 0xF0, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0x80,
  0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0xFE, 0xF8, 0x03, 0xFF,
  0xFE, 0x7C, 0x00, 0xFF, 0xFE, 0x3E, 0x00, 0x1F, 0xFC, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x0C, 0x00, 0x07, 0xE0, 0xFF, 0xC0, 0x07, 0xC3, 0xFF, 0xF0, 0x07,
  0xCF, 0xFF, 0xF8, 0x07, 0xCF, 0xFF, 0xF8, 0x07, 0xDF, 0x07, 0xFC, 0x07,
  0xF8, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x7E, 0x1F,
  0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x7C, 0x3F,
  0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0xF8, 0x3E,
  0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x03, 0xE0, 0x7F, 0x00, 0x07, 0xE0, 0xFF, 0x80, 0x1F, 0xC0, 0xFF,
  0xE0, 0x7F, 0xC0, 0xF9, 0xFF, 0xFF, 0x80, 0xF9, 0xFF, 0xFF, 0x00, 0xF8,
  0xFF, 0xFC, 0x00, 0xF8, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x01, 0xFC,
  0x00, 0xFF, 0x07, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x0F, 0x8F,
  0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x7C, 0x3F, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x07, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0xFF, 0x81, 0xFF, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x17, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x20, 0x0F, 0xC0,
  0x00, 0xFF, 0xC1, 0xF8, 0x00, 0x7F, 0xFE, 0x3E, 0x00, 0x1F, 0xFF, 0xE7,
  0xC0, 0x07, 0xFF, 0xFC, 0xF8, 0x01, 0xFE, 0x07, 0xDF, 0x00, 0x7F, 0x00,
  0x3B, 0xE0, 0x1F, 0xC0, 0x03, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0xFC,
  0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x7E, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x7E, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xFE, 0x01, 0xFC,
  0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xF8, 0x03, 0xFC, 0x07, 0xFF, 0x00,
  0x3F, 0xFF, 0xF7, 0xC0, 0x07, 0xFF, 0xFC, 0xF8, 0x00, 0x7F, 0xFF, 0x1F,
  0x00, 0x03, 0xFF, 0x83, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x00,
  0x7E, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x01,
  0xF8, 0x7C, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7E,
  0x3E, 0x00, 0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x8F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x3F, 0x00, 0x7F,
  0xFE, 0x3E, 0x00, 0xFF, 0xFF, 0x3E, 0x01, 0xFF, 0xFF, 0xBE, 0x03, 0xFC,
  0x0F, 0xBE, 0x07, 0xF0, 0x03, 0xBE, 0x0F, 0xE0, 0x01, 0xFE, 0x0F, 0xC0,
  0x00, 0xFE, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3E, 0x00,
  0x00, 0xFC, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00,
  0x00, 0xF8, 0x7E, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7C, 0x00,
  0x01, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x03, 0xF0, 0x7C, 0x00,
  0x07, 0xF0, 0x7E, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0xFB, 0xE0, 0x3F, 0xFF, 0xF3, 0xE0, 0x1F, 0xFF,
  0xE7, 0xE0, 0x0F, 0xFF, 0xC7, 0xE0, 0x03, 0xFF, 0x07, 0xC0, 0x00, 0x30,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x0C, 0x00, 0x07, 0xE1,
  0xFF, 0xC0, 0x07, 0xC3, 0xFF, 0xF0, 0x07, 0xCF, 0xFF, 0xF8, 0x07, 0xDF,
  0xFF, 0xF8, 0x07, 0xDE, 0x03, 0xFC, 0x07, 0xF8, 0x01, 0xFC, 0x0F, 0xF0,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x7E, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x80,
  0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x7E, 0x1F, 0x00,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x3F, 0x00,
  0x00, 0x7C, 0x3F, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0xFC, 0x3E, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00,
  0x00, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7C, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x01, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xF8, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x07, 0xE0, 0x3E, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x1F, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x03, 0xF0, 0x0F,
  0xE0, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0x80,
  0x00, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x01, 0xF8, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0x80, 0x04, 0x00, 0x7C, 0x7F, 0x03, 0xF8, 0x07, 0xCF, 0xF8, 0xFF,
  0xC0, 0x7D, 0xFF, 0xDF, 0xFE, 0x07, 0xFF, 0xFD, 0xFF, 0xE0, 0x7E, 0x0F,
  0xF0, 0x7E, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0xFC, 0x07, 0xE0, 0x3E, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0xF8, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x78, 0x03, 0xE0, 0xF8, 0x07,
  0x80, 0x7C, 0x1F, 0x00, 0x78, 0x07, 0xC1, 0xF0, 0x0F, 0x80, 0x7C, 0x1F,
  0x00, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF0, 0x07,
  0xC1, 0xF0, 0x0F, 0x00, 0x7C, 0x3E, 0x00, 0xF0, 0x0F, 0x83, 0xE0, 0x0F,
  0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x00, 0xF8, 0x3E,
  0x01, 0xF0, 0x0F, 0x83, 0xE0, 0x1E, 0x00, 0xF8, 0x7C, 0x01, 0xE0, 0x1F,
  0x07, 0xC0, 0x1E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x1F, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x1F, 0x07, 0xC0, 0x3C, 0x01, 0xF0, 0x7C,
  0x03, 0xC0, 0x1F, 0x0F, 0x80, 0x3C, 0x03, 0xE0, 0xF8, 0x07, 0xC0, 0x3E,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x78,
  0x03, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x07, 0xE1, 0xFF, 0xC0, 0x07, 0xC3,
  0xFF, 0xF0, 0x07, 0xCF, 0xFF, 0xF8, 0x07, 0xDF, 0xFF, 0xF8, 0x07, 0xDE,
  0x03, 0xFC, 0x07, 0xF8, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0x80,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0x7E, 0x1F, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x7C, 0x3F, 0x00,
  0x00, 0xFC, 0x3E, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x7E, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0xFC, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x01, 0xFC, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x01,
  0xF8, 0x7C, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x7E,
  0x3E, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3F, 0x1F,
  0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x01, 0xF1, 0xF8,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0x3E, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF0, 0x3F, 0x00,
  0x07, 0xE0, 0x7F, 0x00, 0x3F, 0x80, 0xFF, 0x81, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x7E,
  0x0F, 0xFC, 0x00, 0x1F, 0x0F, 0xFF, 0xC0, 0x07, 0xCF, 0xFF, 0xF8, 0x01,
  0xF7, 0xFF, 0xFE, 0x00, 0x7D, 0xF0, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0,
  0x0F, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x0F, 0x81, 0xF8, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x00,
  0x00, 0x7E, 0x07, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x1F, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7C, 0x07, 0xE0, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x7F, 0x00, 0x07, 0xE0, 0x3F, 0xE0,
  0x07, 0xF0, 0x0F, 0xFE, 0x07, 0xFC, 0x03, 0xE7, 0xFF, 0xFE, 0x00, 0xF9,
  0xFF, 0xFF, 0x00, 0x3E, 0x3F, 0xFF, 0x00, 0x0F, 0x83, 0xFF, 0x80, 0x07,
  0xE0, 0x1C, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x07, 0xFE, 0x0F, 0xC0,
  0x0F, 0xFF, 0xC7, 0xC0, 0x0F, 0xFF, 0xF3, 0xE0, 0x0F, 0xFF, 0xF9, 0xF0,
  0x0F, 0xF0, 0x3E, 0xF8, 0x0F, 0xE0, 0x07, 0xFC, 0x0F, 0xE0, 0x01, 0xFE,
  0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x1F,
  0x81, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x03,
  0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00,
  0x7C, 0x1F, 0x80, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xC0, 0x00,
  0x1F, 0x83, 0xE0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0xF8, 0x3F, 0x00,
  0x00, 0xFC, 0x1F, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0xE0,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xF0, 0x07,
  0xFF, 0xFE, 0xF8, 0x03, 0xFF, 0xFE, 0x7C, 0x00, 0xFF, 0xFE, 0x3E, 0x00,
  0x1F, 0xFC, 0x1F, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x03, 0xE0,
  0xFF, 0xC0, 0x07, 0xE3, 0xFF, 0xF0, 0x07, 0xC7, 0xFF, 0xF8, 0x07, 0xCF,
  0xFF, 0xFC, 0x07, 0xDF, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x3F, 0x0F, 0x80,
  0x00, 0x3E, 0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFE,
  0x03, 0xFE, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xC0,
  0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0xFC, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x07, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xE0, 0x00,
  0x0F, 0xC1, 0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x01, 0xF0, 0x7E, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x00,
  0x00, 0x7E, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x0F, 0x83, 0xF0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xF8,
  0x00, 0x03, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x1F, 0x07,
  0xE0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0xF8,
  0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x3E,
  0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3E, 0x7C, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x7C, 0x7C, 0x00,
  0x00, 0xFC, 0x7C, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x01, 0xF0, 0x3E, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x07, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xF8, 0x01,
  0xF8, 0x01, 0xEF, 0x00, 0x3F, 0x00, 0x7D, 0xE0, 0x07, 0xE0, 0x0F, 0xBC,
  0x01, 0xFC, 0x01, 0xE7, 0x80, 0x3F, 0x80, 0x7C, 0xF0, 0x07, 0xF0, 0x0F,
  0x9E, 0x01, 0xFE, 0x01, 0xE3, 0xC0, 0x3B, 0xC0, 0x3C, 0x78, 0x07, 0x78,
  0x0F, 0x8F, 0x01, 0xEF, 0x01, 0xE1, 0xE0, 0x39, 0xE0, 0x3C, 0x3C, 0x07,
  0x3C, 0x0F, 0x87, 0x81, 0xE7, 0x81, 0xE0, 0xF0, 0x38, 0xF0, 0x3C, 0x1E,
  0x07, 0x1E, 0x0F, 0x83, 0xC1, 0xE3, 0xC1, 0xE0, 0x78, 0x38, 0x78, 0x3C,
  0x0F, 0x07, 0x0F, 0x0F, 0x81, 0xE1, 0xE1, 0xE1, 0xE0, 0x3C, 0x38, 0x3C,
  0x3C, 0x07, 0x87, 0x07, 0x87, 0x80, 0xF1, 0xE0, 0xF1, 0xE0, 0x1E, 0x38,
  0x1E, 0x3C, 0x03, 0xC7, 0x03, 0xC7, 0x80, 0x79, 0xE0, 0x79, 0xF0, 0x0F,
  0x38, 0x0F, 0x3C, 0x01, 0xE7, 0x01, 0xE7, 0x80, 0x3D, 0xE0, 0x3D, 0xF0,
  0x07, 0xBC, 0x07, 0xBC, 0x00, 0xF7, 0x00, 0xF7, 0x80, 0x1F, 0xE0, 0x1F,
  0xF0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x0F, 0xE0,
  0x0F, 0xF0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x07,
  0xE0, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00,
  0x1F, 0x80, 0x3F, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x7C,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x0F, 0x87, 0xE0, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xFE, 0x00,
  0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E,
  0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7E,
  0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C,
  0x1F, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC,
  0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x01, 0xF8,
  0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0,
  0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x03, 0xF0,
  0x7C, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x3B, 0xE0, 0x3F, 0xE0, 0xFB, 0xE0, 0x3F, 0xFF, 0xF7, 0xE0,
  0x1F, 0xFF, 0xE7, 0xE0, 0x0F, 0xFF, 0xC7, 0xC0, 0x03, 0xFF, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x08, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0x83, 0xFF, 0x80, 0x07, 0xC3,
  0xFF, 0xE0, 0x03, 0xE3, 0xFF, 0xF8, 0x01, 0xF3, 0xF8, 0xFE, 0x00, 0xF9,
  0xF0, 0x3F, 0x00, 0xF8, 0xF8, 0x0F, 0xC0, 0x7C, 0xF8, 0x03, 0xF0, 0x7E,
  0x7C, 0x01, 0xFE, 0xFE, 0x3E, 0x00, 0x7F, 0xFF, 0x1F, 0x00, 0x1F, 0xFF,
  0x0F, 0x80, 0x07, 0xFF, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
};

const GFXglyph JetBrainsMono_LightItalic67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 40, 0, -1 },
  { 1, 15, 49, 40, 13, -49 },
  { 93, 22, 20, 40, 13, -49 },
  { 148, 38, 49, 40, 2, -49 },
  { 381, 35, 67, 40, 3, -58 },
  { 675, 46, 49, 40, -2, -49 },
  { 957, 36, 51, 40, 2, -50 },
  { 1187, 9, 20, 40, 19, -49 },
  { 1210, 28, 65, 40, 11, -57 },
  { 1438, 27, 65, 40, 3, -57 },
  { 1658, 35, 35, 40, 4, -41 },
  { 1812, 32, 32, 40, 5, -38 },
  { 1940, 17, 21, 40, 7, -10 },
  { 1985, 22, 4, 40, 10, -24 },
  { 1996, 12, 11, 40, 12, -10 },
  { 2013, 40, 63, 40, 1, -56 },
  { 2328, 34, 51, 40, 4, -50 },
  { 2545, 31, 49, 40, 3, -49 },
  { 2735, 35, 50, 40, 3, -50 },
  { 2954, 33, 50, 40, 4, -49 },
  { 3161, 32, 49, 40, 4, -49 },
  { 3357, 33, 50, 40, 4, -49 },
  { 3564, 32, 50, 40, 4, -49 },
  { 3764, 32, 49, 40, 8, -49 },
  { 3960, 33, 51, 40, 4, -50 },
  { 4171, 32, 50, 40, 7, -50 },
  { 4371, 16, 39, 40, 12, -38 },
  { 4449, 21, 49, 40, 7, -38 },
  { 4578, 32, 35, 40, 6, -40 },
  { 4718, 32, 20, 40, 5, -32 },
  { 4798, 31, 35, 40, 4, -40 },
  { 4934, 27, 49, 40, 10, -49 },
  { 5100, 39, 62, 40, 1, -50 },
  { 5403, 33, 49, 40, 1, -49 },
  { 5606, 34, 49, 40, 4, -49 },
  { 5815, 33, 51, 40, 5, -50 },
  { 6026, 33, 49, 40, 4, -49 },
  { 6229, 35, 49, 40, 4, -49 },
  { 6444, 36, 49, 40, 4, -49 },
  { 6665, 33, 51, 40, 5, -50 },
  { 6876, 34, 49, 40, 4, -49 },
  { 7085, 34, 49, 40, 4, -49 },
  { 7294, 36, 50, 40, 2, -49 },
  { 7519, 37, 49, 40, 4, -49 },
  { 7746, 29, 49, 40, 5, -49 },
  { 7924, 38, 49, 40, 2, -49 },
  { 8157, 36, 49, 40, 3, -49 },
  { 8378, 32, 51, 40, 5, -50 },
  { 8582, 36, 49, 40, 4, -49 },
  { 8803, 34, 62, 40, 4, -50 },
  { 9067, 35, 49, 40, 4, -49 },
  { 9282, 35, 51, 40, 3, -50 },
  { 9506, 33, 49, 40, 8, -49 },
  { 9709, 35, 50, 40, 4, -49 },
  { 9928, 32, 49, 40, 9, -49 },
  { 10124, 38, 49, 40, 5, -49 },
  { 10357, 41, 49, 40, 0, -49 },
  { 10609, 35, 49, 40, 7, -49 },
  { 10824, 35, 49, 40, 3, -49 },
  { 11039, 26, 63, 40, 10, -56 },
  { 11244, 20, 63, 40, 11, -56 },
  { 11402, 26, 63, 40, 6, -56 },
  { 11607, 29, 26, 40, 6, -49 },
  { 11702, 33, 4, 40, 0, 2 },
  { 11719, 12, 10, 40, 18, -53 },
  { 11734, 33, 39, 40, 4, -38 },
  { 11895, 32, 50, 40, 4, -49 },
  { 12095, 31, 39, 40, 5, -38 },
  { 12247, 35, 50, 40, 4, -49 },
  { 12466, 31, 39, 40, 5, -38 },
  { 12618, 45, 61, 40, -3, -49 },
  { 12962, 32, 50, 40, 5, -38 },
  { 13162, 32, 49, 40, 4, -49 },
  { 13358, 31, 52, 40, 3, -52 },
  { 13560, 34, 64, 40, 1, -52 },
  { 13832, 35, 49, 40, 4, -49 },
  { 14047, 28, 49, 40, 7, -49 },
  { 14219, 36, 38, 40, 2, -38 },
  { 14390, 32, 38, 40, 4, -38 },
  { 14542, 31, 39, 40, 5, -38 },
  { 14694, 34, 50, 40, 2, -38 },
  { 14907, 33, 50, 40, 4, -38 },
  { 15114, 32, 38, 40, 5, -38 },
  { 15266, 32, 39, 40, 4, -38 },
  { 15422, 31, 47, 40, 6, -47 },
  { 15605, 33, 38, 40, 4, -37 },
  { 15762, 32, 37, 40, 7, -37 },
  { 15910, 35, 37, 40, 5, -37 },
  { 16072, 37, 37, 40, 1, -37 },
  { 16244, 32, 49, 40, 5, -37 },
  { 16440, 33, 37, 40, 3, -37 },
  { 16593, 34, 63, 40, 6, -56 },
  { 16861, 16, 63, 40, 13, -56 },
  { 16987, 33, 63, 40, 2, -56 },
  { 17247, 33, 13, 40, 4, -30 },
};

const GFXfont JetBrainsMono_LightItalic67pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_LightItalic67pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_LightItalic67pt7bGlyphs,
  0x20, 0x7E, 88
};

#endif // _JETBRAINSMONO_LIGHTITALIC67PT7B_H_
