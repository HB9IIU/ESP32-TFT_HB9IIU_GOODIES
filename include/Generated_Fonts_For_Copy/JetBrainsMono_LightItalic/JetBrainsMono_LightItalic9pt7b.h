#ifndef _JETBRAINSMONO_LIGHTITALIC9PT7B_H_
#define _JETBRAINSMONO_LIGHTITALIC9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-LightItalic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_LightItalic9pt7bBitmaps[] PROGMEM = {
  0x00, 0x56, 0x88, 0xB7, 0x00, 0x29, 0x5E, 0xAF, 0xAA, 0x80, 0x11, 0x96,
  0xA3, 0x16, 0xAE, 0x20, 0x66, 0xAB, 0x14, 0x39, 0xA9, 0x80, 0x32, 0x50,
  0xCA, 0xCB, 0xA0, 0xE0, 0x12, 0x44, 0x44, 0x84, 0x20, 0x43, 0x11, 0x11,
  0x12, 0xC0, 0x16, 0xC8, 0xA0, 0x24, 0xF4, 0x60, 0xE0, 0x80, 0x08, 0x44,
  0x42, 0x21, 0x10, 0x69, 0x9D, 0x99, 0xE0, 0x13, 0x84, 0x22, 0x13, 0xE0,
  0x32, 0x42, 0x22, 0x23, 0xC0, 0x78, 0x4C, 0x20, 0xC5, 0xC0, 0x12, 0x49,
  0x9E, 0x20, 0x78, 0x8F, 0x11, 0xE0, 0x10, 0x88, 0xE4, 0xC5, 0xC0, 0xF9,
  0x12, 0x24, 0x80, 0x32, 0x52, 0x64, 0xC5, 0xC0, 0x69, 0x99, 0x64, 0xC0,
  0xC0, 0x80, 0x60, 0x05, 0x00, 0x3C, 0x86, 0xFF, 0x60, 0xC5, 0xC0, 0x61,
  0x12, 0x40, 0xC0, 0x32, 0x57, 0x5A, 0xD6, 0x50, 0x60, 0x11, 0x8C, 0xA7,
  0x26, 0x20, 0x32, 0x52, 0xE4, 0xA7, 0xC0, 0x69, 0x88, 0x89, 0xE0, 0x32,
  0x52, 0x94, 0xAB, 0xC0, 0x78, 0x8F, 0x88, 0xE0, 0x3A, 0x10, 0xF4, 0x22,
  0x00, 0x69, 0x88, 0xB9, 0xE0, 0x4A, 0x52, 0xF4, 0xAA, 0x40, 0x72, 0x24,
  0x44, 0xE0, 0x18, 0x42, 0x10, 0xC9, 0xC0, 0x45, 0x25, 0x1C, 0x51, 0x48,
  0x80, 0x48, 0x88, 0x88, 0xF0, 0x4A, 0x5E, 0xD4, 0xC6, 0x20, 0x4B, 0x5A,
  0xD6, 0xAA, 0x40, 0x69, 0x99, 0x99, 0xE0, 0x32, 0x52, 0xF4, 0x22, 0x00,
  0x69, 0x99, 0x99, 0xE2, 0x20, 0x32, 0x52, 0xF5, 0x2A, 0x40, 0x32, 0x50,
  0x60, 0xC5, 0xC0, 0xF9, 0x08, 0x84, 0x21, 0x00, 0x99, 0x99, 0x99, 0xE0,
  0x8C, 0xA5, 0x4A, 0x51, 0x00, 0xAD, 0x7D, 0xEB, 0x52, 0x80, 0x45, 0x23,
  0x08, 0x31, 0x48, 0x80, 0x8C, 0x98, 0xC4, 0x21, 0x00, 0x78, 0x44, 0x42,
  0x23, 0xC0, 0x74, 0x44, 0x44, 0x8E, 0xC9, 0x24, 0x49, 0x64, 0x92, 0x96,
  0x26, 0x69, 0xF0, 0xC0, 0x79, 0x99, 0xE0, 0x42, 0x1C, 0x94, 0xA7, 0xC0,
  0x69, 0x89, 0xE0, 0x11, 0x79, 0x99, 0xE0, 0x69, 0xF8, 0xE0, 0x1C, 0x87,
  0x88, 0x20, 0x82, 0x10, 0x80, 0x79, 0x9A, 0xE2, 0xC0, 0x42, 0x1C, 0x94,
  0xA6, 0x40, 0x10, 0x1C, 0x22, 0x13, 0xE0, 0x18, 0x1C, 0x21, 0x08, 0x44,
  0xC0, 0x42, 0x12, 0xA6, 0x2A, 0x40, 0xC4, 0x44, 0x44, 0x70, 0x7B, 0x6B,
  0x5A, 0x80, 0x72, 0x52, 0x99, 0x00, 0x69, 0x99, 0xE0, 0x72, 0x52, 0x97,
  0x42, 0x00, 0x79, 0x9A, 0xE2, 0x20, 0xF9, 0x88, 0x80, 0xF8, 0x61, 0xE0,
  0x4F, 0x44, 0x46, 0x99, 0x99, 0xE0, 0x99, 0xAA, 0x40, 0xDD, 0xBA, 0xA0,
  0x49, 0x88, 0xA9, 0x00, 0x99, 0x9A, 0xE2, 0xC0, 0x78, 0x88, 0x8F, 0x00,
  0x32, 0x2C, 0x24, 0x46, 0x56, 0xAA, 0x71, 0x08, 0x72, 0x10, 0x98, 0xDA,
};

const GFXglyph JetBrainsMono_LightItalic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 7, 5, 2, -7 },
  { 3, 3, 3, 5, 2, -7 },
  { 5, 5, 7, 5, 0, -7 },
  { 10, 5, 9, 5, 0, -8 },
  { 16, 6, 7, 5, 0, -7 },
  { 22, 5, 7, 5, 0, -7 },
  { 27, 1, 3, 5, 3, -7 },
  { 28, 4, 9, 5, 1, -8 },
  { 33, 4, 9, 5, 0, -8 },
  { 38, 5, 4, 5, 0, -5 },
  { 41, 4, 4, 5, 1, -5 },
  { 43, 2, 2, 5, 1, -1 },
  { 44, 3, 1, 5, 1, -3 },
  { 45, 1, 1, 5, 2, -1 },
  { 46, 5, 8, 5, 0, -7 },
  { 51, 4, 7, 5, 1, -7 },
  { 55, 5, 7, 5, 0, -7 },
  { 60, 5, 7, 5, 0, -7 },
  { 65, 5, 7, 5, 0, -7 },
  { 70, 4, 7, 5, 1, -7 },
  { 74, 4, 7, 5, 1, -7 },
  { 78, 5, 7, 5, 0, -7 },
  { 83, 4, 7, 5, 1, -7 },
  { 87, 5, 7, 5, 0, -7 },
  { 92, 4, 7, 5, 1, -7 },
  { 96, 2, 5, 5, 2, -5 },
  { 98, 3, 6, 5, 1, -5 },
  { 101, 4, 4, 5, 1, -5 },
  { 103, 4, 2, 5, 1, -4 },
  { 104, 5, 4, 5, 0, -5 },
  { 107, 4, 7, 5, 1, -7 },
  { 111, 5, 9, 5, 0, -7 },
  { 117, 5, 7, 5, 0, -7 },
  { 122, 5, 7, 5, 0, -7 },
  { 127, 4, 7, 5, 1, -7 },
  { 131, 5, 7, 5, 0, -7 },
  { 136, 4, 7, 5, 1, -7 },
  { 140, 5, 7, 5, 0, -7 },
  { 145, 4, 7, 5, 1, -7 },
  { 149, 5, 7, 5, 0, -7 },
  { 154, 4, 7, 5, 1, -7 },
  { 158, 5, 7, 5, 0, -7 },
  { 163, 6, 7, 5, 0, -7 },
  { 169, 4, 7, 5, 1, -7 },
  { 173, 5, 7, 5, 0, -7 },
  { 178, 5, 7, 5, 0, -7 },
  { 183, 4, 7, 5, 1, -7 },
  { 187, 5, 7, 5, 0, -7 },
  { 192, 4, 9, 5, 1, -7 },
  { 197, 5, 7, 5, 0, -7 },
  { 202, 5, 7, 5, 0, -7 },
  { 207, 5, 7, 5, 1, -7 },
  { 212, 4, 7, 5, 1, -7 },
  { 216, 5, 7, 5, 1, -7 },
  { 221, 5, 7, 5, 1, -7 },
  { 226, 6, 7, 5, 0, -7 },
  { 232, 5, 7, 5, 1, -7 },
  { 237, 5, 7, 5, 0, -7 },
  { 242, 4, 8, 5, 1, -7 },
  { 246, 3, 8, 5, 1, -7 },
  { 249, 3, 8, 5, 1, -7 },
  { 252, 4, 4, 5, 1, -7 },
  { 254, 4, 1, 5, 0, 0 },
  { 255, 2, 1, 5, 2, -7 },
  { 256, 4, 5, 5, 1, -5 },
  { 259, 5, 7, 5, 0, -7 },
  { 264, 4, 5, 5, 1, -5 },
  { 267, 4, 7, 5, 1, -7 },
  { 271, 4, 5, 5, 1, -5 },
  { 274, 6, 9, 5, 0, -7 },
  { 281, 4, 7, 5, 1, -5 },
  { 285, 5, 7, 5, 0, -7 },
  { 290, 5, 7, 5, 0, -7 },
  { 295, 5, 9, 5, 0, -7 },
  { 301, 5, 7, 5, 0, -7 },
  { 306, 4, 7, 5, 1, -7 },
  { 310, 5, 5, 5, 0, -5 },
  { 314, 5, 5, 5, 0, -5 },
  { 318, 4, 5, 5, 1, -5 },
  { 321, 5, 7, 5, 0, -5 },
  { 326, 4, 7, 5, 1, -5 },
  { 330, 4, 5, 5, 1, -5 },
  { 333, 4, 5, 5, 1, -5 },
  { 336, 4, 6, 5, 1, -6 },
  { 339, 4, 5, 5, 1, -5 },
  { 342, 4, 5, 5, 1, -5 },
  { 345, 4, 5, 5, 1, -5 },
  { 348, 5, 5, 5, 0, -5 },
  { 352, 4, 7, 5, 1, -5 },
  { 356, 5, 5, 5, 0, -5 },
  { 360, 4, 8, 5, 1, -7 },
  { 364, 2, 8, 5, 2, -7 },
  { 366, 5, 8, 5, 0, -7 },
  { 371, 4, 2, 5, 1, -4 },
};

const GFXfont JetBrainsMono_LightItalic9pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_LightItalic9pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_LightItalic9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _JETBRAINSMONO_LIGHTITALIC9PT7B_H_
