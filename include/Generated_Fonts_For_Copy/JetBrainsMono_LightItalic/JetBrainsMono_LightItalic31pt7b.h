#ifndef _JETBRAINSMONO_LIGHTITALIC31PT7B_H_
#define _JETBRAINSMONO_LIGHTITALIC31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-LightItalic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_LightItalic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x1C, 0x38, 0x71, 0xC3, 0x87, 0x0E, 0x1C, 0x30, 0x60, 0xC1,
  0x86, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x0F, 0x1E, 0x3C, 0x00, 0x71, 0xDC,
  0x76, 0x1D, 0x87, 0xE1, 0xB8, 0x6E, 0x3B, 0x0E, 0xC3, 0x30, 0xC0, 0x00,
  0xC1, 0x80, 0x30, 0x60, 0x18, 0x38, 0x06, 0x0C, 0x01, 0x83, 0x00, 0xC1,
  0x80, 0x30, 0x60, 0xFF, 0xFF, 0x06, 0x0C, 0x01, 0x83, 0x00, 0x60, 0xC0,
  0x30, 0x60, 0x0C, 0x18, 0x07, 0x06, 0x01, 0x83, 0x03, 0xFF, 0xF8, 0xFF,
  0xFE, 0x0C, 0x18, 0x03, 0x06, 0x01, 0xC1, 0x80, 0x60, 0xC0, 0x18, 0x30,
  0x0C, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x01,
  0xF0, 0x07, 0xFC, 0x0F, 0xDE, 0x1C, 0xCE, 0x18, 0xC6, 0x38, 0xC6, 0x38,
  0xC0, 0x38, 0x80, 0x38, 0x80, 0x1D, 0x80, 0x1F, 0x80, 0x0F, 0xF0, 0x01,
  0xF8, 0x01, 0x38, 0x01, 0x1C, 0x03, 0x1C, 0x03, 0x1C, 0xC3, 0x1C, 0xC3,
  0x18, 0xE2, 0x38, 0xF2, 0x70, 0x7F, 0xE0, 0x3F, 0xC0, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x03, 0xC0, 0x18, 0x3F, 0x01, 0x83, 0x1C,
  0x1C, 0x38, 0x60, 0xC1, 0x83, 0x0C, 0x0C, 0x30, 0xC0, 0x61, 0x8C, 0x03,
  0x0C, 0xC0, 0x1C, 0xEC, 0x00, 0x7E, 0x60, 0x00, 0xC6, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x67, 0xC0, 0x06, 0x7F, 0x00, 0x73, 0x1C, 0x03,
  0x30, 0x60, 0x31, 0x86, 0x03, 0x0C, 0x30, 0x30, 0x61, 0x83, 0x03, 0x0C,
  0x38, 0x1F, 0xC3, 0x80, 0x7C, 0x00, 0x01, 0xF0, 0x01, 0xFE, 0x01, 0xC7,
  0x01, 0xC1, 0xC0, 0xC0, 0xE0, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x07, 0xC0, 0x07, 0xF0, 0x17, 0x38, 0x33, 0x8E, 0x39,
  0x83, 0x38, 0xC1, 0xD8, 0xE0, 0x78, 0x70, 0x3C, 0x38, 0x1E, 0x1C, 0x0F,
  0x0E, 0x1D, 0xC3, 0xFC, 0x60, 0xFC, 0x38, 0x77, 0x66, 0xEE, 0xEC, 0xCC,
  0x00, 0x18, 0x03, 0xC0, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0x30, 0x03,
  0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3E, 0x00, 0x70, 0x00,
  0x80, 0x0C, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x60,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x03, 0x80,
  0x38, 0x07, 0x00, 0xE0, 0x3C, 0x0F, 0x80, 0xE0, 0x08, 0x00, 0x00, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0xE1, 0x87, 0xF9, 0xBF,
  0x7F, 0x7C, 0x07, 0xC0, 0x03, 0x80, 0x06, 0xC0, 0x1C, 0xE0, 0x1C, 0xE0,
  0x38, 0x70, 0x70, 0x70, 0x20, 0x20, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x7F, 0xFF, 0xFF, 0xFE, 0x07,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x0F,
  0x0E, 0x1E, 0x1C, 0x3C, 0x38, 0x30, 0x70, 0x60, 0xE0, 0x7F, 0xFF, 0xF8,
  0x37, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x07, 0xFC, 0x0F, 0x1E, 0x1C, 0x0E, 0x38, 0x06, 0x38, 0x06, 0x30, 0x06,
  0x30, 0x06, 0x70, 0x0E, 0x70, 0x0E, 0x73, 0x8E, 0x63, 0xCC, 0x63, 0x8C,
  0x60, 0x0C, 0x60, 0x0C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x18, 0xE0, 0x18,
  0xE0, 0x38, 0x70, 0x70, 0x7F, 0xE0, 0x3F, 0xC0, 0x00, 0xF0, 0x07, 0xC0,
  0x7E, 0x03, 0x98, 0x3C, 0x60, 0xC3, 0x82, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x83, 0xFF, 0xFF, 0xFF,
  0x80, 0x01, 0xF0, 0x0F, 0xF8, 0x38, 0x78, 0xE0, 0x73, 0x80, 0x66, 0x00,
  0xCC, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x1F, 0xFF, 0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x3F,
  0xFC, 0x7F, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x07, 0xC0, 0x1F, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0C, 0x00, 0x19, 0x80, 0x33, 0x00, 0xE7, 0x01, 0x8F, 0x0F,
  0x0F, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x30, 0x30, 0xE0, 0xE3, 0x81, 0xCE, 0x03, 0x98, 0x06, 0x70, 0x0C, 0xFF,
  0xF9, 0xFF, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x0F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x1C, 0x00, 0x39, 0xE0, 0x6F, 0xF0, 0xF9, 0xE1, 0xC0, 0xE7,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x33, 0x80,
  0xE7, 0x01, 0xC7, 0x07, 0x0F, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x0E,
  0x00, 0x77, 0x83, 0xFF, 0x8F, 0x0F, 0x70, 0x1D, 0x80, 0x7E, 0x00, 0xF8,
  0x03, 0xC0, 0x0F, 0x00, 0x7E, 0x01, 0xB8, 0x0E, 0x70, 0x71, 0xFF, 0x81,
  0xFC, 0x00, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0x00, 0xEE, 0x01, 0x98,
  0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xF0,
  0x0F, 0xF8, 0x3C, 0x78, 0xE0, 0x71, 0x80, 0x67, 0x00, 0xCE, 0x03, 0x9C,
  0x06, 0x18, 0x1C, 0x3C, 0x70, 0x1F, 0x80, 0x3E, 0x01, 0xEF, 0x07, 0x07,
  0x1C, 0x06, 0x30, 0x0E, 0xE0, 0x1D, 0xC0, 0x3B, 0x00, 0x67, 0x01, 0xCF,
  0x07, 0x0F, 0xFC, 0x0F, 0xF0, 0x00, 0x03, 0xE0, 0x1F, 0xF0, 0x79, 0xF1,
  0xC0, 0xE7, 0x00, 0xCC, 0x01, 0xD8, 0x03, 0xF0, 0x06, 0xE0, 0x0D, 0xC0,
  0x3B, 0x80, 0x73, 0x83, 0xC7, 0xFF, 0x07, 0xEE, 0x00, 0x38, 0x00, 0xE0,
  0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x0E,
  0x00, 0x00, 0x1E, 0x7C, 0xF9, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x3E, 0x7C, 0xF0, 0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x03, 0x81, 0xE0,
  0x70, 0x1C, 0x0E, 0x03, 0x01, 0xC0, 0x60, 0x38, 0x00, 0x00, 0x04, 0x00,
  0x70, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x38, 0x00, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x00,
  0x04, 0x3F, 0xFE, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF0, 0x30, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0x00, 0x3C,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x0E, 0x00, 0x20, 0x00,
  0x3C, 0x03, 0xFC, 0x7F, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x70, 0x06,
  0x00, 0xE0, 0x0E, 0x01, 0xC3, 0xF8, 0x3E, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x3F, 0xF0, 0x0E, 0x0E, 0x03, 0x00, 0xE0, 0xC0, 0x0C, 0x38,
  0x01, 0x86, 0x00, 0x30, 0xC0, 0x06, 0x38, 0x3E, 0xC7, 0x0F, 0xF8, 0xC3,
  0x87, 0x18, 0x60, 0xE3, 0x0C, 0x1C, 0x61, 0x83, 0x0C, 0x70, 0x63, 0x8E,
  0x0C, 0x61, 0x81, 0x8C, 0x30, 0x71, 0x87, 0x0E, 0x30, 0xFF, 0x86, 0x0F,
  0xB0, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xDC, 0x01, 0xCC, 0x01, 0x8C,
  0x03, 0x8C, 0x03, 0x0C, 0x03, 0x0C, 0x07, 0x0C, 0x06, 0x0C, 0x0E, 0x0E,
  0x0C, 0x0E, 0x0F, 0xFE, 0x1F, 0xFE, 0x18, 0x06, 0x38, 0x06, 0x30, 0x06,
  0x70, 0x06, 0x70, 0x06, 0xE0, 0x07, 0x1F, 0xC0, 0x1F, 0xFC, 0x1F, 0xFC,
  0x18, 0x0E, 0x18, 0x0E, 0x38, 0x06, 0x38, 0x06, 0x38, 0x0E, 0x30, 0x0C,
  0x30, 0x1C, 0x3F, 0xF0, 0x7F, 0xF0, 0x70, 0x78, 0x70, 0x1C, 0x60, 0x1C,
  0x60, 0x0C, 0x60, 0x0C, 0x60, 0x1C, 0xE0, 0x18, 0xE0, 0x38, 0xC0, 0xF0,
  0xFF, 0xE0, 0xFF, 0x80, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0x1E, 0x1C, 0x0E,
  0x18, 0x06, 0x38, 0x06, 0x38, 0x06, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0xE0, 0x1C, 0xE0, 0x18, 0xE0, 0x38, 0x70, 0x70, 0x7F, 0xE0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0xF0, 0x7F, 0xF0, 0xC0, 0xF1, 0x80, 0xE7,
  0x01, 0xCE, 0x03, 0x9C, 0x07, 0x30, 0x0E, 0x60, 0x1C, 0xC0, 0x33, 0x80,
  0x67, 0x00, 0xCE, 0x03, 0x98, 0x07, 0x30, 0x0E, 0x60, 0x19, 0xC0, 0x33,
  0x80, 0xE7, 0x03, 0x8E, 0x0E, 0x1F, 0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0xFF,
  0x1F, 0xFF, 0x1F, 0xFF, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x3F, 0xFC, 0x3F, 0xF8, 0x30, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0x1F, 0xFF, 0x8F, 0xFF,
  0x87, 0xFF, 0xC3, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0xFF, 0x87, 0xFF, 0xC3,
  0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x01, 0xF0, 0x07,
  0xFC, 0x0F, 0x1E, 0x1C, 0x0E, 0x18, 0x06, 0x38, 0x06, 0x38, 0x06, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x71, 0xFC, 0x61,
  0xFC, 0x60, 0x0C, 0x60, 0x1C, 0x60, 0x1C, 0xE0, 0x18, 0xE0, 0x18, 0xE0,
  0x38, 0x70, 0x70, 0x7F, 0xE0, 0x1F, 0xC0, 0x1C, 0x07, 0x1C, 0x07, 0x18,
  0x06, 0x18, 0x06, 0x18, 0x06, 0x38, 0x06, 0x38, 0x0E, 0x38, 0x0E, 0x30,
  0x0E, 0x30, 0x0C, 0x3F, 0xFC, 0x7F, 0xFC, 0x70, 0x1C, 0x70, 0x1C, 0x60,
  0x1C, 0x60, 0x18, 0x60, 0x18, 0x60, 0x18, 0xE0, 0x38, 0xE0, 0x38, 0xE0,
  0x38, 0xC0, 0x30, 0xC0, 0x30, 0x0F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0x06,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x1F, 0xFE, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0xE0,
  0x1C, 0xE0, 0x18, 0xE0, 0x38, 0x70, 0x70, 0x7F, 0xE0, 0x3F, 0xC0, 0x1C,
  0x03, 0x8E, 0x01, 0x86, 0x01, 0xC3, 0x01, 0xC1, 0x80, 0xC1, 0xC0, 0xE0,
  0xE0, 0xE0, 0x70, 0x60, 0x30, 0x70, 0x18, 0x70, 0x0F, 0xF0, 0x0F, 0xF8,
  0x07, 0x0C, 0x03, 0x87, 0x01, 0x83, 0x80, 0xC0, 0xC0, 0x60, 0x70, 0x70,
  0x38, 0x38, 0x0C, 0x1C, 0x07, 0x0E, 0x03, 0x86, 0x00, 0xC3, 0x00, 0x70,
  0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x07, 0xFF, 0xEF, 0xFF, 0x80, 0x0E, 0x03, 0x87, 0x03, 0xC7, 0x81, 0xE3,
  0x61, 0xF1, 0xB0, 0xD8, 0xD8, 0xFC, 0x6C, 0x6C, 0x36, 0x36, 0x3B, 0x33,
  0x1C, 0xD9, 0x8C, 0x79, 0xC6, 0x3C, 0xE3, 0x1C, 0x61, 0x80, 0x31, 0xC0,
  0x18, 0xE0, 0x0C, 0x70, 0x0E, 0x30, 0x07, 0x18, 0x03, 0x0C, 0x01, 0x8E,
  0x00, 0xC7, 0x00, 0x63, 0x80, 0x70, 0x1C, 0x07, 0x1E, 0x07, 0x1E, 0x07,
  0x1E, 0x06, 0x3E, 0x06, 0x3F, 0x06, 0x3B, 0x06, 0x33, 0x0E, 0x33, 0x0E,
  0x33, 0x0C, 0x33, 0x8C, 0x71, 0x8C, 0x71, 0x8C, 0x61, 0x9C, 0x61, 0x9C,
  0x61, 0xDC, 0x60, 0xD8, 0xE0, 0xD8, 0xE0, 0xD8, 0xE0, 0xD8, 0xC0, 0xF8,
  0xC0, 0x78, 0xC0, 0x70, 0x01, 0xF0, 0x0F, 0xF8, 0x3C, 0x70, 0xE0, 0x71,
  0x80, 0xE7, 0x00, 0xCE, 0x01, 0x98, 0x07, 0x30, 0x0E, 0x60, 0x1D, 0xC0,
  0x33, 0x80, 0x67, 0x00, 0xCC, 0x03, 0x98, 0x07, 0x30, 0x0E, 0x60, 0x19,
  0xC0, 0x33, 0x80, 0xE7, 0x01, 0xC7, 0x07, 0x0F, 0xFC, 0x07, 0xE0, 0x00,
  0x1F, 0xF0, 0x1F, 0xFC, 0x1F, 0xFE, 0x18, 0x07, 0x18, 0x07, 0x38, 0x03,
  0x38, 0x03, 0x38, 0x07, 0x30, 0x07, 0x30, 0x0E, 0x30, 0x1E, 0x7F, 0xFC,
  0x7F, 0xF0, 0x7F, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x01, 0xF0,
  0x0F, 0xF8, 0x3C, 0x78, 0xE0, 0x71, 0x80, 0x67, 0x00, 0xCC, 0x01, 0x98,
  0x03, 0x30, 0x0E, 0xE0, 0x1D, 0xC0, 0x3B, 0x80, 0x66, 0x00, 0xCC, 0x01,
  0x98, 0x07, 0x70, 0x0E, 0xE0, 0x1D, 0xC0, 0x33, 0x80, 0xE7, 0x01, 0xC7,
  0x07, 0x0F, 0xFC, 0x0F, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03,
  0x80, 0x03, 0x00, 0x07, 0x00, 0x1F, 0xF0, 0x1F, 0xFC, 0x1F, 0xFE, 0x18,
  0x0E, 0x18, 0x07, 0x38, 0x07, 0x38, 0x07, 0x38, 0x07, 0x30, 0x06, 0x30,
  0x0E, 0x30, 0x1C, 0x7F, 0xF8, 0x7F, 0xE0, 0x70, 0xC0, 0x60, 0xE0, 0x60,
  0xE0, 0x60, 0x60, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0x38, 0xC0,
  0x38, 0xC0, 0x38, 0x00, 0xF8, 0x01, 0xFF, 0x01, 0xE3, 0xC1, 0xC0, 0xE0,
  0xC0, 0x30, 0xE0, 0x18, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x30, 0x07, 0x18, 0x03, 0x0E, 0x03, 0x87, 0x83, 0x81,
  0xFF, 0x80, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x18, 0x00,
  0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x00,
  0x1C, 0x07, 0x18, 0x07, 0x18, 0x07, 0x18, 0x06, 0x18, 0x06, 0x38, 0x06,
  0x38, 0x0E, 0x38, 0x0E, 0x30, 0x0E, 0x30, 0x0C, 0x30, 0x0C, 0x70, 0x0C,
  0x70, 0x1C, 0x70, 0x1C, 0x60, 0x1C, 0x60, 0x1C, 0x60, 0x18, 0xE0, 0x18,
  0xE0, 0x38, 0x60, 0x30, 0x70, 0x70, 0x7F, 0xE0, 0x3F, 0xC0, 0xC0, 0x07,
  0xC0, 0x1F, 0x80, 0x37, 0x00, 0xEE, 0x01, 0x9C, 0x07, 0x18, 0x0E, 0x30,
  0x18, 0x60, 0x70, 0xC0, 0xC1, 0x83, 0x83, 0x06, 0x07, 0x0C, 0x0E, 0x38,
  0x1C, 0x60, 0x39, 0xC0, 0x33, 0x00, 0x66, 0x00, 0xD8, 0x01, 0xB0, 0x03,
  0xE0, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x60, 0xE0, 0xD8, 0x38, 0x76, 0x0E,
  0x19, 0x87, 0x86, 0x61, 0xE1, 0x98, 0x58, 0xE6, 0x36, 0x31, 0x8D, 0x8C,
  0x63, 0x67, 0x18, 0x99, 0x86, 0x66, 0x61, 0x99, 0x98, 0x64, 0x4E, 0x1B,
  0x13, 0x06, 0xC4, 0xC3, 0xB1, 0x30, 0xE8, 0x58, 0x3E, 0x16, 0x0D, 0x85,
  0x83, 0x41, 0x60, 0xF0, 0x70, 0x3C, 0x1C, 0x0E, 0x0F, 0x00, 0x0E, 0x00,
  0xE1, 0xC0, 0x18, 0x18, 0x07, 0x03, 0x81, 0xC0, 0x30, 0x70, 0x07, 0x0C,
  0x00, 0xE3, 0x80, 0x0C, 0xE0, 0x01, 0xD8, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x03, 0x60, 0x00, 0xEC, 0x00, 0x39, 0xC0,
  0x06, 0x18, 0x01, 0xC3, 0x80, 0x70, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0,
  0xE0, 0x0C, 0x38, 0x01, 0xC0, 0xE0, 0x03, 0xB0, 0x03, 0x9C, 0x01, 0x8E,
  0x01, 0xC3, 0x01, 0xC1, 0xC0, 0xC0, 0xE0, 0xE0, 0x30, 0xE0, 0x1C, 0x60,
  0x0E, 0x70, 0x03, 0x30, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF,
  0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x03, 0xFF, 0xE3, 0xFF, 0xF0, 0x0F, 0xF0, 0xFE, 0x0C, 0x00,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F,
  0xE0, 0xFE, 0x00, 0xE0, 0x70, 0x18, 0x0C, 0x07, 0x03, 0x80, 0xC0, 0x60,
  0x38, 0x1C, 0x0E, 0x03, 0x01, 0x80, 0xE0, 0x70, 0x18, 0x0C, 0x07, 0x03,
  0x80, 0xC0, 0x60, 0x30, 0x1C, 0x0E, 0x03, 0x01, 0x80, 0xE0, 0x70, 0x18,
  0x0F, 0xF0, 0xFF, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18,
  0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x70, 0x07, 0x0F, 0xF0, 0xFE, 0x00, 0x01, 0xC0, 0x0E, 0x00,
  0xF0, 0x0E, 0xC0, 0x66, 0x07, 0x30, 0x31, 0xC3, 0x06, 0x38, 0x31, 0x81,
  0x9C, 0x07, 0xC0, 0x30, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0xC3, 0x87, 0x07,
  0xEE, 0x3F, 0xFC, 0x70, 0x79, 0xC0, 0xE3, 0x00, 0xCE, 0x01, 0x9C, 0x07,
  0x38, 0x0E, 0x60, 0x1C, 0xC0, 0x31, 0x80, 0x67, 0x00, 0xCE, 0x03, 0x9C,
  0x07, 0x1C, 0x1E, 0x3F, 0xDC, 0x3F, 0x30, 0x1C, 0x00, 0x38, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0xFC, 0x1F, 0xFC, 0x34, 0x1C,
  0x70, 0x38, 0xC0, 0x33, 0x80, 0x67, 0x00, 0xCE, 0x03, 0x98, 0x07, 0x30,
  0x0E, 0x60, 0x19, 0xC0, 0x33, 0x80, 0xE7, 0x01, 0xCF, 0x07, 0x1B, 0xFC,
  0x33, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0xF0, 0x70, 0x71, 0xC0, 0x63, 0x00,
  0xCE, 0x01, 0x9C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07,
  0x00, 0xCE, 0x01, 0x9C, 0x07, 0x1C, 0x1C, 0x3F, 0xF0, 0x1F, 0xC0, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x07,
  0xEE, 0x1F, 0xFE, 0x1C, 0x1E, 0x38, 0x1C, 0x30, 0x0C, 0x70, 0x0C, 0x70,
  0x1C, 0x70, 0x1C, 0x60, 0x1C, 0x60, 0x18, 0x60, 0x18, 0xE0, 0x18, 0xE0,
  0x38, 0xE0, 0x38, 0x70, 0x78, 0x7F, 0xB8, 0x3F, 0x30, 0x07, 0xF0, 0x3F,
  0xE1, 0xC1, 0xCE, 0x03, 0x30, 0x0D, 0xC0, 0x37, 0x00, 0xDF, 0xFF, 0x7F,
  0xFD, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0xE7, 0x07, 0x1F,
  0xF8, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x02, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0xEE, 0x3F, 0xFC, 0x70, 0x79, 0xC0, 0xE3,
  0x00, 0xCE, 0x01, 0x9C, 0x07, 0x38, 0x0E, 0x60, 0x1C, 0xC0, 0x31, 0x80,
  0x63, 0x01, 0xC7, 0x03, 0x8F, 0x1F, 0x0F, 0xEE, 0x0F, 0x9C, 0x00, 0x30,
  0x00, 0x60, 0x01, 0xC0, 0x03, 0x87, 0xFE, 0x0F, 0xF8, 0x1F, 0x80, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E,
  0xFE, 0x1F, 0xFC, 0x34, 0x1C, 0x70, 0x38, 0xC0, 0x33, 0x80, 0x67, 0x01,
  0xCE, 0x03, 0x98, 0x07, 0x30, 0x0E, 0x60, 0x19, 0xC0, 0x33, 0x80, 0x67,
  0x01, 0xCE, 0x03, 0x98, 0x07, 0x30, 0x0C, 0x00, 0x00, 0x38, 0x00, 0xF0,
  0x01, 0xE0, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x04, 0x07, 0xF0, 0x1F,
  0xE0, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x30, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x07, 0xFC, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x7F,
  0xC0, 0x7F, 0x80, 0xF8, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x07, 0x38, 0x0E, 0x38, 0x1C, 0x30,
  0x38, 0x30, 0x70, 0x30, 0xE0, 0x71, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x61,
  0xC0, 0x61, 0xC0, 0x60, 0xE0, 0xE0, 0xE0, 0xE0, 0x70, 0xE0, 0x70, 0xC0,
  0x38, 0xC0, 0x38, 0x7F, 0x07, 0xF8, 0x3F, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01,
  0xC0, 0x0F, 0xFC, 0x1F, 0xE0, 0x3F, 0xDF, 0x37, 0xFF, 0x38, 0xE3, 0x30,
  0xC3, 0x30, 0xC3, 0x30, 0xC3, 0x70, 0xC7, 0x71, 0x87, 0x61, 0x86, 0x61,
  0x86, 0x61, 0x86, 0x61, 0x86, 0xE1, 0x8E, 0xE3, 0x8E, 0xC3, 0x0E, 0xC3,
  0x0C, 0xC3, 0x0C, 0x3B, 0xF8, 0x7F, 0xF0, 0xD0, 0x71, 0xC0, 0xE3, 0x00,
  0xCE, 0x01, 0x9C, 0x07, 0x38, 0x0E, 0x60, 0x1C, 0xC0, 0x39, 0x80, 0x67,
  0x00, 0xCE, 0x01, 0x9C, 0x07, 0x38, 0x0E, 0x60, 0x1C, 0xC0, 0x30, 0x07,
  0xF0, 0x3F, 0xE1, 0xC1, 0xCE, 0x07, 0x30, 0x0D, 0xC0, 0x37, 0x00, 0xD8,
  0x07, 0x60, 0x1D, 0x80, 0x76, 0x01, 0xB8, 0x06, 0xE0, 0x3B, 0x80, 0xE7,
  0x07, 0x1F, 0xF8, 0x1F, 0x80, 0x1D, 0xFC, 0x1F, 0xFC, 0x1A, 0x0E, 0x1C,
  0x0E, 0x18, 0x06, 0x38, 0x06, 0x38, 0x06, 0x38, 0x0E, 0x30, 0x0E, 0x30,
  0x0E, 0x30, 0x0C, 0x70, 0x0C, 0x70, 0x1C, 0x70, 0x1C, 0x68, 0x38, 0x6F,
  0xF0, 0x67, 0xE0, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x07, 0xEE, 0x3F, 0xFC, 0x70, 0x79, 0xC0, 0xE3, 0x00,
  0xCE, 0x01, 0x9C, 0x07, 0x30, 0x0E, 0x60, 0x1C, 0xC0, 0x31, 0x80, 0x67,
  0x00, 0xCE, 0x03, 0x9C, 0x07, 0x1C, 0x1E, 0x3F, 0xD8, 0x3F, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x19,
  0xF8, 0x37, 0xF8, 0xF0, 0x79, 0xC0, 0x73, 0x80, 0xE7, 0x01, 0xCC, 0x03,
  0x98, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x0F, 0xF8, 0x7F, 0xF3, 0x81,
  0xCE, 0x03, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x0F, 0xF0, 0x0F, 0xF0, 0x03,
  0xE0, 0x03, 0x80, 0x06, 0x00, 0x1B, 0x80, 0xEE, 0x07, 0x9F, 0xFC, 0x3F,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x03, 0xFF, 0xFF,
  0xFF, 0xC1, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x07, 0x00,
  0x1F, 0xF0, 0x3F, 0x80, 0x38, 0x0E, 0x60, 0x1C, 0xC0, 0x39, 0x80, 0x63,
  0x00, 0xCE, 0x01, 0x9C, 0x07, 0x38, 0x0E, 0x60, 0x1C, 0xC0, 0x39, 0x80,
  0x67, 0x00, 0xCE, 0x03, 0x8C, 0x06, 0x1C, 0x1C, 0x3F, 0xF0, 0x1F, 0x80,
  0xE0, 0x0E, 0xC0, 0x19, 0x80, 0x73, 0x00, 0xC7, 0x03, 0x8E, 0x06, 0x1C,
  0x1C, 0x18, 0x30, 0x30, 0xE0, 0x61, 0x80, 0xE7, 0x01, 0xCC, 0x01, 0xB8,
  0x03, 0x60, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0xC3, 0x87, 0xC3, 0x86,
  0xC3, 0x86, 0xC7, 0x8E, 0xC7, 0x8C, 0xC5, 0x8C, 0xCD, 0x8C, 0xCD, 0x98,
  0xC9, 0x98, 0xD9, 0x98, 0xD9, 0xB0, 0xD1, 0xB0, 0xF1, 0xB0, 0xF1, 0xE0,
  0xA1, 0xE0, 0xE1, 0xE0, 0xE1, 0xC0, 0x0E, 0x03, 0xC3, 0x80, 0xC0, 0x70,
  0x70, 0x1C, 0x38, 0x03, 0x9C, 0x00, 0xEE, 0x00, 0x1B, 0x00, 0x07, 0xC0,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x1C, 0xE0, 0x0E, 0x38, 0x07,
  0x07, 0x01, 0x81, 0xC0, 0xE0, 0x38, 0xF0, 0x0E, 0x00, 0x38, 0x0E, 0x60,
  0x1C, 0xC0, 0x39, 0x80, 0x63, 0x00, 0xCE, 0x01, 0x9C, 0x07, 0x38, 0x0E,
  0x60, 0x1C, 0xC0, 0x31, 0x80, 0x63, 0x01, 0xC7, 0x07, 0x8F, 0x3F, 0x0F,
  0xEE, 0x07, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x87, 0xFE,
  0x0F, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0xFE, 0x7F, 0xF8, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x7F, 0xFC, 0xFF,
  0xF0, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xE0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0x80, 0x03, 0x80, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0xE0, 0x03, 0xE0, 0x06,
  0x0C, 0x38, 0x70, 0xE1, 0x83, 0x06, 0x1C, 0x38, 0x70, 0xC1, 0x83, 0x0E,
  0x1C, 0x38, 0x70, 0xC1, 0x83, 0x0E, 0x1C, 0x38, 0x60, 0xC1, 0x87, 0x0E,
  0x00, 0x0F, 0x00, 0x1F, 0x80, 0x0F, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x3F, 0x80, 0x7F, 0x01, 0x80, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0C, 0x00, 0x38, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0x1E, 0x06, 0xFE, 0x0D,
  0x8E, 0x1F, 0x0C, 0x7E, 0x1F, 0xD8, 0x1F, 0x00,
};

const GFXglyph JetBrainsMono_LightItalic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 7, 23, 19, 6, -23 },
  { 22, 10, 10, 19, 6, -23 },
  { 35, 18, 23, 19, 1, -23 },
  { 87, 16, 31, 19, 2, -27 },
  { 149, 21, 23, 19, -1, -23 },
  { 210, 17, 23, 19, 1, -23 },
  { 259, 4, 10, 19, 9, -23 },
  { 264, 13, 30, 19, 5, -26 },
  { 313, 12, 30, 19, 2, -26 },
  { 358, 16, 16, 19, 2, -19 },
  { 390, 15, 15, 19, 2, -18 },
  { 419, 8, 10, 19, 3, -5 },
  { 429, 11, 2, 19, 4, -11 },
  { 432, 5, 5, 19, 6, -5 },
  { 436, 18, 29, 19, 1, -26 },
  { 502, 16, 23, 19, 2, -23 },
  { 548, 14, 23, 19, 2, -23 },
  { 589, 15, 23, 19, 2, -23 },
  { 633, 15, 23, 19, 2, -23 },
  { 677, 15, 23, 19, 2, -23 },
  { 721, 15, 23, 19, 2, -23 },
  { 765, 14, 23, 19, 2, -23 },
  { 806, 15, 23, 19, 4, -23 },
  { 850, 15, 23, 19, 2, -23 },
  { 894, 15, 23, 19, 3, -23 },
  { 938, 7, 17, 19, 6, -17 },
  { 953, 10, 22, 19, 3, -17 },
  { 981, 14, 16, 19, 3, -18 },
  { 1009, 15, 10, 19, 2, -15 },
  { 1028, 14, 16, 19, 2, -18 },
  { 1056, 12, 23, 19, 5, -23 },
  { 1091, 19, 29, 19, 0, -23 },
  { 1160, 16, 23, 19, 0, -23 },
  { 1206, 16, 23, 19, 2, -23 },
  { 1252, 16, 23, 19, 2, -23 },
  { 1298, 15, 23, 19, 2, -23 },
  { 1342, 16, 23, 19, 2, -23 },
  { 1388, 17, 23, 19, 2, -23 },
  { 1437, 16, 23, 19, 2, -23 },
  { 1483, 16, 23, 19, 2, -23 },
  { 1529, 15, 23, 19, 2, -23 },
  { 1573, 16, 23, 19, 1, -23 },
  { 1619, 17, 23, 19, 2, -23 },
  { 1668, 14, 23, 19, 2, -23 },
  { 1709, 17, 23, 19, 1, -23 },
  { 1758, 16, 23, 19, 2, -23 },
  { 1804, 15, 23, 19, 2, -23 },
  { 1848, 16, 23, 19, 2, -23 },
  { 1894, 15, 29, 19, 2, -23 },
  { 1949, 16, 23, 19, 2, -23 },
  { 1995, 17, 23, 19, 1, -23 },
  { 2044, 15, 23, 19, 4, -23 },
  { 2088, 16, 23, 19, 2, -23 },
  { 2134, 15, 23, 19, 4, -23 },
  { 2178, 18, 23, 19, 2, -23 },
  { 2230, 19, 23, 19, 0, -23 },
  { 2285, 17, 23, 19, 3, -23 },
  { 2334, 17, 23, 19, 1, -23 },
  { 2383, 12, 29, 19, 5, -26 },
  { 2427, 9, 29, 19, 5, -26 },
  { 2460, 12, 29, 19, 3, -26 },
  { 2504, 13, 12, 19, 3, -23 },
  { 2524, 15, 2, 19, 0, 1 },
  { 2528, 6, 4, 19, 8, -24 },
  { 2531, 15, 17, 19, 2, -17 },
  { 2563, 15, 23, 19, 2, -23 },
  { 2607, 15, 17, 19, 2, -17 },
  { 2639, 16, 23, 19, 2, -23 },
  { 2685, 14, 17, 19, 2, -17 },
  { 2715, 20, 29, 19, -1, -23 },
  { 2788, 15, 23, 19, 2, -17 },
  { 2832, 15, 23, 19, 2, -23 },
  { 2876, 15, 24, 19, 1, -24 },
  { 2921, 16, 30, 19, 0, -24 },
  { 2981, 16, 23, 19, 2, -23 },
  { 3027, 13, 23, 19, 3, -23 },
  { 3065, 16, 17, 19, 1, -17 },
  { 3099, 15, 17, 19, 2, -17 },
  { 3131, 14, 17, 19, 2, -17 },
  { 3161, 16, 23, 19, 1, -17 },
  { 3207, 15, 23, 19, 2, -17 },
  { 3251, 15, 17, 19, 2, -17 },
  { 3283, 14, 17, 19, 2, -17 },
  { 3313, 14, 22, 19, 3, -22 },
  { 3352, 15, 17, 19, 2, -17 },
  { 3384, 15, 17, 19, 3, -17 },
  { 3416, 16, 17, 19, 3, -17 },
  { 3450, 18, 17, 19, 0, -17 },
  { 3489, 15, 23, 19, 2, -17 },
  { 3533, 15, 17, 19, 2, -17 },
  { 3565, 16, 29, 19, 3, -26 },
  { 3623, 7, 29, 19, 6, -26 },
  { 3649, 15, 29, 19, 1, -26 },
  { 3704, 15, 6, 19, 2, -14 },
};

const GFXfont JetBrainsMono_LightItalic31pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_LightItalic31pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_LightItalic31pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _JETBRAINSMONO_LIGHTITALIC31PT7B_H_
