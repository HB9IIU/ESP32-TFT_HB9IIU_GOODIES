#ifndef _JETBRAINSMONO_LIGHTITALIC52PT7B_H_
#define _JETBRAINSMONO_LIGHTITALIC52PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-LightItalic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_LightItalic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x07, 0xE0, 0xFF, 0x0F, 0xE0, 0xFE, 0x07, 0xC0, 0x3C, 0x0F,
  0x9E, 0x07, 0xDF, 0x03, 0xCF, 0x81, 0xE7, 0xC0, 0xF3, 0xC0, 0xF9, 0xE0,
  0x7C, 0xF0, 0x3E, 0x78, 0x1E, 0x3C, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xCF,
  0x01, 0xE7, 0x80, 0xE3, 0xC0, 0xF1, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x01, 0xC0, 0x1C, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x01, 0xC0,
  0x3C, 0x01, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xF0, 0x07, 0x80, 0x78, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xF0, 0x0F, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x01,
  0xE0, 0x1E, 0x00, 0x07, 0x00, 0x70, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF0,
  0x0F, 0x00, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFC, 0x01, 0xC0, 0x1C, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x3C, 0x03, 0x80,
  0x00, 0xE0, 0x0E, 0x00, 0x07, 0x80, 0x78, 0x00, 0x1C, 0x01, 0xC0, 0x00,
  0x70, 0x07, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x38,
  0x07, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xF6, 0xFE, 0x01, 0xF1, 0xC7, 0xE0,
  0x7C, 0x38, 0x7C, 0x0F, 0x07, 0x07, 0x81, 0xE0, 0xE0, 0xF0, 0x7C, 0x1C,
  0x1E, 0x0F, 0x03, 0x83, 0xC1, 0xE0, 0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x07,
  0xC3, 0x80, 0x00, 0xF8, 0x70, 0x00, 0x0F, 0x8E, 0x00, 0x01, 0xF9, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x18, 0xFC,
  0x00, 0x07, 0x0F, 0x80, 0x00, 0xE0, 0xF8, 0x00, 0x1C, 0x1F, 0x00, 0x03,
  0x83, 0xE0, 0x00, 0x70, 0x7C, 0x78, 0x0C, 0x0F, 0x0F, 0x03, 0x81, 0xE1,
  0xE0, 0x70, 0x3C, 0x3E, 0x0E, 0x0F, 0x87, 0xC1, 0xC3, 0xE0, 0x7C, 0x38,
  0xF8, 0x0F, 0xE7, 0x7F, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xE0, 0x1F, 0xF8, 0x00, 0x78,
  0x07, 0xFF, 0x00, 0x1E, 0x01, 0xE1, 0xF0, 0x03, 0x80, 0x78, 0x1E, 0x00,
  0xE0, 0x0E, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x78, 0x0F, 0x00, 0x38, 0x0F,
  0x03, 0xC0, 0x0F, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0x38, 0x1C, 0x00, 0x3C,
  0x07, 0x07, 0x00, 0x07, 0x80, 0xE1, 0xC0, 0x00, 0xF0, 0x3C, 0x78, 0x00,
  0x1F, 0x0F, 0x1E, 0x00, 0x01, 0xFF, 0xC7, 0x80, 0x00, 0x3F, 0xF0, 0xE0,
  0x00, 0x01, 0xFC, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x0F, 0xE0, 0x00, 0x01, 0xC7, 0xFE, 0x00, 0x00, 0x71, 0xFF, 0xE0,
  0x00, 0x1C, 0x7C, 0x3C, 0x00, 0x07, 0x8F, 0x03, 0xC0, 0x01, 0xE1, 0xC0,
  0x78, 0x00, 0x78, 0x78, 0x0E, 0x00, 0x0E, 0x0F, 0x01, 0xC0, 0x03, 0x81,
  0xE0, 0x38, 0x00, 0xE0, 0x38, 0x07, 0x00, 0x3C, 0x07, 0x01, 0xE0, 0x0F,
  0x00, 0xE0, 0x3C, 0x03, 0xC0, 0x1C, 0x07, 0x00, 0xF0, 0x03, 0xC1, 0xE0,
  0x1C, 0x00, 0x7F, 0xF8, 0x07, 0x00, 0x07, 0xFE, 0x01, 0xE0, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x03, 0xC0,
  0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0x3C, 0x01, 0xF1, 0xF1, 0xF0, 0x0F, 0x1F, 0x07, 0xC0, 0xF0, 0xF0, 0x1E,
  0x0F, 0x07, 0x80, 0xF8, 0xF8, 0x3C, 0x03, 0xC7, 0x81, 0xE0, 0x1F, 0x78,
  0x0F, 0x00, 0x7F, 0xC0, 0xF8, 0x03, 0xFC, 0x07, 0x80, 0x0F, 0xC0, 0x3C,
  0x00, 0x3C, 0x01, 0xE0, 0x03, 0xF0, 0x0F, 0x00, 0x1F, 0x80, 0x78, 0x01,
  0xFE, 0x03, 0xE0, 0x3E, 0xF0, 0x1F, 0x87, 0xE3, 0xC0, 0x7F, 0xFE, 0x1F,
  0x01, 0xFF, 0xE0, 0x78, 0x07, 0xFC, 0x03, 0xE0, 0x06, 0x00, 0x00, 0x00,
  0x3C, 0xF7, 0xDF, 0x7D, 0xF7, 0x9E, 0x7B, 0xEF, 0xBC, 0xF3, 0xCF, 0x38,
  0x00, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x07, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x70, 0x0F, 0x00, 0xEF, 0xC1,
  0xE0, 0xFF, 0xFE, 0x38, 0x7F, 0xFF, 0xE7, 0x3F, 0xF3, 0xFF, 0xDF, 0xF8,
  0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0x9F, 0x00, 0x01, 0xF1, 0xE0, 0x00,
  0x7C, 0x3E, 0x00, 0x1F, 0x03, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x00, 0xF8, 0x03, 0x80, 0x0E, 0x00, 0x20, 0x01, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01,
  0xF0, 0x1F, 0x80, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xE0,
  0x1F, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xE7, 0xFF, 0xFB, 0xFF, 0xFE, 0x0E,
  0x1F, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFC, 0xFC, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x07, 0xE0, 0xFE, 0x03, 0xE0, 0x0F,
  0x81, 0xF0, 0x01, 0xF0, 0x78, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x0F, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0xF1, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x1E,
  0x00, 0x03, 0xC7, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E,
  0x3E, 0x1E, 0x07, 0x8F, 0x07, 0xC1, 0xE3, 0xC3, 0xF0, 0x78, 0xF0, 0xFC,
  0x3E, 0x3C, 0x1F, 0x0F, 0x0F, 0x03, 0x83, 0xC7, 0xC0, 0x00, 0xF1, 0xE0,
  0x00, 0x3C, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0xC7, 0x80, 0x01, 0xE1,
  0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x3E, 0x00, 0x07, 0x87, 0x80, 0x03,
  0xC1, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x78, 0x1F, 0x80, 0x7E, 0x03, 0xF0,
  0x7F, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0,
  0x03, 0xFF, 0x80, 0x0F, 0xDE, 0x00, 0x7E, 0x3C, 0x01, 0xF8, 0x78, 0x07,
  0xC0, 0xF0, 0x0F, 0x01, 0xE0, 0x18, 0x07, 0xC0, 0x20, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0x80,
  0x1F, 0xFF, 0xF0, 0x0F, 0xF0, 0xFE, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x01,
  0xF0, 0xF8, 0x00, 0x7C, 0x3C, 0x00, 0x0F, 0x1F, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0xF1, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00,
  0x03, 0xC3, 0xE0, 0x01, 0xE0, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x07,
  0xF0, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x0F, 0x01, 0xF0, 0x07,
  0x81, 0xF0, 0x07, 0xC1, 0xF0, 0x03, 0xC1, 0xF0, 0x01, 0xE0, 0xF0, 0x00,
  0xF0, 0xF8, 0x00, 0x78, 0xF8, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x3C, 0x00,
  0x1F, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x07, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC3, 0xF8,
  0x00, 0xF3, 0xFF, 0x80, 0x3D, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xF0,
  0x1F, 0x81, 0xF8, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x1E, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x01, 0xF0, 0x78,
  0x00, 0x78, 0x1F, 0x00, 0x7E, 0x03, 0xF0, 0x7F, 0x00, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xBF, 0xE0,
  0x07, 0xBF, 0xF8, 0x07, 0xBF, 0xFE, 0x07, 0xF8, 0x3F, 0x83, 0xF0, 0x07,
  0xC3, 0xE0, 0x01, 0xF1, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x3C, 0xF0, 0x00,
  0x1E, 0x78, 0x00, 0x0F, 0x7C, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00,
  0x01, 0xEF, 0x00, 0x01, 0xF7, 0x80, 0x00, 0xF3, 0xE0, 0x00, 0xF9, 0xF0,
  0x00, 0x78, 0x7C, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x0F, 0xE1, 0xFC, 0x07,
  0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x80, 0x00,
  0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xF7, 0x80, 0x00, 0xFB, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x7C, 0xF0, 0x00,
  0x3C, 0x78, 0x00, 0x3C, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x01, 0xF8, 0x3F, 0x80, 0xF8, 0x03, 0xE0, 0x3C, 0x00, 0x7C, 0x1E, 0x00,
  0x1F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x3C,
  0x00, 0x1E, 0x0F, 0x80, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0x78, 0x01, 0xF0,
  0x1F, 0x00, 0xF8, 0x03, 0xF0, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x7C,
  0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x1E, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0x87,
  0xC0, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x3E, 0x00, 0x07,
  0x8F, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3C, 0x1E, 0x00,
  0x1F, 0x07, 0xC0, 0x0F, 0x81, 0xFE, 0x1F, 0xC0, 0x3F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xFE, 0x1F, 0xC0, 0xF8, 0x03,
  0xE0, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x7C, 0x00,
  0x0F, 0xBC, 0x00, 0x07, 0xDE, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0xF7, 0xC0, 0x00, 0x7B, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x3C, 0x78,
  0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x7F, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0xF7, 0x80, 0x1F, 0xE7, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0x83,
  0xFC, 0x1F, 0xF0, 0xFF, 0x07, 0xF8, 0x1F, 0x80, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x07, 0xF0, 0x7F,
  0x83, 0xFC, 0x1F, 0xE0, 0xFE, 0x07, 0xE0, 0x04, 0x00, 0x00, 0x7C, 0x00,
  0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFC, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0x00,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFE,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x30, 0x3F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x08, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x0F,
  0xF8, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0xFC, 0x00,
  0xF8, 0x00, 0xF8, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0xC1, 0xE0,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3C, 0x78, 0x01, 0xF8,
  0xF1, 0xE0, 0x1F, 0xFB, 0x87, 0x80, 0xFF, 0xEE, 0x1C, 0x07, 0xC0, 0xF8,
  0x70, 0x1E, 0x03, 0xE3, 0xC0, 0xF0, 0x07, 0x8F, 0x03, 0xC0, 0x1E, 0x3C,
  0x0F, 0x00, 0x70, 0xF0, 0x3C, 0x03, 0xC3, 0xC0, 0xE0, 0x0F, 0x0E, 0x03,
  0x80, 0x3C, 0x78, 0x1E, 0x00, 0xF1, 0xE0, 0x78, 0x03, 0xC7, 0x81, 0xE0,
  0x0E, 0x1E, 0x07, 0x80, 0x78, 0x78, 0x1E, 0x01, 0xE1, 0xC0, 0x78, 0x07,
  0x87, 0x01, 0xE0, 0x3E, 0x3C, 0x07, 0xC1, 0xF8, 0xF0, 0x1F, 0xFD, 0xC3,
  0xC0, 0x3F, 0xE7, 0x0F, 0x00, 0x7F, 0x1C, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3D, 0xE0,
  0x00, 0x1E, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0x9E,
  0x00, 0x07, 0x8F, 0x00, 0x03, 0xC7, 0x80, 0x03, 0xC1, 0xC0, 0x01, 0xE0,
  0xE0, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x78,
  0x0F, 0x00, 0x3C, 0x07, 0x80, 0x3E, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0x38, 0x07, 0x80, 0x1E, 0x07, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xF0, 0x00, 0xF0,
  0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x7C, 0x00, 0x1E, 0x3C, 0x00, 0x0F,
  0x3E, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x3C, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0x80, 0x1F, 0x81, 0xE0, 0x03, 0xE0,
  0x78, 0x00, 0x7C, 0x1E, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xC3, 0xC0, 0x00,
  0xF0, 0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0,
  0x03, 0xC0, 0xF0, 0x01, 0xF0, 0x78, 0x00, 0xF8, 0x1E, 0x03, 0xFC, 0x07,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1E, 0x00, 0xFC,
  0x0F, 0x00, 0x0F, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x7C, 0x3C, 0x00,
  0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF1, 0xF0, 0x00, 0x3C, 0x78,
  0x00, 0x1F, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0xF0,
  0x78, 0x00, 0x7C, 0x1E, 0x00, 0x7E, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0x0F, 0xE0, 0x7C, 0x01, 0xF0,
  0x3C, 0x00, 0x7C, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x07,
  0x8F, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x03, 0xC7, 0x80, 0x01, 0xE3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0,
  0xF8, 0x00, 0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0xC3, 0xF8, 0x07, 0xFF, 0xF8,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07,
  0x80, 0x3F, 0x01, 0xE0, 0x03, 0xE0, 0x78, 0x00, 0xF8, 0x1E, 0x00, 0x1E,
  0x0F, 0x80, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00,
  0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE1, 0xF0, 0x00, 0x78, 0x78,
  0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0,
  0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x01,
  0xF0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0,
  0x01, 0xE1, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07,
  0x80, 0x07, 0xC1, 0xE0, 0x01, 0xE0, 0x78, 0x01, 0xF8, 0x3E, 0x00, 0xFC,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFF, 0x80, 0x7F, 0x0F, 0xE0, 0x7C, 0x01, 0xF0, 0x3C, 0x00, 0x7C, 0x3C,
  0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x83, 0xFF, 0xE7, 0x81, 0xFF, 0xE3, 0xC0, 0xFF,
  0xF1, 0xE0, 0x7F, 0xF8, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x3C, 0x00,
  0x1F, 0x3C, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xC7, 0x80,
  0x01, 0xE3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0xF0, 0x3E,
  0x00, 0xF8, 0x1F, 0xC3, 0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00,
  0x7C, 0x1F, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0F,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x0F, 0x80, 0x07,
  0xC1, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0xF0,
  0x00, 0x78, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xE0, 0xF0, 0x00, 0x78,
  0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x81, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00,
  0x78, 0x3E, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x1E,
  0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x0F,
  0x83, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F,
  0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xE0, 0x7C,
  0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x83, 0xF8, 0x01, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x1E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x78, 0x0F,
  0x00, 0x07, 0xC0, 0x78, 0x00, 0x7C, 0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x00,
  0x3E, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0,
  0x03, 0xC0, 0x1F, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x80, 0x07,
  0x80, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xC0, 0x7C, 0x00, 0x1E, 0x07,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00,
  0x01, 0xE0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x07,
  0x80, 0x7C, 0x00, 0x3C, 0x03, 0xE0, 0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x00,
  0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x7C,
  0x01, 0xE0, 0x03, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x7C, 0x07,
  0xC0, 0x03, 0xE0, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x7C, 0x0F, 0x00,
  0x03, 0xE0, 0x78, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0xC1, 0xFC,
  0x00, 0xFC, 0x0E, 0xE0, 0x0F, 0xE0, 0x77, 0x00, 0x77, 0x03, 0xB8, 0x07,
  0xB8, 0x1D, 0xC0, 0x3B, 0xC0, 0xEF, 0x01, 0xDE, 0x07, 0x38, 0x1C, 0xE0,
  0x79, 0xC0, 0xE7, 0x03, 0xCE, 0x0F, 0x38, 0x1E, 0x70, 0x73, 0xC0, 0xF3,
  0xC7, 0x9E, 0x07, 0x9E, 0x38, 0xF0, 0x38, 0x73, 0xC7, 0x03, 0xC3, 0x9C,
  0x78, 0x1E, 0x1D, 0xE3, 0xC0, 0xF0, 0xEE, 0x1E, 0x07, 0x87, 0xF0, 0xF0,
  0x3C, 0x1F, 0x07, 0x81, 0xE0, 0xF8, 0x7C, 0x1F, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0,
  0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x01,
  0xE0, 0xFC, 0x00, 0x3C, 0x1F, 0xC0, 0x07, 0x83, 0xF8, 0x01, 0xE0, 0x7F,
  0x00, 0x3C, 0x0E, 0xE0, 0x07, 0x81, 0xDE, 0x00, 0xF0, 0x7B, 0xC0, 0x1E,
  0x0F, 0x78, 0x03, 0xC1, 0xE7, 0x00, 0xF8, 0x3C, 0xE0, 0x1E, 0x07, 0x9E,
  0x03, 0xC0, 0xF3, 0xC0, 0x78, 0x1E, 0x78, 0x0F, 0x07, 0x87, 0x01, 0xE0,
  0xF0, 0xE0, 0x3C, 0x1E, 0x1E, 0x0F, 0x03, 0xC3, 0xC1, 0xE0, 0x78, 0x78,
  0x3C, 0x0F, 0x07, 0x07, 0x83, 0xC0, 0xE0, 0xF0, 0x78, 0x1E, 0x1E, 0x0F,
  0x03, 0xC7, 0x81, 0xE0, 0x78, 0xF0, 0x3C, 0x07, 0x1E, 0x07, 0x80, 0xF3,
  0xC1, 0xE0, 0x1E, 0x78, 0x3C, 0x03, 0xCF, 0x07, 0x80, 0x79, 0xC0, 0xF0,
  0x07, 0x78, 0x1E, 0x00, 0xFF, 0x03, 0xC0, 0x1F, 0xE0, 0x78, 0x03, 0xFC,
  0x1E, 0x00, 0x3F, 0x83, 0xC0, 0x07, 0xF0, 0x78, 0x00, 0xFC, 0x0F, 0x00,
  0x1F, 0x81, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x7F, 0x1F, 0xE0, 0x7C, 0x01, 0xF0, 0x3C, 0x00,
  0x78, 0x3C, 0x00, 0x3E, 0x1E, 0x00, 0x1F, 0x1E, 0x00, 0x07, 0x8F, 0x00,
  0x07, 0xC7, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF1, 0xF0,
  0x00, 0x78, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x1F, 0x1E,
  0x00, 0x0F, 0x0F, 0x00, 0x07, 0x8F, 0x80, 0x03, 0xC7, 0x80, 0x01, 0xE3,
  0xC0, 0x00, 0xF1, 0xE0, 0x00, 0xF8, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C,
  0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x8F, 0x00, 0x07,
  0xC7, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x01, 0xF0, 0xF8, 0x01,
  0xF0, 0x3E, 0x01, 0xF8, 0x1F, 0xC3, 0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x07, 0x80,
  0x0F, 0xE0, 0x78, 0x00, 0x3E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E,
  0x0F, 0x80, 0x01, 0xF0, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x7C, 0x1E, 0x00, 0x0F, 0x81, 0xE0, 0x01, 0xF8, 0x1F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x07, 0xF0, 0xFE, 0x03, 0xE0,
  0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x78, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x0F,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x7C, 0x00, 0x1F,
  0x1E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00,
  0x1E, 0x1E, 0x00, 0x07, 0x8F, 0x80, 0x03, 0xE3, 0xC0, 0x00, 0xF0, 0xF0,
  0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF1,
  0xF0, 0x00, 0x3C, 0x78, 0x00, 0x1F, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x01,
  0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x87, 0x80,
  0x03, 0xC1, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x78, 0x1F, 0x80, 0x7E, 0x03,
  0xF8, 0x7F, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0x02, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x78, 0x00, 0xFC, 0x0F,
  0x00, 0x0F, 0x81, 0xE0, 0x00, 0xF8, 0x3C, 0x00, 0x1F, 0x0F, 0x80, 0x01,
  0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x87, 0x80, 0x01, 0xF0, 0xF0,
  0x00, 0x3C, 0x1E, 0x00, 0x07, 0x87, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x7C,
  0x1E, 0x00, 0x1F, 0x03, 0xC0, 0x0F, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0x01, 0xF0, 0x01,
  0xE0, 0x1E, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0x80, 0x7C, 0x00, 0xF0, 0x07,
  0x80, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x1F, 0x00, 0xF0, 0x03, 0xE0, 0x1E,
  0x00, 0x3C, 0x03, 0xC0, 0x07, 0xC0, 0x78, 0x00, 0xF8, 0x1F, 0x00, 0x0F,
  0x03, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x3E, 0x0F, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0x00, 0x7E,
  0x01, 0xE0, 0x03, 0xE0, 0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xE0, 0x78,
  0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x87, 0x80, 0x00, 0xF0,
  0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0,
  0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0xF8, 0x00, 0x3C, 0x1E, 0x00,
  0x0F, 0x83, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0xF0, 0x7C, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0xF8, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x1E,
  0x00, 0x0F, 0x07, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x7C, 0x1E, 0x00, 0x0F,
  0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x83, 0xE0,
  0x00, 0xF0, 0x78, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0,
  0x3C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC1, 0xF0, 0x00, 0x78, 0x3C, 0x00,
  0x0F, 0x07, 0x80, 0x03, 0xE0, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x03,
  0xE0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xFE, 0x1F,
  0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x08, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xBC, 0x00, 0x03,
  0xDE, 0x00, 0x03, 0xEF, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF3, 0xC0, 0x00,
  0xF1, 0xE0, 0x00, 0x78, 0xF8, 0x00, 0x7C, 0x3C, 0x00, 0x3C, 0x1E, 0x00,
  0x3E, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x0F, 0x01, 0xE0,
  0x07, 0x80, 0xF0, 0x07, 0xC0, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1F,
  0x01, 0xE0, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x78, 0x00,
  0xF0, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x1E, 0x00,
  0x0F, 0x0F, 0x00, 0x07, 0x8F, 0x80, 0x01, 0xC7, 0x80, 0x00, 0xF3, 0xC0,
  0x00, 0x7B, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x78, 0x07, 0xC0, 0x3B, 0xC0, 0x3E, 0x03, 0xDE, 0x03, 0xF0,
  0x1E, 0xF0, 0x1F, 0x80, 0xE7, 0x80, 0xFC, 0x0F, 0x3C, 0x06, 0xC0, 0x79,
  0xE0, 0x76, 0x03, 0xCF, 0x03, 0xB0, 0x1C, 0x78, 0x19, 0x81, 0xE3, 0xC1,
  0xCC, 0x0F, 0x1E, 0x0E, 0x60, 0x78, 0xE0, 0x73, 0x03, 0x87, 0x03, 0x18,
  0x3C, 0x38, 0x38, 0xC1, 0xE1, 0xC1, 0xCE, 0x0E, 0x0E, 0x0C, 0x70, 0xF0,
  0x70, 0xE3, 0x87, 0x83, 0x87, 0x1C, 0x3C, 0x3C, 0x38, 0xE1, 0xC1, 0xE1,
  0x87, 0x1E, 0x0F, 0x1C, 0x38, 0xF0, 0x78, 0xE1, 0xC7, 0x03, 0xC6, 0x0E,
  0x38, 0x1E, 0x70, 0x73, 0xC0, 0xF3, 0x83, 0x9E, 0x07, 0x9C, 0x1C, 0xE0,
  0x3C, 0xC0, 0xE7, 0x01, 0xEE, 0x07, 0x78, 0x0F, 0x70, 0x3B, 0xC0, 0x7B,
  0x01, 0xDC, 0x03, 0xB8, 0x0D, 0xE0, 0x1D, 0xC0, 0x6F, 0x00, 0xEE, 0x03,
  0x70, 0x07, 0x60, 0x1B, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x7C, 0x01, 0xE0,
  0x00, 0x3C, 0x03, 0xE0, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0x80,
  0x00, 0x1E, 0x0F, 0x80, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x0F, 0x1E, 0x00,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x3C, 0x78, 0x00,
  0x00, 0x7C, 0x7C, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x01, 0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x07, 0xC0, 0x1F, 0x00,
  0x07, 0x80, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x3E, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xC0,
  0xF8, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x1E, 0x3C, 0x00, 0x07, 0xC7, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x3C,
  0x0F, 0x00, 0x0F, 0x81, 0xE0, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x03, 0xC0,
  0x1F, 0x00, 0x78, 0x03, 0xC0, 0x07, 0x80, 0xF8, 0x00, 0xF0, 0x1E, 0x00,
  0x1E, 0x07, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0xFB, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFE,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00,
  0x1E, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3B, 0xC0, 0x01, 0xE7, 0x00, 0x0F, 0x1C, 0x00,
  0x3C, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x83, 0x80, 0x3C, 0x0E, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x01, 0xC0, 0xF0, 0x07, 0x87, 0x80, 0x1E,
  0x3C, 0x00, 0x38, 0xF0, 0x00, 0xE7, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE,
  0xF8, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0x78, 0x3E, 0x00, 0x3F, 0x87, 0x80,
  0x7F, 0xF3, 0xC0, 0x7F, 0xFD, 0xE0, 0x7F, 0xFE, 0xF0, 0x7C, 0x03, 0x78,
  0x7C, 0x00, 0xFC, 0x3C, 0x00, 0x7C, 0x3E, 0x00, 0x1E, 0x1E, 0x00, 0x0F,
  0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC7, 0x80, 0x01, 0xE3, 0xC0, 0x01,
  0xF1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00,
  0x1E, 0x3E, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x8F, 0x00, 0x07, 0x87, 0x80,
  0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x01, 0xF0, 0xF8, 0x01, 0xF8, 0x7E,
  0x01, 0xFC, 0x1F, 0x83, 0xFC, 0x0F, 0xFF, 0xDE, 0x03, 0xFF, 0xCF, 0x00,
  0xFF, 0xC7, 0x80, 0x06, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x83,
  0xF8, 0x03, 0xC7, 0xFF, 0x01, 0xE7, 0xFF, 0xC0, 0xF7, 0xDF, 0xE0, 0x7F,
  0x01, 0xF8, 0x7E, 0x00, 0x7C, 0x3E, 0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x0F,
  0x00, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF1,
  0xF0, 0x00, 0x78, 0xF0, 0x00, 0x7C, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1E,
  0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x8F, 0x80, 0x03, 0xC7, 0x80, 0x03,
  0xE3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00,
  0x78, 0x7F, 0x00, 0x7C, 0x3D, 0xE0, 0xFC, 0x1E, 0xFF, 0xFC, 0x0F, 0x3F,
  0xFC, 0x07, 0x8F, 0xF8, 0x00, 0x00, 0x40, 0x00, 0x00, 0x3F, 0xC0, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xC0, 0x7E, 0x1F,
  0x00, 0x3E, 0x1E, 0x00, 0x1E, 0x3E, 0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x3C,
  0x00, 0x1E, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0xF0,
  0x00, 0x78, 0xF0, 0x00, 0x78, 0xF8, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0x7F,
  0x0F, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xF0, 0xF0,
  0x03, 0xFF, 0x9E, 0x00, 0xFF, 0xFB, 0xC0, 0x3F, 0xFF, 0x78, 0x0F, 0x80,
  0x6F, 0x03, 0xE0, 0x07, 0xE0, 0x78, 0x00, 0xFC, 0x1F, 0x00, 0x0F, 0x03,
  0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0xF0, 0x78, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3C,
  0x00, 0x1E, 0x07, 0x80, 0x03, 0xC1, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1F,
  0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x03, 0xC0,
  0x03, 0xE0, 0x7C, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x80, 0xFC, 0x1F, 0xE0,
  0x1F, 0xFF, 0xBC, 0x01, 0xFF, 0xE7, 0x80, 0x1F, 0xF8, 0xF0, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07,
  0xFB, 0xFC, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0x3E, 0x1E, 0x00, 0x1E, 0x3C,
  0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x7C, 0x00, 0x1E, 0x78,
  0x00, 0x1E, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFC, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x78, 0xF8,
  0x00, 0xF0, 0x78, 0x01, 0xF0, 0x7E, 0x07, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x0F, 0x01, 0xFF, 0xCF, 0x03, 0xFF, 0xEF, 0x07, 0xFF, 0xEF, 0x0F, 0x80,
  0x6F, 0x1F, 0x00, 0x3F, 0x1E, 0x00, 0x3E, 0x3E, 0x00, 0x1E, 0x3C, 0x00,
  0x1E, 0x3C, 0x00, 0x1E, 0x7C, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00,
  0x3E, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00,
  0x3C, 0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x78, 0xF8, 0x00,
  0xF8, 0x78, 0x01, 0xF8, 0x7C, 0x03, 0xF8, 0x7F, 0xFF, 0x78, 0x3F, 0xFE,
  0x78, 0x1F, 0xFC, 0xF0, 0x07, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF,
  0x00, 0x7F, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x83, 0xF8, 0x03,
  0xC7, 0xFF, 0x01, 0xEF, 0xFF, 0xC0, 0xF7, 0xDF, 0xE0, 0x7E, 0x01, 0xF8,
  0x7E, 0x00, 0x7C, 0x3E, 0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x0F, 0x00, 0x07,
  0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF1, 0xE0, 0x00,
  0xF8, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x00,
  0x0F, 0x0F, 0x00, 0x07, 0x8F, 0x80, 0x03, 0xC7, 0x80, 0x03, 0xE3, 0xC0,
  0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x7C,
  0x00, 0x1E, 0x3C, 0x00, 0x1F, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87,
  0x80, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x3C, 0x00,
  0x1F, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0xF8, 0x1E, 0x00, 0x3E, 0x03,
  0xC0, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x3E,
  0x00, 0x78, 0x07, 0xC0, 0x0F, 0x01, 0xF0, 0x01, 0xE0, 0x7C, 0x00, 0x3F,
  0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0x81, 0xF0, 0x00, 0xF0, 0x3E, 0x00, 0x1E, 0x03, 0xE0, 0x07, 0xC0,
  0x7C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x80,
  0x78, 0x01, 0xF0, 0x0F, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x78, 0x00,
  0x3E, 0x0F, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x7C, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0x1F, 0x07, 0xC0, 0x73, 0xF9,
  0xFE, 0x0F, 0x7F, 0x9F, 0xE0, 0xFC, 0x7F, 0x1F, 0x0F, 0x83, 0xE0, 0xF0,
  0xF0, 0x3C, 0x0F, 0x0F, 0x03, 0xC0, 0xF0, 0xF0, 0x38, 0x0F, 0x0E, 0x03,
  0x80, 0xF1, 0xE0, 0x38, 0x0E, 0x1E, 0x07, 0x81, 0xE1, 0xE0, 0x78, 0x1E,
  0x1E, 0x07, 0x81, 0xE1, 0xE0, 0x78, 0x1E, 0x1C, 0x07, 0x01, 0xE3, 0xC0,
  0x70, 0x1C, 0x3C, 0x07, 0x03, 0xC3, 0xC0, 0xF0, 0x3C, 0x3C, 0x0F, 0x03,
  0xC3, 0xC0, 0xF0, 0x3C, 0x3C, 0x0E, 0x03, 0xC7, 0x80, 0xE0, 0x3C, 0x78,
  0x0E, 0x07, 0x87, 0x81, 0xE0, 0x78, 0x78, 0x1E, 0x07, 0x87, 0x81, 0xE0,
  0x78, 0x78, 0x1C, 0x07, 0x87, 0x01, 0xC0, 0x78, 0xF0, 0x1C, 0x0F, 0x00,
  0x0F, 0x07, 0xF0, 0x07, 0x8F, 0xFE, 0x03, 0xDF, 0xFF, 0x81, 0xEF, 0xBF,
  0xC0, 0xFC, 0x03, 0xF0, 0xFC, 0x00, 0xF8, 0x7C, 0x00, 0x3C, 0x3E, 0x00,
  0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0,
  0x01, 0xE3, 0xC0, 0x01, 0xF1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78,
  0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x1F, 0x00, 0x07, 0x8F,
  0x00, 0x07, 0xC7, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0,
  0xF0, 0x00, 0x78, 0xF8, 0x00, 0x3C, 0x78, 0x00, 0x3E, 0x3C, 0x00, 0x1E,
  0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xC0, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0x80, 0x7C, 0x1F, 0x00,
  0x3E, 0x1E, 0x00, 0x1E, 0x3E, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00,
  0x1E, 0x7C, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00,
  0x3E, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0xF8, 0x00, 0x3C, 0xF0, 0x00,
  0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x78, 0xF0, 0x00,
  0x78, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0xF0, 0x7C, 0x03, 0xF0, 0x7F, 0x0F,
  0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x40,
  0x00, 0x03, 0xC1, 0xFC, 0x00, 0x78, 0xFF, 0xE0, 0x0F, 0x7F, 0xFE, 0x01,
  0xEF, 0xBF, 0xC0, 0x3F, 0x80, 0xFC, 0x0F, 0xC0, 0x0F, 0x81, 0xF0, 0x00,
  0xF0, 0x3E, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x1E,
  0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0xF8, 0x00, 0x3C, 0x1E, 0x00, 0x0F,
  0x83, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0xF0, 0x7C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0xF0,
  0x3C, 0x00, 0x1E, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xF0, 0x3F, 0x80,
  0x3E, 0x07, 0xBC, 0x1F, 0x80, 0xF7, 0xFF, 0xE0, 0x1E, 0x7F, 0xF8, 0x03,
  0xC7, 0xFC, 0x00, 0x78, 0x08, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x87, 0x80, 0x7F, 0xF3, 0xC0, 0xFF, 0xFD, 0xE0, 0xFF, 0xFE, 0xF0, 0x7C,
  0x03, 0x78, 0x7C, 0x00, 0xFC, 0x3C, 0x00, 0x7C, 0x3E, 0x00, 0x1E, 0x1E,
  0x00, 0x0F, 0x0F, 0x00, 0x07, 0x8F, 0x80, 0x03, 0xC7, 0x80, 0x03, 0xE3,
  0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C,
  0x7C, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x8F, 0x00, 0x07,
  0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x01, 0xF0, 0xF8, 0x01,
  0xF8, 0x7E, 0x01, 0xBC, 0x1F, 0x83, 0xFC, 0x0F, 0xFF, 0xDE, 0x03, 0xFF,
  0xCF, 0x00, 0xFF, 0x87, 0x80, 0x06, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0x0F, 0xF0,
  0x07, 0x9F, 0xFE, 0x03, 0xDF, 0xFF, 0x81, 0xFF, 0xBF, 0xC0, 0xFC, 0x03,
  0xF0, 0xFC, 0x00, 0xF8, 0x7C, 0x00, 0x3C, 0x3E, 0x00, 0x1E, 0x1E, 0x00,
  0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC7, 0xC0, 0x01, 0xE3, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFC, 0x01, 0xF0, 0x78, 0x00, 0x78, 0x3C,
  0x00, 0x3E, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xF3, 0xC0, 0x00, 0xF1, 0xF0, 0x00, 0x78, 0x7C, 0x00, 0x7C, 0x3F, 0x00,
  0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x0F, 0x00, 0x07, 0xC3, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78,
  0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00,
  0xF8, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0,
  0x00, 0xF0, 0xF8, 0x00, 0x3C, 0x3C, 0x00, 0x1F, 0x0F, 0x00, 0x07, 0x83,
  0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x1F, 0x00, 0x07,
  0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1E, 0x00,
  0x0F, 0x07, 0xC0, 0x07, 0x81, 0xF0, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F,
  0xE1, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x08, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3C, 0xF8, 0x00, 0x7C, 0x78, 0x00,
  0x78, 0x78, 0x00, 0xF8, 0x78, 0x00, 0xF0, 0x78, 0x01, 0xF0, 0x78, 0x01,
  0xE0, 0x7C, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07,
  0x80, 0x3C, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x1E,
  0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x78,
  0x00, 0x0E, 0x78, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x0F, 0x00, 0xFE, 0x03,
  0xE0, 0x3F, 0xC0, 0x7C, 0x07, 0xF8, 0x0F, 0x80, 0xEF, 0x03, 0xF0, 0x1D,
  0xE0, 0x7E, 0x07, 0xBC, 0x0D, 0xC0, 0xE7, 0x83, 0xB8, 0x1C, 0xF0, 0x77,
  0x07, 0x9E, 0x0C, 0xE0, 0xE3, 0xC3, 0x9C, 0x1C, 0x78, 0x73, 0x87, 0x8F,
  0x0C, 0x70, 0xE1, 0xE3, 0x8E, 0x1C, 0x3C, 0x71, 0xC7, 0x87, 0x8E, 0x38,
  0xE0, 0xF3, 0x87, 0x1C, 0x1E, 0x70, 0xE3, 0x83, 0xCE, 0x1C, 0xE0, 0x7B,
  0x83, 0x9C, 0x0F, 0x70, 0x73, 0x81, 0xEE, 0x0E, 0xF0, 0x3F, 0x81, 0xDC,
  0x07, 0xF0, 0x3B, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xF0,
  0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x1E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x78, 0x00, 0x78, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x0F,
  0x07, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0F, 0xBC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xEF, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x1F, 0x0F,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x01, 0xE0, 0x01, 0xF0, 0x0F, 0x80,
  0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0xF8,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x0F, 0x1E, 0x00,
  0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x3E, 0x00, 0x0F, 0x3C, 0x00,
  0x1F, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00,
  0x1E, 0x3C, 0x00, 0x1E, 0x7C, 0x00, 0x3E, 0x78, 0x00, 0x3C, 0x78, 0x00,
  0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0xF8, 0x00,
  0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x78, 0xF8, 0x00, 0xF8, 0x7C, 0x01,
  0xF8, 0x7E, 0x03, 0x78, 0x7F, 0xFF, 0x78, 0x3F, 0xFE, 0xF8, 0x1F, 0xFC,
  0xF0, 0x07, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x01, 0xFC, 0x00, 0xF1, 0xFF, 0x80, 0x3C, 0xFF, 0xF0,
  0x0E, 0x3C, 0x3E, 0x07, 0x9E, 0x07, 0x81, 0xE7, 0x81, 0xF0, 0x79, 0xE0,
  0x3F, 0xFC, 0x78, 0x07, 0xFE, 0x1E, 0x00, 0xFF, 0x0F, 0x00, 0x0F, 0x00,
};

const GFXglyph JetBrainsMono_LightItalic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 12, 38, 31, 10, -38 },
  { 58, 17, 16, 31, 10, -38 },
  { 92, 30, 38, 31, 1, -38 },
  { 235, 27, 52, 31, 3, -45 },
  { 411, 35, 38, 31, -1, -38 },
  { 578, 29, 39, 31, 1, -38 },
  { 720, 6, 16, 31, 15, -38 },
  { 732, 21, 51, 31, 9, -44 },
  { 866, 21, 51, 31, 3, -44 },
  { 1000, 27, 27, 31, 3, -32 },
  { 1092, 24, 24, 31, 4, -29 },
  { 1164, 13, 16, 31, 5, -8 },
  { 1190, 18, 4, 31, 7, -19 },
  { 1199, 9, 9, 31, 9, -8 },
  { 1210, 31, 49, 31, 1, -43 },
  { 1400, 26, 39, 31, 3, -38 },
  { 1527, 23, 38, 31, 3, -38 },
  { 1637, 26, 38, 31, 3, -38 },
  { 1761, 26, 39, 31, 3, -38 },
  { 1888, 25, 38, 31, 3, -38 },
  { 2007, 26, 39, 31, 3, -38 },
  { 2134, 25, 39, 31, 3, -38 },
  { 2256, 25, 38, 31, 6, -38 },
  { 2375, 26, 40, 31, 3, -39 },
  { 2505, 25, 38, 31, 5, -38 },
  { 2624, 13, 30, 31, 9, -29 },
  { 2673, 16, 37, 31, 6, -29 },
  { 2747, 24, 27, 31, 5, -31 },
  { 2828, 24, 16, 31, 4, -25 },
  { 2876, 25, 27, 31, 3, -31 },
  { 2961, 20, 38, 31, 8, -38 },
  { 3056, 30, 47, 31, 1, -38 },
  { 3233, 25, 38, 31, 1, -38 },
  { 3352, 26, 38, 31, 3, -38 },
  { 3476, 25, 39, 31, 4, -38 },
  { 3598, 26, 38, 31, 3, -38 },
  { 3722, 28, 38, 31, 3, -38 },
  { 3855, 28, 38, 31, 3, -38 },
  { 3988, 25, 39, 31, 4, -38 },
  { 4110, 27, 38, 31, 3, -38 },
  { 4239, 26, 38, 31, 3, -38 },
  { 4363, 28, 39, 31, 1, -38 },
  { 4500, 29, 38, 31, 3, -38 },
  { 4638, 22, 38, 31, 4, -38 },
  { 4743, 29, 38, 31, 2, -38 },
  { 4881, 27, 38, 31, 3, -38 },
  { 5010, 25, 39, 31, 4, -38 },
  { 5132, 28, 38, 31, 3, -38 },
  { 5265, 26, 47, 31, 3, -38 },
  { 5418, 27, 38, 31, 3, -38 },
  { 5547, 28, 40, 31, 2, -39 },
  { 5687, 26, 38, 31, 6, -38 },
  { 5811, 27, 39, 31, 3, -38 },
  { 5943, 25, 38, 31, 7, -38 },
  { 6062, 29, 38, 31, 4, -38 },
  { 6200, 32, 38, 31, 0, -38 },
  { 6352, 27, 38, 31, 6, -38 },
  { 6481, 28, 38, 31, 2, -38 },
  { 6614, 20, 49, 31, 8, -43 },
  { 6737, 15, 49, 31, 9, -43 },
  { 6829, 20, 49, 31, 5, -43 },
  { 6952, 22, 20, 31, 5, -38 },
  { 7007, 26, 4, 31, 0, 1 },
  { 7020, 9, 7, 31, 14, -41 },
  { 7028, 25, 30, 31, 3, -29 },
  { 7122, 25, 39, 31, 3, -38 },
  { 7244, 24, 30, 31, 4, -29 },
  { 7334, 27, 39, 31, 3, -38 },
  { 7466, 24, 30, 31, 4, -29 },
  { 7556, 35, 47, 31, -2, -38 },
  { 7762, 24, 38, 31, 4, -29 },
  { 7876, 25, 38, 31, 3, -38 },
  { 7995, 25, 40, 31, 2, -40 },
  { 8120, 26, 49, 31, 1, -40 },
  { 8280, 27, 38, 31, 3, -38 },
  { 8409, 22, 38, 31, 5, -38 },
  { 8514, 28, 29, 31, 1, -29 },
  { 8616, 25, 29, 31, 3, -29 },
  { 8707, 24, 30, 31, 4, -29 },
  { 8797, 27, 38, 31, 1, -29 },
  { 8926, 25, 38, 31, 3, -29 },
  { 9045, 25, 29, 31, 4, -29 },
  { 9136, 25, 30, 31, 3, -29 },
  { 9230, 24, 36, 31, 5, -36 },
  { 9338, 26, 30, 31, 3, -29 },
  { 9436, 24, 29, 31, 6, -29 },
  { 9523, 27, 29, 31, 4, -29 },
  { 9621, 29, 29, 31, 1, -29 },
  { 9727, 24, 38, 31, 4, -29 },
  { 9841, 25, 29, 31, 3, -29 },
  { 9932, 26, 49, 31, 5, -43 },
  { 10092, 12, 49, 31, 10, -43 },
  { 10166, 27, 49, 31, 1, -43 },
  { 10332, 26, 11, 31, 3, -24 },
};

const GFXfont JetBrainsMono_LightItalic52pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_LightItalic52pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_LightItalic52pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _JETBRAINSMONO_LIGHTITALIC52PT7B_H_
