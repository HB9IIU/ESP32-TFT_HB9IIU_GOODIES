#ifndef _JETBRAINSMONO_LIGHTITALIC51PT7B_H_
#define _JETBRAINSMONO_LIGHTITALIC51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-LightItalic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_LightItalic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x7E, 0x1F, 0xC3,
  0xF8, 0x7F, 0x07, 0xC0, 0x7C, 0x0F, 0x7C, 0x0F, 0x7C, 0x1F, 0x78, 0x1F,
  0x78, 0x1F, 0x78, 0x1E, 0x78, 0x1E, 0xF8, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E,
  0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xE0, 0x3C, 0xE0, 0x3C, 0x00, 0x03,
  0x80, 0x78, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x01, 0xC0,
  0x3C, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x38, 0x03, 0x80, 0x00, 0xE0, 0x1E,
  0x00, 0x07, 0x80, 0x70, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xF0, 0x0F, 0x00,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x01,
  0xE0, 0x1C, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF0,
  0x0E, 0x00, 0x03, 0x80, 0x78, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x70, 0x07,
  0x00, 0x01, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x38, 0x03, 0x80,
  0x00, 0xE0, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF8, 0x03, 0xC0, 0x38, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x38,
  0x07, 0x80, 0x01, 0xE0, 0x1C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x1C, 0x03,
  0xC0, 0x00, 0xF0, 0x0E, 0x00, 0x03, 0x80, 0x38, 0x00, 0x0E, 0x01, 0xE0,
  0x00, 0x78, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0xF0, 0x07, 0xE7, 0x3F, 0x00, 0xF8, 0xE3, 0xE0, 0x3E, 0x1C,
  0x3C, 0x07, 0x83, 0x87, 0xC1, 0xE0, 0x60, 0xF8, 0x3C, 0x1C, 0x1F, 0x07,
  0x83, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0xE1, 0xC0,
  0x00, 0x7C, 0x30, 0x00, 0x07, 0xCE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xE7, 0xE0, 0x00, 0x1C, 0x3E, 0x00, 0x03,
  0x87, 0xC0, 0x00, 0x70, 0x78, 0x00, 0x0E, 0x0F, 0x00, 0x01, 0x81, 0xE1,
  0xE0, 0x70, 0x3C, 0x3C, 0x0E, 0x07, 0x87, 0x81, 0xC1, 0xF0, 0xF0, 0x38,
  0x3C, 0x1F, 0x07, 0x0F, 0x81, 0xF0, 0xC3, 0xE0, 0x3F, 0xB9, 0xF8, 0x03,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x03, 0xC0, 0x7F, 0xF0, 0x00, 0xE0, 0x3F, 0xFC, 0x00, 0x70, 0x0E,
  0x07, 0x00, 0x38, 0x07, 0x81, 0xE0, 0x1C, 0x01, 0xC0, 0x78, 0x0F, 0x00,
  0x70, 0x1C, 0x07, 0x80, 0x3C, 0x07, 0x03, 0xC0, 0x0F, 0x01, 0xC0, 0xE0,
  0x03, 0xC0, 0x70, 0x70, 0x00, 0xE0, 0x3C, 0x38, 0x00, 0x38, 0x0F, 0x1E,
  0x00, 0x0F, 0x07, 0x8F, 0x00, 0x03, 0xFF, 0xC7, 0x80, 0x00, 0x7F, 0xF1,
  0xC0, 0x00, 0x0F, 0xF0, 0xE0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x01, 0xC7, 0xFC, 0x00, 0x00, 0xE3, 0xFF, 0x80,
  0x00, 0x71, 0xF1, 0xF0, 0x00, 0x3C, 0x70, 0x3C, 0x00, 0x1E, 0x3C, 0x07,
  0x00, 0x0F, 0x0F, 0x01, 0xC0, 0x03, 0x83, 0x80, 0xF0, 0x01, 0xC0, 0xE0,
  0x3C, 0x00, 0xE0, 0x38, 0x0F, 0x00, 0x78, 0x0E, 0x03, 0x80, 0x3C, 0x07,
  0x80, 0xE0, 0x1E, 0x01, 0xE0, 0x78, 0x07, 0x00, 0x3C, 0x3C, 0x03, 0x80,
  0x0F, 0xFF, 0x01, 0xC0, 0x01, 0xFF, 0x80, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0xF8, 0x1F, 0x80, 0x0F, 0x00, 0xF8, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0x1F,
  0x01, 0xF1, 0xE0, 0xF0, 0x1E, 0x3C, 0x0F, 0x83, 0xC3, 0xC0, 0x78, 0x78,
  0x3C, 0x07, 0xCF, 0x83, 0xC0, 0x3C, 0xF0, 0x3C, 0x03, 0xFE, 0x07, 0x80,
  0x1F, 0xC0, 0x78, 0x00, 0xFC, 0x07, 0x80, 0x0F, 0x80, 0x78, 0x00, 0xF8,
  0x07, 0x80, 0x1F, 0xC0, 0x78, 0x03, 0xFC, 0x07, 0xC0, 0x7D, 0xE0, 0x7E,
  0x1F, 0x9F, 0x03, 0xFF, 0xF0, 0xF0, 0x3F, 0xFE, 0x0F, 0x80, 0xFF, 0x80,
  0x7C, 0x01, 0x80, 0x00, 0x00, 0x7D, 0xF7, 0xDE, 0x79, 0xEF, 0xBE, 0xFB,
  0xCF, 0x3C, 0xF3, 0x8E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00,
  0x7E, 0x00, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x01, 0x00, 0x78, 0x02, 0x78, 0x0E, 0x03, 0xCF,
  0xE1, 0xC3, 0xFB, 0xFE, 0x39, 0xFF, 0xBF, 0xF6, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF7, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE1, 0xE0,
  0x00, 0xF8, 0x3E, 0x00, 0x1E, 0x03, 0xC0, 0x07, 0xC0, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1C, 0x00, 0xF0, 0x01, 0x00, 0x08, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF8, 0x1F,
  0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00,
  0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0x7F,
  0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0C, 0x1F, 0x9F, 0xEF,
  0xFF, 0xFF, 0xF9, 0xFC, 0xFC, 0x10, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xF0, 0x1F, 0x81,
  0xF0, 0x03, 0xE0, 0x78, 0x00, 0x78, 0x3E, 0x00, 0x1E, 0x0F, 0x00, 0x07,
  0xC3, 0xC0, 0x01, 0xF1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x1E, 0x00,
  0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x3C,
  0x0C, 0x0F, 0x8F, 0x07, 0x83, 0xC3, 0xC3, 0xF0, 0xF0, 0xF0, 0xFC, 0x3C,
  0x3C, 0x3F, 0x0F, 0x0F, 0x07, 0x83, 0xC7, 0x80, 0x00, 0xF1, 0xE0, 0x00,
  0x78, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0,
  0x00, 0x78, 0xF8, 0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xC1,
  0xE0, 0x01, 0xF0, 0x78, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x7F,
  0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0xFC, 0xF0, 0x01, 0xF8, 0xF0, 0x07, 0xE1, 0xF0, 0x07,
  0xC1, 0xE0, 0x07, 0x01, 0xE0, 0x06, 0x01, 0xE0, 0x08, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0x80, 0xF8, 0x07, 0xC0,
  0x0F, 0x81, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC1,
  0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0x80, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x1E, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xC7, 0x80, 0x03, 0xC3,
  0xC0, 0x01, 0xE1, 0xF0, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x3F, 0x83, 0xF0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x1E, 0x07, 0xC0, 0x1E, 0x0F, 0x80, 0x1E, 0x0F, 0x00,
  0x1E, 0x1E, 0x00, 0x1E, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x3C, 0x78, 0x00,
  0x3C, 0x78, 0x00, 0x3C, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF8, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC7,
  0xFC, 0x00, 0xF7, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xE0, 0xFC, 0x07,
  0xE0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x78, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x03, 0xE0,
  0x7C, 0x01, 0xF0, 0x0F, 0xC1, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xCF, 0xC0, 0x07, 0xBF, 0xF0, 0x0F, 0x7F, 0xFC, 0x1F,
  0xF3, 0xFC, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0x3E, 0x3E, 0x00, 0x1E, 0x7C,
  0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x3C, 0xF8, 0x00, 0x7C, 0x78, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x3F,
  0x07, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00,
  0x20, 0x00, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xE7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0xF8,
  0xF0, 0x00, 0x78, 0xF8, 0x00, 0x7C, 0x78, 0x00, 0x3C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F,
  0x01, 0xF0, 0x1E, 0x00, 0x7C, 0x1F, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x0F,
  0x80, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x01, 0xE0,
  0xF0, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0xF8,
  0x01, 0xF1, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xFE, 0x00, 0x3E, 0x0F, 0xC0, 0x3E, 0x03, 0xE0, 0x3C, 0x00,
  0xF8, 0x3C, 0x00, 0x3C, 0x3E, 0x00, 0x1F, 0x1E, 0x00, 0x07, 0x8F, 0x00,
  0x03, 0xCF, 0x00, 0x01, 0xE7, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0xF1, 0xF0,
  0x00, 0x78, 0xF8, 0x00, 0x78, 0x3E, 0x00, 0x7C, 0x1F, 0xC1, 0xFC, 0x07,
  0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x0F, 0xC0, 0x7E, 0x1F, 0x00, 0x3E, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x1F,
  0x3C, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x1E,
  0xF8, 0x00, 0x3E, 0x78, 0x00, 0x7C, 0x7C, 0x00, 0xFC, 0x7E, 0x01, 0xF8,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFE, 0xF0, 0x0F, 0xFD, 0xE0, 0x01, 0xE3, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x80, 0x7E, 0x07, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x07, 0xF0, 0x7F, 0x87, 0xF8, 0xFF, 0x07, 0xF0,
  0x7E, 0x01, 0x00, 0x00, 0x18, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F,
  0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0C, 0x00, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF8, 0x08, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xC0, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xC0, 0x03, 0xC0, 0x3E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x78, 0x1C, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x78, 0x78, 0x00, 0xF1, 0xE1, 0xE0,
  0x1F, 0xF7, 0x87, 0x80, 0xFF, 0xDE, 0x1C, 0x07, 0xE3, 0xF8, 0x70, 0x1E,
  0x03, 0xC3, 0xC0, 0xF0, 0x0F, 0x0F, 0x03, 0xC0, 0x3C, 0x3C, 0x0F, 0x00,
  0xF0, 0xF0, 0x38, 0x03, 0xC3, 0x81, 0xE0, 0x0F, 0x0E, 0x07, 0x80, 0x38,
  0x78, 0x1E, 0x00, 0xE1, 0xE0, 0x78, 0x07, 0x87, 0x81, 0xE0, 0x1E, 0x1E,
  0x07, 0x00, 0x78, 0x78, 0x1C, 0x01, 0xE1, 0xC0, 0x70, 0x0F, 0x0F, 0x01,
  0xE0, 0x3C, 0x3C, 0x07, 0x81, 0xF0, 0xF0, 0x1F, 0xFD, 0xC3, 0xC0, 0x3F,
  0xE7, 0x0F, 0x00, 0x7F, 0x3C, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x3D, 0xC0, 0x00, 0x3C,
  0xE0, 0x00, 0x1E, 0x70, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x1E, 0x00, 0x07,
  0x8F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x03, 0xC1, 0xE0, 0x01,
  0xE0, 0xF0, 0x00, 0xF0, 0x38, 0x00, 0xF0, 0x1C, 0x00, 0x78, 0x0F, 0x00,
  0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xF0,
  0x0F, 0x00, 0x78, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x81, 0xE0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00,
  0x78, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x7C, 0x00, 0x0F, 0x3C, 0x00,
  0x07, 0x9E, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x78, 0x03,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x1E, 0x03, 0xFC,
  0x07, 0x80, 0x1F, 0x81, 0xE0, 0x03, 0xE0, 0x78, 0x00, 0x78, 0x3C, 0x00,
  0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x3C,
  0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0xC1, 0xE0, 0x03, 0xE0,
  0x78, 0x03, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0x70, 0x0F, 0xF0, 0x3C, 0x00, 0x7C, 0x0F, 0x00, 0x0F, 0x83, 0xC0,
  0x01, 0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x87,
  0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x0F,
  0x07, 0x80, 0x07, 0xC1, 0xE0, 0x03, 0xE0, 0xF0, 0x01, 0xF8, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x3E, 0x03, 0xF0, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0x3C, 0x1E, 0x00,
  0x1E, 0x1E, 0x00, 0x0F, 0x8F, 0x00, 0x07, 0xC7, 0x80, 0x03, 0xC3, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xC7, 0x80, 0x03, 0xC3, 0xC0, 0x01,
  0xE1, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0xF0, 0x7E, 0x01, 0xF0, 0x1F, 0x83,
  0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0xF0, 0x1F, 0xC0, 0x78, 0x03, 0xF0, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x3E,
  0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01,
  0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0x78, 0x78, 0x00,
  0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80,
  0x03, 0xC7, 0xC0, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0,
  0x00, 0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E,
  0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x03, 0xC1,
  0xE0, 0x03, 0xE0, 0xF0, 0x03, 0xE0, 0xF0, 0x03, 0xE0, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF0, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x83, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3E, 0x03, 0xF0,
  0x3E, 0x00, 0xF8, 0x3E, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x0F,
  0x8F, 0x00, 0x07, 0xC7, 0x80, 0x03, 0xC3, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x03, 0xFF, 0xC7, 0x81,
  0xFF, 0xE3, 0xC0, 0xFF, 0xF1, 0xE0, 0x7F, 0xF8, 0xF0, 0x00, 0x78, 0x78,
  0x00, 0x3C, 0x7C, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x8F,
  0x00, 0x03, 0xC7, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x01, 0xF0,
  0xF8, 0x00, 0xF0, 0x7E, 0x01, 0xF0, 0x1F, 0x83, 0xF8, 0x07, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x03, 0xC0,
  0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07,
  0x80, 0x07, 0xC1, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x1E,
  0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00,
  0x3C, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x78,
  0x00, 0x3C, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF8, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01,
  0xE0, 0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x07, 0x80,
  0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x1F, 0x07,
  0x80, 0x07, 0x81, 0xE0, 0x01, 0xE0, 0xF8, 0x00, 0x78, 0x3C, 0x00, 0x1E,
  0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x1F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x07, 0x80,
  0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xE0, 0x78, 0x00, 0x3C,
  0x07, 0xC0, 0x07, 0xC0, 0x7E, 0x00, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xE0,
  0x78, 0x00, 0x7C, 0x07, 0x80, 0x07, 0x80, 0x78, 0x00, 0xF8, 0x07, 0x80,
  0x1F, 0x00, 0xF0, 0x01, 0xE0, 0x0F, 0x00, 0x3E, 0x00, 0xF0, 0x07, 0xC0,
  0x0F, 0x00, 0x78, 0x00, 0xF0, 0x0F, 0x80, 0x0F, 0x01, 0xF0, 0x01, 0xE0,
  0x1E, 0x00, 0x1E, 0x03, 0xE0, 0x01, 0xE0, 0x7C, 0x00, 0x1F, 0xFF, 0x80,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3C,
  0x07, 0x80, 0x03, 0xC0, 0x7C, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x3C,
  0x00, 0x3C, 0x03, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1F, 0x00, 0x78, 0x00, 0xF0, 0x07, 0x80, 0x0F, 0x00, 0x78, 0x00,
  0xF8, 0x07, 0x80, 0x07, 0x80, 0xF0, 0x00, 0x7C, 0x0F, 0x00, 0x07, 0xC0,
  0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F,
  0x07, 0xF0, 0x07, 0xF0, 0x77, 0x00, 0x77, 0x07, 0x70, 0x0F, 0xE0, 0x77,
  0x00, 0xEE, 0x07, 0x70, 0x1E, 0xE0, 0x77, 0x01, 0xCE, 0x0F, 0x78, 0x3D,
  0xE0, 0xF3, 0x83, 0x9E, 0x0F, 0x38, 0x79, 0xE0, 0xE3, 0x87, 0x1C, 0x0E,
  0x38, 0xF3, 0xC0, 0xE3, 0x8E, 0x3C, 0x1E, 0x3C, 0xE3, 0xC1, 0xE1, 0xDC,
  0x3C, 0x1E, 0x1D, 0xC3, 0xC1, 0xE1, 0xF8, 0x78, 0x1E, 0x1F, 0x87, 0x81,
  0xE1, 0xF0, 0x78, 0x3C, 0x0F, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x3C, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0,
  0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80,
  0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E,
  0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0xE0, 0x03, 0xC1, 0xF8, 0x00, 0xF0, 0x7E, 0x00,
  0x3C, 0x1F, 0xC0, 0x0F, 0x07, 0xF0, 0x03, 0xC1, 0xDC, 0x00, 0xF0, 0xF7,
  0x00, 0x78, 0x3D, 0xE0, 0x1E, 0x0F, 0x78, 0x07, 0x83, 0xDE, 0x01, 0xE0,
  0xF3, 0x80, 0x78, 0x3C, 0xE0, 0x1E, 0x1E, 0x3C, 0x0F, 0x07, 0x8F, 0x03,
  0xC1, 0xE3, 0xC0, 0xF0, 0x78, 0x70, 0x3C, 0x1E, 0x1C, 0x0F, 0x07, 0x87,
  0x83, 0xC1, 0xC1, 0xE0, 0xE0, 0xF0, 0x78, 0x78, 0x3C, 0x0E, 0x1E, 0x0F,
  0x03, 0x87, 0x83, 0xC0, 0xF1, 0xE0, 0xF0, 0x3C, 0x78, 0x3C, 0x0F, 0x1E,
  0x1E, 0x01, 0xCF, 0x07, 0x80, 0x7B, 0xC1, 0xE0, 0x1E, 0xF0, 0x78, 0x07,
  0xBC, 0x1E, 0x00, 0xEF, 0x07, 0x80, 0x3B, 0xC3, 0xC0, 0x0F, 0xE0, 0xF0,
  0x03, 0xF8, 0x3C, 0x00, 0xFE, 0x0F, 0x00, 0x1F, 0x83, 0xC0, 0x07, 0xE0,
  0xF0, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3E, 0x07, 0xE0, 0x3E, 0x00, 0xF8, 0x3E,
  0x00, 0x7C, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87,
  0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF1, 0xE0, 0x00, 0xF8,
  0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F,
  0x0F, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xC7, 0x80, 0x03, 0xC3, 0xC0, 0x01,
  0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x7C, 0x00,
  0x1E, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80,
  0x03, 0xC3, 0xC0, 0x03, 0xE1, 0xE0, 0x01, 0xE0, 0xF8, 0x01, 0xF0, 0x7C,
  0x01, 0xF0, 0x1F, 0x83, 0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xC0, 0x3F, 0xE0, 0x78, 0x00, 0x7C, 0x0F,
  0x00, 0x07, 0xC1, 0xE0, 0x00, 0xF8, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x01, 0xF0, 0xF0,
  0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x01, 0xF0, 0xF0, 0x00, 0x7C,
  0x1E, 0x00, 0x1F, 0x03, 0xC0, 0x1F, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x03, 0xF0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x7C, 0x00, 0x78, 0x3E, 0x00,
  0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE1, 0xF0, 0x00, 0x78, 0x78,
  0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78,
  0x78, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0xC3, 0xC0,
  0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87,
  0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0F,
  0x07, 0x80, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x00,
  0x7C, 0x03, 0xF0, 0x7F, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x00, 0x05, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xC0, 0x3F, 0xC0, 0x78, 0x00,
  0xF8, 0x0F, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0F,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x01,
  0xE0, 0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xE0, 0xF0,
  0x00, 0xF8, 0x1E, 0x00, 0x3E, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x01,
  0xE0, 0x01, 0xE0, 0x3E, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0x80, 0x78, 0x01,
  0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03,
  0xE0, 0x1E, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x00, 0xF8, 0x1E,
  0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3E, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xC0, 0x1F, 0x80, 0xFC, 0x03, 0xC0, 0x0F, 0x80, 0xF0, 0x00,
  0xF0, 0x1E, 0x00, 0x1F, 0x07, 0x80, 0x03, 0xE0, 0xF0, 0x00, 0x7C, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x87,
  0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0xC3, 0xC0, 0x00,
  0xF0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x80, 0xFE, 0x07, 0xE0, 0x0F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x04, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x03,
  0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80,
  0x03, 0xC1, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0F,
  0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1E,
  0x1F, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00,
  0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0,
  0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0,
  0xF0, 0x00, 0x78, 0x3C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x07, 0x80, 0x03,
  0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x1F, 0x07, 0x80,
  0x07, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x0F, 0xC1, 0xF8, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x03, 0xCF, 0x00,
  0x01, 0xE7, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0xF8, 0xF0,
  0x00, 0x78, 0x78, 0x00, 0x3C, 0x3E, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x07,
  0x80, 0x1F, 0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x07, 0x80, 0xF0, 0x07, 0x80,
  0x78, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF0,
  0x03, 0x80, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x3C,
  0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x8F,
  0x00, 0x03, 0xC7, 0x80, 0x01, 0xE7, 0x80, 0x00, 0x73, 0xC0, 0x00, 0x39,
  0xE0, 0x00, 0x1D, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x78, 0x07, 0x80,
  0x7B, 0xC0, 0x7C, 0x03, 0x9E, 0x03, 0xE0, 0x3C, 0xF0, 0x1B, 0x01, 0xE7,
  0x81, 0xF8, 0x0E, 0x3C, 0x0F, 0xC0, 0x71, 0xE0, 0x7E, 0x07, 0x8F, 0x03,
  0x70, 0x3C, 0x70, 0x3B, 0x81, 0xC3, 0x81, 0xDC, 0x1E, 0x1C, 0x0C, 0xE0,
  0xF0, 0xE0, 0xE7, 0x07, 0x87, 0x07, 0x38, 0x38, 0x38, 0x39, 0xC3, 0xC1,
  0xC1, 0x8E, 0x1E, 0x1E, 0x1C, 0x70, 0xE0, 0xF0, 0xE3, 0x87, 0x07, 0x86,
  0x1C, 0x78, 0x3C, 0x70, 0xE3, 0xC1, 0xE3, 0x87, 0x1C, 0x0F, 0x1C, 0x31,
  0xE0, 0x78, 0xC1, 0x8F, 0x03, 0xCE, 0x0C, 0x70, 0x1E, 0x70, 0x63, 0x80,
  0xF3, 0x03, 0x3C, 0x07, 0xB8, 0x19, 0xE0, 0x3D, 0xC0, 0xCE, 0x01, 0xEE,
  0x06, 0x70, 0x0E, 0x60, 0x37, 0x80, 0x77, 0x01, 0xBC, 0x03, 0xB8, 0x1D,
  0xC0, 0x1D, 0x80, 0xEE, 0x00, 0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x3F, 0x00,
  0x3F, 0x01, 0xF8, 0x01, 0xF0, 0x0F, 0xC0, 0x0F, 0x80, 0x7E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x78, 0x03, 0xC0, 0x01, 0xE0,
  0x07, 0x80, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0xF8, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x7C, 0x1E, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0xF8, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0xF0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF9, 0xE0, 0x00,
  0x3C, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x83, 0xC0, 0x03, 0xC0, 0xF0,
  0x01, 0xE0, 0x1E, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00,
  0x7C, 0x0F, 0x80, 0x0F, 0x03, 0xC0, 0x03, 0xC1, 0xE0, 0x00, 0xF8, 0x78,
  0x00, 0x1E, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07,
  0xFF, 0x81, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xF8, 0x00, 0x0E, 0xE0, 0x00, 0x7B, 0x80, 0x01, 0xCF, 0x00, 0x0F,
  0x3C, 0x00, 0x78, 0x70, 0x01, 0xE1, 0xE0, 0x0F, 0x07, 0x80, 0x78, 0x0E,
  0x01, 0xE0, 0x38, 0x0F, 0x00, 0xF0, 0x3C, 0x03, 0xC1, 0xE0, 0x07, 0x0F,
  0x00, 0x1E, 0x3C, 0x00, 0x79, 0xE0, 0x00, 0xE7, 0x80, 0x03, 0xBC, 0x00,
  0x0F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF0, 0x78, 0x7C, 0x3C, 0x1E, 0x1E, 0x0F, 0x00, 0x04, 0x00,
  0x00, 0x3F, 0xE3, 0xC0, 0x7F, 0xF9, 0xE0, 0x7F, 0xFD, 0xE0, 0x7E, 0x07,
  0xF0, 0x7C, 0x01, 0xF8, 0x3C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1E, 0x00,
  0x1F, 0x0F, 0x00, 0x0F, 0x8F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0,
  0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x7C,
  0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87,
  0x80, 0x03, 0xC3, 0xC0, 0x03, 0xE1, 0xE0, 0x01, 0xE0, 0xF8, 0x01, 0xF0,
  0x7C, 0x01, 0xF8, 0x1F, 0x83, 0xBC, 0x0F, 0xFF, 0xDE, 0x03, 0xFF, 0xCF,
  0x00, 0xFF, 0x8F, 0x80, 0x06, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x80, 0x0F, 0x1F,
  0xF0, 0x0F, 0x3F, 0xFC, 0x0F, 0x7F, 0xFC, 0x0F, 0xE0, 0x7E, 0x1E, 0xC0,
  0x3E, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1E, 0x00, 0x0F, 0x1E, 0x00,
  0x0F, 0x1E, 0x00, 0x1F, 0x3E, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00,
  0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00,
  0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00,
  0x7C, 0x78, 0x00, 0x78, 0x7C, 0x00, 0xF8, 0xF6, 0x01, 0xF0, 0xF7, 0x07,
  0xF0, 0xF7, 0xFF, 0xE0, 0xF3, 0xFF, 0xC0, 0xF1, 0xFF, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x0F, 0xC0, 0xFC, 0x1F, 0x00, 0x3E, 0x1E, 0x00, 0x3E, 0x3E, 0x00,
  0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF8, 0xF8, 0x00,
  0xF0, 0xFC, 0x03, 0xF0, 0x7E, 0x0F, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x04, 0x07,
  0x80, 0x1F, 0xF1, 0xE0, 0x1F, 0xFE, 0x78, 0x0F, 0xFF, 0xBE, 0x07, 0xE0,
  0x7F, 0x03, 0xE0, 0x0F, 0xC0, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1E,
  0x00, 0x1F, 0x07, 0x80, 0x07, 0xC3, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78,
  0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00,
  0x78, 0x7C, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0,
  0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x1F, 0x07, 0x80, 0x07, 0xC1,
  0xF0, 0x03, 0xE0, 0x7C, 0x01, 0xF8, 0x0F, 0xC1, 0xDE, 0x03, 0xFF, 0xF7,
  0x80, 0x7F, 0xF9, 0xE0, 0x0F, 0xF8, 0xF8, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFC,
  0x0F, 0xC3, 0xE0, 0x0F, 0x87, 0x80, 0x0F, 0x1E, 0x00, 0x1F, 0x3C, 0x00,
  0x1E, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x01, 0xE7, 0x80, 0x03,
  0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x3E, 0x78, 0x00, 0x78, 0xF8, 0x01, 0xE0, 0xF8,
  0x0F, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0x8F,
  0x03, 0xFF, 0xCF, 0x07, 0xFF, 0xFE, 0x0F, 0xC0, 0xFE, 0x1F, 0x00, 0x7E,
  0x1E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3C, 0x00, 0x3E, 0x3C, 0x00, 0x3E,
  0x7C, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C,
  0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0x78,
  0xF0, 0x00, 0x78, 0xF8, 0x00, 0x78, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF8,
  0x7C, 0x03, 0xF0, 0x7F, 0x9F, 0xF0, 0x3F, 0xFE, 0xF0, 0x1F, 0xFC, 0xF0,
  0x07, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x01, 0x80, 0x0F, 0x1F, 0xF0, 0x0F, 0x3F, 0xFC, 0x0F, 0x7F, 0xFC,
  0x0F, 0xE0, 0x7E, 0x1E, 0x80, 0x3E, 0x1F, 0x80, 0x1F, 0x1F, 0x00, 0x1F,
  0x1E, 0x00, 0x1F, 0x1E, 0x00, 0x1F, 0x1E, 0x00, 0x1E, 0x3E, 0x00, 0x1E,
  0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E,
  0x3C, 0x00, 0x3E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C,
  0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x7C, 0x78, 0x00, 0x78,
  0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78,
  0xF0, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7E, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xFC, 0x3C, 0x00,
  0x1E, 0x07, 0x80, 0x07, 0xC0, 0xF0, 0x01, 0xF0, 0x1E, 0x00, 0x7C, 0x07,
  0x80, 0x1F, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x01, 0xF0, 0x03, 0xC0, 0x3C,
  0x00, 0x78, 0x0F, 0x80, 0x0F, 0x03, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x3C, 0x0F, 0x00,
  0x07, 0x81, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x03, 0xE0, 0x07, 0x80,
  0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x80,
  0x78, 0x00, 0xF0, 0x1E, 0x00, 0x1F, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00,
  0x3E, 0x0F, 0x00, 0x03, 0xC0, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFE,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x00, 0x0C, 0x02, 0x00, 0x73,
  0xF0, 0xFC, 0x0F, 0x7F, 0x9F, 0xE0, 0xFF, 0xFB, 0xFE, 0x0F, 0x87, 0xE1,
  0xE0, 0xF0, 0x3C, 0x1E, 0x0F, 0x03, 0x81, 0xE0, 0xE0, 0x38, 0x1E, 0x0E,
  0x03, 0x81, 0xE1, 0xE0, 0x78, 0x1E, 0x1E, 0x07, 0x81, 0xE1, 0xE0, 0x78,
  0x1E, 0x1E, 0x07, 0x01, 0xC1, 0xE0, 0x70, 0x3C, 0x1C, 0x07, 0x03, 0xC3,
  0xC0, 0xF0, 0x3C, 0x3C, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0x3C, 0x3C, 0x0E,
  0x03, 0x83, 0xC0, 0xE0, 0x38, 0x38, 0x0E, 0x07, 0x87, 0x80, 0xE0, 0x78,
  0x78, 0x1E, 0x07, 0x87, 0x81, 0xE0, 0x78, 0x78, 0x1C, 0x07, 0x87, 0x81,
  0xC0, 0x70, 0x70, 0x1C, 0x0F, 0x07, 0x01, 0xC0, 0xF0, 0xF0, 0x3C, 0x0F,
  0x00, 0x00, 0x01, 0x80, 0x0F, 0x1F, 0xF0, 0x0F, 0x3F, 0xFC, 0x0F, 0x7F,
  0xFC, 0x0F, 0xE0, 0x7E, 0x1E, 0x80, 0x3E, 0x1F, 0x80, 0x1F, 0x1F, 0x00,
  0x1F, 0x1E, 0x00, 0x1F, 0x1E, 0x00, 0x1F, 0x1E, 0x00, 0x1E, 0x3E, 0x00,
  0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00,
  0x1E, 0x3C, 0x00, 0x3E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00,
  0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x7C, 0x78, 0x00,
  0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00,
  0x78, 0xF0, 0x00, 0xF8, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC0, 0xFC, 0x0F, 0xC3, 0xE0, 0x0F, 0x87, 0x80, 0x0F,
  0x1F, 0x00, 0x1F, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xFB,
  0xC0, 0x01, 0xE7, 0x80, 0x03, 0xCF, 0x00, 0x07, 0x9E, 0x00, 0x0F, 0x3C,
  0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xE7, 0x80,
  0x03, 0xCF, 0x00, 0x07, 0x9E, 0x00, 0x1F, 0x3C, 0x00, 0x3C, 0x7C, 0x00,
  0xF8, 0xF8, 0x03, 0xE0, 0xFC, 0x1F, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0xF1,
  0xFF, 0x00, 0x3C, 0xFF, 0xF0, 0x0F, 0x7F, 0xFC, 0x03, 0xF8, 0x1F, 0x81,
  0xEC, 0x03, 0xE0, 0x7E, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x07, 0x80, 0x03,
  0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x7C, 0x3E, 0x00, 0x1E, 0x0F, 0x00,
  0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0F,
  0x00, 0x07, 0x87, 0xC0, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C,
  0x1E, 0x00, 0x0F, 0x07, 0x80, 0x07, 0xC1, 0xE0, 0x01, 0xE0, 0x7C, 0x00,
  0xF8, 0x3D, 0x80, 0x7C, 0x0F, 0x70, 0x3F, 0x03, 0xDF, 0xFF, 0x80, 0xF3,
  0xFF, 0xC0, 0x3C, 0x7F, 0xC0, 0x0F, 0x03, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x3F, 0xE3, 0xC0, 0x7F, 0xF9, 0xE0, 0x7F, 0xFD, 0xE0,
  0x7E, 0x07, 0xF0, 0x7C, 0x01, 0xF8, 0x3C, 0x00, 0x7C, 0x3E, 0x00, 0x3E,
  0x1E, 0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03,
  0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00,
  0x7C, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00,
  0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x03, 0xE1, 0xE0, 0x01, 0xE0, 0xF8,
  0x01, 0xF0, 0x7C, 0x01, 0xF8, 0x1F, 0x83, 0xBC, 0x0F, 0xFF, 0xDE, 0x03,
  0xFF, 0xCF, 0x00, 0xFF, 0x8F, 0x00, 0x04, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0x00, 0x0F, 0x1F, 0xF0, 0x0F, 0x3F, 0xFC, 0x0F, 0x7F, 0xFC, 0x1E, 0xE0,
  0x7E, 0x1F, 0x80, 0x3E, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1E, 0x00,
  0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x3C, 0x00, 0x1F, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x1F, 0x0F, 0x00, 0x0F, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF8, 0x00,
  0x7C, 0xF8, 0x00, 0xF8, 0x7E, 0x01, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x0F, 0x00, 0x07, 0x87, 0x80,
  0x03, 0xC3, 0xC0, 0x01, 0xE3, 0xE0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0,
  0x00, 0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F,
  0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1,
  0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x7C, 0x7C, 0x00, 0x3C,
  0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x07,
  0xC3, 0xC0, 0x03, 0xC1, 0xF0, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x3F, 0x07,
  0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xBC, 0x00, 0x0F, 0x9E, 0x00, 0x07, 0x8F,
  0x00, 0x03, 0xC7, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE0, 0xF0, 0x01, 0xE0,
  0x78, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x78,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x1E,
  0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x07, 0x80, 0x03, 0xC7,
  0x80, 0x01, 0xE3, 0xC0, 0x00, 0xF3, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x3C,
  0xE0, 0x00, 0x0E, 0xF0, 0x00, 0x07, 0x78, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x1E, 0x01, 0xFE, 0x03, 0xC0,
  0x3B, 0xC0, 0x78, 0x0F, 0x78, 0x1F, 0x01, 0xEF, 0x03, 0xE0, 0x39, 0xE0,
  0x6C, 0x07, 0x3C, 0x1D, 0x81, 0xE7, 0x83, 0xB0, 0x38, 0xF0, 0x66, 0x07,
  0x1E, 0x1C, 0xE1, 0xE3, 0xC3, 0x9C, 0x38, 0x78, 0x63, 0x87, 0x0F, 0x1C,
  0x71, 0xE1, 0xE3, 0x8E, 0x38, 0x3C, 0x61, 0xC7, 0x07, 0x9C, 0x39, 0xE0,
  0xF3, 0x87, 0x38, 0x1E, 0x60, 0xE7, 0x03, 0x9C, 0x1C, 0xE0, 0x73, 0x83,
  0xB8, 0x0E, 0x60, 0x77, 0x01, 0xDC, 0x0E, 0xE0, 0x3B, 0x81, 0xF8, 0x07,
  0x60, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xF8, 0x03, 0xE0, 0x1F,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x3C, 0x00, 0x3E,
  0x03, 0xE0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x0F, 0x00, 0x0F,
  0x01, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x7C, 0x78,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x1E, 0x1F, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x80,
  0x78, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x3C, 0x03, 0xE0, 0x03, 0xE0,
  0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0x1E, 0x00, 0x0F, 0x1E, 0x00,
  0x0F, 0x1E, 0x00, 0x1E, 0x3E, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00,
  0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x7C, 0x00,
  0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00,
  0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00,
  0x78, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF8, 0x7C, 0x03,
  0xF0, 0x7F, 0xBF, 0xF0, 0x3F, 0xFE, 0xF0, 0x1F, 0xF8, 0xF0, 0x07, 0xE0,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF0,
  0x0F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x04, 0x7F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x03, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x03, 0x87, 0xFC, 0x03, 0xC7, 0xFF, 0x01, 0xE7,
  0xCF, 0x80, 0xF7, 0x83, 0xE0, 0x7B, 0xC0, 0xF8, 0x79, 0xE0, 0x3E, 0x7C,
  0xF0, 0x1F, 0xFC, 0x70, 0x07, 0xFC, 0x78, 0x00, 0xFC, 0x00,
};

const GFXglyph JetBrainsMono_LightItalic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 11, 37, 31, 10, -37 },
  { 52, 16, 15, 31, 10, -37 },
  { 82, 30, 37, 31, 1, -37 },
  { 221, 27, 51, 31, 2, -44 },
  { 394, 34, 37, 31, -1, -37 },
  { 552, 28, 39, 31, 1, -38 },
  { 689, 6, 15, 31, 15, -37 },
  { 701, 21, 49, 31, 8, -43 },
  { 830, 20, 49, 31, 3, -43 },
  { 953, 27, 26, 31, 3, -31 },
  { 1041, 24, 24, 31, 4, -29 },
  { 1113, 13, 16, 31, 5, -8 },
  { 1139, 17, 4, 31, 7, -19 },
  { 1148, 9, 9, 31, 9, -8 },
  { 1159, 30, 48, 31, 1, -42 },
  { 1339, 26, 39, 31, 3, -38 },
  { 1466, 24, 37, 31, 2, -37 },
  { 1577, 27, 38, 31, 2, -38 },
  { 1706, 25, 38, 31, 3, -37 },
  { 1825, 24, 37, 31, 3, -37 },
  { 1936, 26, 38, 31, 3, -37 },
  { 2060, 24, 38, 31, 3, -37 },
  { 2174, 25, 37, 31, 6, -37 },
  { 2290, 25, 39, 31, 3, -38 },
  { 2412, 24, 38, 31, 5, -38 },
  { 2526, 12, 30, 31, 9, -29 },
  { 2571, 16, 37, 31, 5, -29 },
  { 2645, 25, 26, 31, 4, -30 },
  { 2727, 24, 16, 31, 4, -25 },
  { 2775, 24, 26, 31, 3, -30 },
  { 2853, 20, 37, 31, 8, -37 },
  { 2946, 30, 47, 31, 1, -38 },
  { 3123, 25, 37, 31, 1, -37 },
  { 3239, 26, 37, 31, 3, -37 },
  { 3360, 25, 39, 31, 4, -38 },
  { 3482, 25, 37, 31, 3, -37 },
  { 3598, 27, 37, 31, 3, -37 },
  { 3723, 27, 37, 31, 3, -37 },
  { 3848, 25, 39, 31, 4, -38 },
  { 3970, 26, 37, 31, 3, -37 },
  { 4091, 26, 37, 31, 3, -37 },
  { 4212, 28, 38, 31, 1, -37 },
  { 4345, 28, 37, 31, 3, -37 },
  { 4475, 22, 37, 31, 4, -37 },
  { 4577, 28, 37, 31, 2, -37 },
  { 4707, 26, 37, 31, 3, -37 },
  { 4828, 25, 39, 31, 4, -38 },
  { 4950, 27, 37, 31, 3, -37 },
  { 5075, 26, 47, 31, 3, -38 },
  { 5228, 27, 37, 31, 3, -37 },
  { 5353, 27, 39, 31, 2, -38 },
  { 5485, 25, 37, 31, 6, -37 },
  { 5601, 26, 38, 31, 3, -37 },
  { 5725, 25, 37, 31, 6, -37 },
  { 5841, 29, 37, 31, 4, -37 },
  { 5976, 31, 37, 31, 0, -37 },
  { 6120, 26, 37, 31, 6, -37 },
  { 6241, 27, 37, 31, 2, -37 },
  { 6366, 19, 48, 31, 8, -42 },
  { 6480, 14, 48, 31, 9, -42 },
  { 6564, 19, 48, 31, 5, -42 },
  { 6678, 22, 20, 31, 5, -37 },
  { 6733, 25, 4, 31, 0, 1 },
  { 6746, 8, 7, 31, 14, -40 },
  { 6753, 25, 30, 31, 3, -29 },
  { 6847, 24, 38, 31, 3, -37 },
  { 6961, 24, 30, 31, 4, -29 },
  { 7051, 26, 38, 31, 3, -37 },
  { 7175, 23, 30, 31, 4, -29 },
  { 7262, 34, 46, 31, -2, -37 },
  { 7458, 24, 38, 31, 4, -29 },
  { 7572, 24, 37, 31, 3, -37 },
  { 7683, 24, 39, 31, 2, -39 },
  { 7800, 26, 48, 31, 1, -39 },
  { 7956, 27, 37, 31, 3, -37 },
  { 8081, 21, 37, 31, 5, -37 },
  { 8179, 28, 29, 31, 1, -29 },
  { 8281, 24, 29, 31, 3, -29 },
  { 8368, 23, 30, 31, 4, -29 },
  { 8455, 26, 38, 31, 1, -29 },
  { 8579, 25, 38, 31, 3, -29 },
  { 8698, 24, 29, 31, 4, -29 },
  { 8785, 24, 30, 31, 3, -29 },
  { 8875, 24, 36, 31, 5, -36 },
  { 8983, 25, 29, 31, 3, -28 },
  { 9074, 25, 28, 31, 5, -28 },
  { 9162, 27, 28, 31, 4, -28 },
  { 9257, 28, 28, 31, 1, -28 },
  { 9355, 24, 37, 31, 4, -28 },
  { 9466, 25, 28, 31, 2, -28 },
  { 9554, 26, 48, 31, 5, -42 },
  { 9710, 12, 48, 31, 10, -42 },
  { 9782, 26, 48, 31, 1, -42 },
  { 9938, 25, 10, 31, 3, -23 },
};

const GFXfont JetBrainsMono_LightItalic51pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_LightItalic51pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_LightItalic51pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _JETBRAINSMONO_LIGHTITALIC51PT7B_H_
