#ifndef _JETBRAINSMONO_LIGHTITALIC19PT7B_H_
#define _JETBRAINSMONO_LIGHTITALIC19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-LightItalic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_LightItalic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x32, 0x26, 0x66, 0x44, 0x00, 0xCC, 0xCF, 0x3C, 0xA2, 0x8A,
  0x60, 0x06, 0x20, 0x8C, 0x11, 0x06, 0x23, 0xFE, 0x11, 0x06, 0x20, 0x8C,
  0x11, 0x1F, 0xF8, 0x8C, 0x11, 0x06, 0x20, 0x8C, 0x00, 0x02, 0x00, 0x80,
  0x20, 0x3C, 0x1D, 0x89, 0x32, 0x4C, 0x90, 0x34, 0x0F, 0x00, 0xF0, 0x26,
  0x09, 0xB2, 0x6C, 0x93, 0xAC, 0x7E, 0x04, 0x01, 0x00, 0x40, 0x0E, 0x08,
  0x98, 0x8C, 0xC8, 0x44, 0xC2, 0x2C, 0x1F, 0x40, 0x04, 0x00, 0x40, 0x05,
  0xE0, 0x69, 0x86, 0x4C, 0x26, 0x62, 0x32, 0x60, 0xE0, 0x07, 0x83, 0x30,
  0x43, 0x08, 0x01, 0x80, 0x30, 0x0F, 0x01, 0x63, 0x66, 0xC8, 0x51, 0x0C,
  0x21, 0x86, 0x78, 0xF9, 0x80, 0x6D, 0x25, 0x80, 0x03, 0x06, 0x18, 0x10,
  0x30, 0x20, 0x60, 0x60, 0x60, 0x40, 0x40, 0x40, 0xC0, 0xC0, 0x40, 0x60,
  0x30, 0x18, 0x10, 0x1C, 0x06, 0x06, 0x02, 0x02, 0x02, 0x02, 0x02, 0x06,
  0x06, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x70, 0xC0, 0x04, 0x01, 0x00, 0x41,
  0x11, 0xF7, 0xC7, 0x81, 0xC0, 0xD8, 0x62, 0x10, 0xC0, 0x04, 0x02, 0x03,
  0x01, 0x8F, 0xF8, 0x40, 0x20, 0x10, 0x18, 0x00, 0x39, 0x98, 0xC4, 0x60,
  0xFC, 0x67, 0x60, 0x00, 0x30, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18,
  0x01, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x00,
  0x30, 0x02, 0x00, 0x60, 0x0C, 0x00, 0x0F, 0x0E, 0x62, 0x0D, 0x83, 0x60,
  0x98, 0x24, 0xC9, 0x32, 0x41, 0xB0, 0x6C, 0x1B, 0x04, 0x63, 0x1F, 0x00,
  0x06, 0x0F, 0x0C, 0x84, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x04, 0x06, 0x03,
  0x01, 0x80, 0x8F, 0xF8, 0x0F, 0x0E, 0x62, 0x0D, 0x83, 0x00, 0x80, 0x60,
  0x10, 0x0C, 0x06, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x3F, 0xC0, 0x3F, 0xCF,
  0xE0, 0x10, 0x08, 0x0C, 0x03, 0x80, 0xF0, 0x04, 0x01, 0x80, 0x4C, 0x13,
  0x0C, 0xC6, 0x1F, 0x00, 0x01, 0x81, 0x80, 0x80, 0x80, 0xC0, 0xC0, 0xC6,
  0xC3, 0x41, 0x60, 0xBF, 0xC0, 0x60, 0x30, 0x18, 0x3F, 0xCF, 0xE3, 0x00,
  0x80, 0x20, 0x0B, 0xC7, 0x39, 0x86, 0x01, 0x80, 0x60, 0x13, 0x04, 0x63,
  0x1F, 0x00, 0x03, 0x03, 0x01, 0x01, 0x01, 0x81, 0xA0, 0xFC, 0xC3, 0x41,
  0xE0, 0xF0, 0x78, 0x26, 0x33, 0xE0, 0x7F, 0xBF, 0xD0, 0x78, 0x20, 0x30,
  0x10, 0x18, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x02, 0x03, 0x00, 0x0F, 0x06,
  0x63, 0x08, 0x82, 0x21, 0x8C, 0xC1, 0xE0, 0xF8, 0x63, 0x10, 0x6C, 0x1B,
  0x04, 0xE3, 0x1F, 0x80, 0x1E, 0x39, 0x90, 0x78, 0x3C, 0x1E, 0x0B, 0x0C,
  0xFC, 0x36, 0x06, 0x02, 0x02, 0x03, 0x03, 0x00, 0x11, 0xCE, 0x00, 0x00,
  0x00, 0x23, 0x98, 0x08, 0x71, 0xC0, 0x00, 0x00, 0x00, 0x38, 0xC6, 0x18,
  0x43, 0x00, 0x01, 0x83, 0x87, 0x0E, 0x0C, 0x06, 0x01, 0xC0, 0x38, 0x06,
  0x01, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x60, 0x1C, 0x03,
  0x80, 0xE0, 0x18, 0x1C, 0x38, 0x70, 0xE0, 0x40, 0x00, 0x78, 0xFC, 0x18,
  0x10, 0x20, 0xC3, 0x3C, 0x60, 0xC0, 0x00, 0x0E, 0x18, 0x00, 0x07, 0xC3,
  0x0C, 0x40, 0x90, 0x12, 0x02, 0xC7, 0x59, 0x9B, 0x23, 0x44, 0x69, 0x89,
  0x31, 0x26, 0x6C, 0x75, 0x80, 0x10, 0x03, 0x00, 0x3C, 0x00, 0x03, 0x01,
  0xC0, 0x70, 0x14, 0x0D, 0x82, 0x61, 0x98, 0x46, 0x10, 0x8F, 0xE2, 0x09,
  0x82, 0x40, 0xB0, 0x30, 0x3F, 0x0F, 0xE2, 0x08, 0x83, 0x20, 0x98, 0x67,
  0xE1, 0x9C, 0x41, 0x90, 0x64, 0x1B, 0x04, 0xC7, 0x3F, 0x00, 0x0F, 0x06,
  0x63, 0x0C, 0x83, 0x60, 0x18, 0x06, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x1B,
  0x04, 0x63, 0x0F, 0x00, 0x3F, 0x08, 0xE2, 0x08, 0x82, 0x20, 0x98, 0x26,
  0x19, 0x86, 0x41, 0x90, 0x64, 0x13, 0x0C, 0xC6, 0x3F, 0x00, 0x3F, 0xCF,
  0xF2, 0x00, 0x80, 0x20, 0x08, 0x07, 0xF9, 0x80, 0x60, 0x10, 0x04, 0x01,
  0x00, 0xC0, 0x3F, 0xC0, 0x3F, 0xCF, 0xF2, 0x00, 0x80, 0x20, 0x18, 0x07,
  0xF9, 0xFE, 0x40, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x0F, 0x06,
  0x63, 0x0C, 0x83, 0x60, 0x18, 0x06, 0x01, 0x1E, 0x49, 0x90, 0x6C, 0x1B,
  0x04, 0x63, 0x0F, 0x00, 0x30, 0xCC, 0x32, 0x0C, 0x82, 0x20, 0x98, 0x27,
  0xF9, 0xFE, 0x41, 0x90, 0x44, 0x13, 0x04, 0xC3, 0x30, 0xC0, 0x3F, 0xCF,
  0xE0, 0x40, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80,
  0x60, 0x18, 0x3F, 0xC0, 0x03, 0xE0, 0x78, 0x01, 0x00, 0x20, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0x80, 0x11, 0x02, 0x20, 0xC6, 0x30, 0x7C, 0x00,
  0x30, 0x66, 0x18, 0x86, 0x10, 0x82, 0x30, 0xCC, 0x1F, 0x83, 0x20, 0x46,
  0x08, 0x41, 0x0C, 0x61, 0x8C, 0x11, 0x83, 0x00, 0x10, 0x18, 0x0C, 0x06,
  0x02, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x04, 0x0F, 0xF8,
  0x30, 0xCC, 0x33, 0x15, 0xC7, 0x7A, 0xD2, 0xA4, 0xC9, 0x32, 0x41, 0xB0,
  0x6C, 0x1B, 0x04, 0x81, 0x20, 0x40, 0x30, 0xCC, 0x33, 0x8C, 0xA2, 0x68,
  0x9A, 0x26, 0xD9, 0x36, 0x45, 0x91, 0x44, 0x53, 0x1C, 0xC7, 0x30, 0xC0,
  0x0F, 0x06, 0x63, 0x08, 0x82, 0x60, 0x98, 0x26, 0x19, 0x06, 0x41, 0x90,
  0x6C, 0x13, 0x0C, 0x66, 0x0F, 0x00, 0x3F, 0x0F, 0xF2, 0x0C, 0x81, 0x20,
  0xD8, 0x36, 0x19, 0xFC, 0x40, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x00,
  0x0F, 0x0E, 0x62, 0x0D, 0x83, 0x60, 0x98, 0x24, 0x09, 0x06, 0x41, 0x90,
  0x6C, 0x13, 0x04, 0x67, 0x1F, 0x00, 0x40, 0x18, 0x06, 0x00, 0x3F, 0x0F,
  0xE2, 0x0C, 0x83, 0x20, 0xD8, 0x26, 0x39, 0xF8, 0x46, 0x11, 0x84, 0x23,
  0x0C, 0xC3, 0x30, 0x40, 0x0F, 0x06, 0x62, 0x0C, 0x83, 0x20, 0x0C, 0x01,
  0xC0, 0x3C, 0x01, 0x80, 0x6C, 0x1B, 0x04, 0xE3, 0x1F, 0x80, 0xFF, 0xFF,
  0xE0, 0x80, 0x20, 0x08, 0x06, 0x01, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x30, 0x0C, 0x00, 0x30, 0xC8, 0x32, 0x0C, 0x82, 0x60, 0x98, 0x26,
  0x19, 0x86, 0x41, 0x90, 0x44, 0x13, 0x0C, 0x66, 0x1F, 0x00, 0xC0, 0xD0,
  0x24, 0x19, 0x04, 0x43, 0x10, 0x86, 0x21, 0x98, 0x64, 0x1B, 0x06, 0x80,
  0xA0, 0x38, 0x0C, 0x00, 0x46, 0x28, 0xCD, 0x19, 0xA5, 0x24, 0xA4, 0x95,
  0x94, 0xA2, 0x94, 0x52, 0x8A, 0x73, 0x8C, 0x72, 0x8E, 0x51, 0x8C, 0x00,
  0x30, 0x31, 0x86, 0x18, 0xC0, 0x88, 0x0D, 0x80, 0x70, 0x06, 0x00, 0x60,
  0x0F, 0x01, 0xB0, 0x11, 0x02, 0x18, 0x60, 0x8C, 0x0C, 0xC0, 0xD0, 0x24,
  0x11, 0x8C, 0x22, 0x09, 0x83, 0xC0, 0x60, 0x18, 0x04, 0x01, 0x00, 0x40,
  0x30, 0x0C, 0x00, 0x3F, 0xCF, 0xF0, 0x18, 0x04, 0x03, 0x01, 0x80, 0xC0,
  0x20, 0x18, 0x0C, 0x02, 0x01, 0x00, 0xC0, 0x3F, 0xC0, 0x1E, 0x7C, 0xC1,
  0x82, 0x04, 0x08, 0x30, 0x60, 0xC1, 0x82, 0x04, 0x08, 0x30, 0x60, 0xC9,
  0xE0, 0xC3, 0x04, 0x10, 0x61, 0x82, 0x08, 0x30, 0xC3, 0x04, 0x10, 0x61,
  0x82, 0x08, 0x30, 0x3E, 0x7C, 0x18, 0x30, 0x40, 0x81, 0x06, 0x0C, 0x18,
  0x20, 0x40, 0x83, 0x06, 0x0C, 0x19, 0xE0, 0x0C, 0x0C, 0x16, 0x32, 0x22,
  0x62, 0xC3, 0x81, 0xFF, 0xFF, 0xC0, 0xCC, 0x80, 0x0C, 0x1F, 0x48, 0x6C,
  0x34, 0x1A, 0x0D, 0x05, 0x82, 0xC3, 0x33, 0x9F, 0xC0, 0x30, 0x10, 0x08,
  0x04, 0xC3, 0xF3, 0x0D, 0x86, 0xC3, 0x41, 0xA0, 0xD0, 0x58, 0x6E, 0x37,
  0xF0, 0x0E, 0x1F, 0x88, 0x6C, 0x14, 0x02, 0x01, 0x01, 0x80, 0xC1, 0x31,
  0x8F, 0x80, 0x00, 0xC0, 0x30, 0x0C, 0x32, 0x3E, 0x88, 0x66, 0x19, 0x06,
  0x41, 0x90, 0x4C, 0x13, 0x0C, 0x67, 0x1F, 0xC0, 0x0E, 0x1F, 0x88, 0x6C,
  0x34, 0x1B, 0xFD, 0x01, 0x80, 0xC1, 0x31, 0x8F, 0x00, 0x00, 0xF8, 0x0F,
  0xC0, 0xC0, 0x06, 0x00, 0x20, 0x0F, 0xF8, 0x08, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0xF8,
  0x00, 0x0C, 0x1F, 0x48, 0x6C, 0x34, 0x1A, 0x0D, 0x04, 0x82, 0x63, 0x3F,
  0x80, 0xC0, 0x60, 0x23, 0xF0, 0x30, 0x10, 0x08, 0x04, 0xC3, 0xF3, 0x0D,
  0x86, 0xC3, 0x41, 0xA0, 0x90, 0x58, 0x2C, 0x16, 0x18, 0x02, 0x03, 0x80,
  0x80, 0x00, 0x01, 0xF0, 0x10, 0x08, 0x04, 0x06, 0x03, 0x01, 0x80, 0x80,
  0x43, 0xFE, 0x00, 0xC0, 0x70, 0x08, 0x00, 0x00, 0x07, 0xE0, 0x18, 0x06,
  0x01, 0x00, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x3F,
  0x00, 0x30, 0x0C, 0x02, 0x00, 0x81, 0x21, 0x98, 0x46, 0x31, 0x98, 0x7C,
  0x13, 0x04, 0x63, 0x18, 0xC3, 0x30, 0xC0, 0xF8, 0xF8, 0x10, 0x10, 0x10,
  0x10, 0x30, 0x30, 0x30, 0x20, 0x20, 0x20, 0x30, 0x3F, 0x04, 0xC7, 0xF8,
  0x89, 0x93, 0x26, 0x64, 0xC8, 0x99, 0x12, 0x26, 0x44, 0xC9, 0x93, 0x32,
  0x00, 0x06, 0x1F, 0x98, 0x6C, 0x36, 0x1A, 0x0D, 0x04, 0x82, 0xC1, 0x60,
  0xB0, 0xC0, 0x0E, 0x1F, 0x88, 0x6C, 0x34, 0x1A, 0x0D, 0x07, 0x82, 0xC3,
  0x31, 0x0F, 0x00, 0x03, 0x07, 0xE3, 0x0C, 0xC3, 0x30, 0xC8, 0x32, 0x0C,
  0x82, 0x61, 0x9C, 0x67, 0xF1, 0x00, 0x40, 0x30, 0x00, 0x0C, 0x1F, 0x48,
  0x6C, 0x34, 0x1A, 0x0D, 0x05, 0x82, 0xC3, 0x33, 0x9F, 0xC0, 0x60, 0x20,
  0x10, 0x06, 0x0B, 0xE3, 0x08, 0x82, 0x60, 0x98, 0x06, 0x01, 0x00, 0x40,
  0x10, 0x0C, 0x00, 0x0E, 0x1F, 0xC8, 0x6C, 0x06, 0x01, 0xF0, 0x0C, 0x02,
  0xC1, 0x61, 0x9F, 0x80, 0x18, 0x0C, 0x04, 0x3F, 0xE1, 0x01, 0x80, 0xC0,
  0x60, 0x20, 0x10, 0x08, 0x06, 0x03, 0xE0, 0x60, 0xB0, 0x58, 0x6C, 0x34,
  0x1A, 0x09, 0x05, 0x86, 0x66, 0x1E, 0x00, 0xC1, 0xE1, 0x90, 0xC8, 0x44,
  0x63, 0x21, 0xB0, 0xD0, 0x38, 0x18, 0x00, 0x98, 0xCC, 0x66, 0x75, 0x2A,
  0x95, 0x5B, 0x29, 0x94, 0xCE, 0x46, 0x00, 0x30, 0xE3, 0x10, 0x24, 0x07,
  0x80, 0x60, 0x1C, 0x06, 0xC1, 0x98, 0x21, 0x9C, 0x30, 0x60, 0xB0, 0x58,
  0x68, 0x34, 0x1A, 0x09, 0x04, 0xC6, 0x7F, 0x01, 0x80, 0xC0, 0x47, 0xE0,
  0x3F, 0x80, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x7F, 0x80,
  0x01, 0x83, 0xC1, 0x00, 0x80, 0x40, 0x60, 0x30, 0x18, 0xF8, 0x78, 0x02,
  0x01, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x18, 0x0F, 0x00, 0x13, 0x33, 0x22,
  0x26, 0x66, 0x44, 0x44, 0xCC, 0xC8, 0x38, 0x1E, 0x01, 0x00, 0x80, 0xC0,
  0x60, 0x20, 0x10, 0x0F, 0x87, 0xC6, 0x03, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x30, 0x70, 0x00, 0x30, 0xDE, 0x24, 0xCB, 0x1E,
};

const GFXglyph JetBrainsMono_LightItalic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 4, 14, 11, 4, -14 },
  { 8, 6, 6, 11, 4, -14 },
  { 13, 11, 14, 11, 0, -14 },
  { 33, 10, 20, 11, 1, -17 },
  { 58, 13, 14, 11, -1, -14 },
  { 81, 11, 14, 11, 0, -14 },
  { 101, 3, 6, 11, 5, -14 },
  { 104, 8, 18, 11, 3, -16 },
  { 122, 8, 18, 11, 1, -16 },
  { 140, 10, 10, 11, 1, -12 },
  { 153, 9, 9, 11, 1, -11 },
  { 164, 5, 6, 11, 2, -3 },
  { 168, 6, 1, 11, 3, -7 },
  { 169, 4, 3, 11, 3, -3 },
  { 171, 12, 18, 11, 0, -16 },
  { 198, 10, 14, 11, 1, -14 },
  { 216, 9, 14, 11, 1, -14 },
  { 232, 10, 14, 11, 1, -14 },
  { 250, 10, 14, 11, 1, -14 },
  { 268, 9, 14, 11, 1, -14 },
  { 284, 10, 14, 11, 1, -14 },
  { 302, 9, 14, 11, 1, -14 },
  { 318, 9, 14, 11, 2, -14 },
  { 334, 10, 14, 11, 1, -14 },
  { 352, 9, 14, 11, 2, -14 },
  { 368, 5, 11, 11, 3, -11 },
  { 375, 6, 14, 11, 2, -11 },
  { 386, 9, 10, 11, 2, -11 },
  { 398, 9, 6, 11, 1, -9 },
  { 405, 9, 10, 11, 1, -11 },
  { 417, 7, 14, 11, 3, -14 },
  { 430, 11, 17, 11, 0, -14 },
  { 454, 10, 14, 11, 0, -14 },
  { 472, 10, 14, 11, 1, -14 },
  { 490, 10, 14, 11, 1, -14 },
  { 508, 10, 14, 11, 1, -14 },
  { 526, 10, 14, 11, 1, -14 },
  { 544, 10, 14, 11, 1, -14 },
  { 562, 10, 14, 11, 1, -14 },
  { 580, 10, 14, 11, 1, -14 },
  { 598, 10, 14, 11, 1, -14 },
  { 616, 11, 14, 11, 0, -14 },
  { 636, 11, 14, 11, 1, -14 },
  { 656, 9, 14, 11, 1, -14 },
  { 672, 10, 14, 11, 1, -14 },
  { 690, 10, 14, 11, 1, -14 },
  { 708, 10, 14, 11, 1, -14 },
  { 726, 10, 14, 11, 1, -14 },
  { 744, 10, 17, 11, 1, -14 },
  { 766, 10, 14, 11, 1, -14 },
  { 784, 10, 14, 11, 1, -14 },
  { 802, 10, 14, 11, 2, -14 },
  { 820, 10, 14, 11, 1, -14 },
  { 838, 10, 14, 11, 2, -14 },
  { 856, 11, 14, 11, 1, -14 },
  { 876, 12, 14, 11, 0, -14 },
  { 897, 10, 14, 11, 2, -14 },
  { 915, 10, 14, 11, 1, -14 },
  { 933, 7, 18, 11, 3, -16 },
  { 949, 6, 18, 11, 3, -16 },
  { 963, 7, 18, 11, 2, -16 },
  { 979, 8, 8, 11, 2, -14 },
  { 987, 9, 2, 11, 0, 0 },
  { 990, 3, 3, 11, 5, -15 },
  { 992, 9, 11, 11, 1, -11 },
  { 1005, 9, 14, 11, 1, -14 },
  { 1021, 9, 11, 11, 1, -11 },
  { 1034, 10, 14, 11, 1, -14 },
  { 1052, 9, 11, 11, 1, -11 },
  { 1065, 13, 17, 11, -1, -14 },
  { 1093, 9, 14, 11, 1, -11 },
  { 1109, 9, 14, 11, 1, -14 },
  { 1125, 9, 15, 11, 1, -15 },
  { 1142, 10, 18, 11, 0, -15 },
  { 1165, 10, 14, 11, 1, -14 },
  { 1183, 8, 14, 11, 2, -14 },
  { 1197, 11, 11, 11, 0, -11 },
  { 1213, 9, 11, 11, 1, -11 },
  { 1226, 9, 11, 11, 1, -11 },
  { 1239, 10, 14, 11, 0, -11 },
  { 1257, 9, 14, 11, 1, -11 },
  { 1273, 10, 11, 11, 1, -11 },
  { 1287, 9, 11, 11, 1, -11 },
  { 1300, 9, 13, 11, 2, -13 },
  { 1315, 9, 10, 11, 1, -10 },
  { 1327, 9, 10, 11, 2, -10 },
  { 1339, 9, 10, 11, 2, -10 },
  { 1351, 11, 10, 11, 0, -10 },
  { 1365, 9, 13, 11, 1, -10 },
  { 1380, 9, 10, 11, 1, -10 },
  { 1392, 9, 18, 11, 2, -16 },
  { 1413, 4, 18, 11, 4, -16 },
  { 1422, 9, 18, 11, 1, -16 },
  { 1443, 10, 4, 11, 1, -9 },
};

const GFXfont JetBrainsMono_LightItalic19pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_LightItalic19pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_LightItalic19pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _JETBRAINSMONO_LIGHTITALIC19PT7B_H_
