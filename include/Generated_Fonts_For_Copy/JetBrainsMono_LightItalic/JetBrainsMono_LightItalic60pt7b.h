#ifndef _JETBRAINSMONO_LIGHTITALIC60PT7B_H_
#define _JETBRAINSMONO_LIGHTITALIC60PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-LightItalic.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_LightItalic60pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x03, 0xF8, 0x1F, 0xE0, 0x7F,
  0x81, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0x01, 0xF3, 0xF0, 0x1F, 0x3F,
  0x03, 0xF3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3,
  0xE0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C,
  0x7C, 0x07, 0xC7, 0x80, 0x7C, 0x78, 0x07, 0x87, 0x80, 0x78, 0x78, 0x07,
  0x8F, 0x80, 0x78, 0x00, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x3F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFF, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0xF0,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x07, 0x80, 0x1E, 0x00,
  0x00, 0xF0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x07, 0x80, 0x1E,
  0x00, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x1E, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xE7, 0x9F, 0xC0, 0x3F, 0x0E, 0x1F, 0x80, 0x7C,
  0x1C, 0x1F, 0x01, 0xF0, 0x38, 0x3F, 0x03, 0xE0, 0x70, 0x3E, 0x07, 0x81,
  0xE0, 0x7C, 0x1F, 0x03, 0xC0, 0xF8, 0x3E, 0x07, 0x00, 0x00, 0x7C, 0x0E,
  0x00, 0x00, 0xF8, 0x1C, 0x00, 0x01, 0xF0, 0x38, 0x00, 0x03, 0xF0, 0x70,
  0x00, 0x03, 0xF1, 0xE0, 0x00, 0x07, 0xF3, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x07, 0x3F, 0xC0, 0x00, 0x0E, 0x1F, 0x80, 0x00, 0x1C, 0x1F, 0x00,
  0x00, 0x78, 0x3F, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x01, 0xC0, 0x7C, 0x00,
  0x03, 0x80, 0xF8, 0x00, 0x07, 0x01, 0xF0, 0xF0, 0x0E, 0x03, 0xC3, 0xE0,
  0x3C, 0x0F, 0x83, 0xC0, 0x78, 0x1F, 0x07, 0xC0, 0xE0, 0x7E, 0x0F, 0x81,
  0xC0, 0xF8, 0x1F, 0x83, 0x83, 0xE0, 0x1F, 0xC7, 0x1F, 0xC0, 0x3F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0x80, 0x1F, 0xFC, 0x00, 0x07, 0x80, 0x1F, 0xFF, 0x00, 0x07,
  0x80, 0x1F, 0xFF, 0x80, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x03, 0xC0, 0x0F,
  0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x07, 0x80, 0x3C,
  0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x03, 0xE0,
  0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x07, 0x81, 0xE0, 0x00, 0x3C,
  0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x01, 0xE1,
  0xE0, 0x00, 0x07, 0x81, 0xF1, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0xF0, 0x00,
  0x00, 0xFF, 0xF0, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x7F, 0xE0, 0x00, 0x00,
  0x78, 0x7F, 0xF8, 0x00, 0x00, 0x78, 0x7F, 0xFC, 0x00, 0x00, 0x7C, 0x7C,
  0x1F, 0x00, 0x00, 0x3C, 0x7C, 0x07, 0x80, 0x00, 0x3C, 0x3C, 0x03, 0xC0,
  0x00, 0x3C, 0x1E, 0x01, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0xF0, 0x00, 0x3C,
  0x0F, 0x00, 0x78, 0x00, 0x3C, 0x07, 0x80, 0x3C, 0x00, 0x3E, 0x03, 0xC0,
  0x1C, 0x00, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0x1E, 0x00, 0xF0, 0x0F, 0x00,
  0x1E, 0x00, 0x78, 0x07, 0x80, 0x1E, 0x00, 0x3E, 0x07, 0x80, 0x1E, 0x00,
  0x1F, 0xDF, 0xC0, 0x1F, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0x00, 0x01, 0xFF,
  0xC0, 0x1F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0xF8, 0x01, 0xF8, 0x01,
  0xF0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0xF8, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xCF, 0x80, 0x1F, 0x1F, 0x0F, 0xC0, 0x1F, 0x3E, 0x07, 0xC0, 0x3E, 0x3E,
  0x07, 0xE0, 0x7C, 0x3C, 0x03, 0xE0, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x7C,
  0x01, 0xF1, 0xF0, 0x7C, 0x00, 0xFB, 0xE0, 0x7C, 0x00, 0xFB, 0xC0, 0x7C,
  0x00, 0x7F, 0xC0, 0x78, 0x00, 0x7F, 0x80, 0x78, 0x00, 0x3F, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x7F, 0x80, 0xF8,
  0x00, 0xFF, 0xC0, 0xFC, 0x01, 0xFF, 0xC0, 0xFE, 0x07, 0xF7, 0xE0, 0x7F,
  0xFF, 0xE3, 0xE0, 0x7F, 0xFF, 0x81, 0xF0, 0x3F, 0xFF, 0x01, 0xF0, 0x0F,
  0xFC, 0x00, 0xF8, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0x3F, 0x3E, 0x3E, 0x3E,
  0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0xF8, 0xF8,
  0xF0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x30, 0x01, 0xE0, 0x02, 0x3E, 0x01, 0xE0, 0x1E, 0x7F,
  0x81, 0xC0, 0xFE, 0x7F, 0xE1, 0xC7, 0xFF, 0xFF, 0xF1, 0x8F, 0xFF, 0x1F,
  0xFD, 0xBF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F,
  0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0E,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0xFE,
  0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x01,
  0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0x0F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFE, 0x7F, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x78, 0x7C,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x1E, 0x00,
  0x00, 0xF8, 0x78, 0x00, 0x03, 0xE3, 0xE0, 0x20, 0x0F, 0x0F, 0x83, 0xE0,
  0x7C, 0x3E, 0x0F, 0xC1, 0xF0, 0xF8, 0x7F, 0x07, 0xC3, 0xC1, 0xFC, 0x1F,
  0x0F, 0x03, 0xF0, 0x7C, 0x7C, 0x0F, 0x81, 0xE1, 0xF0, 0x00, 0x07, 0x87,
  0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE1, 0xE0,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0xF0, 0xF8, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x7C, 0x07, 0xE0, 0x03, 0xF0,
  0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFE, 0x7C, 0x00, 0x3F, 0x8F, 0x80, 0x1F,
  0xC1, 0xF0, 0x03, 0xF0, 0x3C, 0x00, 0xF8, 0x0F, 0x80, 0x1E, 0x01, 0xF0,
  0x03, 0x00, 0x3E, 0x00, 0x40, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0, 0x3F, 0x80,
  0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0xF0, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x1F, 0x07, 0x80, 0x00, 0x7C, 0x1E, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x14, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x03, 0xF0, 0x03, 0xE0, 0x7E, 0x00,
  0x3E, 0x0F, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x3C, 0x1F, 0x00, 0x07, 0xC3,
  0xF0, 0x00, 0x7C, 0x7E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7C, 0x7C, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0x78, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF8, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x8F, 0xFE, 0x00, 0x3E, 0xFF,
  0xFC, 0x00, 0xF7, 0xFF, 0xF8, 0x03, 0xDF, 0xBF, 0xF0, 0x1F, 0xE0, 0x0F,
  0xC0, 0x7F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x78, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F,
  0x83, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x8F, 0xE0,
  0x00, 0xF9, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x07,
  0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x1F, 0x00,
  0x01, 0xF1, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C, 0x78, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x3E, 0x78, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x0F, 0x1F, 0x00,
  0x00, 0xF8, 0xF8, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7C, 0x3F, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x7E, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xBE, 0x00, 0x00,
  0xF9, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x3E, 0x1E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0xFE,
  0x03, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xE0, 0x3F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xBF,
  0x80, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x00, 0x7C,
  0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83,
  0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x03, 0xE1, 0xF0,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x7F,
  0x01, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x7E, 0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7C,
  0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0xFB, 0xE0,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x1F, 0x3F, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0xFC,
  0x3F, 0x00, 0x1F, 0xC0, 0xFE, 0x03, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFB, 0xF0, 0x00, 0xFF, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x0F, 0xE0, 0x7F, 0xC1, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF,
  0x81, 0xFE, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x1F,
  0xE0, 0x7F, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0x81, 0xFC, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x0F, 0x80,
  0x00, 0x3E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0x7C, 0x0F,
  0x00, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0x3E,
  0x1F, 0x00, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x7F,
  0x1E, 0x0F, 0x00, 0x3F, 0xF3, 0xC1, 0xE0, 0x0F, 0xFF, 0x78, 0x7C, 0x03,
  0xFD, 0xEF, 0x0F, 0x80, 0xFC, 0x07, 0xE1, 0xE0, 0x1F, 0x00, 0xF8, 0x3C,
  0x03, 0xC0, 0x0F, 0x07, 0x80, 0xF8, 0x01, 0xE0, 0xF0, 0x1E, 0x00, 0x3C,
  0x3E, 0x03, 0xC0, 0x0F, 0x87, 0xC0, 0x78, 0x01, 0xF0, 0xF0, 0x0F, 0x00,
  0x3E, 0x1E, 0x03, 0xE0, 0x07, 0x83, 0xC0, 0x7C, 0x00, 0xF0, 0x78, 0x0F,
  0x00, 0x1E, 0x1F, 0x01, 0xE0, 0x03, 0xC3, 0xE0, 0x3C, 0x00, 0xF8, 0x7C,
  0x07, 0x80, 0x1F, 0x0F, 0x00, 0xF0, 0x03, 0xC1, 0xE0, 0x1E, 0x00, 0xF8,
  0x3C, 0x03, 0xE0, 0x1F, 0x07, 0x80, 0x7E, 0x0F, 0xE1, 0xF0, 0x0F, 0xFF,
  0xBC, 0x3E, 0x00, 0xFF, 0xE7, 0x87, 0x80, 0x0F, 0xF8, 0xE0, 0xF0, 0x00,
  0x7C, 0x20, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x0F, 0x8F, 0x80,
  0x00, 0x7C, 0x7C, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x3E, 0x0F, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0xF8, 0x1E, 0x00, 0x0F, 0x80,
  0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xC0, 0x3E, 0x00, 0x3E, 0x01, 0xF0,
  0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x0F,
  0x80, 0x0F, 0x00, 0x7C, 0x00, 0x78, 0x03, 0xC0, 0x03, 0xC0, 0x3F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE,
  0x07, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3C, 0x3E,
  0x00, 0x01, 0xE1, 0xF0, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x78, 0xF8, 0x00,
  0x03, 0xC7, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0x80, 0x7C, 0x00, 0x3F, 0x80, 0xF8, 0x00, 0x3F, 0x01,
  0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0x80, 0x00, 0xF8, 0x0F,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x7C, 0x07, 0x80,
  0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x3F, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xE0, 0x0F, 0x80, 0x1F, 0xE0, 0x1F, 0x00, 0x0F, 0xE0, 0x3E, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x1F,
  0x03, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x81,
  0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF8, 0x1F,
  0x00, 0x0F, 0xE0, 0x3E, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xC0, 0x07, 0xE0, 0x3E, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x1E, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x07, 0xC1, 0xE0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x7C, 0x1F, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x07, 0xE0, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF8, 0x03, 0xE0, 0x3F, 0xF0, 0x0F, 0x80, 0x0F, 0xE0, 0x3E,
  0x00, 0x1F, 0x80, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xFC, 0x0F, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8,
  0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x7C, 0x0F,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xFC, 0x07, 0xC0,
  0x07, 0xF0, 0x1F, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xC0, 0x07,
  0xE0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C,
  0x1E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1E, 0x0F,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x3F, 0xFF, 0x0F, 0x80, 0xFF, 0xFC, 0x3E, 0x07, 0xFF, 0xE0,
  0xF8, 0x1F, 0xFF, 0x83, 0xC0, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0xF8, 0x7C,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3C, 0x1F, 0x00,
  0x00, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x1F, 0x07, 0x80, 0x00,
  0x7C, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C,
  0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x3F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0xF8, 0x0F, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x1E, 0x03, 0xE0,
  0x00, 0x7C, 0x07, 0x80, 0x00, 0xF8, 0x0F, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x01, 0xF0, 0x00,
  0x3E, 0x03, 0xC0, 0x00, 0x7C, 0x07, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8,
  0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x7C, 0x0F,
  0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x03, 0xC0, 0x7C,
  0x00, 0x0F, 0x80, 0xF0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xE0, 0x3E, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF0, 0x1F,
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x7C, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x01, 0xF8, 0x07, 0x80,
  0x00, 0xFC, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x3E,
  0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0xF0, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x0F, 0xC0, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x7C, 0x01, 0xF8,
  0x00, 0x1E, 0x00, 0xFC, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x03, 0xE0, 0x1F,
  0x80, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7C,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x01,
  0xF0, 0x0F, 0xC0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x1F, 0x80, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x1F, 0x00,
  0x03, 0xE0, 0x07, 0xC0, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x1E, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0,
  0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xF0, 0x01, 0xEE, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0xF7, 0x00, 0x3D, 0xE0, 0x3D, 0xE0, 0x0F, 0x78, 0x0F, 0x78, 0x07,
  0x9C, 0x03, 0xDE, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0xF3, 0xC0, 0x79, 0xE0,
  0x3C, 0xF0, 0x1E, 0x38, 0x0F, 0x3C, 0x07, 0x8F, 0x07, 0x9F, 0x01, 0xE3,
  0xC1, 0xE7, 0x80, 0x78, 0xF0, 0xF1, 0xE0, 0x1E, 0x3C, 0x3C, 0x78, 0x07,
  0x8F, 0x1E, 0x3E, 0x03, 0xE1, 0xC7, 0x8F, 0x80, 0xF8, 0x7B, 0xC3, 0xE0,
  0x3E, 0x1E, 0xF0, 0xF0, 0x0F, 0x07, 0xF8, 0x3C, 0x03, 0xC1, 0xFE, 0x1F,
  0x00, 0xF0, 0x3F, 0x07, 0xC0, 0x7C, 0x0F, 0xC1, 0xF0, 0x1F, 0x03, 0xE0,
  0x7C, 0x07, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x01, 0xE0, 0x1E, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0xF0, 0x0F,
  0x80, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1E,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x01, 0xFC, 0x00, 0x1E, 0x01, 0xFC, 0x00, 0x1E, 0x03, 0xFC,
  0x00, 0x3E, 0x03, 0xFC, 0x00, 0x3E, 0x03, 0xFC, 0x00, 0x3E, 0x03, 0xFE,
  0x00, 0x3E, 0x03, 0xDE, 0x00, 0x3C, 0x03, 0xDE, 0x00, 0x3C, 0x03, 0xDE,
  0x00, 0x3C, 0x07, 0xDE, 0x00, 0x7C, 0x07, 0xCF, 0x00, 0x7C, 0x07, 0xCF,
  0x00, 0x7C, 0x07, 0x8F, 0x00, 0x7C, 0x07, 0x8F, 0x00, 0x78, 0x07, 0x8F,
  0x80, 0x78, 0x0F, 0x87, 0x80, 0xF8, 0x0F, 0x87, 0x80, 0xF8, 0x0F, 0x87,
  0x80, 0xF8, 0x0F, 0x87, 0x80, 0xF8, 0x0F, 0x07, 0xC0, 0xF0, 0x0F, 0x03,
  0xC0, 0xF0, 0x1F, 0x03, 0xC1, 0xF0, 0x1F, 0x03, 0xC1, 0xF0, 0x1F, 0x03,
  0xC1, 0xF0, 0x1F, 0x03, 0xE1, 0xF0, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x01,
  0xE1, 0xE0, 0x1E, 0x01, 0xE3, 0xE0, 0x3E, 0x01, 0xF3, 0xE0, 0x3E, 0x01,
  0xF3, 0xE0, 0x3E, 0x00, 0xF3, 0xE0, 0x3E, 0x00, 0xF3, 0xE0, 0x3C, 0x00,
  0xF3, 0xC0, 0x3C, 0x00, 0xFB, 0xC0, 0x7C, 0x00, 0x7B, 0xC0, 0x7C, 0x00,
  0x7B, 0xC0, 0x7C, 0x00, 0x7F, 0xC0, 0x7C, 0x00, 0x7F, 0xC0, 0x78, 0x00,
  0x7F, 0x80, 0x78, 0x00, 0x3F, 0x80, 0xF8, 0x00, 0x3F, 0x80, 0xF8, 0x00,
  0x3F, 0x80, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFC, 0x07,
  0xF0, 0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0xF8, 0x1E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3C, 0x00, 0x03, 0xE0, 0xF0,
  0x00, 0x0F, 0x07, 0xC0, 0x00, 0x3C, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1E, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8,
  0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x3E, 0x0F,
  0x00, 0x00, 0xF0, 0x7C, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xE0, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0xF8, 0x1E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x7C, 0x07, 0xE0, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x80,
  0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x07, 0xF0, 0x0F, 0x80, 0x00, 0xFC,
  0x07, 0xC0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00,
  0x7C, 0x07, 0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3F, 0x03, 0xE0, 0x00,
  0x3F, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC,
  0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x3E, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xE0, 0xF8,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0xF8, 0x7C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C,
  0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x78, 0x3E, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x7C, 0x07, 0xE0, 0x03, 0xF0, 0x1F,
  0xC0, 0x3F, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x00, 0xFC,
  0x03, 0xE0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E,
  0x03, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E,
  0x07, 0x80, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xFC,
  0x0F, 0x80, 0x01, 0xF8, 0x0F, 0x80, 0x03, 0xF0, 0x0F, 0x80, 0x1F, 0xF0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x0F, 0xC0, 0x78, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x0F, 0x83,
  0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x1F,
  0x80, 0x07, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01,
  0xA0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xF0,
  0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x0F,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E,
  0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0,
  0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xF0, 0x0F,
  0x80, 0x03, 0xE0, 0x1F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x7F, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xBE, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x3E, 0x7C, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xF8,
  0xF8, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x7C, 0x1E, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x01, 0xF0, 0x00,
  0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xE0,
  0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x03,
  0xE0, 0x01, 0xF0, 0x1E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x0F, 0x80,
  0x01, 0xE0, 0xF8, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x03,
  0xC3, 0xE0, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x3E, 0x78, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0xBC, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0xF8, 0x03, 0xE7, 0x80, 0x3F, 0x00, 0x78, 0xF0, 0x07, 0xE0, 0x0F,
  0x1E, 0x00, 0xFC, 0x03, 0xE3, 0xC0, 0x1F, 0x80, 0x78, 0x78, 0x07, 0x70,
  0x0F, 0x0F, 0x00, 0xEE, 0x01, 0xE1, 0xE0, 0x1D, 0xC0, 0x7C, 0x3C, 0x07,
  0xB8, 0x0F, 0x07, 0x80, 0xE7, 0x01, 0xE0, 0xF0, 0x1C, 0xE0, 0x7C, 0x1E,
  0x03, 0x9C, 0x0F, 0x03, 0xC0, 0xE7, 0x81, 0xE0, 0xF8, 0x1C, 0xF0, 0x3C,
  0x1F, 0x03, 0x9C, 0x0F, 0x83, 0xE0, 0xF3, 0x81, 0xE0, 0x7C, 0x1C, 0x70,
  0x3C, 0x0F, 0x83, 0x8E, 0x07, 0x81, 0xF0, 0xF1, 0xC1, 0xF0, 0x3C, 0x1C,
  0x38, 0x3C, 0x07, 0x83, 0x87, 0x07, 0x80, 0xF0, 0x70, 0xE1, 0xF0, 0x1E,
  0x1E, 0x1C, 0x3C, 0x03, 0xC3, 0x83, 0x87, 0x80, 0x78, 0x70, 0x70, 0xF0,
  0x0F, 0x1E, 0x0E, 0x3E, 0x01, 0xE3, 0x81, 0xC7, 0x80, 0x3C, 0x70, 0x38,
  0xF0, 0x07, 0x8E, 0x07, 0x1E, 0x00, 0xF3, 0xC0, 0xE7, 0x80, 0x1E, 0x70,
  0x1C, 0xF0, 0x03, 0xCE, 0x03, 0x9E, 0x00, 0x7B, 0xC0, 0x73, 0xC0, 0x0F,
  0x70, 0x0E, 0xF0, 0x01, 0xEE, 0x01, 0xDE, 0x00, 0x3D, 0xC0, 0x3B, 0xC0,
  0x07, 0xF0, 0x07, 0xF8, 0x00, 0xEE, 0x00, 0xFE, 0x00, 0x3D, 0xC0, 0x3F,
  0xC0, 0x07, 0xB8, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x1F, 0xC0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x1F, 0x00,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0xF8, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x03, 0xF3,
  0xE0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x3C,
  0x00, 0x1F, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0,
  0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0x00, 0x03, 0xC0,
  0x7C, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x0F, 0x0F,
  0x80, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3D, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF,
  0xFC, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xE7,
  0x80, 0x00, 0xF1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x3E, 0x1E, 0x00, 0x0F,
  0x03, 0xC0, 0x07, 0xC0, 0xF0, 0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x0F, 0x80,
  0x7C, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x0F, 0x80, 0x1E, 0x07, 0xC0, 0x03,
  0xC1, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x9F, 0x00,
  0x01, 0xEF, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x1F, 0x7F, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFC, 0x1F, 0x03, 0xE0, 0x78, 0x1F, 0x03, 0xE0, 0x78,
  0x1F, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFF, 0x87, 0xC0, 0x3F, 0xFE, 0x3E,
  0x03, 0xFF, 0xF9, 0xE0, 0x3F, 0xFF, 0xEF, 0x03, 0xF8, 0x07, 0xF8, 0x3F,
  0x00, 0x1F, 0xC1, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0, 0xF8, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E,
  0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x3C,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1E,
  0x0F, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1F,
  0x00, 0x07, 0xE0, 0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xF0, 0x3F, 0x80,
  0x77, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFB, 0xE0, 0x1F, 0xFF, 0x9F,
  0x00, 0x3F, 0xF0, 0xF8, 0x00, 0x18, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x0C, 0x00,
  0x0F, 0x87, 0xFE, 0x00, 0x7C, 0x7F, 0xFC, 0x03, 0xEF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x80, 0xF7, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF0, 0x7F, 0x00,
  0x0F, 0x83, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x0F,
  0x07, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1E, 0x0F,
  0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x00,
  0x07, 0xC1, 0xFC, 0x00, 0x7E, 0x0F, 0xF0, 0x0F, 0xE0, 0x7F, 0xFF, 0xFE,
  0x03, 0xCF, 0xFF, 0xE0, 0x3E, 0x3F, 0xFE, 0x01, 0xF0, 0xFF, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0x00,
  0xFE, 0x07, 0xC0, 0x07, 0xE0, 0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xF1,
  0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x78, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0x7C,
  0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x0F,
  0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x5C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x0C,
  0x03, 0xE0, 0x01, 0xFF, 0x87, 0xC0, 0x0F, 0xFF, 0x8F, 0x80, 0x3F, 0xFF,
  0x9E, 0x00, 0xFF, 0xFF, 0xBC, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xC0, 0x07,
  0xF0, 0x1F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x1F,
  0x81, 0xF0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8,
  0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0,
  0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x0F,
  0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x7C, 0x07, 0xC0, 0x01, 0xF8, 0x0F, 0x80, 0x07, 0xF0, 0x1F, 0x80,
  0x1F, 0xC0, 0x3F, 0x80, 0x77, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xBE, 0x00, 0x7F, 0xFE, 0x7C, 0x00, 0x3F, 0xF0, 0xF8, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFE, 0x7F, 0xC0, 0x7E, 0x00, 0xFC, 0x07,
  0xC0, 0x07, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x1E, 0x1E, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x1E, 0x3E, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xE3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC7, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x0F,
  0x87, 0xC0, 0x01, 0xF0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x3F,
  0xE7, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xFF, 0x87, 0xC0,
  0x3F, 0xFE, 0x3E, 0x03, 0xFF, 0xF9, 0xE0, 0x3F, 0xFF, 0xEF, 0x03, 0xF8,
  0x07, 0xF8, 0x3F, 0x00, 0x1F, 0xC1, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x03,
  0xF0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x7C, 0x3E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x83, 0xF0,
  0x01, 0xFC, 0x0F, 0xC0, 0x1F, 0xE0, 0x7F, 0x87, 0xDF, 0x01, 0xFF, 0xFC,
  0xF0, 0x07, 0xFF, 0xC7, 0x80, 0x1F, 0xFC, 0x7C, 0x00, 0x3F, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xF0, 0x0C, 0x00, 0x0F, 0x87, 0xFE, 0x00, 0x7C, 0xFF, 0xFC, 0x03,
  0xEF, 0xFF, 0xF0, 0x1F, 0xFC, 0xFF, 0x80, 0xF7, 0x00, 0xFE, 0x07, 0xF0,
  0x03, 0xF0, 0x7E, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x78, 0x3E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00,
  0xF0, 0x78, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x10, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x1F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x7E,
  0x07, 0xC0, 0x00, 0xFC, 0x07, 0xC0, 0x01, 0xF8, 0x07, 0xC0, 0x03, 0xF0,
  0x07, 0x80, 0x03, 0xE0, 0x07, 0x80, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0xC0,
  0x0F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x3F, 0x00, 0x0F, 0x80, 0x7E, 0x00,
  0x0F, 0x80, 0xFC, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x1E, 0x03, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x3E, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x7C, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x0F, 0xC0, 0x78, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x07, 0xE0, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF,
  0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x01,
  0x00, 0x10, 0x01, 0xE7, 0xF0, 0xFE, 0x01, 0xF7, 0xFC, 0xFF, 0x80, 0xFF,
  0xFE, 0x7F, 0xE0, 0x7B, 0x1F, 0x63, 0xF0, 0x3E, 0x07, 0xE0, 0xF8, 0x1F,
  0x03, 0xE0, 0x3C, 0x0F, 0x01, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x0F, 0x07,
  0xC0, 0x78, 0x07, 0x83, 0xE0, 0x3C, 0x07, 0xC1, 0xF0, 0x1E, 0x03, 0xE0,
  0xF0, 0x0F, 0x01, 0xF0, 0x78, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0x78,
  0x3E, 0x03, 0xC0, 0x3C, 0x1F, 0x01, 0xE0, 0x1E, 0x0F, 0x80, 0xF0, 0x1F,
  0x07, 0x80, 0x78, 0x0F, 0x83, 0xC0, 0x3C, 0x07, 0xC1, 0xE0, 0x3E, 0x03,
  0xC1, 0xF0, 0x1E, 0x01, 0xE0, 0xF8, 0x0F, 0x00, 0xF0, 0x7C, 0x07, 0x80,
  0xF8, 0x3C, 0x03, 0xC0, 0x7C, 0x1E, 0x01, 0xE0, 0x3E, 0x0F, 0x00, 0xF0,
  0x1E, 0x07, 0x80, 0xF0, 0x0F, 0x07, 0xC0, 0x78, 0x07, 0x83, 0xE0, 0x3C,
  0x07, 0xC1, 0xF0, 0x1E, 0x03, 0xE0, 0xF0, 0x0F, 0x01, 0xF0, 0x78, 0x07,
  0x80, 0xF0, 0x7C, 0x07, 0x80, 0x78, 0x00, 0x00, 0x00, 0x30, 0x00, 0x3E,
  0x1F, 0xF8, 0x01, 0xF3, 0xFF, 0xF0, 0x0F, 0xBF, 0xFF, 0xC0, 0x7F, 0xF3,
  0xFE, 0x03, 0xDC, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xC1, 0xF8, 0x00, 0x3E,
  0x0F, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1F,
  0x00, 0x03, 0xE0, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x78, 0x3C, 0x00,
  0x07, 0xC1, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3E, 0x0F,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0x00, 0xFC, 0x07, 0xC0, 0x07, 0xE0,
  0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x1F, 0x00,
  0x01, 0xE3, 0xE0, 0x00, 0x1E, 0x3E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3E,
  0x3E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3E, 0x3C, 0x00, 0x03, 0xE3, 0xC0,
  0x00, 0x3C, 0x7C, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x78, 0x78,
  0x00, 0x0F, 0x87, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01,
  0xF0, 0x7E, 0x00, 0x3E, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x03, 0xE1, 0xFF, 0x80, 0x07, 0xCF,
  0xFF, 0xC0, 0x0F, 0xBF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3D, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x3E, 0x03, 0xF0, 0x00,
  0x7C, 0x07, 0xC0, 0x00, 0x78, 0x0F, 0x80, 0x00, 0xF0, 0x1F, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF0,
  0x1E, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x78, 0x0F,
  0x80, 0x01, 0xF0, 0x3F, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x1F, 0x01, 0xFC, 0x00, 0x7E, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xBF,
  0xFF, 0xE0, 0x0F, 0x3F, 0xFF, 0x80, 0x3E, 0x3F, 0xFE, 0x00, 0x7C, 0x3F,
  0xF0, 0x00, 0xF8, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xFF, 0x87, 0xC0, 0x3F, 0xFE, 0x3E, 0x03, 0xFF, 0xF9, 0xE0,
  0x3F, 0xFF, 0xFF, 0x03, 0xF8, 0x07, 0xF8, 0x3F, 0x00, 0x1F, 0xC1, 0xF0,
  0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC3, 0xE0,
  0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x7C, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xF0,
  0x78, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xE0, 0xF8,
  0x00, 0x7F, 0x07, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x77, 0x80, 0xFF, 0xFF,
  0x7C, 0x07, 0xFF, 0xFB, 0xE0, 0x1F, 0xFF, 0x1F, 0x00, 0x3F, 0xF0, 0xF8,
  0x00, 0x18, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x3E, 0x1F, 0xF8,
  0x01, 0xF3, 0xFF, 0xF0, 0x0F, 0xBF, 0xFF, 0xC0, 0x7F, 0xF3, 0xFE, 0x03,
  0xDC, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xC1, 0xFC, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01,
  0xF0, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x78, 0x7C, 0x00, 0x04, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xE0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0xF8, 0x00,
  0x1F, 0x1F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8, 0xFC,
  0x00, 0x1F, 0x0F, 0xE0, 0x03, 0xF0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x40,
  0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1E, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x7C, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1E, 0x0F, 0x80, 0x01, 0xF0,
  0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xFB, 0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7C,
  0xF8, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xE0, 0xF0,
  0x00, 0x1F, 0x07, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x01, 0xE0, 0x03, 0xE0,
  0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x03, 0xC0, 0x7C, 0x00, 0x1E, 0x07,
  0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x3E, 0x1F, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x01,
  0xE7, 0xC0, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xF0, 0x07, 0xC0, 0x1F, 0xE0, 0x0F, 0x80, 0x3F, 0xC0, 0x3F, 0x00,
  0xF7, 0x80, 0x7E, 0x01, 0xEF, 0x00, 0xFC, 0x03, 0xDE, 0x03, 0xB8, 0x0F,
  0x3C, 0x07, 0x70, 0x1E, 0x78, 0x0E, 0xE0, 0x3C, 0xF0, 0x39, 0xC0, 0xF1,
  0xE0, 0x73, 0x81, 0xE3, 0xC0, 0xE7, 0x03, 0xC7, 0x83, 0xCE, 0x07, 0x0F,
  0x07, 0x1C, 0x1E, 0x1E, 0x0E, 0x38, 0x3C, 0x3C, 0x3C, 0x70, 0x78, 0x78,
  0x70, 0xE1, 0xE0, 0xF0, 0xE1, 0xC3, 0xC1, 0xE3, 0xC3, 0x87, 0x83, 0xC7,
  0x07, 0x1E, 0x07, 0x8E, 0x0E, 0x3C, 0x0F, 0x3C, 0x1C, 0x78, 0x1E, 0x70,
  0x39, 0xE0, 0x3C, 0xE0, 0x73, 0xC0, 0x7B, 0xC0, 0xE7, 0x80, 0xF7, 0x01,
  0xDE, 0x01, 0xEE, 0x03, 0xBC, 0x03, 0xFC, 0x07, 0x78, 0x07, 0xF0, 0x0E,
  0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0xF8, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F, 0x80, 0x1F, 0x00,
  0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x03, 0xE0, 0x0F, 0xC0, 0x01, 0xF0,
  0x0F, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F,
  0x87, 0xE0, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x03, 0xF7, 0xC0, 0x00,
  0x01, 0xF1, 0xF0, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x01, 0xF8, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x3C, 0x1E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8,
  0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xE0, 0xF8,
  0x00, 0x1F, 0x07, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x78,
  0x3C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x78, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x3E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x81, 0xF8, 0x03, 0xFC,
  0x0F, 0xF9, 0xFB, 0xE0, 0x3F, 0xFF, 0x9E, 0x00, 0xFF, 0xF9, 0xF0, 0x03,
  0xFF, 0x0F, 0x80, 0x01, 0xC0, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x07,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0,
  0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x78, 0x7F, 0xE0,
  0x03, 0xC7, 0xFF, 0x80, 0x1E, 0x7F, 0xFE, 0x01, 0xF3, 0xE1, 0xF8, 0x0F,
  0xBE, 0x07, 0xC0, 0x79, 0xE0, 0x3F, 0x07, 0xCF, 0x00, 0xFC, 0x7E, 0xF8,
  0x03, 0xFF, 0xE7, 0xC0, 0x0F, 0xFE, 0x3E, 0x00, 0x3F, 0xE1, 0xE0, 0x00,
  0x7C, 0x00,
};

const GFXglyph JetBrainsMono_LightItalic60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 36, 0, -1 },
  { 1, 14, 44, 36, 11, -44 },
  { 78, 20, 18, 36, 11, -44 },
  { 123, 35, 44, 36, 1, -44 },
  { 316, 31, 60, 36, 3, -52 },
  { 549, 41, 44, 36, -2, -44 },
  { 775, 32, 45, 36, 2, -44 },
  { 955, 8, 18, 36, 17, -44 },
  { 973, 25, 59, 36, 10, -51 },
  { 1158, 24, 59, 36, 3, -51 },
  { 1335, 32, 31, 36, 3, -37 },
  { 1459, 29, 28, 36, 4, -34 },
  { 1561, 15, 19, 36, 6, -9 },
  { 1597, 19, 4, 36, 9, -22 },
  { 1607, 10, 10, 36, 11, -9 },
  { 1620, 35, 57, 36, 1, -50 },
  { 1870, 30, 45, 36, 4, -44 },
  { 2039, 27, 44, 36, 3, -44 },
  { 2188, 31, 44, 36, 3, -44 },
  { 2359, 30, 45, 36, 3, -44 },
  { 2528, 28, 44, 36, 4, -44 },
  { 2682, 30, 45, 36, 4, -44 },
  { 2851, 29, 45, 36, 3, -44 },
  { 3015, 29, 44, 36, 7, -44 },
  { 3175, 30, 45, 36, 3, -44 },
  { 3344, 29, 44, 36, 6, -44 },
  { 3504, 14, 35, 36, 11, -34 },
  { 3566, 19, 44, 36, 6, -34 },
  { 3671, 29, 31, 36, 5, -35 },
  { 3784, 29, 18, 36, 4, -29 },
  { 3850, 29, 31, 36, 3, -35 },
  { 3963, 24, 44, 36, 9, -44 },
  { 4095, 35, 55, 36, 1, -44 },
  { 4336, 29, 44, 36, 1, -44 },
  { 4496, 31, 44, 36, 3, -44 },
  { 4667, 30, 45, 36, 4, -44 },
  { 4836, 30, 44, 36, 3, -44 },
  { 5001, 31, 44, 36, 4, -44 },
  { 5172, 33, 44, 36, 3, -44 },
  { 5354, 30, 45, 36, 4, -44 },
  { 5523, 31, 44, 36, 3, -44 },
  { 5694, 30, 44, 36, 4, -44 },
  { 5859, 33, 45, 36, 1, -44 },
  { 6045, 34, 44, 36, 3, -44 },
  { 6232, 26, 44, 36, 4, -44 },
  { 6375, 34, 44, 36, 2, -44 },
  { 6562, 32, 44, 36, 3, -44 },
  { 6738, 30, 45, 36, 4, -44 },
  { 6907, 33, 44, 36, 3, -44 },
  { 7089, 30, 55, 36, 4, -44 },
  { 7296, 32, 44, 36, 3, -44 },
  { 7472, 31, 45, 36, 3, -44 },
  { 7647, 30, 44, 36, 7, -44 },
  { 7812, 31, 45, 36, 4, -44 },
  { 7987, 29, 44, 36, 8, -44 },
  { 8147, 35, 44, 36, 4, -44 },
  { 8340, 37, 44, 36, 0, -44 },
  { 8544, 31, 44, 36, 7, -44 },
  { 8715, 31, 44, 36, 3, -44 },
  { 8886, 23, 57, 36, 9, -50 },
  { 9050, 18, 57, 36, 10, -50 },
  { 9179, 24, 57, 36, 5, -50 },
  { 9350, 26, 24, 36, 6, -44 },
  { 9428, 30, 5, 36, 0, 1 },
  { 9447, 10, 8, 36, 16, -47 },
  { 9457, 29, 35, 36, 4, -34 },
  { 9584, 29, 45, 36, 3, -44 },
  { 9748, 28, 35, 36, 4, -34 },
  { 9871, 31, 45, 36, 4, -44 },
  { 10046, 28, 35, 36, 4, -34 },
  { 10169, 40, 55, 36, -2, -44 },
  { 10444, 29, 45, 36, 4, -34 },
  { 10608, 29, 44, 36, 3, -44 },
  { 10768, 29, 46, 36, 2, -46 },
  { 10935, 31, 57, 36, 1, -46 },
  { 11156, 32, 44, 36, 3, -44 },
  { 11332, 25, 44, 36, 6, -44 },
  { 11470, 33, 34, 36, 1, -34 },
  { 11611, 29, 34, 36, 3, -34 },
  { 11735, 28, 35, 36, 4, -34 },
  { 11858, 31, 45, 36, 1, -34 },
  { 12033, 29, 45, 36, 4, -34 },
  { 12197, 29, 34, 36, 4, -34 },
  { 12321, 28, 35, 36, 4, -34 },
  { 12444, 29, 42, 36, 5, -42 },
  { 12597, 29, 34, 36, 4, -33 },
  { 12721, 29, 33, 36, 6, -33 },
  { 12841, 31, 33, 36, 5, -33 },
  { 12969, 33, 33, 36, 1, -33 },
  { 13106, 29, 44, 36, 4, -33 },
  { 13266, 29, 33, 36, 3, -33 },
  { 13386, 30, 57, 36, 6, -50 },
  { 13600, 14, 57, 36, 12, -50 },
  { 13700, 30, 57, 36, 2, -50 },
  { 13914, 29, 12, 36, 4, -27 },
};

const GFXfont JetBrainsMono_LightItalic60pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_LightItalic60pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_LightItalic60pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _JETBRAINSMONO_LIGHTITALIC60PT7B_H_
