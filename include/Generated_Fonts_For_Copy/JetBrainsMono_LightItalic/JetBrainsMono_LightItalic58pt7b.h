#ifndef _JETBRAINSMONO_LIGHTITALIC58PT7B_H_
#define _JETBRAINSMONO_LIGHTITALIC58PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-LightItalic.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_LightItalic58pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07,
  0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x03,
  0xF0, 0x3F, 0x83, 0xFE, 0x1F, 0xE0, 0xFF, 0x03, 0xF0, 0x00, 0x3E, 0x03,
  0xE7, 0xC0, 0x7C, 0xF8, 0x1F, 0x9F, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F,
  0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x3E,
  0x3C, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x78,
  0xF0, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x78, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x0E,
  0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0xF0,
  0x07, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x07, 0x80, 0x1E, 0x00,
  0x01, 0xE0, 0x0F, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x01, 0xE0, 0x07,
  0x80, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x78,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x0E, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x38, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x01, 0xC0, 0x0F, 0x00,
  0x00, 0xF0, 0x07, 0x80, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xDD, 0xFC, 0x01,
  0xF8, 0xF1, 0xF8, 0x07, 0xC3, 0xC3, 0xE0, 0x3E, 0x0E, 0x0F, 0x80, 0xF0,
  0x38, 0x1E, 0x07, 0xC0, 0xE0, 0x7C, 0x1F, 0x03, 0x81, 0xE0, 0x7C, 0x0E,
  0x00, 0x01, 0xF0, 0x78, 0x00, 0x07, 0xC1, 0xC0, 0x00, 0x1F, 0x07, 0x00,
  0x00, 0x7C, 0x1C, 0x00, 0x01, 0xF8, 0x70, 0x00, 0x03, 0xF1, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x07, 0x1F, 0xC0, 0x00, 0x1C, 0x3F, 0x00, 0x00, 0x70,
  0x7C, 0x00, 0x01, 0xC0, 0xF8, 0x00, 0x07, 0x03, 0xE0, 0x00, 0x3C, 0x0F,
  0x80, 0x00, 0xF0, 0x3E, 0x3E, 0x03, 0x80, 0xF8, 0xF8, 0x0E, 0x03, 0xC3,
  0xE0, 0x38, 0x1F, 0x0F, 0x80, 0xE0, 0x7C, 0x1F, 0x03, 0x83, 0xE0, 0x7E,
  0x1E, 0x1F, 0x81, 0xFC, 0x71, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x00, 0x1F, 0xF0,
  0x00, 0x1E, 0x00, 0x7F, 0xF8, 0x00, 0x1C, 0x00, 0xFF, 0xF8, 0x00, 0x3C,
  0x01, 0xF0, 0x7C, 0x00, 0x78, 0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x01, 0xC0,
  0x3C, 0x01, 0xE0, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x3C, 0x07,
  0x80, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0x03,
  0xC0, 0x38, 0x1E, 0x00, 0x03, 0x80, 0x78, 0x3C, 0x00, 0x07, 0x80, 0x78,
  0x78, 0x00, 0x07, 0xC0, 0x78, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0xF0, 0x00,
  0x03, 0xFF, 0xE1, 0xE0, 0x00, 0x01, 0xFF, 0xE3, 0xC0, 0x00, 0x00, 0xFF,
  0x87, 0x80, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x7F, 0x00, 0x00, 0x01, 0xE1,
  0xFF, 0x80, 0x00, 0x03, 0xC3, 0xFF, 0xC0, 0x00, 0x07, 0x87, 0xEF, 0xE0,
  0x00, 0x07, 0x8F, 0x01, 0xE0, 0x00, 0x0F, 0x0F, 0x01, 0xE0, 0x00, 0x1E,
  0x1E, 0x01, 0xE0, 0x00, 0x3C, 0x1E, 0x01, 0xE0, 0x00, 0x78, 0x1E, 0x01,
  0xE0, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x01,
  0xE0, 0x1C, 0x03, 0xC0, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x07, 0x80, 0x3C,
  0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x07, 0x80, 0x1E, 0x00, 0x1F, 0x9F, 0x80,
  0x3C, 0x00, 0x1F, 0xFF, 0x00, 0x3C, 0x00, 0x0F, 0xFE, 0x00, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x1F,
  0x80, 0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xE0,
  0x01, 0xF0, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x07, 0xE7, 0xC0, 0x0F, 0x9F, 0x07, 0xC0, 0x3E,
  0x3E, 0x0F, 0xC0, 0x78, 0x78, 0x0F, 0x81, 0xF1, 0xF0, 0x0F, 0x87, 0xC3,
  0xE0, 0x1F, 0x0F, 0x07, 0xC0, 0x1F, 0x3E, 0x0F, 0x80, 0x3E, 0xF8, 0x1E,
  0x00, 0x3F, 0xE0, 0x3C, 0x00, 0x3F, 0x80, 0xF8, 0x00, 0x7F, 0x01, 0xF0,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xF8, 0x0F, 0x80,
  0x0F, 0xF0, 0x1F, 0x00, 0x3F, 0xF0, 0x3F, 0x01, 0xF9, 0xF0, 0x3F, 0xFF,
  0xE3, 0xE0, 0x7F, 0xFF, 0x83, 0xE0, 0x7F, 0xFC, 0x07, 0xC0, 0x7F, 0xE0,
  0x07, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x3E, 0xFD, 0xF3, 0xE7, 0xCF, 0x9F,
  0x3E, 0xFD, 0xF3, 0xE7, 0xCF, 0x9E, 0x3C, 0x78, 0xF0, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x30, 0x03, 0xC0, 0x0C, 0x7C, 0x07, 0x80, 0xF9, 0xFE, 0x0E,
  0x0F, 0xF3, 0xFF, 0x1C, 0x7F, 0xFF, 0xFF, 0x39, 0xFF, 0xC3, 0xFF, 0xEF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x03, 0xCF, 0x80,
  0x00, 0x0F, 0x8F, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x3F, 0x00,
  0x03, 0xF0, 0x3E, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xC0, 0x01, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03,
  0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07,
  0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x07, 0xE3, 0xFD, 0xFF, 0x7F, 0xDF,
  0xF7, 0xFD, 0xFE, 0x3F, 0x02, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xC1, 0xFE, 0x01, 0xF8, 0x03, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xF8, 0x00,
  0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C,
  0x3E, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x78, 0x78,
  0x00, 0x07, 0xC3, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00,
  0x0F, 0x0F, 0x81, 0x80, 0x78, 0x7C, 0x1F, 0x03, 0xC3, 0xC1, 0xF8, 0x3E,
  0x1E, 0x0F, 0xE1, 0xF1, 0xF0, 0x7E, 0x0F, 0x8F, 0x83, 0xF0, 0x7C, 0x7C,
  0x0F, 0x03, 0xC3, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xF0, 0xF0, 0x00,
  0x0F, 0x87, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1E,
  0x1F, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x3E,
  0x00, 0x03, 0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0x3E, 0x00,
  0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xFD, 0xFF, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0x7C, 0x00, 0x3F, 0x9F, 0x00, 0x3F, 0x87, 0xC0, 0x1F,
  0xC1, 0xF0, 0x07, 0xC0, 0x78, 0x01, 0xE0, 0x1E, 0x00, 0x60, 0x0F, 0x80,
  0x10, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFE, 0x0F, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x3E, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x7C, 0x1E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x07, 0xE0, 0x03,
  0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x1F, 0x00,
  0x0F, 0x87, 0xC0, 0x01, 0xE1, 0xF8, 0x00, 0x3C, 0x3E, 0x00, 0x0F, 0x8F,
  0x80, 0x01, 0xF1, 0xE0, 0x00, 0x3E, 0x3C, 0x00, 0x07, 0xC7, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x03,
  0xF0, 0x00, 0xF1, 0xFF, 0xC0, 0x0F, 0x3F, 0xFE, 0x01, 0xF7, 0xFF, 0xF0,
  0x1F, 0xF8, 0x7F, 0x81, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC1, 0xF0,
  0x00, 0x7C, 0x1E, 0x00, 0x07, 0xC2, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F,
  0x80, 0x03, 0xE0, 0x7C, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF3, 0xFC, 0x00, 0x3E, 0xFF, 0xF0, 0x07, 0xDF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFC, 0x0F, 0xF0, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x1F, 0x80, 0x07,
  0xE3, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x1E, 0x7C,
  0x00, 0x01, 0xE7, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x3E, 0x78, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xC7,
  0x80, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF8, 0x7E, 0x00,
  0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x14, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFE, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x78, 0x00, 0x07, 0xC7,
  0x80, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF0, 0xF8, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0xFC, 0x00, 0xF8,
  0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0xF8, 0x1E,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00,
  0x0F, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x7C,
  0x03, 0xF0, 0x07, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x1F, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1E,
  0x00, 0x01, 0xE1, 0xF0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x78, 0x78, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x3E, 0x1E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0xF8, 0x3F, 0x00, 0x0F, 0x80, 0xFC, 0x01, 0xFC, 0x07,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0x87, 0xF8, 0x1F,
  0x80, 0x1F, 0x87, 0xE0, 0x01, 0xF1, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xBC, 0x00, 0x01, 0xF7, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1E,
  0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0x7E, 0x00,
  0x0F, 0xC7, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0xFE, 0x1F, 0xE0, 0x7F, 0x81,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0x7C, 0x01, 0xFF, 0xDF, 0x00, 0x03, 0xC3,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xF0,
  0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x80, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF,
  0x07, 0xF8, 0x0F, 0xC0, 0x08, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x20,
  0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF8, 0x04, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x7F, 0x1E, 0x0F, 0x00, 0x7F,
  0xE7, 0x87, 0xC0, 0x3F, 0xFD, 0xE1, 0xE0, 0x1F, 0xC7, 0x78, 0x78, 0x07,
  0xC0, 0x7C, 0x1E, 0x03, 0xE0, 0x1F, 0x07, 0x80, 0xF0, 0x03, 0xC1, 0xE0,
  0x3C, 0x00, 0xF0, 0xF8, 0x0F, 0x00, 0x3C, 0x3C, 0x07, 0xC0, 0x1F, 0x0F,
  0x01, 0xE0, 0x07, 0x83, 0xC0, 0x78, 0x01, 0xE0, 0xF0, 0x1E, 0x00, 0x78,
  0x3C, 0x07, 0x80, 0x1E, 0x1F, 0x01, 0xE0, 0x07, 0x87, 0xC0, 0xF8, 0x03,
  0xE1, 0xE0, 0x3C, 0x00, 0xF8, 0x78, 0x0F, 0x00, 0x3C, 0x1E, 0x03, 0xC0,
  0x0F, 0x07, 0x80, 0xF8, 0x07, 0xC1, 0xE0, 0x3F, 0x03, 0xF0, 0xF8, 0x07,
  0xFF, 0xBC, 0x3C, 0x01, 0xFF, 0xEF, 0x0F, 0x00, 0x3F, 0xE3, 0x83, 0xC0,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x3E, 0xF0, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x87, 0x80, 0x00, 0xF0, 0x78,
  0x00, 0x1F, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x3E, 0x07, 0x80, 0x03,
  0xE0, 0x7C, 0x00, 0x3C, 0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x78, 0x07,
  0xC0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x3C, 0x01,
  0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x3C, 0x03, 0xE0, 0x03, 0xC0, 0x3F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0,
  0xF8, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x1E, 0x1F, 0x00,
  0x01, 0xE3, 0xE0, 0x00, 0x1E, 0x3E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1F,
  0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x07, 0xF0, 0x0F, 0x00, 0x07,
  0xE0, 0x3C, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8,
  0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x3E, 0x07,
  0x80, 0x00, 0xF8, 0x1E, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x3E, 0x00, 0x7E, 0x00, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC,
  0x01, 0xF0, 0x03, 0xF8, 0x07, 0xC0, 0x03, 0xF0, 0x1E, 0x00, 0x07, 0xC0,
  0x78, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3E,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x3E, 0x0F, 0x00,
  0x00, 0xF8, 0x3C, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0xFC, 0x1F, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x3F, 0x01, 0xE0, 0x07, 0xFC,
  0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xE1, 0xFE, 0x01, 0xF8,
  0x01, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x07, 0x80, 0x00,
  0xF0, 0x7C, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x3E, 0x07, 0xC0, 0x03, 0xF0, 0x3E, 0x00, 0x3F, 0x01, 0xFC, 0x03,
  0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3E,
  0x00, 0xFE, 0x01, 0xE0, 0x01, 0xF8, 0x0F, 0x00, 0x07, 0xC0, 0x78, 0x00,
  0x3F, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E,
  0x0F, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x78, 0x3E,
  0x00, 0x03, 0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00,
  0x0F, 0x83, 0xC0, 0x00, 0x7C, 0x1E, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x1E,
  0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1E,
  0x00, 0x03, 0xE0, 0xF0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0xF0, 0x7C, 0x00,
  0x07, 0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F,
  0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1F,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xE0, 0x3C, 0x01,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFE, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xE1,
  0xFE, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x3E,
  0x07, 0x80, 0x00, 0xF0, 0x7C, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x3C, 0x1E,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x1F, 0xFF, 0x87, 0xC0, 0xFF, 0xF8, 0x3C, 0x07,
  0xFF, 0xC1, 0xE0, 0x3F, 0xFE, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xF0, 0x3E, 0x00, 0x3F,
  0x01, 0xFC, 0x03, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xE0, 0x3C, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0,
  0x1E, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F,
  0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xF0, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x1E, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0xF0, 0x1E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xC0, 0x7C, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x0F, 0x80, 0x3E, 0x00,
  0x1F, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x1F, 0x80, 0xF8,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x0F, 0xC0, 0x1E,
  0x00, 0x07, 0xC0, 0x0F, 0x00, 0x07, 0xC0, 0x07, 0x80, 0x07, 0xE0, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x03, 0xF0, 0x00,
  0xF8, 0x01, 0xF0, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x3C, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0xFC, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x3E, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x03, 0xE0, 0x07,
  0xC0, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x1F, 0x00,
  0x07, 0xC0, 0x0F, 0x80, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0xF8, 0x03, 0xC0,
  0x00, 0x7C, 0x01, 0xE0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0xFF,
  0x03, 0xBC, 0x00, 0xFF, 0x03, 0xBC, 0x01, 0xEE, 0x03, 0xBC, 0x01, 0xEE,
  0x03, 0x9C, 0x03, 0xDE, 0x07, 0x9C, 0x03, 0xDE, 0x07, 0x9E, 0x07, 0x9E,
  0x07, 0x9E, 0x07, 0x9E, 0x07, 0x9E, 0x0F, 0x3C, 0x07, 0x9E, 0x0F, 0x3C,
  0x07, 0x8E, 0x1E, 0x3C, 0x0F, 0x8E, 0x1E, 0x3C, 0x0F, 0x8F, 0x3C, 0x3C,
  0x0F, 0x0F, 0x3C, 0x7C, 0x0F, 0x0F, 0x38, 0x7C, 0x0F, 0x07, 0x78, 0x78,
  0x0F, 0x07, 0x70, 0x78, 0x1F, 0x07, 0xF0, 0x78, 0x1F, 0x07, 0xE0, 0xF8,
  0x1F, 0x07, 0xE0, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x01, 0xF0,
  0x3E, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3C,
  0x0F, 0xE0, 0x00, 0xF0, 0x3F, 0x80, 0x03, 0xC0, 0xFF, 0x00, 0x1F, 0x03,
  0xFC, 0x00, 0x7C, 0x0F, 0xF0, 0x01, 0xF0, 0x3F, 0xC0, 0x07, 0x81, 0xFF,
  0x00, 0x1E, 0x07, 0xDE, 0x00, 0x78, 0x1E, 0x78, 0x03, 0xE0, 0x79, 0xE0,
  0x0F, 0x81, 0xE7, 0x80, 0x3E, 0x07, 0x9E, 0x00, 0xF0, 0x3E, 0x3C, 0x03,
  0xC0, 0xF8, 0xF0, 0x0F, 0x03, 0xE3, 0xC0, 0x7C, 0x0F, 0x0F, 0x01, 0xF0,
  0x3C, 0x3E, 0x07, 0xC0, 0xF0, 0x78, 0x1E, 0x03, 0xC1, 0xE0, 0x78, 0x1F,
  0x07, 0x81, 0xE0, 0x7C, 0x1E, 0x07, 0x81, 0xF0, 0x3C, 0x3E, 0x07, 0x80,
  0xF0, 0xF8, 0x1E, 0x03, 0xC3, 0xE0, 0x78, 0x0F, 0x0F, 0x03, 0xE0, 0x3C,
  0x3C, 0x0F, 0x80, 0x78, 0xF0, 0x3E, 0x01, 0xE7, 0xC0, 0xF0, 0x07, 0x9F,
  0x03, 0xC0, 0x1E, 0x7C, 0x0F, 0x00, 0x7D, 0xE0, 0x7C, 0x00, 0xF7, 0x81,
  0xF0, 0x03, 0xDE, 0x07, 0xC0, 0x0F, 0x78, 0x1E, 0x00, 0x3D, 0xE0, 0x78,
  0x00, 0xFF, 0x81, 0xE0, 0x01, 0xFC, 0x0F, 0x80, 0x07, 0xF0, 0x3E, 0x00,
  0x1F, 0xC0, 0xF8, 0x00, 0x7F, 0x03, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xE0, 0x03, 0xF0, 0x7C,
  0x00, 0x1F, 0x07, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01,
  0xF0, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x1F,
  0x00, 0x01, 0xE1, 0xF0, 0x00, 0x1E, 0x1F, 0x00, 0x03, 0xE1, 0xE0, 0x00,
  0x3E, 0x1E, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xC3,
  0xE0, 0x00, 0x3C, 0x3E, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x7C, 0x3C, 0x00,
  0x07, 0xC3, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x78,
  0x7C, 0x00, 0x07, 0x87, 0xC0, 0x00, 0xF8, 0x78, 0x00, 0x0F, 0x87, 0x80,
  0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x1F,
  0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xE0, 0x7E,
  0x00, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x3E, 0x00, 0x1F, 0xC0, 0x78, 0x00, 0x1F, 0x80, 0xF0, 0x00, 0x1F, 0x81,
  0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0xF8, 0x3C, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x03, 0xE0, 0xF0,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0xF8, 0x1F, 0x00, 0x03, 0xF0, 0x3C, 0x00, 0x0F, 0xC0, 0x78, 0x00,
  0x7F, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xE1, 0xFE, 0x01, 0xF8, 0x03,
  0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0,
  0x7C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x3E, 0x00, 0x01, 0xE1, 0xF0,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xC0, 0x00,
  0x3E, 0x1E, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF8,
  0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1E, 0x00, 0x01, 0xF0, 0xF0,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x7C, 0x00, 0x03, 0xC3, 0xE0, 0x00,
  0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x7C,
  0x3C, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x1E, 0x1F, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x3E, 0x0F, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x3F, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3E, 0x00, 0x3F, 0x80,
  0x78, 0x00, 0x1F, 0x80, 0xF0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x3C,
  0x00, 0x03, 0xE0, 0x78, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x1E, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF8, 0x1F, 0x00,
  0x07, 0xE0, 0x3C, 0x00, 0x1F, 0x80, 0x78, 0x03, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x1E, 0x01, 0xF0, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x78, 0x03, 0xE0,
  0x01, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x0F, 0x80,
  0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0xF8, 0x07,
  0xC0, 0x01, 0xF0, 0x0F, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x78, 0x1F, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0xF8,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x7E, 0x07, 0xF0, 0x07,
  0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x3E, 0x00, 0x03,
  0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83,
  0xC0, 0x00, 0x7C, 0x1E, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x1E, 0x0F, 0x80,
  0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1E, 0x00, 0x03,
  0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0xF0, 0x7C, 0x00, 0x07, 0x83,
  0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x1F, 0x07, 0x80,
  0x00, 0xF8, 0x3C, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x3C, 0x1F, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0xC1,
  0xE0, 0x00, 0x3C, 0x1F, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x3E, 0x0F, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0xF8, 0x1E, 0x00, 0x07, 0x80,
  0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x0F,
  0x9E, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x3E, 0x3E,
  0x00, 0x01, 0xE1, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF0, 0x7C, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x3E,
  0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0xF8, 0x07,
  0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80,
  0x3E, 0x00, 0x7C, 0x01, 0xE0, 0x01, 0xE0, 0x1F, 0x00, 0x0F, 0x00, 0xF8,
  0x00, 0x78, 0x07, 0x80, 0x03, 0xC0, 0x7C, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0xF0, 0x3E, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x3C, 0x7C, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x0F, 0x3E, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x1E, 0xF8, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x9E, 0x00, 0xF8, 0x03, 0xCF, 0x00,
  0xFC, 0x03, 0xE7, 0x80, 0x7E, 0x01, 0xE3, 0xC0, 0x3F, 0x00, 0xF1, 0xE0,
  0x3B, 0x80, 0xF8, 0xF0, 0x1D, 0xC0, 0x78, 0x78, 0x0E, 0xE0, 0x3C, 0x7C,
  0x07, 0x70, 0x1E, 0x3E, 0x07, 0x38, 0x1F, 0x1F, 0x03, 0x9C, 0x0F, 0x0F,
  0x81, 0xCE, 0x07, 0x87, 0x81, 0xC7, 0x03, 0xC3, 0xC0, 0xE3, 0x83, 0xC1,
  0xE0, 0x71, 0xC1, 0xE0, 0xF0, 0x38, 0xE0, 0xF0, 0x78, 0x38, 0x70, 0x78,
  0x3C, 0x1C, 0x38, 0x78, 0x1E, 0x0E, 0x38, 0x3C, 0x0F, 0x0E, 0x1C, 0x1E,
  0x07, 0x87, 0x0E, 0x1F, 0x03, 0xC3, 0x87, 0x0F, 0x01, 0xE1, 0xC3, 0x87,
  0x80, 0xF1, 0xC1, 0xC3, 0xC0, 0x78, 0xE0, 0xE3, 0xC0, 0x3C, 0x70, 0x71,
  0xE0, 0x1E, 0x70, 0x38, 0xF0, 0x0F, 0x38, 0x1C, 0x78, 0x07, 0x9C, 0x0E,
  0x78, 0x03, 0xCE, 0x07, 0x3C, 0x01, 0xEE, 0x03, 0x9E, 0x00, 0xF7, 0x01,
  0xDE, 0x00, 0xF3, 0x80, 0xEF, 0x00, 0x7B, 0x80, 0x77, 0x80, 0x3D, 0xC0,
  0x3B, 0xC0, 0x1E, 0xE0, 0x1F, 0xC0, 0x0F, 0x70, 0x0F, 0xE0, 0x07, 0xF0,
  0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xBE, 0x00,
  0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x01, 0xF0, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x3F,
  0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0xF8,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00,
  0xF9, 0xF0, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x7C, 0x07, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xE0,
  0x1F, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x7C, 0x01, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x01,
  0xF0, 0x3E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x1F,
  0x78, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3E, 0xE0, 0x00, 0x3C,
  0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF0, 0xF0, 0x01, 0xF0,
  0x78, 0x01, 0xE0, 0x78, 0x03, 0xE0, 0x78, 0x03, 0xC0, 0x3C, 0x07, 0x80,
  0x3C, 0x0F, 0x80, 0x3C, 0x0F, 0x00, 0x3C, 0x1F, 0x00, 0x1E, 0x3E, 0x00,
  0x1E, 0x3C, 0x00, 0x1E, 0x7C, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x3E, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0xC0,
  0xF0, 0x3E, 0x07, 0xC0, 0x00, 0x3F, 0xE1, 0xF0, 0x0F, 0xFF, 0x1F, 0x01,
  0xFF, 0xF9, 0xE0, 0x3F, 0xFF, 0xDE, 0x07, 0xE0, 0x1F, 0xE0, 0xFC, 0x00,
  0xFE, 0x0F, 0x80, 0x07, 0xE1, 0xF0, 0x00, 0x7E, 0x1F, 0x00, 0x07, 0xC1,
  0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00,
  0x07, 0xC3, 0xC0, 0x00, 0x7C, 0x3C, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x78,
  0x7C, 0x00, 0x07, 0x87, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x87, 0x80,
  0x00, 0xF8, 0x78, 0x00, 0x0F, 0x87, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x1F,
  0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xF0, 0x7C,
  0x00, 0x7F, 0x07, 0xE0, 0x0D, 0xE0, 0x3F, 0xCF, 0xDE, 0x03, 0xFF, 0xFB,
  0xE0, 0x1F, 0xFF, 0x3E, 0x00, 0xFF, 0xC3, 0xE0, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC3, 0xFE, 0x00, 0x78, 0xFF, 0xF8, 0x07, 0x9F, 0xFF, 0xC0, 0x7B, 0xFF,
  0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xE0,
  0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x1F, 0x00,
  0x01, 0xE1, 0xF0, 0x00, 0x1E, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E,
  0x1E, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x3E, 0x1E, 0x00, 0x03, 0xC3, 0xE0,
  0x00, 0x3C, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07,
  0xC3, 0xC0, 0x00, 0x7C, 0x3C, 0x00, 0x07, 0x87, 0xC0, 0x00, 0xF8, 0x7E,
  0x00, 0x0F, 0x87, 0xE0, 0x01, 0xF0, 0x7F, 0x00, 0x3F, 0x07, 0xB8, 0x07,
  0xE0, 0x7B, 0xF3, 0xFC, 0x0F, 0xBF, 0xFF, 0x80, 0xF9, 0xFF, 0xF0, 0x0F,
  0x87, 0xFC, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x7E, 0x01, 0xFC,
  0x1F, 0x80, 0x0F, 0x83, 0xE0, 0x01, 0xF8, 0xF8, 0x00, 0x1F, 0x1F, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x78, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xE1, 0xF0,
  0x01, 0xF8, 0x3F, 0x80, 0x7E, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x0F, 0xF8, 0x7C, 0x01, 0xFF, 0xE3, 0xE0, 0x1F, 0xFF, 0x9E, 0x01, 0xFF,
  0xFE, 0xF0, 0x1F, 0x80, 0x7F, 0x81, 0xF8, 0x01, 0xFC, 0x0F, 0x80, 0x07,
  0xE0, 0xF8, 0x00, 0x3F, 0x07, 0xC0, 0x01, 0xF0, 0x3C, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0x80,
  0x00, 0xF8, 0x3C, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x3C, 0x1F, 0x00, 0x01,
  0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0xC1,
  0xE0, 0x00, 0x3E, 0x0F, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x07,
  0xF0, 0x3F, 0x00, 0x6F, 0x00, 0xFF, 0x3F, 0x78, 0x07, 0xFF, 0xF7, 0xC0,
  0x1F, 0xFF, 0x3E, 0x00, 0x7F, 0xE1, 0xF0, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x01, 0xFE, 0x3F,
  0xC0, 0x7E, 0x00, 0xF8, 0x1F, 0x80, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0xF8,
  0x00, 0x3E, 0x1E, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x78, 0xF8, 0x00, 0x0F,
  0x1F, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x7C, 0x78, 0x00, 0x0F, 0x8F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x8F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x0F,
  0x80, 0x03, 0xC1, 0xF0, 0x00, 0xF8, 0x3F, 0x00, 0x7E, 0x03, 0xF8, 0x7F,
  0x80, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xE1, 0xF0, 0x0F, 0xFF, 0x9F, 0x01, 0xFF, 0xF9, 0xE0, 0x3F, 0xFF, 0xDE,
  0x07, 0xE0, 0x1F, 0xE0, 0xFC, 0x00, 0xFE, 0x0F, 0x80, 0x07, 0xE1, 0xF0,
  0x00, 0x7E, 0x1F, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x3C, 0x3E, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x7C, 0x3C,
  0x00, 0x07, 0x87, 0xC0, 0x00, 0x78, 0x7C, 0x00, 0x07, 0x87, 0xC0, 0x00,
  0xF8, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x87,
  0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xE0, 0x02, 0xF0, 0x7E, 0x00,
  0x7F, 0x03, 0xF8, 0x3F, 0xF0, 0x3F, 0xFF, 0xDF, 0x01, 0xFF, 0xF9, 0xE0,
  0x0F, 0xFE, 0x1E, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x3F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC3, 0xFE, 0x00, 0x78, 0xFF, 0xF8, 0x07, 0x9F, 0xFF, 0xC0, 0x7B,
  0xE3, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0x7E, 0x0F, 0xC0, 0x03,
  0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x1F,
  0x00, 0x01, 0xE1, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x3E, 0x1E, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC3,
  0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3C, 0x00,
  0x07, 0xC3, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x87, 0xC0, 0x00, 0xF8,
  0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x87, 0x80,
  0x00, 0xF0, 0x78, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x1F,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x1F, 0x80,
  0xF0, 0x00, 0x7E, 0x01, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x0F,
  0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x78,
  0x03, 0xF0, 0x00, 0xF0, 0x0F, 0xC0, 0x03, 0xE0, 0x3F, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x07, 0xC0, 0x7E, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x00, 0xFC,
  0x00, 0x3C, 0x00, 0xF8, 0x00, 0x78, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0,
  0x03, 0xE0, 0x03, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x07, 0xE0,
  0x1E, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x1F, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x07, 0xCF,
  0xC1, 0xF8, 0x07, 0x9F, 0xE3, 0xFC, 0x07, 0xBF, 0xE7, 0xFE, 0x07, 0xE1,
  0xFC, 0x3E, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x0F, 0x80,
  0xF0, 0x1E, 0x0F, 0x80, 0xF0, 0x1E, 0x0F, 0x00, 0xF0, 0x1E, 0x0F, 0x01,
  0xE0, 0x3E, 0x0F, 0x01, 0xE0, 0x3E, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x01,
  0xE0, 0x3C, 0x1F, 0x01, 0xE0, 0x3C, 0x1F, 0x01, 0xE0, 0x3C, 0x1E, 0x01,
  0xC0, 0x3C, 0x1E, 0x03, 0xC0, 0x7C, 0x1E, 0x03, 0xC0, 0x7C, 0x1E, 0x03,
  0xC0, 0x78, 0x3E, 0x03, 0xC0, 0x78, 0x3E, 0x03, 0xC0, 0x78, 0x3C, 0x03,
  0x80, 0x78, 0x3C, 0x07, 0x80, 0xF8, 0x3C, 0x07, 0x80, 0xF8, 0x3C, 0x07,
  0x80, 0xF0, 0x7C, 0x07, 0x80, 0xF0, 0x7C, 0x07, 0x80, 0xF0, 0x78, 0x07,
  0x80, 0xF0, 0x78, 0x0F, 0x01, 0xF0, 0x78, 0x0F, 0x01, 0xF0, 0x78, 0x0F,
  0x01, 0xF0, 0xF8, 0x0F, 0x01, 0xE0, 0x07, 0xC3, 0xFE, 0x00, 0x7C, 0xFF,
  0xF8, 0x07, 0x9F, 0xFF, 0xC0, 0x7B, 0xE3, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0,
  0xFE, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80,
  0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x1F, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x3E,
  0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x03, 0xE1, 0xE0,
  0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x78, 0x3C,
  0x00, 0x07, 0x87, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0xF8, 0x7C, 0x00, 0x0F, 0x87, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x0F,
  0x80, 0x00, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x83, 0xE0, 0x01, 0xF0, 0xF8, 0x00,
  0x3E, 0x1F, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x78, 0xF8, 0x00, 0x0F, 0x1F,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x7C, 0x78, 0x00, 0x0F, 0x8F, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0x8F, 0x80, 0x00, 0xF1, 0xF0,
  0x00, 0x3E, 0x3C, 0x00, 0x07, 0xC7, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x1F,
  0x3E, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x0F, 0x80,
  0x07, 0xC1, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x03, 0xFE, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xF0, 0xFF, 0x80, 0x07, 0x8F, 0xFF, 0x80, 0x1E, 0x7F,
  0xFF, 0x00, 0x7B, 0xFF, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x07,
  0xE0, 0x3F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x78,
  0x0F, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x1E, 0x07,
  0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x0F, 0x81, 0xE0,
  0x00, 0x3E, 0x07, 0x80, 0x00, 0xF0, 0x3E, 0x00, 0x03, 0xC0, 0xF8, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x3C, 0x00, 0x07,
  0xC0, 0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x80, 0x03, 0xE0,
  0x7E, 0x00, 0x1F, 0x01, 0xEC, 0x00, 0xFC, 0x07, 0xB8, 0x07, 0xE0, 0x1E,
  0xFC, 0xFF, 0x00, 0xF9, 0xFF, 0xF8, 0x03, 0xE7, 0xFF, 0xC0, 0x0F, 0x87,
  0xFC, 0x00, 0x3E, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE1, 0xF0, 0x0F, 0xFF, 0x1E, 0x03,
  0xFF, 0xF9, 0xE0, 0x7F, 0xFF, 0xDE, 0x07, 0xE0, 0x1F, 0xE0, 0xFC, 0x00,
  0xFE, 0x0F, 0x80, 0x07, 0xE1, 0xF0, 0x00, 0x7E, 0x1E, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3C, 0x00,
  0x07, 0xC3, 0xC0, 0x00, 0x7C, 0x3C, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x78,
  0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x87, 0x80,
  0x00, 0xF8, 0x78, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x1F,
  0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xF0, 0x7C,
  0x00, 0x7E, 0x07, 0xE0, 0x0D, 0xE0, 0x7F, 0xCF, 0xDE, 0x03, 0xFF, 0xFB,
  0xE0, 0x1F, 0xFF, 0x3E, 0x00, 0xFF, 0xC3, 0xE0, 0x01, 0xC0, 0x3E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xC3, 0xFE, 0x00, 0x78,
  0xFF, 0xF8, 0x07, 0x9F, 0xFF, 0xC0, 0x7B, 0xE3, 0xFC, 0x0F, 0xF0, 0x07,
  0xE0, 0xFE, 0x00, 0x3E, 0x0F, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x0F,
  0x80, 0x01, 0xF0, 0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF1, 0xF0, 0x00,
  0x1E, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0xF8, 0xF8,
  0x00, 0x1F, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x0F, 0x1F,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x07, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x1E,
  0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE1, 0xE0,
  0x00, 0x3E, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x3E, 0x00, 0x03,
  0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3C,
  0x00, 0x07, 0xC3, 0xC0, 0x00, 0x78, 0x7C, 0x00, 0x07, 0x87, 0xC0, 0x00,
  0xF8, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x78, 0x00, 0x0F, 0x87,
  0x80, 0x00, 0xF0, 0x78, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xF0, 0x78, 0x00,
  0x1E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x07, 0xF0, 0x0F, 0xC0,
  0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x20, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3E, 0x78, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0x87,
  0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x07, 0xC0, 0x01, 0xF0, 0x3C, 0x00,
  0x1E, 0x03, 0xC0, 0x03, 0xE0, 0x3C, 0x00, 0x3C, 0x03, 0xE0, 0x07, 0xC0,
  0x3E, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0xF8, 0x01, 0xE0,
  0x1F, 0x00, 0x1E, 0x01, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x0F,
  0x0F, 0x80, 0x00, 0xF8, 0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x07, 0xBE, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x0F,
  0x80, 0x3F, 0xC0, 0x3E, 0x00, 0xFF, 0x00, 0xF8, 0x07, 0xBC, 0x07, 0xE0,
  0x1E, 0xF0, 0x1F, 0x80, 0x7B, 0xC0, 0x7E, 0x03, 0xCF, 0x03, 0xB8, 0x0F,
  0x3C, 0x0E, 0xE0, 0x3C, 0xF0, 0x3B, 0x81, 0xE3, 0xC1, 0xEE, 0x07, 0x8F,
  0x07, 0x38, 0x1E, 0x3C, 0x1C, 0xE0, 0xF0, 0xF0, 0xF3, 0x83, 0xC3, 0xC3,
  0x8E, 0x0F, 0x0F, 0x0E, 0x38, 0x38, 0x3C, 0x78, 0xE1, 0xE0, 0xF1, 0xC3,
  0x87, 0x83, 0xC7, 0x0E, 0x1C, 0x0F, 0x1C, 0x38, 0xF0, 0x3C, 0xE0, 0xE3,
  0xC0, 0xF3, 0x83, 0x8E, 0x03, 0xCE, 0x0E, 0x78, 0x0E, 0x70, 0x39, 0xE0,
  0x39, 0xC0, 0xE7, 0x00, 0xE7, 0x03, 0xBC, 0x03, 0xB8, 0x0E, 0xF0, 0x0E,
  0xE0, 0x3B, 0x80, 0x3B, 0x80, 0xEE, 0x00, 0xFC, 0x03, 0xF8, 0x03, 0xF0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7C, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x7C,
  0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1E,
  0x1F, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x7C,
  0x7C, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0,
  0x1F, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x1F, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x07, 0xC0, 0x7E, 0x00,
  0x03, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0xF0, 0x00,
  0x1E, 0x0F, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x3E, 0x1E, 0x00,
  0x03, 0xC3, 0xE0, 0x00, 0x3C, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C,
  0x3E, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x7C, 0x3C, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x78, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x07, 0xC0, 0x01, 0xF0, 0x7C,
  0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0xFF, 0x03, 0xFC, 0x3D,
  0xF0, 0x3F, 0xFF, 0xDE, 0x01, 0xFF, 0xF9, 0xE0, 0x07, 0xFE, 0x1E, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0xF0, 0xFF, 0xC0, 0x0F, 0x1F, 0xFE, 0x00, 0xF3,
  0xFF, 0xE0, 0x1F, 0x7C, 0x1F, 0x01, 0xF7, 0x81, 0xF8, 0x1E, 0x78, 0x0F,
  0xC3, 0xEF, 0x80, 0x7F, 0xFC, 0xF8, 0x03, 0xFF, 0xCF, 0x00, 0x3F, 0xF8,
  0xF0, 0x00, 0xFE, 0x00,
};

const GFXglyph JetBrainsMono_LightItalic58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 13, 42, 35, 11, -42 },
  { 70, 19, 17, 35, 11, -42 },
  { 111, 34, 42, 35, 1, -42 },
  { 290, 30, 58, 35, 3, -50 },
  { 508, 40, 43, 35, -2, -43 },
  { 723, 31, 44, 35, 2, -43 },
  { 894, 7, 17, 35, 17, -42 },
  { 909, 23, 56, 35, 10, -49 },
  { 1070, 23, 56, 35, 3, -49 },
  { 1231, 31, 29, 35, 3, -35 },
  { 1344, 28, 27, 35, 4, -33 },
  { 1439, 14, 18, 35, 6, -9 },
  { 1471, 19, 4, 35, 8, -21 },
  { 1481, 10, 10, 35, 10, -9 },
  { 1494, 34, 54, 35, 1, -48 },
  { 1724, 29, 44, 35, 4, -43 },
  { 1884, 26, 42, 35, 3, -42 },
  { 2021, 30, 43, 35, 3, -43 },
  { 2183, 29, 43, 35, 3, -42 },
  { 2339, 27, 42, 35, 4, -42 },
  { 2481, 28, 43, 35, 4, -42 },
  { 2632, 28, 43, 35, 3, -42 },
  { 2783, 28, 42, 35, 7, -42 },
  { 2930, 29, 44, 35, 3, -43 },
  { 3090, 27, 43, 35, 6, -43 },
  { 3236, 14, 33, 35, 10, -32 },
  { 3294, 18, 41, 35, 6, -32 },
  { 3387, 28, 30, 35, 5, -34 },
  { 3492, 28, 18, 35, 4, -28 },
  { 3555, 28, 30, 35, 3, -34 },
  { 3660, 23, 42, 35, 9, -42 },
  { 3781, 34, 53, 35, 1, -43 },
  { 4007, 28, 42, 35, 1, -42 },
  { 4154, 30, 42, 35, 3, -42 },
  { 4312, 29, 44, 35, 4, -43 },
  { 4472, 29, 42, 35, 3, -42 },
  { 4625, 30, 42, 35, 4, -42 },
  { 4783, 32, 42, 35, 3, -42 },
  { 4951, 29, 44, 35, 4, -43 },
  { 5111, 30, 42, 35, 3, -42 },
  { 5269, 29, 42, 35, 4, -42 },
  { 5422, 32, 43, 35, 1, -42 },
  { 5594, 33, 42, 35, 3, -42 },
  { 5768, 25, 42, 35, 4, -42 },
  { 5900, 32, 42, 35, 2, -42 },
  { 6068, 30, 42, 35, 3, -42 },
  { 6226, 28, 44, 35, 4, -43 },
  { 6380, 31, 42, 35, 3, -42 },
  { 6543, 29, 53, 35, 4, -43 },
  { 6736, 31, 42, 35, 3, -42 },
  { 6899, 30, 44, 35, 3, -43 },
  { 7064, 29, 42, 35, 7, -42 },
  { 7217, 29, 43, 35, 4, -42 },
  { 7373, 29, 42, 35, 7, -42 },
  { 7526, 33, 42, 35, 4, -42 },
  { 7700, 36, 42, 35, 0, -42 },
  { 7889, 31, 42, 35, 6, -42 },
  { 8052, 31, 42, 35, 2, -42 },
  { 8215, 22, 54, 35, 9, -48 },
  { 8364, 17, 54, 35, 10, -48 },
  { 8479, 23, 54, 35, 5, -48 },
  { 8635, 24, 22, 35, 6, -42 },
  { 8701, 29, 4, 35, 0, 1 },
  { 8716, 10, 9, 35, 16, -46 },
  { 8728, 28, 33, 35, 4, -32 },
  { 8844, 28, 43, 35, 3, -42 },
  { 8995, 27, 33, 35, 4, -32 },
  { 9107, 29, 43, 35, 4, -42 },
  { 9263, 27, 33, 35, 4, -32 },
  { 9375, 38, 52, 35, -2, -42 },
  { 9622, 28, 42, 35, 4, -32 },
  { 9769, 28, 42, 35, 3, -42 },
  { 9916, 28, 45, 35, 2, -45 },
  { 10074, 30, 55, 35, 1, -45 },
  { 10281, 31, 42, 35, 3, -42 },
  { 10444, 24, 42, 35, 6, -42 },
  { 10570, 32, 32, 35, 1, -32 },
  { 10698, 28, 32, 35, 3, -32 },
  { 10810, 27, 33, 35, 4, -32 },
  { 10922, 30, 42, 35, 1, -32 },
  { 11080, 28, 42, 35, 4, -32 },
  { 11227, 28, 32, 35, 4, -32 },
  { 11339, 27, 33, 35, 4, -32 },
  { 11451, 27, 41, 35, 5, -41 },
  { 11590, 28, 33, 35, 4, -32 },
  { 11706, 28, 32, 35, 6, -32 },
  { 11818, 30, 32, 35, 5, -32 },
  { 11938, 32, 32, 35, 1, -32 },
  { 12066, 28, 42, 35, 4, -32 },
  { 12213, 28, 32, 35, 3, -32 },
  { 12325, 29, 54, 35, 6, -48 },
  { 12521, 13, 54, 35, 12, -48 },
  { 12609, 29, 54, 35, 2, -48 },
  { 12805, 28, 11, 35, 4, -26 },
};

const GFXfont JetBrainsMono_LightItalic58pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_LightItalic58pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_LightItalic58pt7bGlyphs,
  0x20, 0x7E, 77
};

#endif // _JETBRAINSMONO_LIGHTITALIC58PT7B_H_
