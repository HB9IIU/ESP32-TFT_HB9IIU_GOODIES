#ifndef _JETBRAINSMONO_LIGHTITALIC55PT7B_H_
#define _JETBRAINSMONO_LIGHTITALIC55PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-LightItalic.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_LightItalic55pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0xFE, 0x07,
  0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xE0,
  0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x01, 0xE7, 0xC0, 0x79, 0xF0, 0x3E,
  0x7C, 0x0F, 0x9F, 0x03, 0xE7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x1E,
  0x03, 0xC7, 0x80, 0xF3, 0xC0, 0x38, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x03,
  0xC0, 0x1E, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x07, 0x80, 0x38, 0x00, 0x07, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0x08, 0x3C, 0x01, 0xC0, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0x78, 0x03, 0x80, 0x00, 0x70, 0x07, 0x80, 0x00, 0xF0,
  0x07, 0x80, 0x00, 0xF0, 0x07, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x01, 0xE0,
  0x0F, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x03, 0xC0,
  0x1E, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0x80, 0x78, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0xE0, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x3C, 0x01,
  0xC0, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xC0, 0x0F, 0xEE, 0xFE, 0x01, 0xF1, 0xE3, 0xE0, 0x3E, 0x1C, 0x1F, 0x03,
  0xC1, 0xC1, 0xF0, 0x7C, 0x1C, 0x1F, 0x07, 0x81, 0xC1, 0xF0, 0x78, 0x1C,
  0x1F, 0x0F, 0x83, 0xC0, 0x00, 0xF8, 0x38, 0x00, 0x0F, 0x83, 0x80, 0x00,
  0x7C, 0x38, 0x00, 0x07, 0xC3, 0x80, 0x00, 0x7E, 0x38, 0x00, 0x03, 0xFB,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xE3, 0xF0, 0x00, 0x0E, 0x1F, 0x80, 0x00, 0xE0, 0xF8, 0x00, 0x0E, 0x0F,
  0x80, 0x00, 0xE0, 0x78, 0x00, 0x0E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0xF8,
  0x1C, 0x07, 0x8F, 0x81, 0xC0, 0xF8, 0xF8, 0x1C, 0x0F, 0x0F, 0x81, 0xC1,
  0xF0, 0x7C, 0x1C, 0x3E, 0x07, 0xE1, 0xC7, 0xE0, 0x3F, 0xFB, 0xFC, 0x03,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3C, 0x01, 0xFF, 0xC0, 0x01, 0xE0,
  0x0F, 0xFF, 0x00, 0x0F, 0x00, 0x7C, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x78,
  0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x0E, 0x00, 0x3C, 0x07, 0x80, 0x70, 0x00,
  0xF0, 0x1E, 0x03, 0xC0, 0x03, 0x80, 0x78, 0x1E, 0x00, 0x0E, 0x01, 0xE0,
  0xF0, 0x00, 0x78, 0x07, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x3C, 0x00, 0x07,
  0x80, 0xF0, 0xE0, 0x00, 0x1E, 0x07, 0x87, 0x80, 0x00, 0x3E, 0x7E, 0x3C,
  0x00, 0x00, 0xFF, 0xF1, 0xE0, 0x00, 0x01, 0xFF, 0x8F, 0x00, 0x00, 0x01,
  0xF8, 0x78, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x1E, 0x1F, 0xC0, 0x00, 0x00, 0xF1, 0xFF, 0xC0, 0x00, 0x03, 0x8F, 0xFF,
  0x00, 0x00, 0x1C, 0x3E, 0x3E, 0x00, 0x00, 0xF1, 0xE0, 0x78, 0x00, 0x07,
  0x87, 0x00, 0xE0, 0x00, 0x3C, 0x3C, 0x03, 0x80, 0x01, 0xE0, 0xF0, 0x1E,
  0x00, 0x0F, 0x03, 0xC0, 0x78, 0x00, 0x38, 0x0F, 0x01, 0xE0, 0x01, 0xE0,
  0x38, 0x07, 0x80, 0x0F, 0x00, 0xE0, 0x1C, 0x00, 0x78, 0x03, 0x80, 0xF0,
  0x03, 0xC0, 0x0F, 0x03, 0xC0, 0x1E, 0x00, 0x3E, 0x3E, 0x00, 0x70, 0x00,
  0xFF, 0xF8, 0x03, 0x80, 0x01, 0xFF, 0x80, 0x3E, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x0F,
  0x80, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x01, 0xE0, 0x07, 0xC0,
  0x07, 0x80, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0xF1, 0xF0,
  0xF8, 0x07, 0x87, 0x81, 0xF0, 0x3E, 0x3E, 0x07, 0xC0, 0xF0, 0xF8, 0x0F,
  0x87, 0x83, 0xC0, 0x3E, 0x3E, 0x0F, 0x00, 0x7D, 0xF0, 0x3C, 0x00, 0xF7,
  0x80, 0xF0, 0x03, 0xFC, 0x07, 0xC0, 0x07, 0xF0, 0x1F, 0x00, 0x1F, 0x80,
  0x78, 0x00, 0x3E, 0x01, 0xE0, 0x01, 0xF8, 0x07, 0x80, 0x0F, 0xF0, 0x1F,
  0x00, 0x7F, 0xC0, 0x7C, 0x03, 0xEF, 0x81, 0xFE, 0x7F, 0x1F, 0x03, 0xFF,
  0xF8, 0x7C, 0x07, 0xFF, 0xC0, 0xF8, 0x0F, 0xFC, 0x01, 0xF0, 0x06, 0x00,
  0x00, 0x00, 0x3E, 0x79, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0xF9, 0xF3, 0xE7,
  0xCF, 0x1E, 0x3C, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x3C, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x20, 0x07, 0x80, 0x13,
  0xC0, 0x3C, 0x03, 0x9F, 0xC1, 0xC0, 0xFF, 0xFF, 0x8E, 0x3F, 0xFF, 0xFE,
  0x73, 0xFF, 0x8F, 0xFF, 0x7F, 0xE0, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x01, 0xE7, 0xC0, 0x00, 0x1F, 0x1E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x1F,
  0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x1F, 0x80, 0x18, 0x00, 0x70, 0x00, 0x40, 0x02, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0,
  0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3C,
  0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0x3F, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFC, 0x1F, 0xC0,
  0x3F, 0x00, 0x7E, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x07, 0x80,
  0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x1F,
  0x0F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x1E, 0x1F, 0x00, 0x01, 0xE1, 0xF0,
  0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3E, 0x1E, 0x0F, 0x83,
  0xE1, 0xE1, 0xF8, 0x3C, 0x3E, 0x1F, 0x83, 0xC3, 0xE1, 0xF8, 0x3C, 0x3C,
  0x0F, 0x83, 0xC3, 0xC0, 0xF0, 0x7C, 0x3C, 0x00, 0x07, 0xC3, 0xC0, 0x00,
  0x78, 0x7C, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x07, 0x87,
  0x80, 0x00, 0xF8, 0x78, 0x00, 0x0F, 0x87, 0x80, 0x00, 0xF0, 0x78, 0x00,
  0x0F, 0x07, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xE0,
  0x3E, 0x00, 0xFC, 0x03, 0xFC, 0x3F, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xEF,
  0x80, 0x0F, 0xE7, 0xC0, 0x1F, 0xC3, 0xC0, 0x0F, 0xC1, 0xE0, 0x07, 0x80,
  0xF0, 0x03, 0x00, 0x78, 0x03, 0x00, 0x7C, 0x01, 0x00, 0x3E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x07,
  0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x1E, 0x0F, 0x80, 0x01, 0xF0, 0xF0, 0x00,
  0x1F, 0x0F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF0, 0xF8,
  0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1E, 0x0F, 0x80, 0x03,
  0xE0, 0x7C, 0x00, 0x7C, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x87, 0xF0, 0x03,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x07, 0xC1, 0xF0,
  0x03, 0xC1, 0xF0, 0x01, 0xE0, 0xF8, 0x00, 0xF0, 0xF8, 0x00, 0xF8, 0xF8,
  0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x3E,
  0x00, 0x07, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC7, 0xFC, 0x00, 0xFB, 0xFF,
  0xE0, 0x1E, 0xFF, 0xFE, 0x03, 0xDF, 0x7F, 0xC0, 0x7F, 0x00, 0xFC, 0x0F,
  0x80, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x87, 0x80, 0x01, 0xF0, 0xF0, 0x00, 0x3C, 0x1F, 0x00,
  0x0F, 0x83, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0xFC, 0x07, 0xFC, 0xFF, 0x00,
  0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xCF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0x80, 0xFE, 0x1F, 0x80, 0x1F, 0x8F, 0xC0,
  0x03, 0xE3, 0xE0, 0x00, 0x7C, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xDE,
  0x00, 0x01, 0xF7, 0x80, 0x00, 0x7D, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xBE, 0x00, 0x01, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3C, 0xF8, 0x00,
  0x1F, 0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x03, 0xE1, 0xF8, 0x03, 0xF0, 0x3F,
  0xC7, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x78, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0xF3, 0xE0, 0x00, 0x7C, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0x00, 0x7E, 0x03,
  0xE0, 0x03, 0xE0, 0x3C, 0x00, 0x1E, 0x07, 0xC0, 0x01, 0xE0, 0x78, 0x00,
  0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xE0,
  0x78, 0x00, 0x3C, 0x07, 0xC0, 0x07, 0xC0, 0x3C, 0x00, 0xF8, 0x03, 0xE0,
  0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x7E,
  0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x87, 0x80, 0x00, 0xF8, 0x78,
  0x00, 0x0F, 0x87, 0x80, 0x00, 0xF8, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x01,
  0xF0, 0x78, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0x7E, 0x00, 0xFC, 0x03,
  0xFE, 0x7F, 0xC0, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0x87, 0xF8, 0x1F, 0x80,
  0x3F, 0x03, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7,
  0x80, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x3E, 0x00, 0x01, 0xE7, 0xC0, 0x00,
  0x3C, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x3C, 0x78,
  0x00, 0x07, 0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x3F, 0x00, 0x1F,
  0x83, 0xE0, 0x07, 0xE0, 0x7F, 0x03, 0xFC, 0x07, 0xFF, 0xEF, 0x00, 0x7F,
  0xFB, 0xE0, 0x07, 0xFE, 0xF8, 0x00, 0x0C, 0x3E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x3F, 0x81, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xF8, 0x3F, 0xC0,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x3F, 0x03, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F,
  0x81, 0xF8, 0x02, 0x00, 0x00, 0x1E, 0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0C, 0x00, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x00,
  0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0x7C, 0x01, 0xF0, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x1E, 0x07, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x0F, 0x80, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x0E,
  0x1E, 0x1E, 0x00, 0x7F, 0x9E, 0x1E, 0x00, 0xFF, 0xDE, 0x1E, 0x01, 0xFF,
  0xFE, 0x1E, 0x03, 0xE0, 0x7E, 0x1E, 0x03, 0xC0, 0x3E, 0x1E, 0x07, 0x80,
  0x3C, 0x3C, 0x07, 0x80, 0x3C, 0x3C, 0x07, 0x80, 0x3C, 0x3C, 0x07, 0x80,
  0x3C, 0x3C, 0x0F, 0x00, 0x3C, 0x3C, 0x0F, 0x00, 0x3C, 0x3C, 0x0F, 0x00,
  0x78, 0x78, 0x0F, 0x00, 0x78, 0x78, 0x0F, 0x00, 0x78, 0x78, 0x0F, 0x00,
  0x78, 0x78, 0x1E, 0x00, 0x78, 0x78, 0x1E, 0x00, 0xF8, 0x78, 0x1F, 0x00,
  0xF8, 0x78, 0x0F, 0x01, 0xF0, 0xF0, 0x0F, 0xC7, 0x70, 0xF0, 0x0F, 0xFE,
  0xF0, 0xF0, 0x07, 0xFC, 0xF0, 0xF0, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x3E, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x3C, 0x78, 0x00, 0x07, 0x87, 0x80, 0x01, 0xF0, 0xF0, 0x00, 0x3C, 0x1E,
  0x00, 0x0F, 0x83, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x0F,
  0x01, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x7C, 0x07, 0x80, 0x0F, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x03, 0xE0,
  0x07, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF8, 0x1F, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xF0, 0xF8, 0x00,
  0x3E, 0x1E, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x1E,
  0x00, 0x01, 0xE7, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0xBE, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x1F, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xC0, 0x0F, 0xE0, 0x7C, 0x00,
  0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0,
  0x78, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x1E, 0x0F, 0x80,
  0x03, 0xE0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0xF8,
  0x0F, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xE0, 0x07, 0xF0, 0x1E, 0x00, 0x1F,
  0x81, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x78, 0x3C,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x78, 0x7C, 0x00, 0x07, 0x87, 0xC0, 0x00, 0xF8, 0x78, 0x00, 0x0F, 0x07,
  0x80, 0x01, 0xF0, 0x78, 0x00, 0x7E, 0x07, 0x80, 0x1F, 0xC0, 0x7F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xC0, 0x1F, 0xC3, 0xFC, 0x07, 0xC0, 0x1F, 0x81, 0xF0, 0x01, 0xF0,
  0x3C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xE0, 0x00, 0x7C, 0x3C, 0x00,
  0x0F, 0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF0,
  0xF8, 0x00, 0x1E, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF0, 0x3E, 0x00,
  0x3E, 0x07, 0xE0, 0x1F, 0x80, 0xFF, 0x0F, 0xE0, 0x0F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8,
  0x03, 0xC0, 0x1F, 0xC0, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x78,
  0x00, 0x3E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01,
  0xE0, 0xF8, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xE0, 0xF0, 0x00, 0x3E, 0x0F,
  0x00, 0x03, 0xE0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC1, 0xF0, 0x00,
  0x3C, 0x1F, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x7C, 0x1E, 0x00, 0x07, 0xC1,
  0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x3E, 0x00,
  0x07, 0x83, 0xE0, 0x00, 0xF8, 0x3C, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0xF0,
  0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0,
  0x01, 0xE0, 0x78, 0x00, 0x3E, 0x07, 0x80, 0x07, 0xC0, 0x78, 0x00, 0xFC,
  0x07, 0x80, 0x3F, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xC0, 0x1F, 0xC3, 0xFC, 0x07, 0xC0, 0x1F, 0x81, 0xF0, 0x01,
  0xF0, 0x3C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xE0, 0x00, 0x7C, 0x3C,
  0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x1F, 0xFF, 0x0F, 0x03, 0xFF, 0xE3, 0xE0, 0x7F, 0xFC, 0x7C, 0x0F,
  0xFF, 0x8F, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87,
  0x80, 0x00, 0xF0, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0xF0, 0xF8, 0x00, 0x1E, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF0, 0x3E,
  0x00, 0x3E, 0x07, 0xE0, 0x1F, 0x80, 0xFF, 0x0F, 0xE0, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0xF8, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3C, 0x07, 0x80,
  0x01, 0xE0, 0x3C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x07,
  0xC0, 0xF0, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x78, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x07, 0xC0,
  0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x03,
  0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF8, 0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1E, 0x03, 0xC0,
  0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0xF0, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3C, 0x07, 0x80, 0x03,
  0xE0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x1E,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0xE0,
  0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0xC3, 0xFC, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0xF8, 0x0F, 0x00, 0x03,
  0xE0, 0x1E, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x7C,
  0x01, 0xF0, 0x00, 0xF8, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x80,
  0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x7C, 0x01, 0xF0, 0x00,
  0xF8, 0x03, 0xE0, 0x01, 0xE0, 0x0F, 0x80, 0x03, 0xC0, 0x3E, 0x00, 0x07,
  0x80, 0x7C, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xC0,
  0x7C, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xE0, 0x07,
  0xC0, 0x03, 0xC0, 0x0F, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x7C,
  0x01, 0xE0, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF0,
  0x1F, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x07, 0xC0,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0x03, 0xF0, 0x00, 0xFE, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xE0, 0x07, 0xF0,
  0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x3D, 0xC0, 0xF7, 0x00, 0x7F, 0x81,
  0xEE, 0x01, 0xEF, 0x03, 0xDC, 0x03, 0xDC, 0x07, 0xBC, 0x0F, 0x38, 0x0F,
  0x78, 0x1E, 0xF0, 0x1C, 0x70, 0x79, 0xE0, 0x78, 0xE0, 0xF3, 0xC0, 0xF1,
  0xC3, 0xC7, 0x81, 0xE3, 0xC7, 0x9E, 0x03, 0xC7, 0x8E, 0x3C, 0x07, 0x8F,
  0x3C, 0x78, 0x0F, 0x0E, 0x70, 0xF0, 0x1E, 0x1D, 0xE1, 0xE0, 0x7C, 0x3B,
  0x87, 0xC0, 0xF0, 0x7F, 0x0F, 0x01, 0xE0, 0xFC, 0x1E, 0x03, 0xC1, 0xF8,
  0x3C, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x1F, 0x00, 0x01, 0xF0,
  0x3E, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF8, 0x1F,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x80, 0x03,
  0xF0, 0x00, 0xF8, 0x1F, 0x80, 0x07, 0x80, 0xFE, 0x00, 0x3C, 0x07, 0xF0,
  0x01, 0xE0, 0x7F, 0x80, 0x0F, 0x03, 0xFC, 0x00, 0x78, 0x1E, 0xE0, 0x07,
  0xC0, 0xF7, 0x80, 0x3E, 0x07, 0xBC, 0x01, 0xE0, 0x3D, 0xE0, 0x0F, 0x03,
  0xEF, 0x00, 0x78, 0x1F, 0x38, 0x03, 0xC0, 0xF1, 0xE0, 0x3E, 0x07, 0x8F,
  0x01, 0xF0, 0x3C, 0x78, 0x0F, 0x01, 0xE3, 0xC0, 0x78, 0x0F, 0x0E, 0x03,
  0xC0, 0xF8, 0x78, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x3C, 0x1E, 0x0F, 0x81,
  0xE0, 0xF0, 0x78, 0x0F, 0x03, 0xC3, 0xC0, 0x78, 0x1E, 0x1E, 0x07, 0xC0,
  0xF0, 0xF0, 0x3C, 0x07, 0x87, 0x81, 0xE0, 0x3C, 0x7C, 0x0F, 0x00, 0xF3,
  0xE0, 0x78, 0x07, 0x9E, 0x03, 0xC0, 0x3C, 0xF0, 0x3E, 0x01, 0xE7, 0x81,
  0xF0, 0x07, 0x3C, 0x0F, 0x00, 0x3D, 0xE0, 0x78, 0x01, 0xEF, 0x03, 0xC0,
  0x0F, 0xF0, 0x1E, 0x00, 0x7F, 0x80, 0xF0, 0x01, 0xFC, 0x0F, 0x80, 0x0F,
  0xE0, 0x78, 0x00, 0x7F, 0x03, 0xC0, 0x03, 0xF8, 0x1E, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x80, 0x1F, 0xC3, 0xF8, 0x07, 0xC0, 0x1F, 0x81, 0xF0, 0x01, 0xF0,
  0x3C, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x3C, 0x00,
  0x0F, 0x0F, 0x80, 0x01, 0xE1, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x87,
  0x80, 0x01, 0xF0, 0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x07, 0x87, 0xC0, 0x00,
  0xF0, 0xF8, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF8, 0x78,
  0x00, 0x1F, 0x0F, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x78, 0x7C, 0x00, 0x0F,
  0x0F, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x0F, 0x87, 0x80,
  0x01, 0xF0, 0xF0, 0x00, 0x3C, 0x3E, 0x00, 0x07, 0x87, 0xC0, 0x00, 0xF0,
  0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0x83, 0xE0, 0x01, 0xF0, 0x3E, 0x00,
  0x7C, 0x07, 0xE0, 0x1F, 0x80, 0xFF, 0x3F, 0xE0, 0x0F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFC, 0x03, 0xC0, 0x03, 0xF0, 0x1F, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x0F,
  0x81, 0xE0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0xF8, 0x3C,
  0x00, 0x03, 0xE0, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x7C, 0x0F, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x81, 0xF0, 0x01, 0xFC, 0x07, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xC3, 0xF8, 0x07, 0xC0, 0x1F,
  0x81, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C,
  0x3C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF1, 0xF0, 0x00, 0x3E, 0x3E, 0x00,
  0x07, 0xC7, 0x80, 0x00, 0xF8, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x78, 0xF8, 0x00, 0x0F, 0x1F, 0x00, 0x03, 0xE3, 0xC0, 0x00,
  0x7C, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x7C,
  0x00, 0x07, 0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x3C, 0x00, 0x07,
  0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x07, 0xC3, 0xE0,
  0x01, 0xF0, 0x7C, 0x00, 0x7E, 0x07, 0xE0, 0x1F, 0x80, 0xFF, 0x1F, 0xE0,
  0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x15,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0,
  0x3C, 0x00, 0x7F, 0x03, 0xE0, 0x01, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF0,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0xC1, 0xE0, 0x00,
  0x3E, 0x1F, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF8,
  0x3C, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x7C, 0x0F, 0x00, 0x07, 0xE0, 0xF8,
  0x00, 0x7E, 0x07, 0xC0, 0x1F, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xC0, 0x7C, 0x00,
  0x3E, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x78,
  0x03, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x03,
  0xE0, 0x0F, 0x80, 0x0F, 0x00, 0x78, 0x00, 0x7C, 0x03, 0xC0, 0x03, 0xE0,
  0x1E, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0x7C,
  0x00, 0x0F, 0x03, 0xE0, 0x00, 0x7C, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFC,
  0x00, 0xFE, 0x1F, 0xE0, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF0, 0x3C,
  0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x1F, 0x07, 0x80, 0x01,
  0xF0, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x8F, 0x80,
  0x00, 0x78, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x1F,
  0x07, 0xC0, 0x03, 0xE0, 0x7E, 0x00, 0x7E, 0x03, 0xFE, 0x7F, 0xC0, 0x3F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x0F,
  0x80, 0x01, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x00, 0x03, 0xE0, 0xF0, 0x00,
  0x3E, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x1F, 0x00, 0x03, 0xC1,
  0xF0, 0x00, 0x3C, 0x1F, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x7C, 0x1E, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x78,
  0x3E, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0xF8, 0x3C, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0xF0, 0x7C, 0x00, 0x1F,
  0x07, 0x80, 0x01, 0xF0, 0x78, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xE0, 0x78,
  0x00, 0x1E, 0x0F, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03,
  0xE0, 0xF8, 0x00, 0x3C, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7F, 0x8F, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xCF, 0x80,
  0x00, 0xF8, 0xF0, 0x00, 0x1F, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF8,
  0x78, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0xF0, 0x3E, 0x00,
  0x1E, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xF0, 0x1F, 0x00, 0x3E, 0x01,
  0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07,
  0x80, 0x1E, 0x01, 0xF0, 0x03, 0xC0, 0x3C, 0x00, 0x78, 0x0F, 0x80, 0x0F,
  0x81, 0xE0, 0x01, 0xF0, 0x3C, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xC1, 0xE0,
  0x00, 0x78, 0x7C, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C,
  0x78, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x1E, 0x78, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3C, 0x03, 0xE0, 0x1E, 0xF0, 0x07, 0xC0, 0x3D, 0xE0, 0x1F, 0x80, 0x7B,
  0xC0, 0x3F, 0x01, 0xE7, 0x80, 0x7E, 0x03, 0xCF, 0x00, 0xDC, 0x07, 0x9E,
  0x03, 0xB8, 0x0F, 0x3C, 0x07, 0x70, 0x3C, 0x78, 0x0E, 0xE0, 0x78, 0xF0,
  0x39, 0xC0, 0xF1, 0xE0, 0x73, 0x83, 0xC3, 0xC0, 0xE6, 0x07, 0x87, 0x83,
  0x8C, 0x0F, 0x0F, 0x07, 0x18, 0x1E, 0x1E, 0x0E, 0x30, 0x78, 0x3C, 0x1C,
  0x60, 0xF0, 0x78, 0x71, 0xC1, 0xE0, 0xF0, 0xE3, 0x83, 0x81, 0xE1, 0xC7,
  0x0F, 0x03, 0xC7, 0x0E, 0x1E, 0x07, 0x8E, 0x1C, 0x3C, 0x0E, 0x1C, 0x38,
  0x70, 0x1C, 0x38, 0x71, 0xE0, 0x38, 0xE0, 0xE3, 0xC0, 0x71, 0xC1, 0xC7,
  0x81, 0xE3, 0x83, 0x9E, 0x03, 0xCE, 0x07, 0x3C, 0x07, 0x9C, 0x0E, 0x78,
  0x0F, 0x38, 0x1C, 0xE0, 0x1E, 0x60, 0x3B, 0xC0, 0x3D, 0xC0, 0x77, 0x80,
  0x7B, 0x80, 0xEF, 0x00, 0xF7, 0x01, 0xDC, 0x01, 0xFC, 0x03, 0xF8, 0x03,
  0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F,
  0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x3C, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x01, 0xF0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x0F, 0x80, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x3C,
  0x1F, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3D, 0xF0, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x0F, 0x8F,
  0x00, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0xF8,
  0x1F, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x3E, 0x00, 0x07, 0xC0, 0x07, 0x80, 0x01, 0xF0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x0F, 0x80, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0xF8,
  0xF8, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x7C, 0x1E, 0x00, 0x03, 0xC0, 0xF8,
  0x00, 0x3E, 0x03, 0xC0, 0x03, 0xE0, 0x1E, 0x00, 0x1E, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0xF8, 0x0F, 0x80,
  0x03, 0xC0, 0xF8, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x78, 0xF0, 0x00,
  0x78, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0x70, 0x01, 0xE0, 0x78, 0x03,
  0xC0, 0x78, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x3C, 0x0F, 0x80, 0x3C, 0x0F,
  0x00, 0x3C, 0x1E, 0x00, 0x1C, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x7C,
  0x00, 0x1E, 0xF8, 0x00, 0x0F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x3E, 0x0F, 0x07, 0xC1,
  0xE0, 0x78, 0x3E, 0x0F, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xF0, 0xF0, 0x1F,
  0xFE, 0x7C, 0x0F, 0xFF, 0xDF, 0x07, 0xE0, 0x7F, 0x83, 0xE0, 0x07, 0xE1,
  0xF0, 0x01, 0xF8, 0x7C, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x8F, 0x80, 0x03,
  0xE3, 0xC0, 0x00, 0xF8, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x1F, 0x00,
  0x03, 0xC7, 0xC0, 0x00, 0xF1, 0xF0, 0x00, 0x7C, 0x78, 0x00, 0x1F, 0x1E,
  0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0xF8, 0x00, 0x1E,
  0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF0, 0xF8, 0x00,
  0x7C, 0x3F, 0x00, 0x3F, 0x07, 0xC0, 0x1B, 0xC1, 0xFE, 0x1F, 0xF0, 0x3F,
  0xFF, 0x7C, 0x07, 0xFF, 0x9F, 0x00, 0xFF, 0x87, 0x80, 0x03, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x78, 0xFF, 0xC0,
  0x3E, 0x7F, 0xFC, 0x0F, 0xBF, 0xFF, 0x03, 0xDE, 0x0F, 0xE0, 0xFE, 0x00,
  0xF8, 0x3F, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC7, 0xC0, 0x01, 0xF1, 0xF0,
  0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1E, 0x00, 0x07, 0xC7, 0x80, 0x01, 0xE1,
  0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x3E, 0x00, 0x07, 0x8F, 0x80, 0x03,
  0xE3, 0xC0, 0x00, 0xF8, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00,
  0x03, 0xC7, 0xC0, 0x00, 0xF1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1E, 0x1F,
  0x00, 0x0F, 0x87, 0xE0, 0x07, 0xC1, 0xFC, 0x03, 0xF0, 0xFF, 0xC7, 0xF8,
  0x3E, 0xFF, 0xFC, 0x0F, 0x9F, 0xFE, 0x03, 0xC3, 0xFE, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF8, 0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x07, 0xE1, 0xF0, 0x00,
  0xF8, 0x7C, 0x00, 0x3E, 0x1E, 0x00, 0x07, 0x8F, 0x80, 0x01, 0xE3, 0xC0,
  0x00, 0x78, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x07, 0x8F, 0x80, 0x01, 0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3C, 0x1F,
  0x00, 0x1F, 0x07, 0xE0, 0x1F, 0x81, 0xFE, 0x3F, 0xC0, 0x3F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x3C, 0x00, 0xFF, 0xC3,
  0xC0, 0x1F, 0xFE, 0x7C, 0x03, 0xFF, 0xF7, 0xC0, 0x7E, 0x07, 0xFC, 0x0F,
  0x80, 0x1F, 0x81, 0xF0, 0x01, 0xF8, 0x1F, 0x00, 0x0F, 0x81, 0xE0, 0x00,
  0xF8, 0x3E, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0xF8, 0x3C, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0xF0, 0x7C, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0xF0, 0x7C, 0x00,
  0x1F, 0x07, 0x80, 0x01, 0xF0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0,
  0x78, 0x00, 0x1E, 0x0F, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80,
  0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC0, 0xFC, 0x00, 0xFC,
  0x07, 0xC0, 0x1B, 0xC0, 0x7F, 0x87, 0xFC, 0x03, 0xFF, 0xF7, 0xC0, 0x1F,
  0xFE, 0x7C, 0x00, 0xFF, 0x87, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7E,
  0x03, 0xF0, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0x3C, 0x3C, 0x00, 0x1F, 0x1E,
  0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x00, 0x03, 0xE7, 0x80, 0x01, 0xF3,
  0xC0, 0x00, 0xF3, 0xE0, 0x00, 0x79, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x7C, 0xF8, 0x00, 0x3C, 0x3C, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x0F, 0xE0,
  0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0x60, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0xF8, 0xF0, 0x1F, 0xFF, 0x7C, 0x0F, 0xFF, 0xDF,
  0x07, 0xE0, 0x7F, 0x83, 0xE0, 0x07, 0xE1, 0xF0, 0x01, 0xF8, 0x7C, 0x00,
  0x3E, 0x1E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xC0, 0x00, 0xF8, 0xF0,
  0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x1F, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0xF1,
  0xF0, 0x00, 0x7C, 0x78, 0x00, 0x1F, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x01,
  0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x87, 0xC0,
  0x07, 0xE1, 0xF0, 0x03, 0xF0, 0x7F, 0x03, 0xFC, 0x0F, 0xFF, 0xEF, 0x01,
  0xFF, 0xF3, 0xC0, 0x3F, 0xF8, 0xF0, 0x03, 0xF8, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x78, 0xFF,
  0xC0, 0x3E, 0x7F, 0xFC, 0x0F, 0xBF, 0xFF, 0x03, 0xDC, 0x0F, 0xE0, 0xFE,
  0x00, 0xF8, 0x3F, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC7, 0xC0, 0x01, 0xF1,
  0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x01,
  0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x8F, 0x80,
  0x03, 0xE3, 0xC0, 0x00, 0xF8, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F,
  0x00, 0x03, 0xC7, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x78, 0x00, 0x1F,
  0x1E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0xF8, 0x00,
  0x1E, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xC0, 0x00, 0xF0, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00,
  0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x7E, 0x0F, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x7E,
  0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x01, 0xE0, 0x03, 0xE0, 0x0F,
  0x00, 0x3E, 0x00, 0x78, 0x03, 0xE0, 0x07, 0xC0, 0x3F, 0x00, 0x3E, 0x03,
  0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x78, 0x0F, 0x80, 0x03, 0xC0, 0x3E, 0x00, 0x1E, 0x01,
  0xF0, 0x00, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x03, 0xC0, 0x07, 0xC0, 0x1E, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0xF8, 0x07,
  0x80, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x1F, 0x00,
  0x03, 0xE0, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x0F, 0x01, 0xE0, 0x1E, 0x7F, 0x1F, 0xC0,
  0x7B, 0xFC, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xC3, 0xF0, 0x7C, 0x3E,
  0x07, 0x81, 0xF0, 0xF0, 0x1E, 0x07, 0xC3, 0xC0, 0x78, 0x1E, 0x0F, 0x01,
  0xC0, 0x78, 0x3C, 0x07, 0x01, 0xE0, 0xF0, 0x3C, 0x07, 0x87, 0xC0, 0xF0,
  0x1E, 0x1E, 0x03, 0xC0, 0x78, 0x78, 0x0F, 0x03, 0xE1, 0xE0, 0x3C, 0x0F,
  0x07, 0x80, 0xE0, 0x3C, 0x1E, 0x03, 0x80, 0xF0, 0xF8, 0x1E, 0x03, 0xC3,
  0xC0, 0x78, 0x0F, 0x0F, 0x01, 0xE0, 0x3C, 0x3C, 0x07, 0x81, 0xE0, 0xF0,
  0x1C, 0x07, 0x83, 0xC0, 0x70, 0x1E, 0x0F, 0x03, 0xC0, 0x78, 0x78, 0x0F,
  0x01, 0xE1, 0xE0, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0x3C, 0x1E, 0x03, 0x80,
  0xF0, 0x78, 0x0E, 0x03, 0xC1, 0xE0, 0x78, 0x0F, 0x0F, 0x81, 0xE0, 0x3C,
  0x00, 0x00, 0x01, 0xF0, 0x01, 0xE3, 0xFF, 0x00, 0xF9, 0xFF, 0xF0, 0x3E,
  0xFF, 0xFC, 0x0F, 0x70, 0x3F, 0x83, 0xF8, 0x03, 0xE0, 0xFC, 0x00, 0x7C,
  0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF1, 0xF0, 0x00,
  0x7C, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0,
  0x00, 0x78, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x8F, 0x00, 0x03, 0xE3,
  0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x1F, 0x00, 0x07,
  0xC7, 0xC0, 0x01, 0xF1, 0xE0, 0x00, 0x7C, 0x78, 0x00, 0x1E, 0x1E, 0x00,
  0x07, 0x87, 0x80, 0x01, 0xE3, 0xE0, 0x00, 0x78, 0xF8, 0x00, 0x3E, 0x3E,
  0x00, 0x0F, 0x8F, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0x07, 0xF0, 0x7C, 0x00,
  0xF8, 0x7C, 0x00, 0x3C, 0x3E, 0x00, 0x1F, 0x1E, 0x00, 0x0F, 0x9F, 0x00,
  0x07, 0xCF, 0x00, 0x03, 0xE7, 0x80, 0x01, 0xF3, 0xC0, 0x00, 0xF3, 0xE0,
  0x00, 0x79, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x1F, 0x3C,
  0x00, 0x0F, 0x9E, 0x00, 0x07, 0xCF, 0x00, 0x03, 0xCF, 0x80, 0x01, 0xE7,
  0xC0, 0x00, 0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x78, 0xF8, 0x00, 0x7C,
  0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x7E, 0x0F, 0xF1, 0xFE, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x1E, 0x3F, 0xF0, 0x03, 0xE7, 0xFF, 0xC0, 0x3E, 0xFF, 0xFC,
  0x03, 0xDE, 0x0F, 0xE0, 0x3F, 0x80, 0x3E, 0x03, 0xF0, 0x01, 0xF0, 0x3E,
  0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01,
  0xF0, 0x78, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x0F,
  0x80, 0x01, 0xE0, 0xF8, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xE0, 0xF0, 0x00,
  0x3E, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC1,
  0xF0, 0x00, 0x3C, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x78, 0x1F, 0x00,
  0x0F, 0x81, 0xF8, 0x01, 0xF0, 0x1F, 0xC0, 0x3F, 0x03, 0xFF, 0x1F, 0xE0,
  0x3E, 0xFF, 0xFC, 0x03, 0xC7, 0xFF, 0x80, 0x3C, 0x3F, 0xE0, 0x03, 0xC0,
  0x20, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0xF0, 0xF0, 0x1F, 0xFE, 0x7C, 0x1F, 0xFF, 0xDF, 0x07,
  0xE0, 0x7F, 0x83, 0xE0, 0x07, 0xE1, 0xF0, 0x01, 0xF8, 0x7C, 0x00, 0x3E,
  0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xC0, 0x00, 0xF0, 0xF0, 0x00,
  0x3C, 0x3C, 0x00, 0x0F, 0x1F, 0x00, 0x03, 0xC7, 0xC0, 0x01, 0xF1, 0xE0,
  0x00, 0x7C, 0x78, 0x00, 0x1F, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE3,
  0xE0, 0x00, 0x78, 0xF8, 0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03,
  0xE3, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x3F, 0x07, 0xC0,
  0x1B, 0xC1, 0xFC, 0x3F, 0xF0, 0x3F, 0xFF, 0x7C, 0x07, 0xFF, 0x9E, 0x00,
  0xFF, 0x87, 0x80, 0x03, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0xF1, 0xFF, 0x80, 0x3E, 0x7F, 0xFC, 0x07, 0xDF,
  0xFF, 0xC0, 0xF7, 0x01, 0xF8, 0x1F, 0xC0, 0x1F, 0x83, 0xF0, 0x01, 0xF0,
  0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x78, 0x7C, 0x00,
  0x1F, 0x0F, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xF0,
  0x1F, 0x81, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3C, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0xF8, 0x00, 0x1F, 0x1E, 0x00, 0x07, 0x87, 0xC0, 0x07,
  0xE1, 0xFE, 0x0F, 0xF0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x80,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x1F, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0xF1, 0xF0, 0x00, 0x7C, 0x78, 0x00,
  0x1F, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0xF8,
  0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x8F, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0xF0,
  0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x1F, 0x00, 0x03, 0xC7, 0xC0, 0x01,
  0xF1, 0xE0, 0x00, 0x7C, 0x78, 0x00, 0x1F, 0x1E, 0x00, 0x07, 0x87, 0x80,
  0x01, 0xE3, 0xE0, 0x00, 0x78, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x8F,
  0x80, 0x03, 0xC3, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x1F, 0x80, 0x7E,
  0x03, 0xF8, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0xF9, 0xE0, 0x00, 0x7C, 0x78, 0x00, 0x1F, 0x1E, 0x00, 0x0F,
  0x87, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0xF0, 0x7C, 0x00, 0x7C, 0x0F, 0x00,
  0x1E, 0x03, 0xC0, 0x0F, 0x80, 0xF0, 0x03, 0xC0, 0x3C, 0x01, 0xF0, 0x0F,
  0x80, 0x78, 0x03, 0xE0, 0x3E, 0x00, 0x78, 0x0F, 0x00, 0x1E, 0x07, 0xC0,
  0x07, 0x81, 0xE0, 0x01, 0xE0, 0xF8, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x1F,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0xF3, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x0F,
  0x7C, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x77, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xE0, 0x1F, 0x00, 0xFE, 0x01,
  0xF0, 0x0F, 0xE0, 0x1F, 0x00, 0xEE, 0x03, 0xF0, 0x1E, 0xE0, 0x3F, 0x01,
  0xEE, 0x03, 0xF0, 0x1C, 0xE0, 0x77, 0x03, 0xCE, 0x07, 0x70, 0x3C, 0xE0,
  0x77, 0x03, 0x8E, 0x0E, 0x70, 0x78, 0xE0, 0xE7, 0x07, 0x8E, 0x0E, 0x70,
  0x70, 0xE1, 0xC7, 0x0F, 0x0E, 0x1C, 0x70, 0xF0, 0xE1, 0xC7, 0x0E, 0x0E,
  0x38, 0x70, 0xE0, 0xE3, 0x87, 0x1E, 0x0E, 0x38, 0x71, 0xC0, 0xE7, 0x07,
  0x1C, 0x0E, 0x70, 0x73, 0xC0, 0xE7, 0x07, 0x38, 0x0E, 0xE0, 0x73, 0x80,
  0xEE, 0x07, 0x78, 0x0E, 0xE0, 0x77, 0x00, 0xEC, 0x07, 0x70, 0x0F, 0xC0,
  0x7F, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0x80, 0x7E, 0x00, 0xF8, 0x07, 0xE0,
  0x0F, 0x80, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0,
  0x1F, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x07, 0xE0, 0x03,
  0xE0, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E,
  0x3E, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xCF, 0x00, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x3E, 0x03, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x0F, 0xC0,
  0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0xF0, 0x0F, 0x80, 0x03,
  0xE0, 0x7C, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x07,
  0xC7, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x78, 0x00, 0x1E, 0x1E, 0x00,
  0x07, 0x87, 0x80, 0x01, 0xE3, 0xE0, 0x00, 0x78, 0xF8, 0x00, 0x3E, 0x3E,
  0x00, 0x0F, 0x8F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C,
  0x3C, 0x00, 0x0F, 0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF1, 0xE0, 0x00,
  0x7C, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0,
  0x00, 0xF8, 0x78, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x87, 0xC0, 0x0F, 0xC1,
  0xFC, 0x0E, 0xF0, 0x3F, 0xFF, 0xBC, 0x07, 0xFF, 0xCF, 0x00, 0xFF, 0xC7,
  0xC0, 0x0F, 0xC1, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80,
  0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x03, 0xE1, 0xFE, 0x00, 0x78,
  0xFF, 0xE0, 0x0F, 0x1F, 0xFE, 0x01, 0xE7, 0xC3, 0xE0, 0x3C, 0xF0, 0x3E,
  0x07, 0xBE, 0x07, 0xC1, 0xE7, 0x80, 0x7F, 0xFC, 0xF0, 0x07, 0xFF, 0x1E,
  0x00, 0x7F, 0xC3, 0xC0, 0x07, 0xE0, 0x00,
};

const GFXglyph JetBrainsMono_LightItalic55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 33, 0, -1 },
  { 1, 13, 40, 33, 10, -40 },
  { 66, 18, 16, 33, 10, -40 },
  { 102, 32, 40, 33, 1, -40 },
  { 262, 28, 56, 33, 3, -48 },
  { 458, 38, 40, 33, -2, -40 },
  { 648, 30, 42, 33, 1, -41 },
  { 806, 7, 16, 33, 16, -40 },
  { 820, 23, 53, 33, 9, -46 },
  { 973, 22, 53, 33, 3, -46 },
  { 1119, 29, 29, 33, 3, -34 },
  { 1225, 26, 26, 33, 4, -31 },
  { 1310, 13, 17, 33, 6, -8 },
  { 1338, 18, 4, 33, 8, -20 },
  { 1347, 9, 9, 33, 10, -8 },
  { 1358, 32, 52, 33, 1, -46 },
  { 1566, 28, 42, 33, 3, -41 },
  { 1713, 25, 40, 33, 3, -40 },
  { 1838, 28, 41, 33, 3, -41 },
  { 1982, 28, 41, 33, 3, -40 },
  { 2126, 25, 40, 33, 4, -40 },
  { 2251, 27, 41, 33, 4, -40 },
  { 2390, 26, 41, 33, 3, -40 },
  { 2524, 26, 40, 33, 7, -40 },
  { 2654, 28, 42, 33, 3, -41 },
  { 2801, 27, 41, 33, 5, -41 },
  { 2940, 13, 32, 33, 10, -31 },
  { 2992, 17, 40, 33, 6, -31 },
  { 3077, 26, 29, 33, 5, -33 },
  { 3172, 26, 17, 33, 4, -27 },
  { 3228, 26, 29, 33, 3, -33 },
  { 3323, 22, 40, 33, 8, -40 },
  { 3433, 32, 51, 33, 1, -41 },
  { 3637, 27, 40, 33, 1, -40 },
  { 3772, 28, 40, 33, 3, -40 },
  { 3912, 27, 42, 33, 4, -41 },
  { 4054, 28, 40, 33, 3, -40 },
  { 4194, 29, 40, 33, 3, -40 },
  { 4339, 30, 40, 33, 3, -40 },
  { 4489, 27, 42, 33, 4, -41 },
  { 4631, 29, 40, 33, 3, -40 },
  { 4776, 27, 40, 33, 4, -40 },
  { 4911, 30, 41, 33, 1, -40 },
  { 5065, 31, 40, 33, 3, -40 },
  { 5220, 24, 40, 33, 4, -40 },
  { 5340, 31, 40, 33, 2, -40 },
  { 5495, 29, 40, 33, 3, -40 },
  { 5640, 27, 42, 33, 4, -41 },
  { 5782, 30, 40, 33, 3, -40 },
  { 5932, 27, 51, 33, 4, -41 },
  { 6105, 29, 40, 33, 3, -40 },
  { 6250, 28, 42, 33, 3, -41 },
  { 6397, 28, 40, 33, 6, -40 },
  { 6537, 28, 41, 33, 4, -40 },
  { 6681, 27, 40, 33, 7, -40 },
  { 6816, 31, 40, 33, 4, -40 },
  { 6971, 34, 40, 33, 0, -40 },
  { 7141, 29, 40, 33, 6, -40 },
  { 7286, 30, 40, 33, 2, -40 },
  { 7436, 21, 52, 33, 8, -46 },
  { 7573, 16, 52, 33, 9, -46 },
  { 7677, 21, 52, 33, 5, -46 },
  { 7814, 24, 21, 33, 5, -40 },
  { 7877, 27, 4, 33, 0, 1 },
  { 7891, 9, 8, 33, 15, -43 },
  { 7900, 26, 32, 33, 4, -31 },
  { 8004, 26, 41, 33, 3, -40 },
  { 8138, 26, 32, 33, 4, -31 },
  { 8242, 28, 41, 33, 4, -40 },
  { 8386, 25, 32, 33, 4, -31 },
  { 8486, 36, 50, 33, -2, -40 },
  { 8711, 26, 41, 33, 4, -31 },
  { 8845, 26, 40, 33, 3, -40 },
  { 8975, 26, 43, 33, 2, -43 },
  { 9115, 28, 53, 33, 1, -43 },
  { 9301, 29, 40, 33, 3, -40 },
  { 9446, 22, 40, 33, 6, -40 },
  { 9556, 30, 31, 33, 1, -31 },
  { 9673, 26, 31, 33, 3, -31 },
  { 9774, 25, 32, 33, 4, -31 },
  { 9874, 28, 41, 33, 1, -31 },
  { 10018, 26, 41, 33, 4, -31 },
  { 10152, 27, 31, 33, 4, -31 },
  { 10257, 26, 32, 33, 3, -31 },
  { 10361, 26, 39, 33, 5, -39 },
  { 10488, 26, 31, 33, 4, -30 },
  { 10589, 26, 30, 33, 6, -30 },
  { 10687, 28, 30, 33, 5, -30 },
  { 10792, 30, 30, 33, 1, -30 },
  { 10905, 26, 40, 33, 4, -30 },
  { 11035, 27, 30, 33, 3, -30 },
  { 11137, 28, 52, 33, 5, -46 },
  { 11319, 12, 52, 33, 11, -46 },
  { 11397, 27, 52, 33, 2, -46 },
  { 11573, 27, 11, 33, 4, -25 },
};

const GFXfont JetBrainsMono_LightItalic55pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_LightItalic55pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_LightItalic55pt7bGlyphs,
  0x20, 0x7E, 73
};

#endif // _JETBRAINSMONO_LIGHTITALIC55PT7B_H_
