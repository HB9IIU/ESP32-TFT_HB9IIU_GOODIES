#pragma once

// Auto-generated by fontMaker.py
#include <TFT_eSPI.h>

struct FontEntry
{
  const GFXfont *font;
  uint16_t sizePt;
  const char *name;
};

// Includes are in all_fonts.h (include that before this file)
static const FontEntry kFonts[] = {
  { &JetBrainsMono_LightItalic6pt7b, 6, "JetBrainsMono_LightItalic6pt7b" },
  { &JetBrainsMono_LightItalic7pt7b, 7, "JetBrainsMono_LightItalic7pt7b" },
  { &JetBrainsMono_LightItalic8pt7b, 8, "JetBrainsMono_LightItalic8pt7b" },
  { &JetBrainsMono_LightItalic9pt7b, 9, "JetBrainsMono_LightItalic9pt7b" },
  { &JetBrainsMono_LightItalic10pt7b, 10, "JetBrainsMono_LightItalic10pt7b" },
  { &JetBrainsMono_LightItalic11pt7b, 11, "JetBrainsMono_LightItalic11pt7b" },
  { &JetBrainsMono_LightItalic12pt7b, 12, "JetBrainsMono_LightItalic12pt7b" },
  { &JetBrainsMono_LightItalic13pt7b, 13, "JetBrainsMono_LightItalic13pt7b" },
  { &JetBrainsMono_LightItalic14pt7b, 14, "JetBrainsMono_LightItalic14pt7b" },
  { &JetBrainsMono_LightItalic15pt7b, 15, "JetBrainsMono_LightItalic15pt7b" },
  { &JetBrainsMono_LightItalic16pt7b, 16, "JetBrainsMono_LightItalic16pt7b" },
  { &JetBrainsMono_LightItalic17pt7b, 17, "JetBrainsMono_LightItalic17pt7b" },
  { &JetBrainsMono_LightItalic18pt7b, 18, "JetBrainsMono_LightItalic18pt7b" },
  { &JetBrainsMono_LightItalic19pt7b, 19, "JetBrainsMono_LightItalic19pt7b" },
  { &JetBrainsMono_LightItalic20pt7b, 20, "JetBrainsMono_LightItalic20pt7b" },
  { &JetBrainsMono_LightItalic21pt7b, 21, "JetBrainsMono_LightItalic21pt7b" },
  { &JetBrainsMono_LightItalic22pt7b, 22, "JetBrainsMono_LightItalic22pt7b" },
  { &JetBrainsMono_LightItalic23pt7b, 23, "JetBrainsMono_LightItalic23pt7b" },
  { &JetBrainsMono_LightItalic24pt7b, 24, "JetBrainsMono_LightItalic24pt7b" },
  { &JetBrainsMono_LightItalic25pt7b, 25, "JetBrainsMono_LightItalic25pt7b" },
  { &JetBrainsMono_LightItalic26pt7b, 26, "JetBrainsMono_LightItalic26pt7b" },
  { &JetBrainsMono_LightItalic27pt7b, 27, "JetBrainsMono_LightItalic27pt7b" },
  { &JetBrainsMono_LightItalic28pt7b, 28, "JetBrainsMono_LightItalic28pt7b" },
  { &JetBrainsMono_LightItalic29pt7b, 29, "JetBrainsMono_LightItalic29pt7b" },
  { &JetBrainsMono_LightItalic30pt7b, 30, "JetBrainsMono_LightItalic30pt7b" },
  { &JetBrainsMono_LightItalic31pt7b, 31, "JetBrainsMono_LightItalic31pt7b" },
  { &JetBrainsMono_LightItalic32pt7b, 32, "JetBrainsMono_LightItalic32pt7b" },
  { &JetBrainsMono_LightItalic33pt7b, 33, "JetBrainsMono_LightItalic33pt7b" },
  { &JetBrainsMono_LightItalic34pt7b, 34, "JetBrainsMono_LightItalic34pt7b" },
  { &JetBrainsMono_LightItalic35pt7b, 35, "JetBrainsMono_LightItalic35pt7b" },
  { &JetBrainsMono_LightItalic36pt7b, 36, "JetBrainsMono_LightItalic36pt7b" },
  { &JetBrainsMono_LightItalic37pt7b, 37, "JetBrainsMono_LightItalic37pt7b" },
  { &JetBrainsMono_LightItalic38pt7b, 38, "JetBrainsMono_LightItalic38pt7b" },
  { &JetBrainsMono_LightItalic39pt7b, 39, "JetBrainsMono_LightItalic39pt7b" },
  { &JetBrainsMono_LightItalic40pt7b, 40, "JetBrainsMono_LightItalic40pt7b" },
  { &JetBrainsMono_LightItalic41pt7b, 41, "JetBrainsMono_LightItalic41pt7b" },
  { &JetBrainsMono_LightItalic42pt7b, 42, "JetBrainsMono_LightItalic42pt7b" },
  { &JetBrainsMono_LightItalic43pt7b, 43, "JetBrainsMono_LightItalic43pt7b" },
  { &JetBrainsMono_LightItalic44pt7b, 44, "JetBrainsMono_LightItalic44pt7b" },
  { &JetBrainsMono_LightItalic45pt7b, 45, "JetBrainsMono_LightItalic45pt7b" },
  { &JetBrainsMono_LightItalic46pt7b, 46, "JetBrainsMono_LightItalic46pt7b" },
  { &JetBrainsMono_LightItalic47pt7b, 47, "JetBrainsMono_LightItalic47pt7b" },
  { &JetBrainsMono_LightItalic48pt7b, 48, "JetBrainsMono_LightItalic48pt7b" },
  { &JetBrainsMono_LightItalic49pt7b, 49, "JetBrainsMono_LightItalic49pt7b" },
  { &JetBrainsMono_LightItalic50pt7b, 50, "JetBrainsMono_LightItalic50pt7b" },
  { &JetBrainsMono_LightItalic51pt7b, 51, "JetBrainsMono_LightItalic51pt7b" },
  { &JetBrainsMono_LightItalic52pt7b, 52, "JetBrainsMono_LightItalic52pt7b" },
  { &JetBrainsMono_LightItalic53pt7b, 53, "JetBrainsMono_LightItalic53pt7b" },
  { &JetBrainsMono_LightItalic54pt7b, 54, "JetBrainsMono_LightItalic54pt7b" },
  { &JetBrainsMono_LightItalic55pt7b, 55, "JetBrainsMono_LightItalic55pt7b" },
  { &JetBrainsMono_LightItalic56pt7b, 56, "JetBrainsMono_LightItalic56pt7b" },
  { &JetBrainsMono_LightItalic57pt7b, 57, "JetBrainsMono_LightItalic57pt7b" },
  { &JetBrainsMono_LightItalic58pt7b, 58, "JetBrainsMono_LightItalic58pt7b" },
  { &JetBrainsMono_LightItalic59pt7b, 59, "JetBrainsMono_LightItalic59pt7b" },
  { &JetBrainsMono_LightItalic60pt7b, 60, "JetBrainsMono_LightItalic60pt7b" },
  { &JetBrainsMono_LightItalic61pt7b, 61, "JetBrainsMono_LightItalic61pt7b" },
  { &JetBrainsMono_LightItalic62pt7b, 62, "JetBrainsMono_LightItalic62pt7b" },
  { &JetBrainsMono_LightItalic63pt7b, 63, "JetBrainsMono_LightItalic63pt7b" },
  { &JetBrainsMono_LightItalic64pt7b, 64, "JetBrainsMono_LightItalic64pt7b" },
  { &JetBrainsMono_LightItalic65pt7b, 65, "JetBrainsMono_LightItalic65pt7b" },
  { &JetBrainsMono_LightItalic66pt7b, 66, "JetBrainsMono_LightItalic66pt7b" },
  { &JetBrainsMono_LightItalic67pt7b, 67, "JetBrainsMono_LightItalic67pt7b" },
  { &JetBrainsMono_LightItalic68pt7b, 68, "JetBrainsMono_LightItalic68pt7b" },
  { &JetBrainsMono_LightItalic69pt7b, 69, "JetBrainsMono_LightItalic69pt7b" },
  { &JetBrainsMono_LightItalic70pt7b, 70, "JetBrainsMono_LightItalic70pt7b" },
  { &JetBrainsMono_LightItalic71pt7b, 71, "JetBrainsMono_LightItalic71pt7b" },
  { &JetBrainsMono_LightItalic72pt7b, 72, "JetBrainsMono_LightItalic72pt7b" },
};
static constexpr size_t kFontCount = sizeof(kFonts) / sizeof(kFonts[0]);
