#ifndef _JETBRAINSMONO_LIGHTITALIC62PT7B_H_
#define _JETBRAINSMONO_LIGHTITALIC62PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-LightItalic.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_LightItalic62pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xE0, 0xFF,
  0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xC0, 0x7E, 0x00, 0x3F, 0x03, 0xF3, 0xE0,
  0x3F, 0x3E, 0x03, 0xF7, 0xE0, 0x3E, 0x7E, 0x03, 0xE7, 0xE0, 0x3E, 0x7C,
  0x03, 0xE7, 0xC0, 0x7E, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xCF,
  0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x78, 0xF8, 0x07, 0x8F, 0x80, 0x78,
  0xF0, 0x0F, 0x8F, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x1E, 0x00, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x01, 0xE0,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x78, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x3E, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x07, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x83, 0xC0, 0x0F, 0x00, 0x00, 0x7C, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x1E, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFE, 0x38, 0xFE,
  0x00, 0xF8, 0x38, 0x7E, 0x01, 0xF0, 0x38, 0x3F, 0x01, 0xF0, 0x78, 0x3F,
  0x03, 0xE0, 0x78, 0x1F, 0x03, 0xE0, 0x78, 0x1F, 0x03, 0xE0, 0x70, 0x1F,
  0x07, 0xE0, 0x70, 0x00, 0x07, 0xC0, 0x70, 0x00, 0x07, 0xE0, 0xF0, 0x00,
  0x07, 0xE0, 0xF0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x03, 0xF0, 0xE0, 0x00,
  0x03, 0xF8, 0xE0, 0x00, 0x01, 0xFE, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xDF, 0xE0,
  0x00, 0x03, 0xC7, 0xF0, 0x00, 0x03, 0xC3, 0xF0, 0x00, 0x03, 0x81, 0xF8,
  0x00, 0x03, 0x81, 0xF8, 0x00, 0x03, 0x80, 0xF8, 0x00, 0x03, 0x80, 0xF8,
  0x00, 0x07, 0x80, 0xF8, 0x7C, 0x07, 0x80, 0xF8, 0x7C, 0x07, 0x81, 0xF0,
  0x7C, 0x07, 0x01, 0xF0, 0x7C, 0x07, 0x01, 0xF0, 0x7C, 0x07, 0x03, 0xE0,
  0x7E, 0x0F, 0x07, 0xE0, 0x7F, 0x0F, 0x0F, 0xC0, 0x3F, 0xCF, 0x3F, 0x80,
  0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x03, 0xFF,
  0x00, 0x00, 0x78, 0x00, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0x80, 0x0F, 0xC7, 0xE0, 0x01, 0xF0, 0x03, 0xE0, 0x3C, 0x00, 0x7C,
  0x00, 0x78, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x03,
  0xE0, 0x1E, 0x00, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x00,
  0x78, 0x0F, 0x00, 0x01, 0xE0, 0x0F, 0x03, 0xE0, 0x00, 0x3C, 0x01, 0xE0,
  0x78, 0x00, 0x07, 0x80, 0x7C, 0x1E, 0x00, 0x00, 0xF0, 0x0F, 0x07, 0x80,
  0x00, 0x1E, 0x01, 0xE1, 0xE0, 0x00, 0x03, 0xE0, 0x78, 0x78, 0x00, 0x00,
  0x7F, 0xFF, 0x1F, 0x00, 0x00, 0x07, 0xFF, 0xC7, 0xC0, 0x00, 0x00, 0x7F,
  0xF0, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0xFF, 0x00, 0x00, 0x00, 0x78, 0x7F, 0xF8, 0x00, 0x00,
  0x1E, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0x87, 0xE3, 0xF0, 0x00, 0x01, 0xF1,
  0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x07, 0x80,
  0x78, 0x00, 0x03, 0xC1, 0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x01, 0xE0,
  0x00, 0x3C, 0x07, 0x80, 0x3C, 0x00, 0x0F, 0x80, 0xF0, 0x07, 0x80, 0x03,
  0xE0, 0x1E, 0x01, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x00, 0x1E, 0x00,
  0x78, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x3C, 0x00, 0x78, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0x00, 0x07, 0xFF, 0xE0,
  0x03, 0xC0, 0x00, 0x7F, 0xF8, 0x01, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x03, 0xF0, 0x0F,
  0xC0, 0x03, 0xF0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F,
  0xDF, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x0F, 0x8F, 0x83, 0xF0, 0x0F, 0x8F,
  0x80, 0xF8, 0x0F, 0x87, 0xC0, 0x7E, 0x07, 0xC3, 0xE0, 0x1F, 0x07, 0xC3,
  0xE0, 0x0F, 0xC7, 0xC1, 0xF0, 0x03, 0xE7, 0xE0, 0xF8, 0x00, 0xFB, 0xE0,
  0x7C, 0x00, 0x7F, 0xE0, 0x3E, 0x00, 0x1F, 0xE0, 0x1F, 0x00, 0x0F, 0xF0,
  0x0F, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x01, 0xF8, 0x07, 0xC0, 0x01, 0xFC,
  0x03, 0xE0, 0x00, 0xFF, 0x01, 0xF0, 0x00, 0xFF, 0xC0, 0xFC, 0x01, 0xFB,
  0xE0, 0x3F, 0x03, 0xF9, 0xF8, 0x1F, 0xFF, 0xF8, 0x7C, 0x07, 0xFF, 0xF8,
  0x3F, 0x01, 0xFF, 0xF8, 0x0F, 0x80, 0x7F, 0xF0, 0x03, 0xE0, 0x07, 0x00,
  0x00, 0x00, 0x3F, 0x3E, 0x3E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0xFC,
  0xFC, 0xFC, 0xF8, 0xF8, 0xF8, 0xF8, 0xF0, 0xF0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x08, 0x00, 0xF8, 0x00,
  0x8F, 0x80, 0x78, 0x03, 0xC7, 0xF0, 0x3C, 0x0F, 0xF7, 0xFE, 0x1E, 0x1F,
  0xFF, 0xFF, 0xCE, 0x3F, 0xFC, 0xFF, 0xF7, 0x7F, 0xF8, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF0,
  0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xF8,
  0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x04, 0x00, 0x08, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0x01, 0xFE,
  0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0x87, 0xF9, 0xFF, 0x3F, 0xF7, 0xFF, 0xFF, 0x9F, 0xF3, 0xFC, 0x3F, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFD,
  0xFF, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0xFC, 0x00, 0x3F, 0x01, 0xF0, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x00,
  0xF8, 0x7C, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x07,
  0x87, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7C,
  0x3E, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xE3,
  0xE0, 0x7C, 0x0F, 0x87, 0xC1, 0xFC, 0x1F, 0x0F, 0x83, 0xF8, 0x3E, 0x1F,
  0x07, 0xF0, 0x7C, 0x3E, 0x0F, 0xE0, 0xF8, 0x7C, 0x0F, 0x81, 0xF1, 0xF0,
  0x0E, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF8, 0x78, 0x00,
  0x01, 0xE1, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x03,
  0xF0, 0x3E, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xDF, 0x00, 0x07, 0xF9, 0xF0, 0x00, 0xFE, 0x1E, 0x00, 0x3F, 0xC3,
  0xE0, 0x03, 0xF0, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0x80, 0x3E, 0x00,
  0x60, 0x03, 0xE0, 0x04, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01,
  0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x1E, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x10, 0x7F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0x7E,
  0x00, 0x0F, 0x80, 0x7F, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0xF8, 0x1F, 0x80, 0x07, 0xC1, 0xF8, 0x00, 0x3C, 0x1F, 0x80,
  0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0xFC, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF1, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x7C, 0x00, 0x0F, 0x8F, 0xFF, 0x00, 0x1F, 0x3F, 0xFF,
  0x00, 0x3E, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0x7C, 0x1F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0x3F,
  0xF8, 0x00, 0xFB, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xF0, 0x7F,
  0xC0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x1F, 0x80, 0x01, 0xF8,
  0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3E, 0x7E,
  0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x0F, 0x9F, 0x00,
  0x00, 0x3E, 0x7C, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x1F, 0x1F, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xF0, 0x3F, 0xC0, 0x7F, 0x80,
  0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xC0, 0x00,
  0x0F, 0xBE, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x7C,
  0xF8, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xF1, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xEF, 0xFC, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3C, 0x03,
  0xE0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x03,
  0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0x80, 0x03, 0xE0, 0x1F,
  0x00, 0x03, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x03, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x3F,
  0xC0, 0x3F, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0xFC, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0xF9,
  0xF0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x3E, 0x78,
  0x00, 0x00, 0xFB, 0xF0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x1F, 0x1F, 0x00,
  0x00, 0xFC, 0x7C, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x1F, 0x87, 0xF0, 0x00,
  0xFC, 0x0F, 0xE0, 0x0F, 0xF0, 0x3F, 0xFB, 0xFF, 0x80, 0x7F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xCF, 0x80, 0x00, 0xB0, 0x7C, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0x81, 0xFF, 0x03, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0xFC, 0x03, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0x01, 0xFC, 0x00, 0x60, 0x00,
  0x00, 0x07, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x1F,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFE, 0x00, 0x04, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xE0, 0x3F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x0F, 0x80, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xF1, 0xE0, 0xF0, 0x01, 0xFF,
  0x9E, 0x0F, 0x00, 0x3F, 0xFD, 0xE0, 0xF0, 0x07, 0xFF, 0xDE, 0x1F, 0x00,
  0xFC, 0x0F, 0xE1, 0xF0, 0x0F, 0x80, 0x7E, 0x1F, 0x01, 0xF0, 0x03, 0xC1,
  0xE0, 0x1E, 0x00, 0x3C, 0x1E, 0x01, 0xE0, 0x03, 0xC1, 0xE0, 0x3E, 0x00,
  0x3C, 0x3E, 0x03, 0xE0, 0x07, 0xC3, 0xE0, 0x3E, 0x00, 0x7C, 0x3E, 0x03,
  0xC0, 0x07, 0xC3, 0xC0, 0x3C, 0x00, 0x78, 0x3C, 0x03, 0xC0, 0x07, 0x83,
  0xC0, 0x7C, 0x00, 0x78, 0x3C, 0x07, 0xC0, 0x0F, 0x87, 0xC0, 0x7C, 0x00,
  0xF8, 0x7C, 0x07, 0xC0, 0x0F, 0x87, 0xC0, 0x7C, 0x00, 0xF0, 0x78, 0x07,
  0xC0, 0x1F, 0x07, 0x80, 0x7C, 0x03, 0xF0, 0x78, 0x07, 0xF0, 0x6F, 0x0F,
  0x80, 0x3F, 0xFE, 0xF0, 0xF8, 0x01, 0xFF, 0xCF, 0x0F, 0x80, 0x0F, 0xF9,
  0xE0, 0xF8, 0x00, 0x18, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x0F, 0xBC, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x3E, 0x3C, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0x78, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x7C, 0x07, 0x80, 0x01, 0xF0, 0x1E, 0x00, 0x0F, 0x80, 0x78,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x00,
  0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x00, 0x1F, 0x00, 0x7C, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0xF0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xF8, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E,
  0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xE3, 0xF0, 0x00, 0x07, 0x8F,
  0x80, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7C, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFC, 0x01, 0xF0, 0x03, 0xFC, 0x01, 0xE0, 0x00, 0xFE, 0x03, 0xE0,
  0x00, 0x7E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF8, 0x07, 0x80,
  0x07, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0x00,
  0x07, 0xF0, 0x1F, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x01, 0xF8, 0x1F, 0x00,
  0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1E, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x03, 0xF0, 0x3C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0xE0, 0x7C, 0x00,
  0x1F, 0xC0, 0x7C, 0x03, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7E, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x00,
  0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0xF8, 0x1F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xC0, 0x7F, 0x00, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0x00, 0x7F, 0x80, 0x3C, 0x00, 0x3F,
  0x80, 0xF8, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x7E,
  0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x1E, 0x00, 0x01, 0xF0,
  0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x3E,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x0F, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C,
  0x0F, 0x80, 0x01, 0xF8, 0x1F, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x3F, 0x80,
  0x7C, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x7E, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x01, 0xFF, 0xFC, 0x3E,
  0x03, 0xFF, 0xF8, 0x7C, 0x07, 0xFF, 0xF0, 0xF8, 0x0F, 0xFF, 0xC1, 0xF0,
  0x1F, 0xFF, 0x83, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x1F, 0x00,
  0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x07,
  0xC0, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x1F, 0x00,
  0x01, 0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x03, 0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x07,
  0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x1F, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x01,
  0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0x3E, 0x01, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x1F, 0x00,
  0x01, 0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x20, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xF8, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x3F, 0x80,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x01,
  0xF0, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x1F, 0x00,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x0F, 0x80, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x3F, 0x00,
  0x01, 0xF0, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x01, 0xF0,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00,
  0x7C, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x3C, 0x00, 0x00, 0xF8, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0xEF, 0x00, 0x1E, 0xE0, 0x1D, 0xE0, 0x03, 0xFC, 0x07, 0xBC, 0x00,
  0xF7, 0x80, 0xF7, 0x80, 0x1E, 0xF0, 0x1E, 0xF0, 0x07, 0x9C, 0x03, 0xCE,
  0x00, 0xF7, 0x80, 0x79, 0xE0, 0x3C, 0xF0, 0x0F, 0x3C, 0x07, 0x9E, 0x01,
  0xE7, 0x81, 0xE3, 0xC0, 0x7C, 0xF0, 0x3C, 0xF8, 0x0F, 0x9E, 0x0F, 0x1F,
  0x01, 0xF1, 0xC1, 0xE3, 0xC0, 0x3C, 0x3C, 0x78, 0x78, 0x07, 0x87, 0x8F,
  0x1F, 0x00, 0xF0, 0xF3, 0xC3, 0xE0, 0x3E, 0x1E, 0x78, 0x7C, 0x07, 0xC3,
  0xCE, 0x0F, 0x80, 0xF8, 0x3B, 0xC1, 0xE0, 0x1F, 0x07, 0xF0, 0x7C, 0x03,
  0xE0, 0xFE, 0x0F, 0x80, 0x78, 0x1F, 0x81, 0xF0, 0x1F, 0x03, 0xF0, 0x3E,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x07, 0x80,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x7C,
  0x03, 0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x01, 0xF0, 0x0F, 0x80,
  0x00, 0x3E, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0xFE, 0x00, 0x07,
  0xC0, 0x7F, 0x00, 0x03, 0xC0, 0x3F, 0xC0, 0x03, 0xE0, 0x1F, 0xE0, 0x01,
  0xF0, 0x1F, 0xF0, 0x00, 0xF8, 0x0F, 0xF8, 0x00, 0x7C, 0x07, 0xFC, 0x00,
  0x3E, 0x03, 0xDF, 0x00, 0x1E, 0x01, 0xE7, 0x80, 0x1F, 0x00, 0xF3, 0xC0,
  0x0F, 0x80, 0xF9, 0xE0, 0x07, 0xC0, 0x7C, 0xF8, 0x03, 0xE0, 0x3E, 0x7C,
  0x01, 0xF0, 0x1F, 0x1E, 0x00, 0xF0, 0x0F, 0x8F, 0x00, 0xF8, 0x07, 0x87,
  0x80, 0x7C, 0x03, 0xC3, 0xE0, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x01, 0xF0,
  0x78, 0x0F, 0x80, 0xF8, 0x3C, 0x07, 0x80, 0x7C, 0x1E, 0x03, 0xC0, 0x3E,
  0x0F, 0x83, 0xE0, 0x1E, 0x03, 0xC1, 0xF0, 0x1F, 0x01, 0xE0, 0xF8, 0x0F,
  0x80, 0xF0, 0x7C, 0x07, 0xC0, 0x7C, 0x3E, 0x03, 0xE0, 0x3E, 0x1E, 0x01,
  0xF0, 0x0F, 0x1F, 0x00, 0xF0, 0x07, 0x8F, 0x80, 0xF8, 0x03, 0xC7, 0xC0,
  0x7C, 0x01, 0xF3, 0xE0, 0x3E, 0x00, 0xF9, 0xF0, 0x1F, 0x00, 0x3C, 0xF0,
  0x0F, 0x80, 0x1E, 0x78, 0x07, 0x80, 0x0F, 0x3C, 0x07, 0xC0, 0x07, 0xFE,
  0x03, 0xE0, 0x03, 0xFF, 0x01, 0xF0, 0x00, 0xFF, 0x80, 0xF8, 0x00, 0x7F,
  0x80, 0x7C, 0x00, 0x3F, 0xC0, 0x3E, 0x00, 0x1F, 0xE0, 0x1E, 0x00, 0x0F,
  0xF0, 0x1F, 0x00, 0x03, 0xF8, 0x0F, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7C, 0x00,
  0x3F, 0x01, 0xF0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x3F,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x16, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xF0, 0x01, 0xFF, 0x00, 0x78,
  0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x7E, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0xF8,
  0x0F, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x03, 0xF8, 0x0F, 0x80, 0x01, 0xFC, 0x03, 0xE0, 0x07, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0x80, 0x3F,
  0x00, 0xFC, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xE0,
  0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF8, 0x7C,
  0x00, 0x01, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x00,
  0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xE0, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0x7C, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C,
  0x1F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x3F, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x16, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F,
  0x00, 0x1F, 0xE0, 0x0F, 0x00, 0x03, 0xF8, 0x0F, 0x80, 0x00, 0xFC, 0x07,
  0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0xF8, 0x00, 0x07, 0xE0, 0x78, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x01, 0xF0,
  0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7E,
  0x07, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3F,
  0x01, 0xF0, 0x00, 0x3F, 0x80, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x03, 0xE0, 0x0F,
  0x80, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xF0, 0x03, 0xE0,
  0x00, 0xF8, 0x03, 0xE0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x7C, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0xF0, 0x1F,
  0x00, 0x01, 0xF8, 0x0F, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xF8, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3F,
  0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF0,
  0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0,
  0x7E, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x0F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80,
  0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x0F,
  0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x0F,
  0x80, 0x00, 0x78, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x0F,
  0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x1F,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0x7E,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3E, 0xF8, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0xF8, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C,
  0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x07,
  0xC0, 0x01, 0xF0, 0x0F, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x03, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x7C,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x78, 0x07, 0x80, 0x01, 0xE0, 0x3E, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x7C,
  0x7C, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x0F, 0x3E,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x01,
  0xF3, 0xE0, 0x0F, 0xC0, 0x1E, 0x3E, 0x00, 0xFC, 0x01, 0xE3, 0xE0, 0x1F,
  0xC0, 0x3E, 0x3E, 0x01, 0xDC, 0x03, 0xE3, 0xE0, 0x1F, 0xC0, 0x3C, 0x3C,
  0x03, 0xFC, 0x03, 0xC3, 0xC0, 0x3B, 0xC0, 0x7C, 0x3C, 0x03, 0xBC, 0x07,
  0x83, 0xC0, 0x3B, 0x80, 0x78, 0x3C, 0x07, 0xB8, 0x0F, 0x83, 0xC0, 0x73,
  0x80, 0xF8, 0x3C, 0x07, 0x38, 0x0F, 0x03, 0xC0, 0xF3, 0x80, 0xF0, 0x3C,
  0x0E, 0x38, 0x1F, 0x03, 0xC0, 0xE3, 0x81, 0xE0, 0x3C, 0x0E, 0x38, 0x1E,
  0x03, 0xC1, 0xE3, 0x81, 0xE0, 0x7C, 0x1C, 0x38, 0x3E, 0x07, 0xC1, 0xC3,
  0x83, 0xC0, 0x7C, 0x3C, 0x38, 0x3C, 0x07, 0xC3, 0x83, 0x87, 0xC0, 0x7C,
  0x38, 0x38, 0x7C, 0x07, 0xC3, 0x83, 0x87, 0x80, 0x7C, 0x78, 0x38, 0x78,
  0x07, 0xC7, 0x03, 0x8F, 0x80, 0x78, 0x70, 0x38, 0xF0, 0x07, 0x8F, 0x03,
  0x8F, 0x00, 0x78, 0xE0, 0x38, 0xF0, 0x07, 0x8E, 0x03, 0x9F, 0x00, 0x78,
  0xE0, 0x79, 0xE0, 0x07, 0x9E, 0x07, 0x9E, 0x00, 0x79, 0xC0, 0x79, 0xE0,
  0x07, 0x9C, 0x07, 0xBC, 0x00, 0x7B, 0xC0, 0x7B, 0xC0, 0x07, 0xB8, 0x07,
  0x3C, 0x00, 0x7B, 0x80, 0x73, 0xC0, 0x07, 0xB8, 0x07, 0x78, 0x00, 0x7F,
  0x80, 0x77, 0x80, 0x07, 0xF0, 0x07, 0x78, 0x00, 0x7F, 0x00, 0x7F, 0x80,
  0x07, 0xF0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x7D, 0xF0, 0x00, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0x0F, 0x8F, 0x80,
  0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x0F, 0x80,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3E, 0x7C, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00,
  0xF8, 0x3E, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03,
  0xE0, 0x1F, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x0F, 0x80, 0x3E,
  0x00, 0x07, 0xC0, 0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x3E, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xF1,
  0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xE0, 0xF8, 0x00,
  0x78, 0x0F, 0x00, 0x1F, 0x01, 0xE0, 0x07, 0xC0, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x3E, 0x00, 0x78, 0x0F, 0x80, 0x0F, 0x01, 0xF0, 0x01, 0xF0, 0x7C,
  0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x0F,
  0x9F, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x1F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8,
  0x3F, 0x07, 0xC0, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xFF, 0xE1, 0xF0, 0x07, 0xFF, 0xC7, 0xC0, 0x7F,
  0xFF, 0x9F, 0x03, 0xFF, 0xFE, 0xF8, 0x1F, 0xC0, 0x3F, 0xE0, 0x7E, 0x00,
  0x3F, 0x83, 0xF0, 0x00, 0xFE, 0x0F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x07,
  0xE1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x3E,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x1F, 0x00,
  0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x3E, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0xFC, 0x1F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0xC1,
  0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xF8, 0x0F, 0xFF, 0xFB, 0xE0, 0x1F,
  0xFF, 0xCF, 0x80, 0x3F, 0xFE, 0x3E, 0x00, 0x7F, 0xF0, 0xF8, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xF0, 0x7F, 0xE0, 0x07,
  0xC7, 0xFF, 0xE0, 0x1F, 0x3F, 0xFF, 0xC0, 0x7D, 0xFF, 0xFF, 0x01, 0xFF,
  0x00, 0xFE, 0x07, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xE0, 0xFC, 0x00,
  0x0F, 0x83, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0xF8,
  0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x1F,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x1F,
  0x07, 0xF0, 0x00, 0xFC, 0x1F, 0xE0, 0x07, 0xE0, 0x7F, 0xC0, 0x3F, 0x81,
  0xF7, 0xFF, 0xFC, 0x07, 0xDF, 0xFF, 0xE0, 0x1E, 0x3F, 0xFE, 0x00, 0xF8,
  0x7F, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0x3F,
  0x0F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3E, 0x3E,
  0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0xF8, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x01, 0xFC, 0x07,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x7C, 0x00, 0x3F, 0xF8, 0x7C, 0x00, 0x7F, 0xFC, 0x7C, 0x01, 0xFF,
  0xFE, 0x7C, 0x03, 0xFF, 0xFE, 0xF8, 0x07, 0xF0, 0x0F, 0xF8, 0x07, 0xE0,
  0x03, 0xF8, 0x0F, 0xC0, 0x03, 0xF8, 0x0F, 0x80, 0x01, 0xF8, 0x1F, 0x80,
  0x01, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0xC0, 0x7C, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0xFF, 0x80, 0x3F, 0xFF, 0xEF, 0x80, 0x1F, 0xFF, 0xCF, 0x80, 0x0F, 0xFF,
  0x8F, 0x80, 0x07, 0xFF, 0x0F, 0x80, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xF7, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC1,
  0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x3C, 0x3E, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00,
  0xF8, 0xF8, 0x00, 0x07, 0xC7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x3F, 0x00, 0x0F, 0x80, 0xFC,
  0x01, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFF, 0x87, 0xC0, 0x3F,
  0xFE, 0x3E, 0x07, 0xFF, 0xF9, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xF0, 0x07,
  0xF8, 0x3F, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0xFE, 0x1F, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00,
  0x7C, 0x7C, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x3F, 0x1F, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0xFC, 0x1F, 0x80, 0x0F, 0xE0, 0xFE, 0x01, 0xDF, 0x03, 0xFF, 0xFE, 0xF8,
  0x1F, 0xFF, 0xE7, 0x80, 0x7F, 0xFE, 0x7C, 0x01, 0xFF, 0xC3, 0xE0, 0x01,
  0xF0, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x1F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0xF0, 0xFF, 0xE0, 0x07,
  0xC7, 0xFF, 0xE0, 0x1F, 0x3F, 0xFF, 0xC0, 0x7D, 0xF9, 0xFF, 0x01, 0xFF,
  0x00, 0xFE, 0x07, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xE0, 0xFC, 0x00,
  0x0F, 0x83, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0xF8,
  0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x1F,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1E, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x3E, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x03,
  0xF0, 0x0F, 0x80, 0x03, 0xF0, 0x07, 0xC0, 0x03, 0xF0, 0x03, 0xE0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x01,
  0xF8, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x1F, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x07,
  0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x3E, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x38,
  0x03, 0xCF, 0xF0, 0xFF, 0x01, 0xEF, 0xFC, 0xFF, 0x80, 0xF7, 0xFE, 0xFF,
  0xE0, 0xFE, 0x1F, 0x63, 0xF0, 0x7E, 0x07, 0xE0, 0xF8, 0x3E, 0x03, 0xE0,
  0x3C, 0x1F, 0x01, 0xE0, 0x1E, 0x0F, 0x00, 0xF0, 0x0F, 0x07, 0x80, 0x78,
  0x07, 0x87, 0xC0, 0x3C, 0x07, 0xC3, 0xE0, 0x3E, 0x03, 0xE1, 0xF0, 0x1F,
  0x01, 0xF0, 0xF8, 0x0F, 0x00, 0xF8, 0x78, 0x07, 0x80, 0x78, 0x3C, 0x03,
  0xC0, 0x3C, 0x3E, 0x01, 0xE0, 0x3E, 0x1F, 0x00, 0xF0, 0x1F, 0x0F, 0x80,
  0xF8, 0x0F, 0x87, 0xC0, 0x78, 0x07, 0xC3, 0xC0, 0x3C, 0x03, 0xC1, 0xE0,
  0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x00, 0xF0, 0xF8, 0x07, 0x80, 0xF8, 0x7C,
  0x07, 0xC0, 0x7C, 0x3E, 0x03, 0xC0, 0x3E, 0x1F, 0x01, 0xE0, 0x1F, 0x0F,
  0x00, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x07, 0x87, 0xC0, 0x3C, 0x07, 0xC3,
  0xE0, 0x1E, 0x03, 0xE1, 0xF0, 0x1E, 0x01, 0xF0, 0xF8, 0x0F, 0x00, 0xF8,
  0x78, 0x07, 0x80, 0x78, 0x3C, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x0F, 0x8F, 0xFE, 0x00, 0x7C, 0x7F, 0xFE, 0x01, 0xF3, 0xFF, 0xFC,
  0x07, 0xDF, 0x9F, 0xF0, 0x1F, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0xF8, 0x3F, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00,
  0x03, 0xE0, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0xF8, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C,
  0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x0F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07,
  0xC1, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC1, 0xF8,
  0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0xFC, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x7C, 0x3E, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xF8,
  0xF8, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF1, 0xF0,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0x3E, 0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C,
  0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x1F, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x80, 0xFE, 0x03,
  0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x7F, 0xE0, 0x01, 0xF1, 0xFF, 0xF8, 0x01, 0xF3, 0xFF, 0xFC,
  0x01, 0xF7, 0xFF, 0xFC, 0x01, 0xFF, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x80, 0x01, 0xF0,
  0x1F, 0xC0, 0x03, 0xF0, 0x1F, 0xE0, 0x07, 0xE0, 0x1F, 0xF0, 0x0F, 0xE0,
  0x1F, 0x7F, 0xFF, 0xC0, 0x1F, 0x7F, 0xFF, 0x80, 0x3E, 0x3F, 0xFF, 0x00,
  0x3E, 0x1F, 0xFC, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0xE1, 0xF0, 0x0F, 0xFF, 0xC7, 0xC0,
  0x7F, 0xFF, 0x9E, 0x03, 0xFF, 0xFE, 0xF8, 0x1F, 0xC0, 0x3F, 0xE0, 0x7E,
  0x00, 0x3F, 0x83, 0xF0, 0x00, 0xFE, 0x0F, 0x80, 0x01, 0xF8, 0x7C, 0x00,
  0x07, 0xE1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1E, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C,
  0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x1F,
  0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x3C, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0xFC, 0x1F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0xFE, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xFF, 0xFB, 0xE0,
  0x1F, 0xFF, 0xCF, 0x80, 0x3F, 0xFE, 0x3E, 0x00, 0x7F, 0xE0, 0xF8, 0x00,
  0x1C, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xC7, 0xFF,
  0x00, 0x0F, 0x1F, 0xFF, 0x80, 0x3E, 0x7F, 0xFF, 0x80, 0x7D, 0xF9, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0x01, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E,
  0x07, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0,
  0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x83,
  0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x03, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE1, 0xF0,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF1, 0xF0,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xC1, 0xF8, 0x00,
  0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0x80, 0x00, 0x7C,
  0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xC1, 0xF0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x7C,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x1F, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3F, 0x07, 0xC0, 0x00,
  0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x7F, 0x00, 0x3F, 0x00, 0xFE, 0x03, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0x7E, 0x3C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x01,
  0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0,
  0x78, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x3E, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0xF0, 0x0F,
  0x80, 0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x3C, 0x1F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F,
  0x8F, 0x80, 0x00, 0x7C, 0x78, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F, 0x3C,
  0x00, 0x00, 0x7B, 0xE0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xF0, 0x03, 0xE0, 0x0F, 0xF0, 0x07, 0xE0, 0x0F, 0xF0, 0x07, 0xE0, 0x1F,
  0xF0, 0x07, 0xE0, 0x1E, 0xF0, 0x0E, 0xE0, 0x1E, 0xF0, 0x0E, 0xE0, 0x3E,
  0xF0, 0x0E, 0xE0, 0x3C, 0xF0, 0x1E, 0xE0, 0x3C, 0xF0, 0x1C, 0xE0, 0x3C,
  0xF0, 0x1C, 0xE0, 0x78, 0xF0, 0x3C, 0xE0, 0x78, 0xF0, 0x38, 0xE0, 0x78,
  0xF0, 0x38, 0xE0, 0xF0, 0xF0, 0x78, 0xE0, 0xF0, 0xF0, 0x70, 0xE0, 0xF0,
  0xF0, 0x70, 0xE1, 0xE0, 0xF0, 0xF0, 0xE1, 0xE0, 0xF0, 0xE0, 0xE1, 0xE0,
  0xF0, 0xE0, 0xE3, 0xC0, 0xF1, 0xE0, 0xE3, 0xC0, 0xF1, 0xC0, 0xE3, 0xC0,
  0xF1, 0xC0, 0xE7, 0x80, 0xF3, 0xC0, 0xE7, 0x80, 0xF3, 0x80, 0xE7, 0x80,
  0xF3, 0x80, 0xE7, 0x00, 0xF7, 0x80, 0xEF, 0x00, 0xF7, 0x00, 0xEF, 0x00,
  0xF7, 0x00, 0xEE, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x07,
  0xE0, 0x1F, 0x80, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x00,
  0xF8, 0xFC, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x0F, 0xCF,
  0x80, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0xF8,
  0x1F, 0x80, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x1F, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0xF8, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3E, 0x3E, 0x00,
  0x01, 0xE1, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07,
  0xC3, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00,
  0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x83,
  0xF0, 0x03, 0xFC, 0x1F, 0xC0, 0x3B, 0xE0, 0xFF, 0xFF, 0xDE, 0x03, 0xFF,
  0xFD, 0xF0, 0x0F, 0xFF, 0xCF, 0x80, 0x1F, 0xF8, 0x7C, 0x00, 0x0C, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x3C, 0x1F, 0xF8, 0x00, 0xF1, 0xFF, 0xF0, 0x03, 0xC7, 0xFF, 0xC0, 0x1F,
  0x3E, 0x1F, 0x80, 0x7D, 0xF0, 0x3F, 0x01, 0xF7, 0xC0, 0x7C, 0x07, 0x9F,
  0x01, 0xF8, 0x3E, 0x78, 0x03, 0xFF, 0xF1, 0xE0, 0x07, 0xFF, 0xCF, 0x80,
  0x0F, 0xFE, 0x3E, 0x00, 0x1F, 0xE0,
};

const GFXglyph JetBrainsMono_LightItalic62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 37, 0, -1 },
  { 1, 14, 45, 37, 12, -45 },
  { 80, 20, 18, 37, 12, -45 },
  { 125, 36, 45, 37, 1, -45 },
  { 328, 32, 63, 37, 3, -54 },
  { 580, 43, 46, 37, -2, -46 },
  { 828, 33, 47, 37, 2, -46 },
  { 1022, 8, 18, 37, 18, -45 },
  { 1040, 26, 60, 37, 10, -52 },
  { 1235, 25, 60, 37, 3, -52 },
  { 1423, 33, 32, 37, 3, -38 },
  { 1555, 30, 29, 37, 4, -35 },
  { 1664, 16, 19, 37, 6, -9 },
  { 1702, 20, 5, 37, 9, -23 },
  { 1715, 11, 10, 37, 11, -9 },
  { 1729, 37, 58, 37, 1, -51 },
  { 1998, 31, 47, 37, 4, -46 },
  { 2181, 28, 45, 37, 3, -45 },
  { 2339, 32, 46, 37, 3, -46 },
  { 2523, 32, 46, 37, 3, -45 },
  { 2707, 29, 45, 37, 4, -45 },
  { 2871, 31, 46, 37, 4, -45 },
  { 3050, 30, 46, 37, 3, -45 },
  { 3223, 29, 45, 37, 8, -45 },
  { 3387, 32, 47, 37, 3, -46 },
  { 3575, 30, 46, 37, 6, -46 },
  { 3748, 15, 36, 37, 11, -35 },
  { 3816, 19, 45, 37, 7, -35 },
  { 3923, 30, 33, 37, 5, -37 },
  { 4047, 30, 19, 37, 4, -30 },
  { 4119, 30, 33, 37, 3, -37 },
  { 4243, 25, 45, 37, 9, -45 },
  { 4384, 36, 57, 37, 1, -46 },
  { 4641, 30, 45, 37, 1, -45 },
  { 4810, 32, 45, 37, 3, -45 },
  { 4990, 31, 47, 37, 4, -46 },
  { 5173, 31, 45, 37, 3, -45 },
  { 5348, 33, 45, 37, 4, -45 },
  { 5534, 34, 45, 37, 3, -45 },
  { 5726, 31, 47, 37, 4, -46 },
  { 5909, 33, 45, 37, 3, -45 },
  { 6095, 31, 45, 37, 4, -45 },
  { 6270, 34, 46, 37, 1, -45 },
  { 6466, 35, 45, 37, 3, -45 },
  { 6663, 27, 45, 37, 4, -45 },
  { 6815, 35, 45, 37, 2, -45 },
  { 7012, 33, 45, 37, 3, -45 },
  { 7198, 31, 47, 37, 4, -46 },
  { 7381, 34, 45, 37, 3, -45 },
  { 7573, 31, 57, 37, 4, -46 },
  { 7794, 33, 45, 37, 3, -45 },
  { 7980, 32, 47, 37, 3, -46 },
  { 8168, 31, 45, 37, 7, -45 },
  { 8343, 32, 46, 37, 4, -45 },
  { 8527, 30, 45, 37, 8, -45 },
  { 8696, 36, 45, 37, 4, -45 },
  { 8899, 38, 45, 37, 0, -45 },
  { 9113, 32, 45, 37, 7, -45 },
  { 9293, 33, 45, 37, 3, -45 },
  { 9479, 24, 58, 37, 9, -51 },
  { 9653, 18, 58, 37, 10, -51 },
  { 9784, 24, 58, 37, 6, -51 },
  { 9958, 27, 24, 37, 6, -45 },
  { 10039, 31, 4, 37, 0, 2 },
  { 10055, 10, 9, 37, 17, -49 },
  { 10067, 30, 36, 37, 4, -35 },
  { 10202, 30, 46, 37, 3, -45 },
  { 10375, 29, 36, 37, 4, -35 },
  { 10506, 32, 46, 37, 4, -45 },
  { 10690, 29, 36, 37, 4, -35 },
  { 10821, 42, 56, 37, -3, -45 },
  { 11115, 29, 46, 37, 5, -35 },
  { 11282, 30, 45, 37, 3, -45 },
  { 11451, 30, 48, 37, 2, -48 },
  { 11631, 32, 59, 37, 1, -48 },
  { 11867, 33, 45, 37, 3, -45 },
  { 12053, 26, 45, 37, 6, -45 },
  { 12200, 33, 35, 37, 2, -35 },
  { 12345, 30, 35, 37, 3, -35 },
  { 12477, 29, 36, 37, 4, -35 },
  { 12608, 32, 46, 37, 1, -35 },
  { 12792, 30, 46, 37, 4, -35 },
  { 12965, 31, 35, 37, 4, -35 },
  { 13101, 29, 36, 37, 4, -35 },
  { 13232, 29, 43, 37, 6, -43 },
  { 13388, 30, 35, 37, 4, -34 },
  { 13520, 29, 34, 37, 7, -34 },
  { 13644, 32, 34, 37, 5, -34 },
  { 13780, 34, 34, 37, 1, -34 },
  { 13925, 29, 45, 37, 5, -34 },
  { 14089, 30, 34, 37, 3, -34 },
  { 14217, 31, 58, 37, 6, -51 },
  { 14442, 14, 58, 37, 12, -51 },
  { 14544, 31, 58, 37, 2, -51 },
  { 14769, 30, 12, 37, 4, -28 },
};

const GFXfont JetBrainsMono_LightItalic62pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_LightItalic62pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_LightItalic62pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _JETBRAINSMONO_LIGHTITALIC62PT7B_H_
