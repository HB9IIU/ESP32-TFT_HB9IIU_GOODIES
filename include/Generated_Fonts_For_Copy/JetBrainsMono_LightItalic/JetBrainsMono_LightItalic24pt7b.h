#ifndef _JETBRAINSMONO_LIGHTITALIC24PT7B_H_
#define _JETBRAINSMONO_LIGHTITALIC24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-LightItalic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_LightItalic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xCE, 0x73, 0x18, 0xC6, 0x31, 0x08, 0xC6, 0x00, 0x08, 0xE7,
  0x00, 0xE7, 0x8F, 0x1E, 0x3C, 0x78, 0xA1, 0x46, 0x03, 0x18, 0x08, 0x60,
  0x61, 0x01, 0x8C, 0x04, 0x30, 0xFF, 0xF7, 0xFF, 0x82, 0x18, 0x18, 0x40,
  0x63, 0x01, 0x0C, 0x0C, 0x20, 0xFF, 0xF1, 0x86, 0x06, 0x10, 0x10, 0xC0,
  0xC3, 0x03, 0x18, 0x00, 0x00, 0x80, 0x04, 0x00, 0x20, 0x07, 0x80, 0xFF,
  0x0E, 0x98, 0x64, 0xC6, 0x26, 0x31, 0x01, 0xD8, 0x06, 0xC0, 0x3E, 0x00,
  0x7C, 0x01, 0x70, 0x09, 0x80, 0xCC, 0xC6, 0x66, 0x23, 0x19, 0x38, 0xFF,
  0x83, 0xF0, 0x02, 0x00, 0x30, 0x01, 0x80, 0x02, 0x01, 0x87, 0xC1, 0x86,
  0x21, 0x82, 0x10, 0x81, 0x18, 0x81, 0x8C, 0xC0, 0xC6, 0xC0, 0x3E, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x4F, 0x00, 0x4F, 0x80, 0x6C, 0x60, 0x66,
  0x30, 0x62, 0x10, 0x61, 0x08, 0x20, 0xDC, 0x60, 0x3C, 0x00, 0x03, 0x80,
  0x7F, 0x06, 0x18, 0x30, 0xC1, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x3C,
  0x03, 0xB0, 0xD9, 0x8D, 0x86, 0xCC, 0x3C, 0x60, 0xE3, 0x06, 0x18, 0x78,
  0xFE, 0x63, 0xE3, 0x80, 0x6F, 0xED, 0xB6, 0x00, 0xC0, 0xF0, 0x60, 0x30,
  0x18, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10,
  0x0C, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x40,
  0x0C, 0x03, 0x80, 0x30, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x03, 0x01, 0xC0, 0x60,
  0x30, 0x38, 0x3C, 0x0C, 0x00, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x06,
  0x31, 0xFD, 0x7C, 0x7F, 0x00, 0xC0, 0x0D, 0x00, 0xCC, 0x0C, 0x70, 0xE1,
  0x82, 0x08, 0x00, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x61, 0xFF, 0xFF,
  0xF8, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x00, 0x1C, 0x71, 0x8E, 0x31,
  0xC6, 0x30, 0x7F, 0xFF, 0x27, 0xF7, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x00, 0x03, 0xC0, 0x7F, 0x07, 0x0C, 0x70, 0x63, 0x01, 0x18, 0x18,
  0xC0, 0xC6, 0x06, 0x67, 0x33, 0x39, 0x98, 0x8C, 0xC0, 0xC6, 0x06, 0x30,
  0x31, 0x81, 0x8C, 0x18, 0x7B, 0x81, 0xF8, 0x00, 0x01, 0xC0, 0x78, 0x3E,
  0x1C, 0xC3, 0x18, 0x43, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0x80, 0x30, 0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0x7F,
  0x06, 0x0C, 0x60, 0x63, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xFF,
  0xE7, 0xFF, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x38,
  0x06, 0x00, 0x78, 0x07, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x6C, 0x06,
  0xC0, 0xE6, 0x0C, 0x7F, 0x83, 0xF0, 0x00, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x70, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xCE, 0x1B, 0x83, 0x60, 0x6F, 0xFD,
  0xFF, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x3F, 0xE7, 0xFC, 0xC0, 0x18,
  0x03, 0x00, 0xC0, 0x18, 0x83, 0x7C, 0x71, 0xCC, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0xB0, 0x36, 0x0C, 0xF7, 0x0F, 0xC0, 0x00, 0xC0, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0xB8, 0x3F, 0xE3, 0x06, 0x60,
  0x66, 0x03, 0x40, 0x2C, 0x06, 0xC0, 0x66, 0x0C, 0x7B, 0xC3, 0xF0, 0x7F,
  0xFF, 0xFE, 0xC0, 0x6C, 0x06, 0xC0, 0xC0, 0x1C, 0x01, 0x80, 0x30, 0x03,
  0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x60,
  0x06, 0x00, 0x03, 0xC0, 0xFE, 0x1C, 0x31, 0x83, 0x30, 0x33, 0x03, 0x18,
  0x61, 0xCC, 0x0F, 0x80, 0xF8, 0x38, 0xC7, 0x06, 0x60, 0x66, 0x06, 0x40,
  0x66, 0x0C, 0x7B, 0xC3, 0xF0, 0x07, 0x81, 0xFC, 0x38, 0x67, 0x06, 0x60,
  0x36, 0x03, 0x40, 0x6E, 0x06, 0x60, 0xE7, 0x1C, 0x3F, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x3C, 0xF3, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x3C, 0x70, 0x1E, 0x3C, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x38, 0xE1, 0x87, 0x0C, 0x38, 0x60, 0x80, 0x00, 0x30, 0x0E,
  0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0,
  0x03, 0xC0, 0x0C, 0x7F, 0xEF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF7, 0xFE, 0x30, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00,
  0x60, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x0C, 0x00, 0x78, 0x3F, 0x01, 0xC0,
  0x70, 0x18, 0x0C, 0x06, 0x06, 0x06, 0x1E, 0x18, 0x0C, 0x06, 0x00, 0x00,
  0x00, 0x80, 0xE0, 0x70, 0x00, 0x01, 0xE0, 0x1F, 0xE0, 0xC1, 0xC6, 0x03,
  0x10, 0x0C, 0xC0, 0x33, 0x06, 0xCC, 0x7F, 0x23, 0x0D, 0x8C, 0x36, 0x30,
  0x98, 0xC2, 0x62, 0x19, 0x98, 0x64, 0x61, 0x90, 0xFE, 0xC1, 0x83, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x38, 0x00, 0x7C, 0x00, 0x00, 0xC0, 0x1C, 0x01,
  0xC0, 0x36, 0x03, 0x60, 0x26, 0x06, 0x60, 0x66, 0x0C, 0x60, 0xC6, 0x18,
  0x61, 0x82, 0x1F, 0xE3, 0x03, 0x30, 0x36, 0x03, 0x60, 0x3C, 0x03, 0x1F,
  0x00, 0xFF, 0x06, 0x1C, 0x20, 0x63, 0x03, 0x18, 0x18, 0xC0, 0xC6, 0x0C,
  0x3F, 0xC1, 0xFE, 0x18, 0x18, 0xC0, 0xC6, 0x06, 0x30, 0x31, 0x81, 0x8C,
  0x18, 0x7F, 0xC7, 0xF8, 0x00, 0x07, 0x81, 0xFC, 0x38, 0x63, 0x06, 0x60,
  0x66, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x0C, 0xC0, 0xCC, 0x18, 0xF7, 0x87, 0xE0, 0x1F, 0x01, 0xFE, 0x18,
  0x71, 0x03, 0x30, 0x33, 0x03, 0x30, 0x33, 0x03, 0x30, 0x33, 0x02, 0x60,
  0x66, 0x06, 0x60, 0x66, 0x06, 0x60, 0xC6, 0x1C, 0xFF, 0x8F, 0xE0, 0x1F,
  0xF8, 0xFF, 0xC6, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x3F, 0xE1, 0xFF, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x1F, 0xF8, 0xFF, 0xC6, 0x00, 0x30, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x3F, 0xE1, 0xFF, 0x08, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x00, 0x07,
  0x81, 0xFC, 0x38, 0x63, 0x06, 0x60, 0x66, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x04, 0x7E, 0xC7, 0xEC, 0x0C, 0xC0, 0xCC, 0x0C, 0xC0, 0xCC, 0x18, 0xF7,
  0x87, 0xE0, 0x18, 0x18, 0xC0, 0xC6, 0x04, 0x30, 0x63, 0x03, 0x18, 0x18,
  0xC0, 0xC6, 0x06, 0x3F, 0xF1, 0xFF, 0x18, 0x18, 0xC0, 0xC6, 0x06, 0x30,
  0x31, 0x81, 0x8C, 0x18, 0x40, 0xC6, 0x06, 0x00, 0x3F, 0xF3, 0xFE, 0x03,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0xFF, 0x8F, 0xF8, 0x03,
  0xF8, 0x1F, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x60, 0x63, 0x03, 0x18,
  0x38, 0xFF, 0x83, 0xF8, 0x00, 0x18, 0x0C, 0x60, 0x61, 0x83, 0x04, 0x0C,
  0x30, 0x60, 0xC3, 0x03, 0x0C, 0x0C, 0x60, 0x3F, 0x00, 0xFC, 0x06, 0x18,
  0x18, 0x60, 0x61, 0x81, 0x83, 0x06, 0x0C, 0x18, 0x30, 0xC0, 0x63, 0x01,
  0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x00, 0xFF, 0xFF, 0xF0,
  0x18, 0x19, 0xC1, 0xCF, 0x0E, 0x78, 0xF3, 0xC5, 0x9A, 0x68, 0x92, 0x44,
  0xB6, 0x67, 0x33, 0x39, 0x98, 0x0C, 0xC0, 0x46, 0x06, 0x20, 0x33, 0x01,
  0x98, 0x0C, 0xC0, 0x66, 0x03, 0x00, 0x1C, 0x18, 0xE0, 0xC7, 0x06, 0x38,
  0x23, 0x43, 0x1B, 0x18, 0xD8, 0xC6, 0xC6, 0x32, 0x31, 0x11, 0x18, 0xD8,
  0xC6, 0xC6, 0x36, 0x30, 0xB1, 0x85, 0x88, 0x38, 0xC1, 0xC6, 0x0E, 0x00,
  0x07, 0x83, 0xF8, 0xE1, 0x98, 0x36, 0x06, 0xC0, 0xD8, 0x1B, 0x03, 0x60,
  0x68, 0x0B, 0x03, 0x60, 0x6C, 0x0D, 0x81, 0xB0, 0x36, 0x0C, 0xF7, 0x0F,
  0xC0, 0x1F, 0x80, 0xFF, 0x86, 0x0E, 0x20, 0x33, 0x01, 0x98, 0x0C, 0xC0,
  0x66, 0x06, 0x30, 0x71, 0xFF, 0x1F, 0xC0, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x07, 0x81, 0xFC, 0x38, 0x63,
  0x06, 0x60, 0x66, 0x06, 0x60, 0x66, 0x06, 0x40, 0x6C, 0x06, 0xC0, 0x4C,
  0x0C, 0xC0, 0xCC, 0x0C, 0xC0, 0xCC, 0x18, 0xF7, 0x07, 0xE0, 0x06, 0x00,
  0x60, 0x03, 0x00, 0x38, 0x1F, 0x00, 0xFF, 0x86, 0x1C, 0x20, 0x33, 0x01,
  0x98, 0x0C, 0xC0, 0xC6, 0x06, 0x30, 0xE1, 0xFE, 0x18, 0xC0, 0xC3, 0x06,
  0x18, 0x30, 0xC1, 0x83, 0x0C, 0x18, 0xC0, 0xC6, 0x03, 0x00, 0x03, 0xC0,
  0x7F, 0x87, 0x0C, 0x30, 0x63, 0x03, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x60, 0x33, 0x01, 0x8C, 0x1C,
  0x7B, 0xC1, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x33, 0x03, 0x30, 0x32,
  0x06, 0x60, 0x66, 0x06, 0x60, 0x66, 0x06, 0x60, 0x66, 0x0C, 0xC0, 0xCC,
  0x0C, 0xC0, 0xCC, 0x0C, 0xC0, 0xCC, 0x18, 0xF7, 0x07, 0xE0, 0xC0, 0x3C,
  0x06, 0xC0, 0x6C, 0x06, 0xC0, 0xC4, 0x0C, 0x61, 0x86, 0x18, 0x61, 0x06,
  0x30, 0x63, 0x06, 0x60, 0x66, 0x06, 0xC0, 0x6C, 0x02, 0x80, 0x38, 0x03,
  0x80, 0xC3, 0x0E, 0x18, 0xF1, 0xC7, 0x8A, 0x3C, 0x51, 0x66, 0x9B, 0x24,
  0xD9, 0x66, 0xCB, 0x26, 0xDB, 0x34, 0xD9, 0xA6, 0x8F, 0x3C, 0x71, 0xE2,
  0x8B, 0x14, 0x50, 0xE3, 0x86, 0x1C, 0x00, 0x18, 0x06, 0x38, 0x18, 0x30,
  0x60, 0x60, 0xC0, 0x63, 0x00, 0xCC, 0x01, 0xB0, 0x01, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x1E, 0x00, 0x36, 0x00, 0xCC, 0x03, 0x08, 0x0E, 0x18, 0x18,
  0x30, 0x60, 0x31, 0xC0, 0x60, 0xC0, 0x3C, 0x03, 0xC0, 0x66, 0x0C, 0x60,
  0xC6, 0x18, 0x33, 0x03, 0x30, 0x36, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x1F, 0xF8, 0xFF, 0xC0,
  0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xFF, 0xE7,
  0xFE, 0x00, 0x1F, 0x8F, 0xC6, 0x03, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x07, 0xE3, 0xE0, 0xC1, 0x81, 0x03, 0x06, 0x0C, 0x18, 0x18, 0x30,
  0x60, 0xC0, 0x81, 0x83, 0x06, 0x0C, 0x0C, 0x18, 0x30, 0x60, 0x60, 0xC1,
  0x80, 0x0F, 0x8F, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x80,
  0xC7, 0xE3, 0xF0, 0x03, 0x00, 0xE0, 0x1C, 0x06, 0xC0, 0x98, 0x31, 0x0C,
  0x31, 0x86, 0x60, 0x58, 0x0C, 0xFF, 0xF0, 0xE3, 0x0C, 0x30, 0x1F, 0x67,
  0x3D, 0x83, 0xB0, 0x34, 0x0D, 0x81, 0xB0, 0x36, 0x06, 0xC0, 0xD8, 0x1B,
  0x06, 0x7B, 0xC7, 0xD8, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x30, 0x03,
  0x7E, 0x3C, 0xE3, 0x06, 0x30, 0x33, 0x02, 0x60, 0x66, 0x06, 0x60, 0x66,
  0x06, 0x60, 0x66, 0x0C, 0xDB, 0xCD, 0xF0, 0x1F, 0x87, 0x39, 0x81, 0xB0,
  0x3C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x1B, 0x06, 0x7B, 0xC7,
  0xE0, 0x00, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x61, 0xF6, 0x39, 0xE6,
  0x0E, 0x60, 0x64, 0x0C, 0xC0, 0xCC, 0x0C, 0xC0, 0xCC, 0x0C, 0xC0, 0xCC,
  0x18, 0xF7, 0x87, 0xD8, 0x1F, 0x86, 0x19, 0x83, 0x30, 0x3C, 0x05, 0xFF,
  0xBF, 0xF6, 0x00, 0xC0, 0x18, 0x0B, 0x06, 0x79, 0xC7, 0xE0, 0x00, 0x0F,
  0x00, 0x7F, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x1F, 0xFE,
  0x1F, 0xFC, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x1C, 0x00, 0xF8, 0x00, 0x1F, 0x67, 0x3D, 0x83, 0xB0, 0x34,
  0x0D, 0x81, 0xB0, 0x36, 0x06, 0xC0, 0xD8, 0x39, 0xFA, 0x3E, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x38, 0xFE, 0x00, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00,
  0x30, 0x03, 0x7E, 0x3C, 0xE3, 0x07, 0x30, 0x33, 0x06, 0x60, 0x66, 0x06,
  0x60, 0x66, 0x06, 0x60, 0x66, 0x04, 0xC0, 0xCC, 0x0C, 0x00, 0x80, 0x38,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE1, 0xF8, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30, 0x06, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x10, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x07, 0x83,
  0xF8, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x1C,
  0xC1, 0xC6, 0x1C, 0x30, 0xC1, 0x8C, 0x0F, 0xC0, 0xFE, 0x06, 0x30, 0x30,
  0xC1, 0x86, 0x0C, 0x18, 0x40, 0xC6, 0x03, 0x00, 0x7E, 0x1F, 0x88, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x00, 0xE0, 0x1F, 0xC3, 0xF0, 0x2E, 0xF3, 0x99, 0x98, 0xC4,
  0xC4, 0x66, 0x23, 0x31, 0x19, 0x18, 0xD8, 0xC6, 0xC6, 0x26, 0x33, 0x31,
  0x19, 0x88, 0xC8, 0xC6, 0x00, 0x37, 0xE3, 0xCE, 0x30, 0x73, 0x03, 0x30,
  0x66, 0x06, 0x60, 0x66, 0x06, 0x60, 0x66, 0x06, 0x60, 0x4C, 0x0C, 0xC0,
  0xC0, 0x1F, 0x87, 0x39, 0x83, 0x30, 0x3C, 0x07, 0x81, 0xB0, 0x36, 0x06,
  0xC0, 0xD8, 0x1B, 0x06, 0x7B, 0x87, 0xE0, 0x37, 0xE3, 0xCE, 0x30, 0x63,
  0x03, 0x30, 0x26, 0x06, 0x60, 0x66, 0x06, 0x60, 0x66, 0x06, 0x60, 0xCD,
  0xBC, 0xDF, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x1F, 0x67, 0x3D,
  0x83, 0xB0, 0x3C, 0x0D, 0x81, 0xB0, 0x36, 0x06, 0xC0, 0xD8, 0x3B, 0x06,
  0x7B, 0xC7, 0xD8, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x3F, 0xC5, 0x1D,
  0xC1, 0xB0, 0x36, 0x06, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x00, 0x0F, 0xE1, 0x8E, 0x30, 0x33, 0x00, 0x30, 0x03, 0xE0,
  0x1F, 0xC0, 0x0E, 0x00, 0x60, 0x06, 0x60, 0xE7, 0xBC, 0x3F, 0x80, 0x06,
  0x00, 0x80, 0x30, 0x06, 0x0F, 0xFF, 0xFF, 0xC3, 0x00, 0x60, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xFC, 0x0F, 0x80, 0x60,
  0x6C, 0x0D, 0x81, 0xB0, 0x34, 0x0D, 0x81, 0xB0, 0x36, 0x06, 0xC0, 0xD8,
  0x1B, 0x06, 0x7B, 0x87, 0xE0, 0xC0, 0x78, 0x1B, 0x03, 0x60, 0xCC, 0x18,
  0x86, 0x18, 0xC3, 0x30, 0x66, 0x0D, 0x81, 0xB0, 0x1C, 0x03, 0x80, 0xC6,
  0x1E, 0x31, 0xB3, 0x8D, 0x94, 0x4C, 0xA6, 0x6D, 0x33, 0x49, 0x1A, 0x58,
  0xF2, 0xC7, 0x14, 0x28, 0xA1, 0xC7, 0x0C, 0x30, 0x00, 0x18, 0x1C, 0x30,
  0xC0, 0xC7, 0x01, 0x98, 0x06, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x0C,
  0xC0, 0x63, 0x03, 0x8E, 0x0C, 0x18, 0xE0, 0x70, 0x60, 0x6C, 0x0D, 0x81,
  0xB0, 0x34, 0x0D, 0x81, 0xB0, 0x36, 0x06, 0xC0, 0xD8, 0x3B, 0xFE, 0x3E,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x38, 0xFE, 0x00, 0x3F, 0xF3, 0xFF, 0x00,
  0xE0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x70, 0x1F, 0x01, 0x80, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x1E, 0x0F, 0xC0, 0x0E, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0x78, 0x01, 0x80, 0x18, 0xC6, 0x31, 0x98, 0xC6, 0x31, 0x8C, 0x46, 0x31,
  0x8C, 0x63, 0x31, 0x8C, 0x63, 0x00, 0x1C, 0x01, 0xF0, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x07, 0x80, 0x3F,
  0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x18, 0x0F, 0x00, 0xC0, 0x00, 0x38, 0x6F, 0x8F, 0x39, 0xE3, 0xF8, 0x38,
};

const GFXglyph JetBrainsMono_LightItalic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 5, 18, 14, 5, -18 },
  { 13, 7, 8, 14, 5, -18 },
  { 20, 14, 18, 14, 1, -18 },
  { 52, 13, 24, 14, 1, -21 },
  { 91, 17, 18, 14, -1, -18 },
  { 130, 13, 18, 14, 1, -18 },
  { 160, 3, 8, 14, 7, -18 },
  { 163, 10, 23, 14, 4, -20 },
  { 192, 10, 23, 14, 1, -20 },
  { 221, 13, 13, 14, 1, -15 },
  { 243, 11, 12, 14, 2, -14 },
  { 260, 6, 8, 14, 2, -4 },
  { 266, 8, 2, 14, 3, -9 },
  { 268, 4, 4, 14, 4, -4 },
  { 270, 15, 23, 14, 0, -20 },
  { 314, 13, 18, 14, 1, -18 },
  { 344, 11, 18, 14, 1, -18 },
  { 369, 13, 18, 14, 1, -18 },
  { 399, 12, 18, 14, 1, -18 },
  { 426, 11, 18, 14, 2, -18 },
  { 451, 11, 18, 14, 2, -18 },
  { 476, 12, 18, 14, 1, -18 },
  { 503, 12, 18, 14, 3, -18 },
  { 530, 12, 18, 14, 1, -18 },
  { 557, 12, 18, 14, 2, -18 },
  { 584, 6, 13, 14, 4, -13 },
  { 594, 7, 17, 14, 3, -13 },
  { 609, 12, 12, 14, 2, -14 },
  { 627, 11, 8, 14, 2, -12 },
  { 638, 12, 12, 14, 1, -14 },
  { 656, 9, 18, 14, 4, -18 },
  { 677, 14, 22, 14, 0, -18 },
  { 716, 12, 18, 14, 0, -18 },
  { 743, 13, 18, 14, 1, -18 },
  { 773, 12, 18, 14, 2, -18 },
  { 800, 12, 18, 14, 1, -18 },
  { 827, 13, 18, 14, 1, -18 },
  { 857, 13, 18, 14, 1, -18 },
  { 887, 12, 18, 14, 2, -18 },
  { 914, 13, 18, 14, 1, -18 },
  { 944, 12, 18, 14, 2, -18 },
  { 971, 13, 18, 14, 1, -18 },
  { 1001, 14, 18, 14, 1, -18 },
  { 1033, 10, 18, 14, 2, -18 },
  { 1056, 13, 18, 14, 1, -18 },
  { 1086, 13, 18, 14, 1, -18 },
  { 1116, 11, 18, 14, 2, -18 },
  { 1141, 13, 18, 14, 1, -18 },
  { 1171, 12, 22, 14, 2, -18 },
  { 1204, 13, 18, 14, 1, -18 },
  { 1234, 13, 18, 14, 1, -18 },
  { 1264, 12, 18, 14, 3, -18 },
  { 1291, 12, 18, 14, 2, -18 },
  { 1318, 12, 18, 14, 3, -18 },
  { 1345, 13, 18, 14, 2, -18 },
  { 1375, 15, 18, 14, 0, -18 },
  { 1409, 12, 18, 14, 3, -18 },
  { 1436, 13, 18, 14, 1, -18 },
  { 1466, 9, 23, 14, 4, -20 },
  { 1492, 7, 23, 14, 4, -20 },
  { 1513, 9, 23, 14, 2, -20 },
  { 1539, 11, 10, 14, 2, -18 },
  { 1553, 12, 1, 14, 0, 1 },
  { 1555, 5, 4, 14, 6, -19 },
  { 1558, 11, 13, 14, 2, -13 },
  { 1576, 12, 18, 14, 1, -18 },
  { 1603, 11, 13, 14, 2, -13 },
  { 1621, 12, 18, 14, 2, -18 },
  { 1648, 11, 13, 14, 2, -13 },
  { 1666, 16, 22, 14, -1, -18 },
  { 1710, 11, 17, 14, 2, -13 },
  { 1734, 12, 18, 14, 1, -18 },
  { 1761, 11, 19, 14, 1, -19 },
  { 1788, 13, 23, 14, 0, -19 },
  { 1826, 13, 18, 14, 1, -18 },
  { 1856, 10, 18, 14, 2, -18 },
  { 1879, 13, 13, 14, 1, -13 },
  { 1901, 12, 13, 14, 1, -13 },
  { 1921, 11, 13, 14, 2, -13 },
  { 1939, 12, 17, 14, 1, -13 },
  { 1965, 11, 17, 14, 2, -13 },
  { 1989, 11, 13, 14, 2, -13 },
  { 2007, 12, 13, 14, 1, -13 },
  { 2027, 11, 17, 14, 2, -17 },
  { 2051, 11, 13, 14, 2, -13 },
  { 2069, 11, 13, 14, 3, -13 },
  { 2087, 13, 13, 14, 2, -13 },
  { 2109, 14, 13, 14, 0, -13 },
  { 2132, 11, 17, 14, 2, -13 },
  { 2156, 12, 13, 14, 1, -13 },
  { 2176, 12, 23, 14, 2, -20 },
  { 2211, 5, 23, 14, 5, -20 },
  { 2226, 12, 23, 14, 1, -20 },
  { 2261, 11, 5, 14, 2, -11 },
};

const GFXfont JetBrainsMono_LightItalic24pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_LightItalic24pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_LightItalic24pt7bGlyphs,
  0x20, 0x7E, 32
};

#endif // _JETBRAINSMONO_LIGHTITALIC24PT7B_H_
