#ifndef _JETBRAINSMONO_LIGHTITALIC29PT7B_H_
#define _JETBRAINSMONO_LIGHTITALIC29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-LightItalic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_LightItalic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x71, 0xC7, 0x18, 0x63, 0x8E, 0x38, 0xC3, 0x0C, 0x30, 0x82,
  0x00, 0x00, 0x0F, 0x3C, 0xE0, 0xE3, 0xF1, 0xF8, 0xF8, 0x6C, 0x36, 0x1B,
  0x0D, 0x8E, 0x86, 0x00, 0x01, 0x83, 0x00, 0xC1, 0x80, 0x41, 0x80, 0x60,
  0xC0, 0x30, 0xC0, 0x30, 0x64, 0xFF, 0xFC, 0x0C, 0x30, 0x0C, 0x18, 0x06,
  0x0C, 0x03, 0x0C, 0x03, 0x06, 0x01, 0x83, 0x07, 0xFF, 0xE3, 0xFF, 0xF0,
  0x60, 0xC0, 0x30, 0xC0, 0x30, 0x60, 0x18, 0x30, 0x0C, 0x30, 0x0C, 0x18,
  0x00, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x03, 0xFC, 0x07,
  0xFC, 0x0E, 0x4E, 0x1C, 0x46, 0x18, 0xC6, 0x18, 0xC0, 0x18, 0xC0, 0x1C,
  0xC0, 0x1E, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xBC, 0x01,
  0x9C, 0x01, 0x0C, 0x01, 0x1C, 0x63, 0x1C, 0x63, 0x18, 0x73, 0x38, 0x3F,
  0xF0, 0x1F, 0xC0, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07,
  0xC0, 0x70, 0xEE, 0x06, 0x18, 0x60, 0xC1, 0x86, 0x18, 0x18, 0x63, 0x01,
  0x86, 0x60, 0x18, 0xCC, 0x01, 0xDC, 0xC0, 0x0F, 0x98, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x60, 0x01, 0x9F, 0x80, 0x3B, 0x98, 0x03, 0x30,
  0x80, 0x62, 0x18, 0x0C, 0x61, 0x81, 0x86, 0x18, 0x30, 0x61, 0x86, 0x07,
  0xF0, 0xE0, 0x3E, 0x00, 0x03, 0xF0, 0x07, 0xF8, 0x0C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x1F, 0x00,
  0x3B, 0x01, 0x73, 0x86, 0x61, 0x8C, 0x61, 0xD8, 0xE0, 0xF8, 0xE0, 0xF0,
  0xC0, 0x70, 0xC0, 0xF0, 0xE1, 0xF8, 0xFF, 0x98, 0x7E, 0x1C, 0x77, 0x76,
  0x66, 0xEE, 0xC0, 0x00, 0x10, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0x60, 0x07, 0x00, 0x70, 0x03, 0xC0, 0x1F, 0x00, 0xE0, 0x02, 0x00, 0x08,
  0x00, 0x70, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00,
  0x70, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x30, 0x07,
  0x01, 0xE0, 0x78, 0x07, 0x00, 0x80, 0x00, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x08, 0x38, 0x3C, 0x63, 0xFE, 0x5F, 0x9F, 0xF8, 0x03, 0x00,
  0x0F, 0x00, 0x37, 0x00, 0xC6, 0x03, 0x8E, 0x0E, 0x1C, 0x18, 0x18, 0x00,
  0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1E,
  0x38, 0xF1, 0xC3, 0x0E, 0x18, 0x70, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFE,
  0xE0, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x00, 0x07,
  0xF0, 0x3F, 0xE1, 0xC1, 0xCE, 0x03, 0x30, 0x0C, 0xC0, 0x37, 0x00, 0xDC,
  0x03, 0x60, 0x1D, 0x8E, 0x76, 0x79, 0x98, 0xC6, 0xE0, 0x1B, 0x80, 0x6C,
  0x03, 0xB0, 0x0E, 0xC0, 0x33, 0x81, 0xCE, 0x0E, 0x1F, 0xF0, 0x3F, 0x80,
  0x00, 0xF0, 0x0F, 0xC0, 0x76, 0x07, 0x98, 0x18, 0x60, 0x41, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x1F, 0xFF, 0xFF,
  0xF8, 0x03, 0xF8, 0x1F, 0xF8, 0x30, 0x38, 0xC0, 0x31, 0x80, 0x67, 0x00,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x03, 0xFF, 0xCF, 0xFF, 0x80, 0x1F, 0xFC, 0x7F, 0xF0, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x07, 0xE0, 0x1F, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x30, 0x0C, 0xC0, 0x33, 0x01,
  0xCE, 0x0E, 0x1F, 0xF0, 0x3F, 0x80, 0x00, 0x3C, 0x00, 0xC0, 0x06, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x63,
  0x83, 0x9C, 0x0E, 0x60, 0x33, 0x80, 0xCF, 0xFF, 0x3F, 0xFC, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x1F, 0xFC, 0x7F, 0xF1, 0x80,
  0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0xF8, 0x37, 0xF0, 0xF1,
  0xE7, 0x03, 0x9C, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0xC0,
  0x33, 0x01, 0xCE, 0x0E, 0x1F, 0xF0, 0x3F, 0x80, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x30, 0x03, 0x00, 0x38, 0x03, 0x80, 0x1B, 0xE1, 0xBF,
  0x9E, 0x1E, 0xE0, 0x7E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3F,
  0x03, 0xB8, 0x38, 0xFF, 0x83, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xEC, 0x01,
  0xB0, 0x0C, 0xC0, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06,
  0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x07, 0xF0, 0x3F, 0xE1,
  0xC1, 0xCE, 0x03, 0x30, 0x0C, 0xC0, 0x73, 0x01, 0x86, 0x0E, 0x1C, 0x70,
  0x3F, 0x00, 0xFC, 0x07, 0x38, 0x70, 0x71, 0x80, 0xCE, 0x03, 0xB0, 0x0E,
  0xC0, 0x33, 0x00, 0xCE, 0x0E, 0x1F, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0x7F,
  0xC3, 0x83, 0x9C, 0x06, 0x60, 0x1B, 0x80, 0x6C, 0x01, 0xB0, 0x06, 0xE0,
  0x3B, 0x80, 0xC7, 0x0F, 0x1F, 0xF8, 0x1E, 0xC0, 0x07, 0x00, 0x38, 0x00,
  0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x1E, 0x7C,
  0xF8, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x8F, 0x3E, 0x38,
  0x07, 0x87, 0xC3, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0xE0, 0x70, 0x70, 0x30, 0x38, 0x18, 0x0C, 0x0C, 0x00,
  0x00, 0x08, 0x01, 0xC0, 0x3C, 0x07, 0x81, 0xF0, 0x3E, 0x03, 0xC0, 0x10,
  0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x70, 0x00,
  0x80, 0x7F, 0xFD, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0xFF, 0xF0, 0x20, 0x01, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x00, 0x78, 0x0F, 0x01, 0xE0, 0x7C,
  0x0F, 0x80, 0x70, 0x02, 0x00, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0xE0, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x3C, 0x1F, 0x81, 0xE0,
  0x38, 0x03, 0x80, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x0F, 0x00,
  0x70, 0x00, 0x01, 0xFE, 0x01, 0xE7, 0x81, 0x80, 0xE1, 0x80, 0x31, 0xC0,
  0x18, 0xC0, 0x0C, 0x60, 0x06, 0x60, 0x7B, 0x30, 0xFF, 0x98, 0x61, 0xCC,
  0x70, 0xE6, 0x30, 0x63, 0x18, 0x33, 0x0C, 0x19, 0x86, 0x0C, 0xC3, 0x06,
  0x61, 0x87, 0x30, 0xE5, 0x18, 0x7F, 0x8C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x3F, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0xE0, 0x03, 0x60, 0x06, 0xC0, 0x1D, 0x80, 0x33, 0x00, 0xE6, 0x01,
  0x8C, 0x03, 0x18, 0x0C, 0x30, 0x18, 0x60, 0x70, 0xE0, 0xC1, 0xC3, 0xFF,
  0x87, 0xFF, 0x0C, 0x06, 0x38, 0x0C, 0x60, 0x19, 0xC0, 0x33, 0x00, 0x6E,
  0x00, 0xE0, 0x1F, 0xF0, 0x7F, 0xE3, 0x81, 0xCE, 0x07, 0x30, 0x0C, 0xC0,
  0x33, 0x01, 0xCC, 0x06, 0x30, 0x31, 0xFF, 0x87, 0xFE, 0x18, 0x1C, 0x60,
  0x39, 0x80, 0x66, 0x01, 0xB8, 0x06, 0xE0, 0x3B, 0x01, 0xCC, 0x0E, 0x3F,
  0xF0, 0xFF, 0x80, 0x07, 0xF0, 0x3F, 0xE1, 0xC1, 0xCE, 0x03, 0x30, 0x0C,
  0xC0, 0x33, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x0E, 0xE0, 0x33, 0x81, 0xC7, 0x0E,
  0x1F, 0xF0, 0x3F, 0x80, 0x1F, 0xE0, 0x7F, 0xE3, 0x83, 0x8E, 0x07, 0x30,
  0x1C, 0xC0, 0x33, 0x01, 0xCC, 0x07, 0x30, 0x19, 0xC0, 0x67, 0x01, 0x98,
  0x06, 0x60, 0x39, 0x80, 0xE6, 0x03, 0x38, 0x0C, 0xE0, 0x33, 0x01, 0x8C,
  0x1E, 0x3F, 0xF0, 0xFF, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x60, 0x00, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x7F, 0xF1,
  0xFF, 0xC3, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x00, 0x07, 0xFF, 0x8F, 0xFF, 0x00, 0x1F, 0xFE, 0x3F,
  0xFC, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xFF, 0xF1, 0xFF, 0xE3, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x00, 0x07, 0xF0, 0x3F, 0xE1, 0xC1, 0xCE, 0x03, 0x30, 0x0C, 0xC0, 0x33,
  0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x1F, 0x98, 0xFE, 0x60, 0x19,
  0x80, 0x6E, 0x03, 0xB8, 0x0E, 0xE0, 0x33, 0x81, 0xC7, 0x0E, 0x1F, 0xF0,
  0x3F, 0x80, 0x18, 0x0E, 0x30, 0x18, 0xE0, 0x31, 0xC0, 0x63, 0x00, 0xC6,
  0x03, 0x8C, 0x07, 0x18, 0x0C, 0x30, 0x18, 0xFF, 0xF1, 0xFF, 0xE3, 0x01,
  0xC6, 0x03, 0x8C, 0x06, 0x18, 0x0C, 0x70, 0x18, 0xE0, 0x31, 0x80, 0x63,
  0x01, 0xC6, 0x03, 0x8C, 0x06, 0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x1C, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x3F, 0xF8, 0xFF, 0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x60,
  0x1C, 0xC0, 0x39, 0xC0, 0x63, 0x81, 0xC3, 0xFF, 0x03, 0xF8, 0x00, 0x18,
  0x07, 0x18, 0x0E, 0x38, 0x0C, 0x38, 0x18, 0x30, 0x38, 0x30, 0x70, 0x30,
  0x60, 0x30, 0xE0, 0x31, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x61, 0xC0, 0x61,
  0xC0, 0x60, 0xC0, 0x60, 0xE0, 0xE0, 0xE0, 0xE0, 0x60, 0xC0, 0x70, 0xC0,
  0x70, 0xC0, 0x30, 0xC0, 0x38, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x03,
  0xFF, 0xEF, 0xFF, 0x00, 0x1E, 0x07, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x1B,
  0x1E, 0x1E, 0x32, 0x36, 0x33, 0x36, 0x33, 0x66, 0x33, 0x66, 0x33, 0xCE,
  0x31, 0xCC, 0x31, 0x8C, 0x70, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x1C,
  0x60, 0x1C, 0x60, 0x18, 0xE0, 0x18, 0xE0, 0x18, 0xC0, 0x18, 0x0E, 0x07,
  0x0E, 0x06, 0x1E, 0x06, 0x1B, 0x06, 0x1B, 0x06, 0x1B, 0x06, 0x1B, 0x0E,
  0x1B, 0x8E, 0x39, 0x8C, 0x39, 0x8C, 0x31, 0x8C, 0x31, 0x8C, 0x30, 0xDC,
  0x30, 0xDC, 0x70, 0xD8, 0x70, 0xD8, 0x60, 0xD8, 0x60, 0x78, 0x60, 0x78,
  0x60, 0x78, 0xE0, 0x70, 0x07, 0xF0, 0x3F, 0xE1, 0xC1, 0xCE, 0x03, 0x30,
  0x0C, 0xC0, 0x33, 0x01, 0xCC, 0x07, 0x70, 0x19, 0xC0, 0x66, 0x01, 0x98,
  0x06, 0x60, 0x39, 0x80, 0xEE, 0x03, 0x38, 0x0C, 0xE0, 0x33, 0x81, 0xC6,
  0x0E, 0x1F, 0xF0, 0x3F, 0x80, 0x1F, 0xF8, 0x3F, 0xF8, 0xE0, 0x79, 0xC0,
  0x73, 0x00, 0x66, 0x00, 0xCC, 0x03, 0x98, 0x07, 0x30, 0x1C, 0xE0, 0x71,
  0xFF, 0xC3, 0xFF, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xF0, 0x3F,
  0xE1, 0xC1, 0xCE, 0x03, 0x30, 0x0C, 0xC0, 0x33, 0x00, 0xDC, 0x07, 0x70,
  0x1D, 0x80, 0x66, 0x01, 0x98, 0x06, 0x60, 0x1B, 0x80, 0xEE, 0x03, 0xB0,
  0x0C, 0xC0, 0x33, 0x81, 0xCE, 0x0E, 0x1F, 0xF0, 0x3F, 0x80, 0x0E, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x1F, 0xF0, 0x3F, 0xF8, 0xE0,
  0x71, 0xC0, 0x73, 0x00, 0xE6, 0x01, 0xCC, 0x03, 0x18, 0x06, 0x30, 0x1C,
  0xE0, 0xF1, 0xFF, 0xC3, 0xFE, 0x06, 0x1C, 0x0C, 0x38, 0x18, 0x30, 0x70,
  0x70, 0xE0, 0xE1, 0x80, 0xC3, 0x01, 0xC6, 0x03, 0x8C, 0x03, 0x00, 0x03,
  0xFC, 0x07, 0xFE, 0x0E, 0x0E, 0x1C, 0x06, 0x18, 0x06, 0x18, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x78, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x1C, 0x60, 0x1C, 0x60, 0x18, 0x70,
  0x38, 0x3F, 0xF0, 0x1F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x00, 0x18, 0x0E, 0x30,
  0x18, 0xE0, 0x31, 0xC0, 0x63, 0x00, 0xC6, 0x01, 0x8C, 0x07, 0x18, 0x0E,
  0x70, 0x18, 0xE0, 0x31, 0x80, 0x63, 0x00, 0xC6, 0x03, 0x8C, 0x07, 0x38,
  0x0C, 0x70, 0x18, 0xE0, 0x31, 0xC0, 0xE1, 0x83, 0x83, 0xFE, 0x03, 0xF8,
  0x00, 0xC0, 0x1F, 0x00, 0x6C, 0x03, 0xB0, 0x0C, 0xC0, 0x33, 0x81, 0xCE,
  0x06, 0x38, 0x38, 0x60, 0xC1, 0x87, 0x06, 0x18, 0x18, 0x60, 0x63, 0x81,
  0x8C, 0x06, 0x70, 0x1D, 0x80, 0x76, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x38, 0x00, 0x61, 0xC3, 0xB0, 0xE1, 0x98, 0x50, 0xCC, 0x78, 0x66, 0x3C,
  0x63, 0x16, 0x31, 0x8B, 0x18, 0xCD, 0x9C, 0x66, 0xCC, 0x32, 0x66, 0x3B,
  0x33, 0x19, 0x9B, 0x0C, 0x8D, 0x86, 0x46, 0xC3, 0x63, 0x61, 0xB1, 0x60,
  0xD0, 0xB0, 0x78, 0x58, 0x3C, 0x28, 0x1C, 0x1C, 0x0E, 0x0E, 0x00, 0x0C,
  0x01, 0xC3, 0x80, 0xE0, 0x60, 0x70, 0x1C, 0x18, 0x03, 0x0E, 0x00, 0xC7,
  0x00, 0x39, 0x80, 0x06, 0xC0, 0x01, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x01, 0xDC, 0x00, 0x63, 0x00, 0x38, 0xE0, 0x1C,
  0x18, 0x0E, 0x06, 0x03, 0x01, 0xC1, 0xC0, 0x30, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0xC0, 0x19, 0x80, 0x73, 0x80, 0xC3, 0x03, 0x06, 0x0E, 0x0E, 0x18,
  0x0C, 0x60, 0x19, 0xC0, 0x3B, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0,
  0x01, 0xC0, 0x00, 0x0F, 0xFF, 0x1F, 0xFE, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x01, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x60, 0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0x0F, 0xF0, 0xFE,
  0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x07, 0xF0,
  0xFE, 0x00, 0xC0, 0xE0, 0xE0, 0x60, 0x60, 0x60, 0x70, 0x30, 0x30, 0x30,
  0x38, 0x38, 0x18, 0x18, 0x18, 0x1C, 0x0C, 0x0C, 0x0C, 0x0E, 0x0E, 0x06,
  0x06, 0x06, 0x07, 0x03, 0x03, 0x0F, 0xE1, 0xFC, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07,
  0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x1F, 0xC3, 0xF8, 0x00, 0x03, 0x80, 0x38, 0x06, 0xC0,
  0xEC, 0x0C, 0xC1, 0x86, 0x18, 0x63, 0x06, 0x70, 0x66, 0x03, 0xC0, 0x30,
  0xFF, 0xFF, 0xFF, 0xF0, 0xC3, 0x1C, 0x70, 0x0F, 0xDC, 0x7F, 0xF3, 0x83,
  0x8C, 0x06, 0x70, 0x19, 0x80, 0x66, 0x01, 0x98, 0x0E, 0x60, 0x3B, 0x80,
  0xCE, 0x03, 0x38, 0x0C, 0xE0, 0x73, 0x83, 0xC7, 0xFF, 0x0F, 0xD8, 0x18,
  0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x19, 0xF0, 0xDF, 0xC7, 0x07,
  0x30, 0x1B, 0x80, 0xDC, 0x06, 0xC0, 0x36, 0x03, 0xB0, 0x1D, 0x80, 0xDC,
  0x06, 0xE0, 0x37, 0x03, 0xBC, 0x39, 0xBF, 0x8D, 0xF8, 0x00, 0x07, 0xE0,
  0x7F, 0xC3, 0x83, 0x8C, 0x06, 0x70, 0x19, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x0C, 0xE0, 0x71, 0x83, 0x87, 0xFC,
  0x0F, 0xE0, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC1,
  0xFB, 0x87, 0xFF, 0x1C, 0x1C, 0x30, 0x18, 0xE0, 0x31, 0x80, 0x63, 0x00,
  0xC6, 0x03, 0x8C, 0x07, 0x38, 0x0C, 0x70, 0x18, 0xE0, 0x31, 0xC0, 0xE3,
  0x83, 0xC3, 0xFF, 0x83, 0xF6, 0x00, 0x07, 0xE0, 0xFF, 0x8E, 0x0E, 0x60,
  0x37, 0x01, 0xB0, 0x0D, 0x80, 0x6F, 0xFF, 0x7F, 0xFF, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x07, 0x30, 0x31, 0xFF, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x07,
  0xFC, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x80, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xDC,
  0x7F, 0xF3, 0x83, 0x8C, 0x06, 0x70, 0x19, 0x80, 0x66, 0x01, 0x98, 0x0E,
  0x60, 0x3B, 0x80, 0xCE, 0x03, 0x18, 0x1C, 0x70, 0xB1, 0xFF, 0xC1, 0xE7,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x1F, 0xF0, 0x7F, 0x80, 0x18,
  0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x19, 0xF0, 0xDF, 0xC7, 0x07,
  0x30, 0x1B, 0x80, 0xDC, 0x06, 0xC0, 0x36, 0x03, 0xB0, 0x1D, 0x80, 0xDC,
  0x06, 0xE0, 0x36, 0x01, 0xB0, 0x1D, 0x80, 0xEC, 0x06, 0x00, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x07, 0xF0,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x07, 0xFE, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0,
  0xFF, 0x03, 0xFC, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03,
  0x80, 0x06, 0x01, 0xCC, 0x07, 0x18, 0x1C, 0x30, 0x70, 0xE1, 0xC1, 0xC7,
  0x03, 0x0C, 0x07, 0xF8, 0x0F, 0xF0, 0x18, 0x60, 0x70, 0xE0, 0xE0, 0xC1,
  0x81, 0xC3, 0x01, 0x86, 0x03, 0x8C, 0x03, 0x00, 0xFF, 0x0F, 0xE0, 0x06,
  0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x18,
  0x01, 0xFF, 0x0F, 0xF0, 0x37, 0x9C, 0x7F, 0x7C, 0xC7, 0x19, 0x8C, 0x33,
  0x18, 0x6E, 0x30, 0xD8, 0x63, 0xB0, 0xC6, 0x61, 0x8C, 0xC6, 0x19, 0x8C,
  0x37, 0x18, 0x6C, 0x30, 0xD8, 0x63, 0xB0, 0xC6, 0x63, 0x0C, 0x33, 0xE1,
  0xBF, 0x8E, 0x0E, 0xE0, 0x37, 0x01, 0xB8, 0x0D, 0x80, 0x6C, 0x07, 0x60,
  0x3B, 0x01, 0xB8, 0x0D, 0xC0, 0x6C, 0x03, 0x60, 0x3B, 0x01, 0xD8, 0x0C,
  0x07, 0xE0, 0xFF, 0x8E, 0x0E, 0x60, 0x37, 0x01, 0xB0, 0x0D, 0x80, 0x6C,
  0x07, 0x60, 0x3F, 0x01, 0xF8, 0x0D, 0xC0, 0x6E, 0x07, 0x30, 0x71, 0xFF,
  0x07, 0xF0, 0x19, 0xF0, 0x6F, 0xE1, 0xC1, 0xCE, 0x03, 0x38, 0x0C, 0xE0,
  0x33, 0x00, 0xCC, 0x07, 0x30, 0x1C, 0xC0, 0x67, 0x01, 0x9C, 0x06, 0x70,
  0x39, 0xE1, 0xC6, 0xFE, 0x1B, 0xF0, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0x0F, 0xDC, 0x7F, 0xF3, 0x83, 0x8C, 0x06, 0x70, 0x19,
  0x80, 0x66, 0x03, 0x98, 0x0E, 0x60, 0x33, 0x80, 0xCE, 0x03, 0x38, 0x0C,
  0xE0, 0x73, 0x83, 0xC7, 0xFF, 0x0F, 0xD8, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x38, 0x00, 0xE0, 0x3B, 0xF0, 0xFF, 0xE3, 0x41, 0xCE, 0x07, 0x30,
  0x1C, 0xC0, 0x73, 0x01, 0xDC, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0x0F, 0xF0, 0xFF, 0xCE,
  0x0E, 0x60, 0x37, 0x00, 0x38, 0x00, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x03,
  0x80, 0x0C, 0x00, 0x6C, 0x03, 0x70, 0x3B, 0xFF, 0x8F, 0xF8, 0x07, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x0F, 0xFF, 0xFF, 0xFC, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x07, 0xF8, 0x1F, 0x80, 0x30, 0x0C, 0xC0, 0x73, 0x01,
  0xDC, 0x06, 0x70, 0x19, 0x80, 0x66, 0x01, 0x98, 0x0E, 0x60, 0x39, 0x80,
  0xCE, 0x03, 0x38, 0x0C, 0xE0, 0x71, 0x83, 0x87, 0xFC, 0x0F, 0xE0, 0xC0,
  0x1F, 0x80, 0x66, 0x03, 0x98, 0x0C, 0x60, 0x71, 0x81, 0x86, 0x0E, 0x1C,
  0x30, 0x31, 0xC0, 0xC6, 0x03, 0x38, 0x0C, 0xC0, 0x37, 0x00, 0xF8, 0x01,
  0xE0, 0x07, 0x00, 0xC1, 0x87, 0xC3, 0x86, 0xC2, 0x86, 0xC2, 0x8C, 0xC6,
  0x8C, 0xC6, 0x8C, 0xC4, 0x88, 0xCC, 0x98, 0xCC, 0x98, 0xC8, 0x90, 0xD8,
  0xB0, 0xD8, 0xB0, 0xD0, 0xA0, 0xF0, 0xE0, 0xF0, 0xE0, 0xE0, 0xC0, 0x1C,
  0x07, 0x87, 0x03, 0x01, 0x83, 0x80, 0xE3, 0x80, 0x33, 0x80, 0x1D, 0x80,
  0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xB0, 0x01, 0xDC, 0x01, 0xC6,
  0x01, 0xC3, 0x80, 0xC0, 0xC0, 0xC0, 0x71, 0xE0, 0x38, 0x30, 0x1C, 0xC0,
  0x73, 0x01, 0x9C, 0x06, 0x70, 0x19, 0x80, 0x66, 0x03, 0x98, 0x0E, 0x60,
  0x33, 0x80, 0xCE, 0x03, 0x38, 0x1C, 0x70, 0xB1, 0xFF, 0xC1, 0xE7, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x1F, 0xF0, 0x7F, 0x80, 0x1F, 0xFE,
  0x3F, 0xF8, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x1F, 0xFE, 0x7F, 0xFC, 0x00, 0x3C, 0x01, 0xF0, 0x0E, 0x00, 0x70, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00,
  0xC0, 0x0F, 0x03, 0xE0, 0x0F, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x1F, 0x00, 0x3C, 0x00, 0x0C, 0x30, 0xC7, 0x1C, 0x71, 0x86, 0x18, 0x63,
  0x8E, 0x30, 0xC3, 0x0C, 0x71, 0xC6, 0x18, 0x61, 0x8E, 0x38, 0xE3, 0x0C,
  0x00, 0x0F, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xE0,
  0x01, 0xF0, 0x1F, 0xC0, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x03, 0xF0, 0x0F, 0x00,
  0x00, 0x3E, 0x0D, 0xFC, 0x36, 0x70, 0xF0, 0xE6, 0xC1, 0xFB, 0x03, 0x80,
};

const GFXglyph JetBrainsMono_LightItalic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 6, 21, 17, 6, -21 },
  { 17, 9, 9, 17, 6, -21 },
  { 28, 17, 21, 17, 1, -21 },
  { 73, 16, 29, 17, 1, -25 },
  { 131, 20, 21, 17, -1, -21 },
  { 184, 16, 21, 17, 1, -21 },
  { 226, 4, 9, 17, 8, -21 },
  { 231, 12, 29, 17, 5, -25 },
  { 275, 12, 29, 17, 1, -25 },
  { 319, 15, 15, 17, 2, -18 },
  { 348, 14, 13, 17, 2, -16 },
  { 371, 7, 9, 17, 3, -4 },
  { 379, 10, 2, 17, 4, -11 },
  { 382, 5, 4, 17, 5, -4 },
  { 385, 17, 27, 17, 1, -24 },
  { 443, 14, 21, 17, 2, -21 },
  { 480, 14, 21, 17, 1, -21 },
  { 517, 15, 21, 17, 1, -21 },
  { 557, 14, 21, 17, 2, -21 },
  { 594, 14, 21, 17, 2, -21 },
  { 631, 14, 21, 17, 2, -21 },
  { 668, 13, 21, 17, 2, -21 },
  { 703, 14, 21, 17, 4, -21 },
  { 740, 14, 21, 17, 2, -21 },
  { 777, 14, 21, 17, 3, -21 },
  { 814, 7, 16, 17, 5, -16 },
  { 828, 9, 21, 17, 3, -16 },
  { 852, 13, 15, 17, 3, -17 },
  { 877, 14, 9, 17, 2, -14 },
  { 893, 13, 15, 17, 2, -17 },
  { 918, 12, 21, 17, 4, -21 },
  { 950, 17, 26, 17, 0, -21 },
  { 1006, 15, 21, 17, 0, -21 },
  { 1046, 14, 21, 17, 2, -21 },
  { 1083, 14, 21, 17, 2, -21 },
  { 1120, 14, 21, 17, 2, -21 },
  { 1157, 15, 21, 17, 2, -21 },
  { 1197, 15, 21, 17, 2, -21 },
  { 1237, 14, 21, 17, 2, -21 },
  { 1274, 15, 21, 17, 2, -21 },
  { 1314, 14, 21, 17, 2, -21 },
  { 1351, 15, 21, 17, 1, -21 },
  { 1391, 16, 21, 17, 2, -21 },
  { 1433, 13, 21, 17, 2, -21 },
  { 1468, 16, 21, 17, 1, -21 },
  { 1510, 16, 21, 17, 1, -21 },
  { 1552, 14, 21, 17, 2, -21 },
  { 1589, 15, 21, 17, 2, -21 },
  { 1629, 14, 26, 17, 2, -21 },
  { 1675, 15, 21, 17, 2, -21 },
  { 1715, 16, 21, 17, 1, -21 },
  { 1757, 15, 21, 17, 3, -21 },
  { 1797, 15, 21, 17, 2, -21 },
  { 1837, 14, 21, 17, 4, -21 },
  { 1874, 17, 21, 17, 2, -21 },
  { 1919, 18, 21, 17, 0, -21 },
  { 1967, 15, 21, 17, 3, -21 },
  { 2007, 16, 21, 17, 1, -21 },
  { 2049, 12, 27, 17, 4, -24 },
  { 2090, 8, 27, 17, 5, -24 },
  { 2117, 11, 27, 17, 3, -24 },
  { 2155, 12, 11, 17, 3, -21 },
  { 2172, 14, 2, 17, 0, 1 },
  { 2176, 5, 4, 17, 8, -23 },
  { 2179, 14, 16, 17, 2, -16 },
  { 2207, 13, 21, 17, 2, -21 },
  { 2242, 14, 16, 17, 2, -16 },
  { 2270, 15, 21, 17, 2, -21 },
  { 2310, 13, 16, 17, 2, -16 },
  { 2336, 19, 26, 17, -1, -21 },
  { 2398, 14, 21, 17, 2, -16 },
  { 2435, 13, 21, 17, 2, -21 },
  { 2470, 14, 22, 17, 1, -22 },
  { 2509, 15, 27, 17, 0, -22 },
  { 2560, 15, 21, 17, 2, -21 },
  { 2600, 12, 21, 17, 3, -21 },
  { 2632, 15, 16, 17, 1, -16 },
  { 2662, 13, 16, 17, 2, -16 },
  { 2688, 13, 16, 17, 2, -16 },
  { 2714, 14, 21, 17, 1, -16 },
  { 2751, 14, 21, 17, 2, -16 },
  { 2788, 14, 16, 17, 2, -16 },
  { 2816, 13, 16, 17, 2, -16 },
  { 2842, 13, 20, 17, 3, -20 },
  { 2875, 14, 16, 17, 2, -16 },
  { 2903, 14, 16, 17, 3, -16 },
  { 2931, 16, 16, 17, 2, -16 },
  { 2963, 17, 16, 17, 0, -16 },
  { 2997, 14, 21, 17, 2, -16 },
  { 3034, 15, 16, 17, 1, -16 },
  { 3064, 14, 27, 17, 3, -24 },
  { 3112, 6, 27, 17, 6, -24 },
  { 3133, 14, 27, 17, 1, -24 },
  { 3181, 14, 6, 17, 2, -13 },
};

const GFXfont JetBrainsMono_LightItalic29pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_LightItalic29pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_LightItalic29pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _JETBRAINSMONO_LIGHTITALIC29PT7B_H_
