#ifndef _JETBRAINSMONO_LIGHTITALIC72PT7B_H_
#define _JETBRAINSMONO_LIGHTITALIC72PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-LightItalic.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_LightItalic72pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x7F, 0xC0, 0x7F,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0x00, 0x3F,
  0x80, 0x7E, 0x7F, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x07, 0xF3, 0xF0,
  0x0F, 0xEF, 0xE0, 0x1F, 0x9F, 0xC0, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x00,
  0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xC0, 0x1F,
  0x8F, 0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xF8, 0xFC, 0x01, 0xF1,
  0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x1F, 0x8F, 0x80, 0x3E, 0x1F,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x07, 0xC0,
  0x00, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x07, 0x80,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x03, 0xE0,
  0x00, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x07,
  0x80, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xF9, 0xE3,
  0xFC, 0x00, 0x7F, 0x0F, 0x0F, 0xF0, 0x07, 0xF0, 0x78, 0x3F, 0x80, 0x3F,
  0x03, 0xC0, 0xFC, 0x03, 0xF0, 0x1E, 0x07, 0xE0, 0x1F, 0x00, 0xF0, 0x1F,
  0x01, 0xF8, 0x0F, 0x00, 0xF8, 0x0F, 0xC0, 0x78, 0x07, 0xC0, 0x7E, 0x03,
  0xC0, 0x7E, 0x03, 0xF0, 0x1E, 0x00, 0x00, 0x1F, 0x80, 0xF0, 0x00, 0x00,
  0xFC, 0x07, 0x80, 0x00, 0x07, 0xE0, 0x78, 0x00, 0x00, 0x3F, 0x83, 0xC0,
  0x00, 0x01, 0xFC, 0x1E, 0x00, 0x00, 0x0F, 0xF0, 0xF0, 0x00, 0x00, 0x3F,
  0xC7, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xF3, 0xFE, 0x00, 0x00, 0x07, 0x87,
  0xF8, 0x00, 0x00, 0x3C, 0x1F, 0xC0, 0x00, 0x01, 0xE0, 0x7F, 0x00, 0x00,
  0x0F, 0x03, 0xF8, 0x00, 0x00, 0x78, 0x0F, 0xC0, 0x00, 0x07, 0x80, 0x7E,
  0x00, 0x00, 0x3C, 0x03, 0xF0, 0x00, 0x01, 0xE0, 0x1F, 0x87, 0xE0, 0x0F,
  0x00, 0xFC, 0x3F, 0x00, 0x78, 0x07, 0xE1, 0xF8, 0x03, 0xC0, 0x3E, 0x0F,
  0xC0, 0x3C, 0x03, 0xF0, 0x7E, 0x01, 0xE0, 0x1F, 0x83, 0xF8, 0x0F, 0x01,
  0xF8, 0x0F, 0xC0, 0x78, 0x1F, 0xC0, 0x7F, 0x03, 0xC1, 0xFC, 0x03, 0xFE,
  0x1E, 0x3F, 0xC0, 0x0F, 0xFF, 0xEF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x07, 0xFF, 0xF8, 0x00,
  0x07, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x3F, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x07, 0xC0,
  0x07, 0xC0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x78,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x0F,
  0x81, 0xF0, 0x00, 0x03, 0xE0, 0x07, 0xC1, 0xF0, 0x00, 0x01, 0xF0, 0x07,
  0xC1, 0xF0, 0x00, 0x00, 0xFC, 0x07, 0xE1, 0xF0, 0x00, 0x00, 0x3F, 0x0F,
  0xE1, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE1, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x7C, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7C, 0x3F, 0xFF, 0xC0, 0x00,
  0x00, 0x7C, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3E, 0x1F, 0x01, 0xF8, 0x00,
  0x00, 0x3E, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x3E, 0x00,
  0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x80,
  0x00, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x1E, 0x01, 0xF0, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x78, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x3E,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x3F,
  0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0x80, 0x00, 0x3F, 0xFF,
  0x80, 0x0F, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0x8F, 0xC0, 0x03, 0xF0, 0xFC, 0x1F, 0x80, 0x0F, 0xC3,
  0xF0, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x3F, 0x80, 0x7E, 0x1F, 0x80, 0x3F,
  0x01, 0xF8, 0x3F, 0x00, 0x7F, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0,
  0xFC, 0x00, 0x7E, 0x3F, 0x01, 0xF0, 0x00, 0xFC, 0xFC, 0x03, 0xE0, 0x00,
  0xFF, 0xF0, 0x0F, 0xC0, 0x01, 0xFF, 0xE0, 0x1F, 0x80, 0x01, 0xFF, 0x80,
  0x3F, 0x00, 0x03, 0xFE, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x01, 0xF0, 0x00, 0x0F, 0xE0, 0x03, 0xE0, 0x00, 0x3F, 0xE0,
  0x07, 0xC0, 0x00, 0x7F, 0xE0, 0x0F, 0xC0, 0x03, 0xFF, 0xC0, 0x1F, 0x80,
  0x0F, 0xFF, 0xC0, 0x3F, 0x80, 0x3F, 0x9F, 0x80, 0x7F, 0xF7, 0xFE, 0x1F,
  0x80, 0x7F, 0xFF, 0xF8, 0x3F, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x9F, 0xCF, 0xC7, 0xE3, 0xF3, 0xF9, 0xFC, 0xFE, 0x7E,
  0x3F, 0x1F, 0x8F, 0xCF, 0xE7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3E, 0x1F,
  0x0F, 0x87, 0xC0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x02, 0x00, 0x07, 0xC0, 0x00, 0x8F,
  0x00, 0x1F, 0x00, 0x0E, 0x3F, 0x00, 0x7C, 0x01, 0xF9, 0xFF, 0x81, 0xE0,
  0x3F, 0xE7, 0xFF, 0x87, 0x83, 0xFF, 0xFF, 0xFF, 0x1E, 0x3F, 0xFF, 0x3F,
  0xFF, 0x73, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0x81, 0xFE, 0x3F, 0xF7, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFC, 0x3F, 0x80, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xE0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0xFE,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x1F, 0x03,
  0xF0, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x00,
  0x7E, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x00, 0x7E,
  0x07, 0xC0, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x80, 0x1F, 0x83, 0xF0, 0x1F,
  0x80, 0xFC, 0x1F, 0x81, 0xFC, 0x07, 0xE0, 0xFC, 0x0F, 0xF0, 0x3E, 0x07,
  0xE0, 0xFF, 0x81, 0xF0, 0x3F, 0x03, 0xFC, 0x1F, 0x81, 0xF0, 0x1F, 0xC0,
  0xFC, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0xFC, 0x01, 0xC0, 0x3F, 0x07, 0xE0,
  0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x00, 0xFC,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x00, 0x7C, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xA0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xF7,
  0xE0, 0x00, 0x3F, 0xC7, 0xE0, 0x00, 0xFF, 0x87, 0xE0, 0x01, 0xFE, 0x07,
  0xE0, 0x03, 0xFC, 0x07, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xE0, 0x0F,
  0xC0, 0x03, 0x80, 0x0F, 0xC0, 0x03, 0x00, 0x0F, 0xC0, 0x04, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0xFC,
  0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7C,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0x7F, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F,
  0xF8, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x7C, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00,
  0xFC, 0x0F, 0xE0, 0x00, 0x3E, 0x07, 0xF0, 0x00, 0x0F, 0x83, 0xF8, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x01, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x70, 0x00, 0x03,
  0xE0, 0xFF, 0xE0, 0x00, 0x7C, 0x7F, 0xFF, 0x00, 0x1F, 0x9F, 0xFF, 0xF0,
  0x03, 0xF7, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0x01,
  0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x01, 0xFC, 0x0F, 0xE0,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x1F,
  0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x01,
  0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xF8, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x1F, 0xF8, 0x00, 0x1F, 0x9F, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xE3, 0xFF, 0xC0,
  0xFF, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x3F,
  0x87, 0xF0, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00,
  0x7F, 0x3F, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x00, 0xFD, 0xF8, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x0F, 0xBF, 0x00,
  0x00, 0x03, 0xEF, 0xC0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xFC, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xF7, 0xE0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x3F, 0x1F, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFC, 0x03, 0xFE,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x1F,
  0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3E,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x1F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x1F, 0xC0,
  0x00, 0x7F, 0x87, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x80,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00,
  0x7E, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x01, 0xF0,
  0x7E, 0x00, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00,
  0x3F, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x7F, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x7F,
  0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x7F, 0x80, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0xFE, 0x0F, 0xC0,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x0F,
  0xDF, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0x03, 0xF1, 0xF8, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x1F, 0xE0,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0xFC, 0x00, 0x7F, 0xFF, 0x7E, 0x00,
  0x0F, 0xFF, 0x9F, 0x80, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F,
  0xFC, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC,
  0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x04, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x03,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x07, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x07,
  0xF0, 0xF8, 0x1F, 0x00, 0x07, 0xFE, 0x3E, 0x07, 0xC0, 0x07, 0xFF, 0xCF,
  0x83, 0xF0, 0x03, 0xFF, 0xFB, 0xE0, 0xF8, 0x01, 0xFF, 0x1E, 0xF8, 0x3E,
  0x00, 0x7E, 0x01, 0xFE, 0x0F, 0x80, 0x3F, 0x00, 0x3F, 0x03, 0xE0, 0x0F,
  0x80, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x7E, 0x01, 0xF8, 0x00,
  0x7C, 0x1F, 0x80, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0xC1,
  0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x00, 0xF8, 0x1F, 0x00,
  0xFC, 0x00, 0x3E, 0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x83, 0xF0, 0x0F, 0x80,
  0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x01, 0xF8, 0x3E, 0x00, 0xF8, 0x00, 0x7C,
  0x0F, 0x80, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x1F, 0x80, 0x07, 0xC0, 0xF8,
  0x07, 0xE0, 0x01, 0xF0, 0x7E, 0x01, 0xF8, 0x00, 0xFC, 0x1F, 0x00, 0x7E,
  0x00, 0x3F, 0x07, 0xC0, 0x1F, 0x80, 0x1F, 0xC1, 0xF0, 0x03, 0xF0, 0x0F,
  0xE0, 0x7C, 0x00, 0xFF, 0x0F, 0x78, 0x1F, 0x00, 0x3F, 0xFF, 0xBE, 0x0F,
  0xC0, 0x07, 0xFF, 0xCF, 0x83, 0xF0, 0x00, 0xFF, 0xE3, 0xE0, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x1F, 0x7C,
  0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x00, 0x3F,
  0x1F, 0x00, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00,
  0x3F, 0x0F, 0x80, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x01, 0xF8, 0x3E, 0x00,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x01, 0xF8, 0x1F,
  0x80, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF0,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x03,
  0xF0, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x0F, 0x80,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x1F, 0x80,
  0x01, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03, 0xE1, 0xF8, 0x00,
  0x00, 0x7C, 0x3F, 0x00, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x01, 0xF1, 0xF8,
  0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0xFD,
  0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0x00,
  0x01, 0xFC, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0x80, 0x00, 0x3F, 0x80,
  0x7C, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x7C,
  0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x01, 0xF8, 0x03, 0xE0, 0x00, 0x3F, 0x80, 0x1F, 0x00, 0x03, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xF8,
  0x00, 0x7F, 0xE0, 0x07, 0xC0, 0x00, 0x7F, 0x80, 0x7E, 0x00, 0x01, 0xFC,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x00, 0xFC, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0x1F, 0x03,
  0xF0, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x1F, 0x81, 0xF0,
  0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0xFE,
  0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0xFE, 0x01, 0xF8, 0x00,
  0x0F, 0xF0, 0x0F, 0x80, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x7E, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xF8, 0x01, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0x80, 0x01, 0xFC, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x1F, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00,
  0x3E, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00,
  0x7C, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x01,
  0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x3F, 0x00,
  0x00, 0x7E, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x7F,
  0x80, 0x7E, 0x00, 0x0F, 0xF0, 0x07, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x1F, 0xC0, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0xFF, 0xFF, 0x81, 0xF0, 0x0F, 0xFF, 0xF8, 0x3F, 0x00,
  0xFF, 0xFF, 0x83, 0xF0, 0x0F, 0xFF, 0xF8, 0x3F, 0x00, 0xFF, 0xFF, 0x83,
  0xF0, 0x0F, 0xFF, 0xF0, 0x3E, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x01, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x07, 0xF0, 0x03,
  0xFC, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x1F, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x3E, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x3F,
  0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x1F,
  0x80, 0x7C, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x00, 0x3E, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x00, 0xFE,
  0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x01,
  0xFC, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x01, 0xFC,
  0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x3F, 0x00,
  0x00, 0x0F, 0x80, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x01,
  0xEF, 0x00, 0x03, 0xFE, 0x01, 0xEF, 0x00, 0x07, 0xDE, 0x01, 0xEF, 0x80,
  0x07, 0xFE, 0x01, 0xEF, 0x80, 0x0F, 0xBE, 0x01, 0xEF, 0x80, 0x0F, 0xBC,
  0x03, 0xE7, 0x80, 0x1F, 0x3C, 0x03, 0xE7, 0x80, 0x1F, 0x7C, 0x03, 0xE7,
  0x80, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x7C,
  0x7C, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x03, 0xE3, 0xC0, 0xF8, 0xF8, 0x07,
  0xC3, 0xC0, 0xF8, 0xF8, 0x07, 0xC3, 0xC0, 0xF0, 0xF8, 0x07, 0xC3, 0xE1,
  0xF0, 0xF8, 0x07, 0xC3, 0xE1, 0xE1, 0xF8, 0x07, 0xC3, 0xE3, 0xE1, 0xF0,
  0x07, 0xC1, 0xE3, 0xC1, 0xF0, 0x0F, 0xC1, 0xE7, 0xC1, 0xF0, 0x0F, 0xC1,
  0xE7, 0x83, 0xF0, 0x0F, 0xC1, 0xFF, 0x83, 0xF0, 0x0F, 0x81, 0xFF, 0x03,
  0xF0, 0x0F, 0x80, 0xFF, 0x03, 0xE0, 0x0F, 0x80, 0xFE, 0x03, 0xE0, 0x1F,
  0x80, 0xFE, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x07, 0xE0,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x03, 0xFC, 0x00,
  0x03, 0xE0, 0x0F, 0xF0, 0x00, 0x0F, 0x80, 0x3F, 0xC0, 0x00, 0x7E, 0x01,
  0xFF, 0x00, 0x01, 0xF8, 0x07, 0xFE, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x00,
  0x1F, 0x80, 0x7F, 0xE0, 0x00, 0x7C, 0x01, 0xFF, 0x80, 0x01, 0xF0, 0x07,
  0xFE, 0x00, 0x07, 0xC0, 0x3F, 0x7C, 0x00, 0x3F, 0x00, 0xFD, 0xF0, 0x00,
  0xFC, 0x03, 0xE7, 0xC0, 0x03, 0xF0, 0x0F, 0x9F, 0x00, 0x0F, 0x80, 0x3E,
  0x3E, 0x00, 0x3E, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0x07, 0xE3, 0xE0, 0x07,
  0xE0, 0x1F, 0x8F, 0x80, 0x1F, 0x80, 0x7E, 0x3E, 0x00, 0x7E, 0x01, 0xF8,
  0x7C, 0x01, 0xF8, 0x07, 0xC1, 0xF0, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0x0F, 0xC0,
  0xF8, 0x0F, 0xC0, 0x3F, 0x03, 0xE0, 0x3F, 0x00, 0xF8, 0x0F, 0x80, 0xF8,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x0F, 0x80, 0xFC, 0x0F, 0x80, 0x7E, 0x01,
  0xF0, 0x7E, 0x01, 0xF8, 0x07, 0xC1, 0xF8, 0x07, 0xE0, 0x1F, 0x07, 0xE0,
  0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x7C, 0x01, 0xF0, 0x03,
  0xE1, 0xF0, 0x0F, 0xC0, 0x0F, 0x8F, 0xC0, 0x3F, 0x00, 0x3E, 0x3F, 0x00,
  0xFC, 0x00, 0xF8, 0xFC, 0x03, 0xF0, 0x01, 0xF3, 0xF0, 0x0F, 0x80, 0x07,
  0xCF, 0x80, 0x3E, 0x00, 0x1F, 0x3E, 0x01, 0xF8, 0x00, 0x7C, 0xF8, 0x07,
  0xE0, 0x01, 0xF3, 0xE0, 0x1F, 0x80, 0x03, 0xEF, 0x80, 0x7E, 0x00, 0x0F,
  0xFE, 0x01, 0xF0, 0x00, 0x3F, 0xF0, 0x07, 0xC0, 0x00, 0xFF, 0xC0, 0x1F,
  0x00, 0x03, 0xFF, 0x00, 0xFC, 0x00, 0x07, 0xFC, 0x03, 0xF0, 0x00, 0x1F,
  0xF0, 0x0F, 0xC0, 0x00, 0x7F, 0xC0, 0x3E, 0x00, 0x01, 0xFE, 0x00, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x0F,
  0xE0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x01, 0xF0, 0x7E, 0x00,
  0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0x7C, 0x00,
  0x00, 0x7E, 0x0F, 0x80, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x01, 0xF0, 0x7E,
  0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8,
  0x3E, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x00,
  0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x03, 0xF0, 0x7C,
  0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07,
  0xE0, 0x1F, 0xC0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xF8,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3D, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7E, 0x00, 0x03, 0xFE, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x03, 0xE0, 0x00,
  0x03, 0xF8, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x00, 0x3F, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x00, 0x7E,
  0x01, 0xF0, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x0F, 0xC0,
  0x00, 0x3F, 0xC0, 0x1F, 0x80, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xFC, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x00, 0x7E, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0xF8, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x07, 0xC1, 0xF8, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x0F,
  0x83, 0xF0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x01, 0xF8, 0x3E,
  0x00, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x7C, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0xFE, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x7F,
  0x00, 0x07, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xF8, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x80,
  0x01, 0xFF, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x1F, 0x00, 0x00,
  0x3F, 0x80, 0x7C, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x0F,
  0xC0, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0x1F, 0x00, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x00, 0x3E, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0x3E,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x7F, 0x00,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xFE, 0x3F, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x7C, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x03, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0xF8, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x1F,
  0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x3F, 0x00, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x03, 0xFC, 0x00, 0x3F, 0xF8, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07,
  0xE7, 0xC0, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0x3F, 0x1F, 0x00, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x3F,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x01, 0xF0, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x01, 0xF8, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0xFC,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00,
  0x3E, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x00, 0xF8, 0x1F, 0x00,
  0x00, 0x1F, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x00, 0x7E, 0x3F,
  0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x00, 0x3F,
  0x3F, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00,
  0x0F, 0xBE, 0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0xC0, 0x07, 0xCF, 0x80, 0x0F,
  0xE0, 0x07, 0xE7, 0xC0, 0x07, 0xF0, 0x03, 0xE3, 0xE0, 0x03, 0xF8, 0x01,
  0xF1, 0xF0, 0x03, 0xFC, 0x00, 0xF8, 0xF8, 0x01, 0xFE, 0x00, 0xFC, 0x7C,
  0x00, 0xEF, 0x00, 0x7C, 0x3E, 0x00, 0xF7, 0x80, 0x3E, 0x1F, 0x00, 0x7B,
  0xC0, 0x1F, 0x0F, 0x80, 0x3D, 0xE0, 0x1F, 0x87, 0xC0, 0x1C, 0xF0, 0x0F,
  0x83, 0xE0, 0x1E, 0x78, 0x07, 0xC1, 0xF0, 0x0F, 0x3C, 0x03, 0xE0, 0xF8,
  0x07, 0x1E, 0x03, 0xE0, 0x7C, 0x07, 0x8E, 0x01, 0xF0, 0x3E, 0x03, 0xC7,
  0x00, 0xF8, 0x1F, 0x01, 0xE3, 0x80, 0xFC, 0x0F, 0x80, 0xE1, 0xC0, 0x7C,
  0x0F, 0xC0, 0xF0, 0xE0, 0x3E, 0x07, 0xE0, 0x78, 0x70, 0x1F, 0x03, 0xE0,
  0x38, 0x38, 0x1F, 0x01, 0xF0, 0x3C, 0x3C, 0x0F, 0x80, 0xF8, 0x1E, 0x1E,
  0x07, 0xC0, 0x7C, 0x0F, 0x0F, 0x03, 0xE0, 0x3E, 0x07, 0x07, 0x83, 0xE0,
  0x1F, 0x07, 0x83, 0xC1, 0xF0, 0x0F, 0x83, 0xC1, 0xE0, 0xF8, 0x07, 0xC1,
  0xC0, 0xF0, 0xFC, 0x03, 0xE1, 0xE0, 0x78, 0x7C, 0x01, 0xF0, 0xF0, 0x3C,
  0x3E, 0x00, 0xF8, 0x78, 0x1E, 0x1F, 0x00, 0x7C, 0x78, 0x0F, 0x1F, 0x00,
  0x3E, 0x3C, 0x07, 0x8F, 0x80, 0x1F, 0x1E, 0x03, 0xC7, 0xC0, 0x0F, 0x8E,
  0x01, 0xE3, 0xE0, 0x07, 0xCF, 0x00, 0xF3, 0xE0, 0x03, 0xE7, 0x80, 0x79,
  0xF0, 0x01, 0xF3, 0xC0, 0x3C, 0xF8, 0x00, 0xFB, 0xC0, 0x1E, 0x78, 0x00,
  0x7D, 0xE0, 0x0E, 0x7C, 0x00, 0x3C, 0xF0, 0x07, 0x3E, 0x00, 0x1E, 0x70,
  0x03, 0x9F, 0x00, 0x1F, 0x78, 0x01, 0xCF, 0x00, 0x0F, 0xBC, 0x00, 0xEF,
  0x80, 0x07, 0xDE, 0x00, 0x77, 0xC0, 0x03, 0xEE, 0x00, 0x3B, 0xE0, 0x01,
  0xFF, 0x00, 0x1D, 0xE0, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x7F, 0x80,
  0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF0, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x00,
  0x00, 0xF8, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x00,
  0x3F, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0xF8,
  0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x01, 0xF0,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0x00, 0x3E, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x03, 0xF3,
  0xE0, 0x00, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xF0, 0x02, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x01, 0xFB, 0xC0, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7C, 0x1F,
  0x00, 0x01, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0xC0, 0xF8,
  0x00, 0x3F, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x01, 0xF8, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x0F, 0xC0, 0x07, 0xC0, 0x3F, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0xF9, 0xF8,
  0x00, 0x01, 0xF7, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x03, 0xF0,
  0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xE0,
  0x1F, 0x80, 0x7E, 0x00, 0x07, 0xFE, 0x07, 0xC0, 0x07, 0xFF, 0xC1, 0xF0,
  0x07, 0xFF, 0xFC, 0xFC, 0x03, 0xFF, 0xFF, 0x3F, 0x01, 0xFF, 0xFF, 0xEF,
  0xC0, 0xFF, 0x80, 0x7B, 0xF0, 0x7F, 0x80, 0x0E, 0xF8, 0x1F, 0xC0, 0x01,
  0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x0F, 0xE0, 0xF8, 0x00,
  0x03, 0xF8, 0x7E, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00,
  0x7E, 0x1F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xE0,
  0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x03, 0xF8, 0x1F,
  0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xC3, 0xF7, 0xE0,
  0x3F, 0xFF, 0xF9, 0xF8, 0x07, 0xFF, 0xFE, 0x7E, 0x00, 0xFF, 0xFE, 0x1F,
  0x00, 0x0F, 0xFE, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0x0F,
  0xFF, 0x80, 0x0F, 0x8F, 0xFF, 0xF8, 0x03, 0xE7, 0xFF, 0xFF, 0x01, 0xFB,
  0xFF, 0xFF, 0xC0, 0x7E, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0xFE, 0x07,
  0xF8, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0xFC,
  0x3F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xF8,
  0x3F, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x07,
  0xE1, 0xFC, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0xFC, 0x1F, 0xE0, 0x00,
  0x7F, 0x07, 0xF8, 0x00, 0x3F, 0x81, 0xF7, 0x80, 0x3F, 0xC0, 0x7D, 0xF8,
  0x3F, 0xF0, 0x3F, 0x3F, 0xFF, 0xF8, 0x0F, 0xCF, 0xFF, 0xF8, 0x03, 0xF1,
  0xFF, 0xFC, 0x00, 0xFC, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xE0, 0x7C, 0x00, 0x1F,
  0xFF, 0x0F, 0xC0, 0x07, 0xFF, 0xFC, 0xFC, 0x00, 0xFF, 0xFF, 0xCF, 0xC0,
  0x1F, 0xFF, 0xFE, 0xFC, 0x03, 0xFE, 0x01, 0xEF, 0xC0, 0x7F, 0x80, 0x0E,
  0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x03, 0xF8, 0x0F, 0xC0,
  0x00, 0x3F, 0x80, 0xF8, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x7E, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0x07, 0xF8, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0xFD, 0xF8, 0x03,
  0xFF, 0xFF, 0x9F, 0x80, 0x1F, 0xFF, 0xF9, 0xF8, 0x00, 0xFF, 0xFE, 0x1F,
  0x00, 0x03, 0xFF, 0x83, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F,
  0xC0, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x7C,
  0x7E, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x3F, 0x1F, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xF1, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x01, 0xF8, 0x3F, 0x80, 0x01, 0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x07, 0xFC,
  0x07, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x07, 0xC0, 0x07, 0xFF, 0xE1, 0xF0, 0x07, 0xFF, 0xFC,
  0xFC, 0x03, 0xFF, 0xFF, 0xBF, 0x01, 0xFF, 0xFF, 0xEF, 0xC0, 0xFF, 0x80,
  0x7B, 0xF0, 0x7F, 0x80, 0x0F, 0xF8, 0x1F, 0xC0, 0x01, 0xFE, 0x0F, 0xE0,
  0x00, 0x3F, 0x83, 0xF0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00,
  0xF8, 0x3E, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7F,
  0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x7F, 0xC0,
  0xFF, 0x00, 0x7B, 0xE0, 0x1F, 0xFF, 0xFE, 0xF8, 0x07, 0xFF, 0xFF, 0x7E,
  0x00, 0xFF, 0xFF, 0x9F, 0x80, 0x1F, 0xFF, 0x87, 0xE0, 0x01, 0xFF, 0x81,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0x1F,
  0xFF, 0x80, 0x0F, 0x8F, 0xFF, 0xF8, 0x03, 0xE7, 0xFF, 0xFF, 0x01, 0xFB,
  0xFF, 0xFF, 0xC0, 0x7E, 0xF0, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0xFE, 0x07,
  0xF8, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0xFC,
  0x3F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0x1F, 0x83, 0xE0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xF8,
  0x3F, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00,
  0x1F, 0x07, 0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xF0, 0x7C, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x03, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00,
  0x3F, 0x80, 0xFC, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x3E, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0x01, 0xFC, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x0F,
  0xC0, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x03, 0xE1, 0xF8,
  0x0F, 0xE0, 0x07, 0xCF, 0xFC, 0x3F, 0xE0, 0x0F, 0xBF, 0xF8, 0xFF, 0xE0,
  0x1F, 0x7F, 0xFB, 0xFF, 0xE0, 0x7F, 0x87, 0xFE, 0x1F, 0xC0, 0xFE, 0x07,
  0xF8, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0x80, 0x3E,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x3F, 0x00,
  0x7C, 0x03, 0xF0, 0x7E, 0x00, 0xF0, 0x07, 0xE0, 0xFC, 0x03, 0xE0, 0x0F,
  0x81, 0xF0, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x1F, 0x80, 0x3E, 0x01, 0xF8, 0x3F, 0x00, 0x78, 0x03,
  0xF0, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x0F, 0x81, 0xF0,
  0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x00,
  0xFC, 0x1F, 0x80, 0x3C, 0x01, 0xF8, 0x3F, 0x00, 0xF8, 0x03, 0xF0, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC0,
  0x1F, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x0F, 0xC0, 0x1E, 0x00, 0xFC, 0x1F,
  0x80, 0x3C, 0x01, 0xF8, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0x1F, 0x07,
  0xE0, 0x0F, 0x80, 0x7E, 0x0F, 0xC0, 0x1E, 0x00, 0xFC, 0x1F, 0x80, 0x7C,
  0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x03, 0xF0, 0x3F, 0xE0, 0x00, 0xFC, 0x3F, 0xFE, 0x00, 0x3E, 0x3F, 0xFF,
  0xE0, 0x0F, 0x9F, 0xFF, 0xFC, 0x07, 0xEF, 0xFF, 0xFF, 0x01, 0xFB, 0xC0,
  0x1F, 0xE0, 0x7F, 0xC0, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x7E, 0x07, 0xF0,
  0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xE0,
  0xFC, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00,
  0x7C, 0x1F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0xC1, 0xF0, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3E,
  0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0x83, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7E, 0x0F,
  0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x00, 0xFC,
  0xFC, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x3F,
  0x1F, 0x80, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x07,
  0xE3, 0xE0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00,
  0x3F, 0x1F, 0x00, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x0F, 0x8F, 0xC0, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xE0,
  0x07, 0xF8, 0x07, 0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x1E, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x0F, 0xFC, 0x00, 0x0F, 0xC3, 0xFF,
  0xF0, 0x00, 0xF8, 0xFF, 0xFF, 0x80, 0x0F, 0x9F, 0xFF, 0xFC, 0x01, 0xFB,
  0xFF, 0xFF, 0xC0, 0x1F, 0xBC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xE0,
  0x1F, 0xE0, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00,
  0x3F, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0xF8, 0x0F, 0xC0,
  0x00, 0x1F, 0x81, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x01, 0xF6, 0x00, 0x0F,
  0xE0, 0x1F, 0x78, 0x01, 0xFC, 0x03, 0xF7, 0xE0, 0xFF, 0xC0, 0x3F, 0x3F,
  0xFF, 0xF8, 0x03, 0xF3, 0xFF, 0xFF, 0x00, 0x3F, 0x1F, 0xFF, 0xC0, 0x03,
  0xF0, 0x7F, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x07, 0xC0, 0x07, 0xFF, 0xC3, 0xF0,
  0x07, 0xFF, 0xFC, 0xFC, 0x03, 0xFF, 0xFF, 0x3F, 0x01, 0xFF, 0xFF, 0xEF,
  0xC0, 0xFF, 0x00, 0x7B, 0xF0, 0x7F, 0x80, 0x0E, 0xF8, 0x1F, 0x80, 0x01,
  0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x0F, 0xE1, 0xF8, 0x00,
  0x03, 0xF8, 0x7E, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00,
  0x7C, 0x1F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x03, 0xF8, 0x1F,
  0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xC3, 0xF7, 0xE0,
  0x3F, 0xFF, 0xF9, 0xF8, 0x07, 0xFF, 0xFC, 0x7C, 0x00, 0xFF, 0xFE, 0x1F,
  0x00, 0x0F, 0xFE, 0x0F, 0xC0, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x3F, 0xF0, 0x00, 0x7E, 0x1F, 0xFF, 0x80, 0x0F, 0xCF,
  0xFF, 0xF8, 0x01, 0xF3, 0xFF, 0xFF, 0x80, 0x3E, 0xFF, 0xFF, 0xF8, 0x07,
  0xDE, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0x80, 0x0F, 0xE0, 0x3F, 0x80,
  0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x3F,
  0x80, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x7F, 0x00,
  0x03, 0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0xFF,
  0xC3, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x3F, 0x1F, 0x00,
  0x00, 0x1F, 0x87, 0xC0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0xF8, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xF8,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0xF8,
  0x07, 0xE0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x03,
  0xF0, 0x3E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xC0, 0x00,
  0x07, 0xC3, 0xF0, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x7C, 0x7E, 0x00,
  0x00, 0x1F, 0x1F, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x01, 0xFB, 0xE0,
  0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xC0, 0x07,
  0xFE, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x03, 0xF0, 0x01, 0xEF, 0x80, 0x3F,
  0x80, 0x1F, 0x7C, 0x01, 0xFC, 0x00, 0xFB, 0xE0, 0x0E, 0xE0, 0x07, 0xDF,
  0x00, 0xF7, 0x00, 0x7C, 0xF8, 0x07, 0xB8, 0x03, 0xE7, 0xC0, 0x3D, 0xE0,
  0x1F, 0x3E, 0x03, 0xCF, 0x01, 0xF1, 0xF0, 0x1E, 0x78, 0x0F, 0x8F, 0x80,
  0xF3, 0xC0, 0x7C, 0x7C, 0x0F, 0x1E, 0x07, 0xC3, 0xE0, 0x78, 0xF0, 0x3E,
  0x1F, 0x03, 0xC7, 0x81, 0xF0, 0xF8, 0x3C, 0x3C, 0x0F, 0x07, 0xC1, 0xE1,
  0xE0, 0xF8, 0x3E, 0x0F, 0x0F, 0x07, 0xC1, 0xF0, 0x70, 0x78, 0x3C, 0x0F,
  0x87, 0x83, 0xC3, 0xE0, 0x7C, 0x3C, 0x1E, 0x1F, 0x03, 0xE1, 0xC0, 0xF0,
  0xF0, 0x1F, 0x1E, 0x07, 0x8F, 0x80, 0xF8, 0xF0, 0x3C, 0x7C, 0x07, 0xC7,
  0x01, 0xE3, 0xC0, 0x3E, 0x78, 0x0F, 0x3E, 0x01, 0xF3, 0xC0, 0x79, 0xF0,
  0x0F, 0x9C, 0x03, 0xCF, 0x00, 0x7D, 0xE0, 0x1E, 0x78, 0x03, 0xEF, 0x00,
  0xF7, 0xC0, 0x1E, 0x70, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x07,
  0xBC, 0x01, 0xFF, 0x00, 0x3D, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x07,
  0xE0, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03,
  0xF0, 0x7C, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xF8, 0x3F, 0x00,
  0x00, 0x7E, 0x0F, 0x80, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F, 0x07,
  0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03,
  0xE0, 0xFC, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x00, 0x7C, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFF, 0x03,
  0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x7B, 0xE0, 0x1F, 0xFF, 0xFD, 0xF8,
  0x07, 0xFF, 0xFE, 0x7E, 0x00, 0xFF, 0xFF, 0x1F, 0x80, 0x0F, 0xFF, 0x87,
  0xE0, 0x00, 0xFF, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7C, 0x1F, 0xFE, 0x00, 0x1F, 0x8F,
  0xFF, 0xE0, 0x03, 0xF1, 0xFF, 0xFE, 0x00, 0x7C, 0x7F, 0x1F, 0xC0, 0x0F,
  0x9F, 0x81, 0xFC, 0x01, 0xF3, 0xF0, 0x1F, 0xC0, 0x7E, 0x7C, 0x01, 0xF8,
  0x0F, 0xCF, 0x80, 0x1F, 0xC3, 0xF3, 0xF0, 0x03, 0xFF, 0xFC, 0x7E, 0x00,
  0x3F, 0xFF, 0x8F, 0xC0, 0x03, 0xFF, 0xE1, 0xF0, 0x00, 0x3F, 0xF0, 0x3E,
  0x00, 0x01, 0xF8, 0x00,
};

const GFXglyph JetBrainsMono_LightItalic72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 43, 0, -1 },
  { 1, 16, 53, 43, 14, -53 },
  { 107, 23, 22, 43, 14, -53 },
  { 171, 41, 53, 43, 2, -53 },
  { 443, 37, 73, 43, 4, -63 },
  { 781, 49, 53, 43, -2, -53 },
  { 1106, 39, 54, 43, 2, -53 },
  { 1370, 9, 22, 43, 21, -53 },
  { 1395, 29, 70, 43, 12, -61 },
  { 1649, 29, 70, 43, 4, -61 },
  { 1903, 38, 37, 43, 4, -44 },
  { 2079, 34, 34, 43, 5, -41 },
  { 2224, 18, 23, 43, 7, -11 },
  { 2276, 24, 5, 43, 10, -26 },
  { 2291, 12, 12, 43, 13, -11 },
  { 2309, 43, 68, 43, 1, -60 },
  { 2675, 37, 54, 43, 4, -53 },
  { 2925, 32, 53, 43, 4, -53 },
  { 3137, 37, 53, 43, 4, -53 },
  { 3383, 36, 54, 43, 4, -53 },
  { 3626, 34, 53, 43, 5, -53 },
  { 3852, 35, 54, 43, 5, -53 },
  { 4089, 34, 54, 43, 4, -53 },
  { 4319, 34, 53, 43, 9, -53 },
  { 4545, 36, 54, 43, 4, -53 },
  { 4788, 34, 53, 43, 7, -53 },
  { 5014, 17, 41, 43, 13, -40 },
  { 5102, 22, 52, 43, 8, -40 },
  { 5245, 35, 38, 43, 6, -43 },
  { 5412, 34, 22, 43, 5, -35 },
  { 5506, 34, 38, 43, 4, -43 },
  { 5668, 28, 53, 43, 11, -53 },
  { 5854, 42, 66, 43, 1, -53 },
  { 6201, 35, 53, 43, 1, -53 },
  { 6433, 37, 53, 43, 4, -53 },
  { 6679, 36, 54, 43, 5, -53 },
  { 6922, 36, 53, 43, 4, -53 },
  { 7161, 38, 53, 43, 4, -53 },
  { 7413, 39, 53, 43, 4, -53 },
  { 7672, 36, 54, 43, 5, -53 },
  { 7915, 37, 53, 43, 4, -53 },
  { 8161, 36, 53, 43, 5, -53 },
  { 8400, 39, 54, 43, 2, -53 },
  { 8664, 40, 53, 43, 4, -53 },
  { 8929, 31, 53, 43, 5, -53 },
  { 9135, 40, 53, 43, 3, -53 },
  { 9400, 38, 53, 43, 4, -53 },
  { 9652, 35, 54, 43, 5, -53 },
  { 9889, 39, 53, 43, 4, -53 },
  { 10148, 36, 66, 43, 5, -53 },
  { 10445, 38, 53, 43, 4, -53 },
  { 10697, 38, 54, 43, 3, -53 },
  { 10954, 36, 53, 43, 8, -53 },
  { 11193, 37, 54, 43, 5, -53 },
  { 11443, 35, 53, 43, 9, -53 },
  { 11675, 41, 53, 43, 5, -53 },
  { 11947, 44, 53, 43, 0, -53 },
  { 12239, 38, 53, 43, 8, -53 },
  { 12491, 38, 53, 43, 3, -53 },
  { 12743, 28, 68, 43, 11, -60 },
  { 12981, 21, 68, 43, 12, -60 },
  { 13160, 28, 68, 43, 6, -60 },
  { 13398, 31, 29, 43, 7, -53 },
  { 13511, 35, 5, 43, 0, 2 },
  { 13533, 13, 11, 43, 19, -57 },
  { 13551, 34, 41, 43, 5, -40 },
  { 13726, 34, 54, 43, 4, -53 },
  { 13956, 34, 41, 43, 5, -40 },
  { 14131, 36, 54, 43, 5, -53 },
  { 14374, 33, 41, 43, 5, -40 },
  { 14544, 48, 66, 43, -3, -53 },
  { 14940, 34, 53, 43, 5, -40 },
  { 15166, 34, 53, 43, 4, -53 },
  { 15392, 34, 56, 43, 3, -56 },
  { 15630, 37, 69, 43, 1, -56 },
  { 15950, 38, 53, 43, 4, -53 },
  { 16202, 30, 53, 43, 7, -53 },
  { 16401, 39, 40, 43, 2, -40 },
  { 16596, 34, 40, 43, 4, -40 },
  { 16766, 33, 41, 43, 5, -40 },
  { 16936, 36, 53, 43, 2, -40 },
  { 17175, 34, 53, 43, 5, -40 },
  { 17401, 35, 40, 43, 5, -40 },
  { 17576, 34, 41, 43, 4, -40 },
  { 17751, 33, 50, 43, 7, -50 },
  { 17958, 34, 41, 43, 5, -40 },
  { 18133, 34, 40, 43, 8, -40 },
  { 18303, 37, 40, 43, 6, -40 },
  { 18488, 40, 40, 43, 1, -40 },
  { 18688, 34, 53, 43, 5, -40 },
  { 18914, 35, 40, 43, 4, -40 },
  { 19089, 36, 68, 43, 7, -60 },
  { 19395, 17, 68, 43, 14, -60 },
  { 19540, 36, 68, 43, 2, -60 },
  { 19846, 35, 15, 43, 5, -33 },
};

const GFXfont JetBrainsMono_LightItalic72pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_LightItalic72pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_LightItalic72pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _JETBRAINSMONO_LIGHTITALIC72PT7B_H_
