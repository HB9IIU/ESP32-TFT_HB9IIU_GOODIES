#ifndef _JETBRAINSMONO_LIGHTITALIC25PT7B_H_
#define _JETBRAINSMONO_LIGHTITALIC25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-LightItalic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_LightItalic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xC6, 0x33, 0x98, 0xC6, 0x31, 0x88, 0x42, 0x00, 0x0C, 0xE7,
  0x00, 0x63, 0xE7, 0xC6, 0xC6, 0xC6, 0xC6, 0xC6, 0x03, 0x0C, 0x08, 0x60,
  0x61, 0x81, 0x84, 0x04, 0x30, 0xFF, 0xF4, 0xC2, 0x02, 0x18, 0x18, 0x60,
  0x61, 0x01, 0x0C, 0x3F, 0xFC, 0xFF, 0xF0, 0x86, 0x06, 0x18, 0x18, 0x40,
  0x43, 0x03, 0x0C, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x7F,
  0x07, 0xFC, 0x66, 0x63, 0x33, 0x31, 0x01, 0xC8, 0x06, 0x40, 0x3E, 0x00,
  0xFC, 0x01, 0xF0, 0x09, 0x80, 0x46, 0x02, 0x37, 0x11, 0xB9, 0x98, 0xCC,
  0xC7, 0xFC, 0x1F, 0xC0, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x00, 0x0F,
  0x81, 0x8C, 0xE1, 0x86, 0x31, 0x82, 0x18, 0x81, 0x08, 0x81, 0x8C, 0xC0,
  0x7E, 0xC0, 0x3C, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x4F, 0x00, 0x4C,
  0xC0, 0x6C, 0x20, 0x66, 0x30, 0x63, 0x18, 0x61, 0x8C, 0x20, 0xFC, 0x60,
  0x3C, 0x00, 0x01, 0x00, 0x3F, 0x03, 0x18, 0x30, 0x61, 0x83, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x0C, 0x01, 0xF0, 0x19, 0x86, 0xC6, 0x6C, 0x36, 0x60,
  0xF3, 0x07, 0x18, 0x38, 0xC3, 0xE7, 0xFB, 0x1F, 0x0C, 0x6D, 0xFF, 0xB0,
  0x00, 0xC0, 0x70, 0x70, 0x38, 0x1C, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x1C,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x18, 0x06, 0x01,
  0x80, 0x70, 0x0E, 0x01, 0xE0, 0x18, 0x0C, 0x03, 0x80, 0x70, 0x06, 0x01,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x00,
  0x01, 0x80, 0x06, 0x00, 0x30, 0x10, 0xC2, 0x73, 0x3B, 0xFB, 0xF0, 0xF8,
  0x01, 0x40, 0x0D, 0x80, 0x67, 0x03, 0x8C, 0x1C, 0x38, 0x20, 0x80, 0x03,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xE0, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0xE3, 0x9C, 0x61, 0x8C, 0x30, 0xFF,
  0xFF, 0x6F, 0xFE, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x01,
  0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x70, 0x00,
  0x01, 0x00, 0xFE, 0x1C, 0xE3, 0x03, 0x60, 0x36, 0x03, 0x60, 0x36, 0x03,
  0x66, 0x7C, 0xE6, 0xC6, 0x6C, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0xEC, 0x0C,
  0xC1, 0xCF, 0xF8, 0x7F, 0x00, 0x03, 0xC0, 0x7C, 0x1C, 0xC1, 0x9C, 0x21,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0xFF, 0xFF, 0xFE, 0x00, 0x80, 0x3F, 0x87,
  0x1C, 0x30, 0x33, 0x01, 0x98, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0xFF, 0x3F, 0xF8, 0x1F, 0xF8, 0xFF, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0x80, 0x18, 0x00, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x06,
  0x70, 0x33, 0x81, 0x8C, 0x18, 0x7F, 0xC1, 0xF8, 0x00, 0x00, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x70, 0x1C, 0x03, 0x00, 0xC3, 0x30, 0x6C, 0x0F, 0x83,
  0xE0, 0x6F, 0xFD, 0xFF, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x3F, 0xF3,
  0xFF, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x67, 0x87, 0xFC, 0x70, 0xE6,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0xC0, 0xCC, 0x1C, 0xFF, 0x87,
  0xE0, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x0C, 0x01,
  0xFE, 0x3D, 0xE3, 0x07, 0x60, 0x36, 0x03, 0x60, 0x3E, 0x03, 0x60, 0x66,
  0x0E, 0x7F, 0xC3, 0xF8, 0x7F, 0xF7, 0xFF, 0xC0, 0x6C, 0x06, 0xC0, 0xC0,
  0x0C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0xC0, 0x0C, 0x01,
  0x80, 0x18, 0x03, 0x00, 0x70, 0x06, 0x00, 0x00, 0x80, 0x3F, 0x83, 0x9C,
  0x30, 0x31, 0x81, 0x88, 0x0C, 0x60, 0xC3, 0x0E, 0x0E, 0xC0, 0x3C, 0x07,
  0x70, 0x70, 0xC6, 0x06, 0x30, 0x19, 0x80, 0xCC, 0x0C, 0x60, 0xE3, 0xFE,
  0x0F, 0xE0, 0x01, 0x00, 0xFE, 0x1C, 0xE3, 0x03, 0x60, 0x36, 0x03, 0x60,
  0x36, 0x03, 0x60, 0x67, 0x0E, 0x7F, 0xC1, 0xEC, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x00, 0x3B, 0xDE, 0x60, 0x00, 0x00,
  0x00, 0x01, 0xEF, 0x70, 0x0E, 0x1E, 0x1E, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x38, 0x38, 0x70, 0x60, 0x60, 0xC0, 0xC0, 0x00, 0x10,
  0x07, 0x01, 0xE0, 0x78, 0x1E, 0x07, 0x80, 0xE0, 0x0E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0x40, 0x7F, 0xF7, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xEF, 0xFC, 0x20, 0x03, 0x80, 0x1E, 0x00, 0x70,
  0x03, 0xC0, 0x0F, 0x00, 0x30, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x07, 0x00,
  0xC0, 0x00, 0x7F, 0x1F, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0C,
  0x3F, 0x0F, 0x03, 0x01, 0x80, 0x60, 0x00, 0x00, 0x01, 0x80, 0xE0, 0x38,
  0x00, 0x00, 0x40, 0x07, 0xF0, 0x38, 0x70, 0x60, 0x31, 0x80, 0x62, 0x00,
  0xCC, 0x01, 0x98, 0x7B, 0x31, 0xDC, 0x42, 0x19, 0x8C, 0x33, 0x18, 0x66,
  0x30, 0xCC, 0x61, 0x98, 0x83, 0x31, 0x8C, 0x43, 0xE9, 0x81, 0x23, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0xC0, 0x01, 0x80, 0x00, 0xE0,
  0x0F, 0x00, 0x78, 0x06, 0xC0, 0x36, 0x01, 0x30, 0x19, 0x80, 0xC4, 0x0C,
  0x30, 0x61, 0x86, 0x0C, 0x3F, 0xE1, 0xFF, 0x18, 0x18, 0xC0, 0xCC, 0x06,
  0x60, 0x37, 0x00, 0xC0, 0x1F, 0xE0, 0xFF, 0x86, 0x0E, 0x30, 0x33, 0x01,
  0x98, 0x0C, 0xC0, 0xC6, 0x1C, 0x3F, 0xC1, 0x8F, 0x08, 0x1C, 0xC0, 0x66,
  0x03, 0x30, 0x19, 0x81, 0x8C, 0x1C, 0x7F, 0xC7, 0xF8, 0x00, 0x01, 0x00,
  0xFE, 0x1C, 0xE3, 0x03, 0x30, 0x36, 0x03, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0xEC, 0x0C, 0xC1, 0xC7,
  0xF8, 0x3F, 0x00, 0x1F, 0xE0, 0xFF, 0x86, 0x0C, 0x30, 0x33, 0x01, 0x98,
  0x0C, 0xC0, 0xC6, 0x06, 0x30, 0x31, 0x81, 0x9C, 0x0C, 0xC0, 0x66, 0x06,
  0x30, 0x31, 0x81, 0x8C, 0x18, 0x7F, 0x87, 0xF8, 0x00, 0x3F, 0xF9, 0xFF,
  0x8C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x04, 0x7F, 0xC3,
  0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xFF,
  0xC7, 0xFE, 0x00, 0x1F, 0xFC, 0x7F, 0xF1, 0x80, 0x06, 0x00, 0x18, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3F, 0xF0, 0xFF, 0xC3, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x00, 0x01,
  0x00, 0xFE, 0x1C, 0xE3, 0x03, 0x30, 0x36, 0x03, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x67, 0xEC, 0x7E, 0xC0, 0x6C, 0x06, 0xC0, 0xEC, 0x0C, 0xC1,
  0xC7, 0xF8, 0x3F, 0x00, 0x18, 0x18, 0xC0, 0xC6, 0x06, 0x30, 0x33, 0x01,
  0x98, 0x18, 0xC0, 0xC6, 0x06, 0x3F, 0xF1, 0x81, 0x8C, 0x0C, 0xC0, 0xC6,
  0x06, 0x30, 0x31, 0x81, 0x8C, 0x0C, 0x60, 0x66, 0x07, 0x00, 0x3F, 0xF3,
  0xFF, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0xFF, 0x8F,
  0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x60, 0x33,
  0x03, 0x98, 0x18, 0x7F, 0x81, 0xF8, 0x00, 0x18, 0x0C, 0x60, 0x61, 0x83,
  0x86, 0x0C, 0x30, 0x60, 0xC3, 0x83, 0x0C, 0x0C, 0x60, 0x3F, 0x80, 0xC6,
  0x07, 0x18, 0x18, 0x70, 0x60, 0xC1, 0x83, 0x06, 0x0E, 0x18, 0x18, 0x60,
  0x63, 0x01, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x06,
  0x00, 0xFF, 0xFF, 0xF8, 0x1C, 0x1C, 0x70, 0xF3, 0xC2, 0x8D, 0x1A, 0x34,
  0x58, 0xD3, 0x63, 0x69, 0x89, 0xE6, 0x67, 0x31, 0x8C, 0xC6, 0x03, 0x18,
  0x0C, 0x60, 0x31, 0x80, 0xCC, 0x06, 0x30, 0x18, 0xC0, 0x63, 0x01, 0x80,
  0x1C, 0x18, 0xE0, 0xC7, 0x06, 0x2C, 0x33, 0x61, 0x9B, 0x0C, 0xD8, 0xC6,
  0x46, 0x33, 0x31, 0x99, 0x98, 0xCC, 0xC2, 0x66, 0x16, 0x30, 0xF1, 0x87,
  0x8C, 0x3C, 0x40, 0xE6, 0x07, 0x00, 0x01, 0x00, 0xFE, 0x1C, 0xE3, 0x07,
  0x30, 0x36, 0x03, 0x60, 0x36, 0x06, 0x60, 0x66, 0x06, 0x60, 0x6C, 0x06,
  0xC0, 0x6C, 0x0C, 0xC0, 0xCC, 0x0C, 0xC1, 0xC7, 0xF8, 0x3E, 0x00, 0x1F,
  0xF0, 0x7F, 0xE1, 0x81, 0x86, 0x03, 0x30, 0x0C, 0xC0, 0x73, 0x01, 0x8C,
  0x0E, 0x30, 0xF0, 0xFF, 0x87, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x00, 0x01, 0x00, 0xFE, 0x1C, 0xE3,
  0x03, 0x70, 0x36, 0x03, 0x60, 0x36, 0x03, 0x60, 0x66, 0x06, 0xC0, 0x6C,
  0x06, 0xC0, 0x6C, 0x06, 0xC0, 0xCC, 0x0C, 0xC1, 0xCF, 0xF8, 0x7E, 0x00,
  0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x1F, 0xF0, 0x7F, 0xE1, 0x81,
  0x86, 0x06, 0x30, 0x18, 0xC0, 0x63, 0x01, 0x8C, 0x0C, 0x3F, 0xE0, 0xFF,
  0x06, 0x18, 0x18, 0x60, 0x61, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x38, 0x60,
  0x63, 0x01, 0x80, 0x00, 0x80, 0x3F, 0x83, 0x9E, 0x30, 0x31, 0x81, 0x98,
  0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xC0, 0x03,
  0x00, 0x1B, 0x80, 0xDC, 0x0C, 0x60, 0x63, 0xFE, 0x0F, 0xE0, 0xFF, 0xFF,
  0xFF, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03,
  0x00, 0x30, 0x33, 0x03, 0x30, 0x33, 0x03, 0x60, 0x36, 0x03, 0x60, 0x66,
  0x06, 0x60, 0x66, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0xCC, 0x0C, 0xC0, 0xCC,
  0x18, 0x7F, 0x87, 0xE0, 0xC0, 0x3C, 0x03, 0xC0, 0x66, 0x06, 0x60, 0xC6,
  0x0C, 0x60, 0xC6, 0x18, 0x61, 0x86, 0x30, 0x63, 0x06, 0x60, 0x66, 0x02,
  0x60, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0xC3, 0x0F, 0x0C, 0x3C, 0x71,
  0xB1, 0x46, 0xC5, 0x1B, 0x14, 0x4C, 0xD3, 0x32, 0x4C, 0xC9, 0x33, 0x64,
  0x8D, 0x16, 0x34, 0x58, 0xD1, 0x63, 0xC5, 0x0E, 0x1C, 0x38, 0x70, 0xE3,
  0x83, 0x0E, 0x00, 0x1C, 0x06, 0x18, 0x18, 0x30, 0x60, 0x30, 0xC0, 0x63,
  0x00, 0xEC, 0x00, 0xF8, 0x01, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x1B, 0x00,
  0x36, 0x00, 0xC6, 0x03, 0x0C, 0x0E, 0x18, 0x18, 0x18, 0x60, 0x31, 0xC0,
  0x70, 0xC0, 0x3E, 0x01, 0x98, 0x18, 0xC1, 0x86, 0x0C, 0x18, 0xC0, 0xCC,
  0x06, 0x60, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x0E,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xFF, 0xE7, 0xFF,
  0x00, 0x1F, 0x8F, 0xC6, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x18, 0x0C,
  0x06, 0x03, 0xF1, 0xF8, 0xC1, 0x81, 0x83, 0x06, 0x0C, 0x0C, 0x18, 0x30,
  0x60, 0xC0, 0xC1, 0x83, 0x06, 0x06, 0x0C, 0x18, 0x30, 0x30, 0x60, 0xC1,
  0x83, 0x0F, 0xC3, 0xF0, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x8F, 0xC3, 0xF0, 0x03, 0x80, 0xF0, 0x1E, 0x06,
  0x41, 0x8C, 0x31, 0x8C, 0x31, 0x83, 0x60, 0x78, 0x0C, 0xFF, 0xF0, 0xCE,
  0x63, 0x0F, 0x33, 0xFE, 0x30, 0xE6, 0x06, 0x60, 0x66, 0x06, 0xC0, 0x6C,
  0x06, 0xC0, 0xCC, 0x0C, 0xC0, 0xCC, 0x1C, 0xF6, 0xC7, 0xCC, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x33, 0xC3, 0x7E, 0x38, 0x73, 0x03, 0x30, 0x33,
  0x03, 0x70, 0x36, 0x03, 0x60, 0x66, 0x06, 0x60, 0x66, 0x0E, 0x7F, 0xCC,
  0xF8, 0x0F, 0x83, 0xFC, 0x30, 0x66, 0x06, 0x60, 0x66, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x0C, 0xC0, 0xCC, 0x1C, 0x7F, 0x83, 0xF0, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x0F, 0x33, 0xFF, 0x30, 0xE6, 0x06, 0x60, 0x66,
  0x06, 0xC0, 0x6C, 0x06, 0xC0, 0xCC, 0x0C, 0xC0, 0xCC, 0x1C, 0xF6, 0xC7,
  0xCC, 0x0F, 0x83, 0xF8, 0xC1, 0xB0, 0x36, 0x06, 0xC0, 0xFF, 0xFF, 0xFF,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0xE7, 0x78, 0x7E, 0x00, 0x00, 0x3F, 0x80,
  0x3F, 0x80, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x7F, 0xF8,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0xE0, 0x07, 0xE0, 0x03, 0x80, 0x00, 0x0F, 0x33,
  0xFE, 0x30, 0xE6, 0x06, 0x60, 0x66, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0xCC,
  0x0C, 0xE1, 0xC7, 0xFC, 0x3C, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x8F,
  0xF0, 0xF8, 0x00, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x33, 0xC3, 0x7E,
  0x38, 0x73, 0x03, 0x30, 0x33, 0x03, 0x70, 0x36, 0x03, 0x60, 0x66, 0x06,
  0x60, 0x66, 0x06, 0x60, 0x6C, 0x06, 0x01, 0xC0, 0x1C, 0x00, 0x80, 0x00,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0x38, 0x01, 0xC0, 0x04, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x06,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x03, 0x81, 0xF8,
  0x1E, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x1C, 0xC0,
  0xC3, 0x07, 0x0C, 0x38, 0x30, 0xC0, 0xC6, 0x03, 0xF0, 0x1F, 0xC0, 0x63,
  0x81, 0x86, 0x06, 0x1C, 0x18, 0x30, 0x60, 0xE3, 0x01, 0x80, 0xFC, 0x3F,
  0x00, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x3F, 0xC7, 0xF0, 0x3E, 0x71, 0x7F,
  0xDC, 0xC6, 0xC6, 0x36, 0x31, 0xB1, 0x8D, 0x88, 0xCC, 0x46, 0xC6, 0x36,
  0x31, 0xB1, 0x8D, 0x8C, 0x6C, 0x42, 0x62, 0x30, 0x33, 0xC3, 0x7E, 0x38,
  0x73, 0x03, 0x30, 0x33, 0x03, 0x70, 0x36, 0x03, 0x60, 0x66, 0x06, 0x60,
  0x66, 0x06, 0x60, 0x6C, 0x06, 0x0F, 0x87, 0xF8, 0xC3, 0xB0, 0x36, 0x06,
  0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0xD8, 0x1B, 0x03, 0x60, 0xE7, 0xF8, 0x7C,
  0x00, 0x33, 0xC3, 0x7E, 0x38, 0x73, 0x03, 0x30, 0x33, 0x03, 0x70, 0x36,
  0x03, 0x60, 0x66, 0x06, 0x60, 0x66, 0x0E, 0x7F, 0xCC, 0xF8, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x0F, 0x33, 0xFE, 0x30, 0xE6, 0x06,
  0x60, 0x66, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0xCC, 0x0C, 0xC0, 0xCC, 0x1C,
  0xF6, 0xC7, 0xCC, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x37,
  0xC3, 0xFE, 0x38, 0x67, 0x03, 0x60, 0x36, 0x06, 0x60, 0x06, 0x00, 0x60,
  0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x0F, 0xC7, 0xFD, 0xC1,
  0xB0, 0x06, 0x00, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0xC0, 0x18, 0x03, 0x60,
  0x6F, 0xF8, 0xFE, 0x00, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xFF, 0xFF,
  0xFF, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x1F, 0xC0, 0xFC, 0x60, 0x36, 0x03, 0x60, 0x66,
  0x06, 0x60, 0x66, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0xCC, 0x0C, 0xC0, 0xCC,
  0x18, 0x7F, 0x87, 0xE0, 0xC0, 0x78, 0x0F, 0x03, 0x60, 0x6C, 0x18, 0xC3,
  0x18, 0xC3, 0x18, 0x66, 0x0C, 0xC1, 0xB0, 0x16, 0x03, 0x80, 0x70, 0x00,
  0xC7, 0x1E, 0x38, 0xF1, 0xC5, 0x9E, 0x6C, 0xB3, 0x65, 0x93, 0x2D, 0x9B,
  0x6C, 0xD3, 0x46, 0x9A, 0x3C, 0xF1, 0xC7, 0x0E, 0x38, 0x71, 0xC0, 0x18,
  0x0C, 0x30, 0x60, 0xC3, 0x01, 0x9C, 0x06, 0x60, 0x0F, 0x00, 0x38, 0x00,
  0xE0, 0x07, 0xC0, 0x33, 0x01, 0xCE, 0x0E, 0x18, 0x30, 0x73, 0x80, 0xC0,
  0x60, 0x36, 0x06, 0x60, 0x66, 0x06, 0x60, 0x66, 0x06, 0xC0, 0x6C, 0x06,
  0xC0, 0xCC, 0x0C, 0xE1, 0xC7, 0xEC, 0x3C, 0xC0, 0x0C, 0x01, 0x80, 0x18,
  0x03, 0x8F, 0xF0, 0xF8, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x70, 0x0E, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xFF,
  0xEF, 0xFE, 0x00, 0x38, 0x07, 0xC0, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0xFC, 0x0F, 0xE0, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0,
  0x07, 0x00, 0x1F, 0x00, 0x30, 0x0C, 0x61, 0x86, 0x18, 0x61, 0x86, 0x30,
  0xC3, 0x0C, 0x30, 0xC6, 0x18, 0x61, 0x86, 0x18, 0xC3, 0x0C, 0x30, 0x1C,
  0x01, 0xF0, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x3F, 0x03, 0xF0, 0x60, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0xF8, 0x0C, 0x00, 0x7C,
  0x3E, 0xC3, 0xC6, 0x6C, 0x3E, 0xC1, 0x80,
};

const GFXglyph JetBrainsMono_LightItalic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 5, 18, 15, 5, -18 },
  { 13, 8, 7, 15, 5, -18 },
  { 20, 14, 18, 15, 1, -18 },
  { 52, 13, 26, 15, 1, -22 },
  { 95, 17, 18, 15, -1, -18 },
  { 134, 13, 19, 15, 1, -19 },
  { 165, 3, 7, 15, 7, -18 },
  { 168, 10, 24, 15, 4, -21 },
  { 198, 10, 24, 15, 1, -21 },
  { 228, 14, 13, 15, 1, -15 },
  { 251, 12, 12, 15, 2, -14 },
  { 269, 6, 8, 15, 3, -4 },
  { 275, 8, 2, 15, 4, -9 },
  { 277, 4, 4, 15, 5, -4 },
  { 279, 15, 24, 15, 0, -21 },
  { 324, 12, 19, 15, 2, -19 },
  { 353, 12, 18, 15, 1, -18 },
  { 380, 13, 19, 15, 1, -19 },
  { 411, 13, 18, 15, 1, -18 },
  { 441, 11, 18, 15, 2, -18 },
  { 466, 12, 18, 15, 2, -18 },
  { 493, 12, 18, 15, 1, -18 },
  { 520, 12, 18, 15, 3, -18 },
  { 547, 13, 19, 15, 1, -19 },
  { 578, 12, 19, 15, 2, -19 },
  { 607, 5, 14, 15, 5, -14 },
  { 616, 8, 18, 15, 3, -14 },
  { 634, 12, 13, 15, 2, -15 },
  { 654, 12, 8, 15, 2, -12 },
  { 666, 12, 13, 15, 1, -15 },
  { 686, 10, 18, 15, 4, -18 },
  { 709, 15, 24, 15, 0, -19 },
  { 754, 13, 18, 15, 0, -18 },
  { 784, 13, 18, 15, 1, -18 },
  { 814, 12, 19, 15, 2, -19 },
  { 843, 13, 18, 15, 1, -18 },
  { 873, 13, 18, 15, 2, -18 },
  { 903, 14, 18, 15, 1, -18 },
  { 935, 12, 19, 15, 2, -19 },
  { 964, 13, 18, 15, 1, -18 },
  { 994, 12, 18, 15, 2, -18 },
  { 1021, 13, 18, 15, 1, -18 },
  { 1051, 14, 18, 15, 1, -18 },
  { 1083, 11, 18, 15, 2, -18 },
  { 1108, 14, 18, 15, 1, -18 },
  { 1140, 13, 18, 15, 1, -18 },
  { 1170, 12, 19, 15, 2, -19 },
  { 1199, 14, 18, 15, 1, -18 },
  { 1231, 12, 24, 15, 2, -19 },
  { 1267, 14, 18, 15, 1, -18 },
  { 1299, 13, 19, 15, 1, -19 },
  { 1330, 12, 18, 15, 3, -18 },
  { 1357, 12, 18, 15, 2, -18 },
  { 1384, 12, 18, 15, 3, -18 },
  { 1411, 14, 18, 15, 2, -18 },
  { 1443, 15, 18, 15, 0, -18 },
  { 1477, 13, 18, 15, 3, -18 },
  { 1507, 13, 18, 15, 1, -18 },
  { 1537, 9, 24, 15, 4, -21 },
  { 1564, 7, 24, 15, 4, -21 },
  { 1585, 10, 24, 15, 2, -21 },
  { 1615, 11, 10, 15, 2, -18 },
  { 1629, 12, 1, 15, 0, 1 },
  { 1631, 4, 4, 15, 7, -20 },
  { 1633, 12, 14, 15, 2, -14 },
  { 1654, 12, 18, 15, 1, -18 },
  { 1681, 12, 14, 15, 2, -14 },
  { 1702, 12, 18, 15, 2, -18 },
  { 1729, 11, 14, 15, 2, -14 },
  { 1749, 17, 23, 15, -1, -18 },
  { 1798, 12, 19, 15, 2, -14 },
  { 1827, 12, 18, 15, 1, -18 },
  { 1854, 12, 19, 15, 1, -19 },
  { 1883, 13, 24, 15, 0, -19 },
  { 1922, 14, 18, 15, 1, -18 },
  { 1954, 10, 18, 15, 3, -18 },
  { 1977, 13, 14, 15, 1, -14 },
  { 2000, 12, 14, 15, 1, -14 },
  { 2021, 11, 14, 15, 2, -14 },
  { 2041, 12, 19, 15, 1, -14 },
  { 2070, 12, 19, 15, 2, -14 },
  { 2099, 12, 14, 15, 2, -14 },
  { 2120, 11, 14, 15, 2, -14 },
  { 2140, 12, 18, 15, 2, -18 },
  { 2167, 12, 14, 15, 2, -14 },
  { 2188, 11, 14, 15, 3, -14 },
  { 2208, 13, 14, 15, 2, -14 },
  { 2231, 14, 14, 15, 0, -14 },
  { 2256, 12, 19, 15, 2, -14 },
  { 2285, 12, 14, 15, 1, -14 },
  { 2306, 13, 24, 15, 2, -21 },
  { 2345, 6, 24, 15, 5, -21 },
  { 2363, 12, 24, 15, 1, -21 },
  { 2399, 12, 5, 15, 2, -11 },
};

const GFXfont JetBrainsMono_LightItalic25pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_LightItalic25pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_LightItalic25pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _JETBRAINSMONO_LIGHTITALIC25PT7B_H_
