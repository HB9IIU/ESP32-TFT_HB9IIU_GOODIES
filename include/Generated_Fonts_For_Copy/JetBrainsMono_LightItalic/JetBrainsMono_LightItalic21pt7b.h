#ifndef _JETBRAINSMONO_LIGHTITALIC21PT7B_H_
#define _JETBRAINSMONO_LIGHTITALIC21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-LightItalic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_LightItalic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xCC, 0x63, 0x18, 0xC4, 0x21, 0x18, 0x00, 0x73, 0x80, 0x67,
  0x8F, 0x16, 0x6C, 0xD1, 0x80, 0x03, 0x10, 0x31, 0x81, 0x88, 0x08, 0x43,
  0xFF, 0x86, 0x20, 0x21, 0x03, 0x18, 0x10, 0x83, 0xFF, 0x3F, 0xF8, 0x42,
  0x02, 0x10, 0x31, 0x81, 0x08, 0x00, 0x01, 0x00, 0x20, 0x0C, 0x07, 0xE1,
  0xAE, 0x64, 0xCC, 0x99, 0x90, 0x36, 0x03, 0x80, 0x3E, 0x02, 0xC0, 0x4C,
  0x09, 0xB3, 0x36, 0x4C, 0x6B, 0x87, 0xC0, 0x20, 0x04, 0x01, 0x80, 0x1F,
  0x06, 0x22, 0x10, 0xC4, 0x41, 0x89, 0x83, 0x36, 0x07, 0xD8, 0x03, 0x20,
  0x00, 0x80, 0x02, 0x70, 0x09, 0x30, 0x36, 0x20, 0xC8, 0xC1, 0x11, 0x84,
  0x32, 0x30, 0x38, 0x00, 0x02, 0x03, 0xF0, 0x63, 0x18, 0x63, 0x00, 0x60,
  0x04, 0x01, 0xC0, 0x6C, 0x79, 0x8B, 0x1B, 0x61, 0xCC, 0x31, 0x06, 0x33,
  0x63, 0xC6, 0x6B, 0x6D, 0x80, 0x00, 0x81, 0xC1, 0x81, 0x81, 0x81, 0x80,
  0xC0, 0x40, 0x20, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x18, 0x0E, 0x03, 0x80, 0x40, 0x10, 0x0E, 0x01, 0x80, 0x60, 0x30, 0x18,
  0x04, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x18, 0x0C, 0x0C,
  0x0C, 0x0C, 0x1C, 0x08, 0x00, 0x02, 0x00, 0xC0, 0x18, 0x23, 0x1F, 0x5E,
  0x7F, 0x03, 0x00, 0xD0, 0x33, 0x0C, 0x70, 0x84, 0x00, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x7F, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x19, 0x8C,
  0xC6, 0x60, 0xFF, 0xFC, 0xFF, 0x80, 0x00, 0x38, 0x01, 0x80, 0x18, 0x00,
  0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x10, 0x01, 0x80,
  0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x38,
  0x00, 0x03, 0x01, 0xF8, 0x63, 0x18, 0x32, 0x06, 0xC0, 0xD8, 0x13, 0x32,
  0x6E, 0xCC, 0x99, 0x03, 0x20, 0x6C, 0x08, 0x83, 0x18, 0xC1, 0xF0, 0x07,
  0x07, 0xC3, 0x30, 0x8C, 0x03, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x10, 0x04, 0x3F, 0xFF, 0xF8, 0x03, 0x03, 0xF8, 0xE3, 0x18, 0x36,
  0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x00,
  0xC0, 0x3F, 0xE7, 0xFC, 0x1F, 0xE4, 0x18, 0x06, 0x01, 0x80, 0x60, 0x1C,
  0x03, 0xE0, 0x0C, 0x00, 0xC0, 0x18, 0x02, 0x60, 0x4C, 0x18, 0xC6, 0x0F,
  0x80, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x02, 0x01, 0x8C, 0xC3, 0x60,
  0xD0, 0x27, 0xFB, 0xFE, 0x01, 0x80, 0x60, 0x18, 0x1F, 0xE6, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x5F, 0x0E, 0x63, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x40,
  0x44, 0x18, 0xC6, 0x0F, 0x80, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x06,
  0x03, 0xF9, 0xC7, 0x60, 0xD0, 0x3C, 0x0F, 0x03, 0xC1, 0x98, 0xC3, 0xE0,
  0xFF, 0xF0, 0x28, 0x1A, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x06,
  0x01, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x00, 0x03, 0x01, 0xF8, 0x63, 0x18,
  0x33, 0x04, 0x61, 0x8C, 0x60, 0xF8, 0x1F, 0x06, 0x31, 0x82, 0x20, 0x6C,
  0x09, 0x83, 0x18, 0xE1, 0xF0, 0x06, 0x07, 0xE3, 0x1D, 0x83, 0xC0, 0xF0,
  0x3C, 0x0F, 0x06, 0x63, 0x8F, 0xC0, 0x60, 0x10, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0x33, 0xDC, 0x00, 0x00, 0x00, 0x03, 0x39, 0xC0, 0x0C, 0x3C, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0xC1, 0x86, 0x0C, 0x30, 0x00, 0x00,
  0xC0, 0xE0, 0xE0, 0xE0, 0xE0, 0x30, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xC0,
  0x08, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x20, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xC0, 0x30, 0x78, 0x78, 0x70, 0x30, 0x08, 0x00, 0x7E, 0x07,
  0x03, 0x01, 0x03, 0x03, 0x06, 0x3C, 0x20, 0x20, 0x60, 0x00, 0x00, 0xE0,
  0xE0, 0x01, 0x80, 0x3F, 0x06, 0x0C, 0x20, 0x23, 0x01, 0x10, 0x08, 0x8F,
  0x4C, 0x46, 0x66, 0x33, 0x31, 0x99, 0x8C, 0x88, 0x44, 0x42, 0x23, 0x33,
  0x0E, 0x98, 0x00, 0x40, 0x03, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x03, 0x80,
  0x50, 0x0A, 0x03, 0x40, 0x48, 0x19, 0x82, 0x30, 0xC6, 0x18, 0xC3, 0xF8,
  0xFF, 0x10, 0x26, 0x04, 0xC0, 0xB0, 0x18, 0x3F, 0xC6, 0x18, 0xC1, 0x98,
  0x32, 0x04, 0x41, 0x9F, 0xE3, 0xFC, 0x60, 0xCC, 0x19, 0x03, 0x20, 0x64,
  0x19, 0xFE, 0x3F, 0x80, 0x03, 0x01, 0xF8, 0x63, 0x18, 0x33, 0x06, 0x40,
  0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x0C, 0x83, 0x18,
  0xC1, 0xF0, 0x3F, 0x86, 0x18, 0xC1, 0x18, 0x32, 0x04, 0x40, 0x98, 0x33,
  0x06, 0x60, 0xCC, 0x19, 0x82, 0x20, 0xC4, 0x19, 0x9E, 0x3F, 0x00, 0x1F,
  0xE6, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x0F, 0xF3, 0xFC, 0x60, 0x0C,
  0x01, 0x80, 0x20, 0x04, 0x00, 0xFF, 0x3F, 0xE0, 0x3F, 0xF3, 0x00, 0x30,
  0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x07, 0xFC, 0x60, 0x06, 0x00, 0x60,
  0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x00, 0x03, 0x01, 0xF8, 0x63, 0x18,
  0x33, 0x06, 0x40, 0x08, 0x03, 0x00, 0x67, 0xCC, 0xF9, 0x83, 0x20, 0x64,
  0x08, 0x83, 0x18, 0xC1, 0xF0, 0x30, 0x66, 0x0C, 0xC1, 0x98, 0x22, 0x04,
  0x41, 0x9F, 0xF3, 0xFE, 0x60, 0xCC, 0x11, 0x82, 0x20, 0x44, 0x19, 0x83,
  0x30, 0x60, 0x1F, 0xE0, 0x40, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x20, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0xFF, 0x3F, 0xC0, 0x03,
  0xF0, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x40, 0x04, 0x20, 0xC4, 0x0C, 0x60, 0xC7, 0x38, 0x3F, 0x00, 0x30, 0x33,
  0x06, 0x30, 0xC3, 0x08, 0x21, 0x82, 0x30, 0x7E, 0x07, 0xE0, 0x62, 0x06,
  0x30, 0x43, 0x04, 0x18, 0x41, 0x8C, 0x18, 0xC0, 0xC0, 0x30, 0x10, 0x08,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0x80, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x07,
  0xFF, 0xFC, 0x38, 0x67, 0x1C, 0xA2, 0x94, 0xF6, 0x96, 0xD6, 0xDB, 0x93,
  0x72, 0x40, 0xC8, 0x1B, 0x03, 0x60, 0x6C, 0x09, 0x81, 0x20, 0x60, 0x38,
  0x67, 0x0C, 0xE1, 0x96, 0x32, 0xC4, 0x58, 0x99, 0x33, 0x26, 0x66, 0xCC,
  0xD9, 0x0A, 0x21, 0x4C, 0x29, 0x87, 0x30, 0xE0, 0x03, 0x01, 0xF8, 0x63,
  0x18, 0x33, 0x06, 0x40, 0x88, 0x13, 0x06, 0x60, 0xCC, 0x19, 0x83, 0x20,
  0x44, 0x08, 0x83, 0x18, 0xC1, 0xF0, 0x3F, 0xC6, 0x0C, 0xC1, 0x98, 0x12,
  0x06, 0x40, 0xD8, 0x33, 0xFC, 0x7E, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x01,
  0x80, 0x30, 0x00, 0x03, 0x01, 0xF8, 0x63, 0x18, 0x32, 0x06, 0x40, 0xD8,
  0x13, 0x02, 0x60, 0xCC, 0x19, 0x03, 0x20, 0x6C, 0x08, 0x83, 0x18, 0xC1,
  0xF0, 0x06, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x3F, 0xC6, 0x1C, 0xC1, 0x98,
  0x32, 0x06, 0x40, 0xD8, 0x33, 0xFC, 0x66, 0x0C, 0x61, 0x0C, 0x21, 0x84,
  0x19, 0x83, 0x30, 0x60, 0x03, 0x01, 0xF8, 0x63, 0x98, 0x33, 0x06, 0x60,
  0x0C, 0x00, 0xE0, 0x0F, 0x00, 0x30, 0x03, 0x00, 0x6C, 0x0D, 0x83, 0x18,
  0xE1, 0xF0, 0x7F, 0xF0, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x40, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x00, 0x30,
  0x66, 0x0C, 0xC1, 0x98, 0x32, 0x04, 0x40, 0x98, 0x33, 0x06, 0x60, 0xCC,
  0x19, 0x02, 0x20, 0x44, 0x18, 0xC6, 0x0F, 0x80, 0x80, 0xF0, 0x6C, 0x1B,
  0x04, 0xC3, 0x30, 0x8C, 0x63, 0x18, 0x44, 0x13, 0x04, 0x81, 0x60, 0x78,
  0x1C, 0x07, 0x00, 0x63, 0x1B, 0x29, 0x99, 0x4C, 0x8A, 0x44, 0x72, 0x25,
  0xB1, 0x29, 0x89, 0x48, 0x52, 0x42, 0x96, 0x14, 0xA0, 0xA5, 0x06, 0x28,
  0x31, 0xC3, 0x8C, 0x00, 0x18, 0x38, 0xC1, 0x83, 0x18, 0x19, 0x80, 0x48,
  0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x6C, 0x06, 0x60, 0x21, 0x03,
  0x0C, 0x30, 0x63, 0x01, 0x80, 0xC0, 0x6C, 0x19, 0x82, 0x10, 0xC3, 0x30,
  0x66, 0x05, 0x80, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20,
  0x04, 0x00, 0x3F, 0xE0, 0x0C, 0x03, 0x00, 0xC0, 0x10, 0x06, 0x01, 0x80,
  0x60, 0x0C, 0x03, 0x00, 0xC0, 0x10, 0x06, 0x01, 0xFF, 0x3F, 0xE0, 0x1F,
  0x18, 0x10, 0x10, 0x30, 0x30, 0x30, 0x30, 0x20, 0x20, 0x60, 0x60, 0x60,
  0x60, 0x60, 0x40, 0x40, 0xC0, 0xF8, 0xC0, 0xC1, 0x83, 0x02, 0x06, 0x0C,
  0x18, 0x10, 0x20, 0x60, 0xC1, 0x81, 0x03, 0x06, 0x0C, 0x08, 0x18, 0x1F,
  0x03, 0x03, 0x02, 0x02, 0x06, 0x06, 0x06, 0x06, 0x04, 0x04, 0x0C, 0x0C,
  0x0C, 0x0C, 0x0C, 0x08, 0x08, 0xF8, 0x06, 0x05, 0x06, 0x82, 0x63, 0x13,
  0x09, 0x07, 0x83, 0xFF, 0xC0, 0xCC, 0x0E, 0x47, 0xD3, 0x0D, 0x83, 0x60,
  0xD8, 0x36, 0x0D, 0x02, 0x40, 0x90, 0x66, 0x38, 0xF6, 0x30, 0x0C, 0x03,
  0x00, 0xDC, 0x2F, 0x8C, 0x36, 0x0D, 0x83, 0x60, 0xD8, 0x34, 0x09, 0x02,
  0x61, 0xB8, 0xCD, 0xE0, 0x07, 0x07, 0xE3, 0x0D, 0x83, 0x60, 0x18, 0x06,
  0x01, 0x00, 0x40, 0x90, 0x66, 0x30, 0xF8, 0x00, 0x60, 0x0C, 0x01, 0x87,
  0x21, 0xF4, 0x61, 0x98, 0x33, 0x06, 0x60, 0xCC, 0x19, 0x02, 0x20, 0x44,
  0x18, 0xC7, 0x0F, 0x60, 0x07, 0x07, 0xE3, 0x0D, 0x83, 0x60, 0xDF, 0xF7,
  0xFD, 0x00, 0x40, 0x10, 0x66, 0x30, 0xF8, 0x00, 0xFC, 0x06, 0x00, 0x10,
  0x00, 0x40, 0x03, 0x00, 0x7F, 0xE0, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C,
  0x03, 0xF0, 0x0F, 0x00, 0x00, 0x1C, 0x9F, 0x58, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x02, 0xC3, 0x63, 0x9E, 0xC0, 0x60, 0x30, 0x13, 0xF9, 0xF0, 0x30,
  0x0C, 0x03, 0x00, 0xDC, 0x2F, 0x8C, 0x36, 0x0D, 0x83, 0x60, 0xD8, 0x34,
  0x09, 0x02, 0x41, 0xB0, 0x6C, 0x18, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x3E,
  0x0F, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x10, 0x04, 0x03, 0x0F,
  0xFF, 0xFF, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x30,
  0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x08,
  0x03, 0x00, 0x61, 0xF8, 0x7C, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x33,
  0x0C, 0x43, 0x08, 0x63, 0x18, 0x7E, 0x0F, 0xC1, 0x98, 0x21, 0x84, 0x31,
  0x83, 0x30, 0x60, 0xFC, 0x04, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x20,
  0x10, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xFC, 0x7E, 0x6C, 0xCF, 0xBD, 0x99,
  0xA2, 0x34, 0x44, 0x88, 0xB1, 0x16, 0x66, 0xCC, 0xD1, 0x1A, 0x22, 0x44,
  0x40, 0x37, 0x0B, 0xE3, 0x0D, 0x83, 0x60, 0xD8, 0x36, 0x0D, 0x02, 0x40,
  0x90, 0x6C, 0x1B, 0x06, 0x07, 0x07, 0xE3, 0x0D, 0x83, 0x60, 0xD8, 0x36,
  0x0D, 0x02, 0x40, 0x90, 0x66, 0x30, 0xF8, 0x1B, 0x82, 0xF8, 0x61, 0x98,
  0x33, 0x06, 0x60, 0xCC, 0x19, 0x02, 0x20, 0x4E, 0x19, 0xC6, 0x37, 0x86,
  0x00, 0xC0, 0x10, 0x06, 0x00, 0x0E, 0x47, 0xD3, 0x0D, 0x83, 0x60, 0xD8,
  0x36, 0x0D, 0x02, 0x41, 0x90, 0x66, 0x38, 0xF6, 0x01, 0x80, 0x40, 0x10,
  0x0C, 0x33, 0x87, 0xF8, 0xC3, 0x18, 0x22, 0x04, 0x40, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x00, 0x60, 0x00, 0x0F, 0x0F, 0xF3, 0x0C, 0x80, 0x60,
  0x0F, 0x81, 0xF8, 0x06, 0x00, 0xB0, 0x66, 0x39, 0xFC, 0x0C, 0x02, 0x00,
  0x83, 0xFF, 0xFF, 0xC6, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0F, 0xC1, 0xF0, 0x30, 0x64, 0x08, 0x81, 0x30, 0x66, 0x0C, 0xC1,
  0x98, 0x32, 0x04, 0x40, 0x88, 0x31, 0x8C, 0x1F, 0x00, 0xC0, 0xF0, 0x34,
  0x19, 0x06, 0x63, 0x18, 0xC6, 0x21, 0x98, 0x24, 0x0B, 0x03, 0x80, 0xE0,
  0x8C, 0x71, 0x8A, 0x31, 0x4A, 0x69, 0x49, 0x29, 0x29, 0x65, 0x28, 0xA5,
  0x18, 0xE3, 0x18, 0x63, 0x00, 0x30, 0x31, 0x86, 0x18, 0xC0, 0xCC, 0x05,
  0x80, 0x70, 0x07, 0x00, 0xF0, 0x19, 0x83, 0x18, 0x30, 0xCE, 0x0C, 0x60,
  0xA0, 0x50, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x02, 0xC3, 0x63, 0x9E, 0xC0,
  0x60, 0x30, 0x33, 0xF9, 0xF0, 0x3F, 0xCF, 0xF0, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0F, 0xFB, 0xFE, 0x01, 0xE0, 0x60, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x1F, 0x00, 0x30, 0x06,
  0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x3C, 0x00, 0x18,
  0xC6, 0x21, 0x18, 0xC6, 0x31, 0x08, 0xC6, 0x31, 0x88, 0x46, 0x30, 0x3C,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xF0,
  0xC0, 0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x0E, 0x00, 0x7C,
  0x68, 0x89, 0x1F, 0x61, 0xC0,
};

const GFXglyph JetBrainsMono_LightItalic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 5, 15, 13, 4, -15 },
  { 11, 7, 6, 13, 4, -15 },
  { 17, 13, 15, 13, 0, -15 },
  { 42, 11, 21, 13, 1, -18 },
  { 71, 15, 15, 13, -1, -15 },
  { 100, 11, 16, 13, 1, -16 },
  { 122, 3, 6, 13, 6, -15 },
  { 125, 9, 21, 13, 3, -18 },
  { 149, 9, 21, 13, 1, -18 },
  { 173, 11, 11, 13, 1, -13 },
  { 189, 10, 10, 13, 1, -12 },
  { 202, 5, 6, 13, 2, -3 },
  { 206, 7, 2, 13, 3, -8 },
  { 208, 3, 3, 13, 4, -3 },
  { 210, 13, 19, 13, 0, -17 },
  { 241, 11, 16, 13, 1, -16 },
  { 263, 10, 15, 13, 1, -15 },
  { 282, 11, 16, 13, 1, -16 },
  { 304, 11, 15, 13, 1, -15 },
  { 325, 10, 15, 13, 1, -15 },
  { 344, 11, 15, 13, 1, -15 },
  { 365, 10, 15, 13, 1, -15 },
  { 384, 10, 15, 13, 3, -15 },
  { 403, 11, 16, 13, 1, -16 },
  { 425, 10, 16, 13, 2, -16 },
  { 445, 5, 12, 13, 4, -12 },
  { 453, 7, 15, 13, 2, -12 },
  { 467, 10, 11, 13, 2, -12 },
  { 481, 9, 6, 13, 2, -10 },
  { 488, 10, 11, 13, 1, -12 },
  { 502, 8, 15, 13, 3, -15 },
  { 517, 13, 20, 13, 0, -16 },
  { 550, 11, 15, 13, 0, -15 },
  { 571, 11, 15, 13, 1, -15 },
  { 592, 11, 16, 13, 1, -16 },
  { 614, 11, 15, 13, 1, -15 },
  { 635, 11, 15, 13, 1, -15 },
  { 656, 12, 15, 13, 1, -15 },
  { 679, 11, 16, 13, 1, -16 },
  { 701, 11, 15, 13, 1, -15 },
  { 722, 11, 15, 13, 1, -15 },
  { 743, 12, 15, 13, 0, -15 },
  { 766, 12, 15, 13, 1, -15 },
  { 789, 9, 15, 13, 2, -15 },
  { 806, 11, 15, 13, 1, -15 },
  { 827, 11, 15, 13, 1, -15 },
  { 848, 11, 16, 13, 1, -16 },
  { 870, 11, 15, 13, 1, -15 },
  { 891, 11, 20, 13, 1, -16 },
  { 919, 11, 15, 13, 1, -15 },
  { 940, 11, 16, 13, 1, -16 },
  { 962, 11, 15, 13, 2, -15 },
  { 983, 11, 15, 13, 1, -15 },
  { 1004, 10, 15, 13, 3, -15 },
  { 1023, 13, 15, 13, 1, -15 },
  { 1048, 13, 15, 13, 0, -15 },
  { 1073, 11, 15, 13, 2, -15 },
  { 1094, 11, 15, 13, 1, -15 },
  { 1115, 8, 19, 13, 3, -17 },
  { 1134, 7, 19, 13, 3, -17 },
  { 1151, 8, 19, 13, 2, -17 },
  { 1170, 9, 8, 13, 2, -15 },
  { 1179, 10, 1, 13, 0, 1 },
  { 1181, 3, 2, 13, 6, -16 },
  { 1182, 10, 12, 13, 1, -12 },
  { 1197, 10, 15, 13, 1, -15 },
  { 1216, 10, 12, 13, 1, -12 },
  { 1231, 11, 15, 13, 1, -15 },
  { 1252, 10, 12, 13, 1, -12 },
  { 1267, 14, 19, 13, -1, -15 },
  { 1301, 9, 16, 13, 2, -12 },
  { 1319, 10, 15, 13, 1, -15 },
  { 1338, 10, 16, 13, 1, -16 },
  { 1358, 11, 20, 13, 0, -16 },
  { 1386, 11, 15, 13, 1, -15 },
  { 1407, 9, 15, 13, 2, -15 },
  { 1424, 11, 12, 13, 1, -12 },
  { 1441, 10, 12, 13, 1, -12 },
  { 1456, 10, 12, 13, 1, -12 },
  { 1471, 11, 16, 13, 0, -12 },
  { 1493, 10, 16, 13, 1, -12 },
  { 1513, 11, 12, 13, 1, -12 },
  { 1530, 10, 12, 13, 1, -12 },
  { 1545, 10, 15, 13, 2, -15 },
  { 1564, 11, 12, 13, 1, -12 },
  { 1581, 10, 12, 13, 2, -12 },
  { 1596, 11, 12, 13, 2, -12 },
  { 1613, 12, 12, 13, 0, -12 },
  { 1631, 9, 16, 13, 2, -12 },
  { 1649, 10, 12, 13, 1, -12 },
  { 1664, 11, 19, 13, 2, -17 },
  { 1691, 5, 19, 13, 4, -17 },
  { 1703, 10, 19, 13, 1, -17 },
  { 1727, 11, 4, 13, 1, -9 },
};

const GFXfont JetBrainsMono_LightItalic21pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_LightItalic21pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_LightItalic21pt7bGlyphs,
  0x20, 0x7E, 28
};

#endif // _JETBRAINSMONO_LIGHTITALIC21PT7B_H_
