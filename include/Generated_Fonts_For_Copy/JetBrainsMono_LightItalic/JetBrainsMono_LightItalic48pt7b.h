#ifndef _JETBRAINSMONO_LIGHTITALIC48PT7B_H_
#define _JETBRAINSMONO_LIGHTITALIC48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-LightItalic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_LightItalic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x3E,
  0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0xFE, 0x1F, 0xC1,
  0xF0, 0x00, 0x3C, 0x1F, 0x3C, 0x1F, 0x7C, 0x1E, 0x7C, 0x1E, 0x78, 0x1E,
  0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1C, 0x78, 0x3C, 0x70, 0x3C, 0x70, 0x3C,
  0xF0, 0x3C, 0xF0, 0x38, 0xF0, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x00, 0xF0,
  0x1E, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x1E, 0x03, 0xC0,
  0x01, 0xC0, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x38,
  0x07, 0x00, 0x03, 0x80, 0x70, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0x01, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x0E,
  0x01, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0, 0x38,
  0x00, 0x38, 0x07, 0x80, 0x03, 0x80, 0x70, 0x00, 0x38, 0x07, 0x00, 0x7F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x1C,
  0x00, 0x0E, 0x01, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x1C, 0x03, 0x80, 0x01,
  0xC0, 0x38, 0x00, 0x3C, 0x07, 0x80, 0x03, 0x80, 0x70, 0x00, 0x38, 0x07,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7C, 0xE7, 0xC0, 0x7C, 0x71, 0xF0, 0x3C,
  0x38, 0x78, 0x3C, 0x18, 0x3C, 0x1E, 0x0C, 0x1E, 0x0E, 0x0E, 0x0F, 0x07,
  0x07, 0x00, 0x07, 0xC3, 0x80, 0x01, 0xE1, 0xC0, 0x00, 0xF0, 0xC0, 0x00,
  0x7C, 0x60, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0x9F,
  0x80, 0x01, 0xC3, 0xC0, 0x00, 0xE1, 0xE0, 0x00, 0x70, 0x78, 0x00, 0x30,
  0x3C, 0x00, 0x18, 0x1E, 0x3C, 0x0C, 0x0E, 0x1E, 0x0E, 0x0F, 0x0F, 0x07,
  0x07, 0x87, 0x83, 0x87, 0x83, 0xE1, 0xC7, 0xC0, 0xFC, 0xCF, 0xC0, 0x7F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x07, 0x01,
  0xFF, 0x00, 0x0E, 0x03, 0xFF, 0x80, 0x1C, 0x07, 0x83, 0x80, 0x3C, 0x07,
  0x03, 0xC0, 0x78, 0x07, 0x03, 0xC0, 0x70, 0x0F, 0x03, 0x80, 0xE0, 0x0E,
  0x03, 0x81, 0xC0, 0x0E, 0x03, 0x83, 0x80, 0x0E, 0x03, 0x87, 0x00, 0x0E,
  0x03, 0x8F, 0x00, 0x0E, 0x07, 0x1E, 0x00, 0x0F, 0x0F, 0x1C, 0x00, 0x07,
  0xFE, 0x38, 0x00, 0x07, 0xFC, 0x70, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x07, 0x80, 0x00, 0x0E, 0x3F, 0xE0, 0x00, 0x1C, 0x7F, 0xF0, 0x00,
  0x38, 0xF0, 0xF0, 0x00, 0x78, 0xE0, 0x70, 0x00, 0xF1, 0xE0, 0x70, 0x00,
  0xE1, 0xC0, 0x70, 0x01, 0xC1, 0xC0, 0x70, 0x03, 0x81, 0xC0, 0x70, 0x07,
  0x01, 0xC0, 0x70, 0x0F, 0x01, 0xC0, 0xF0, 0x1E, 0x01, 0xC0, 0xE0, 0x1C,
  0x01, 0xC1, 0xE0, 0x38, 0x01, 0xFF, 0xC0, 0x70, 0x00, 0xFF, 0x80, 0xE0,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x78, 0x07, 0x80, 0x1E,
  0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x0E, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x78, 0xF8, 0x0F, 0x3C, 0x1E, 0x07, 0x8F,
  0x07, 0xC3, 0xC3, 0xC0, 0xF0, 0xF0, 0xE0, 0x1E, 0x78, 0x78, 0x07, 0xBC,
  0x1E, 0x00, 0xFF, 0x07, 0x80, 0x3F, 0x81, 0xE0, 0x07, 0xC0, 0x78, 0x01,
  0xF0, 0x1E, 0x00, 0x7C, 0x07, 0x80, 0x3F, 0x81, 0xE0, 0x1F, 0xE0, 0x7C,
  0x1F, 0x3C, 0x1F, 0xFF, 0x8F, 0x83, 0xFF, 0xC1, 0xE0, 0x7F, 0xC0, 0x3C,
  0x7D, 0xF7, 0x9E, 0x79, 0xEF, 0xBE, 0xF3, 0xCF, 0x3C, 0xE3, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x0E, 0x00, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0xE0, 0x38, 0x06, 0xFC, 0x1C, 0x1F, 0xFF,
  0x8E, 0x7F, 0xFF, 0xF6, 0x7F, 0xC3, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xCF, 0x00,
  0x03, 0xE7, 0xC0, 0x03, 0xE1, 0xE0, 0x01, 0xE0, 0xF8, 0x01, 0xE0, 0x3C,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x07, 0x80, 0x30, 0x03, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xF0, 0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x1F,
  0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x3E, 0x7E, 0xFF,
  0xFF, 0xFE, 0xFE, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x1E,
  0x0F, 0x80, 0x1F, 0x0F, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x0F,
  0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1C, 0x00, 0x0E, 0x3C, 0x00, 0x1E,
  0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x3C, 0x1E, 0x3C, 0x7E, 0x1E,
  0x38, 0x7E, 0x1C, 0x78, 0x3E, 0x3C, 0x78, 0x3C, 0x3C, 0x78, 0x00, 0x3C,
  0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x70, 0x00, 0x3C, 0x70, 0x00, 0x38,
  0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF0,
  0xF8, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0x7E, 0x07, 0xC0, 0x3F, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xF9, 0xE0, 0x0F, 0x87, 0x00, 0x7C,
  0x3C, 0x01, 0xC0, 0xF0, 0x06, 0x03, 0xC0, 0x20, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x7F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0x03, 0xF0, 0x1E,
  0x00, 0x78, 0x1E, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87,
  0x80, 0x03, 0xC3, 0x80, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x70, 0xF0, 0x00, 0xF0,
  0xF0, 0x00, 0xF0, 0xF0, 0x01, 0xE0, 0xF8, 0x03, 0xE0, 0x7C, 0x0F, 0xC0,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x1E, 0x07, 0x80, 0x3C, 0x1E, 0x00,
  0x70, 0x7C, 0x00, 0xE1, 0xF0, 0x03, 0xC3, 0xC0, 0x07, 0x8F, 0x00, 0x0F,
  0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x1F, 0x80, 0x1E, 0x7F, 0xE0, 0x1E, 0xFF, 0xF0, 0x1F,
  0xE3, 0xF8, 0x1F, 0x80, 0xF8, 0x1E, 0x00, 0x7C, 0x3E, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x70, 0xF0, 0x00, 0xF0, 0xF8, 0x01, 0xF0, 0x78, 0x01, 0xE0, 0x7E,
  0x07, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x18, 0x00, 0xFB, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0xFC, 0x03,
  0xE3, 0xE0, 0x07, 0xDF, 0x00, 0x0F, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0xFB, 0xE0, 0x03, 0xC7, 0x80, 0x1E,
  0x1F, 0x81, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE7,
  0x80, 0x03, 0xDE, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x78, 0xF0,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x1E, 0x07,
  0x80, 0x1E, 0x0F, 0x00, 0x0E, 0x0F, 0x00, 0x0E, 0x0F, 0x00, 0x0E, 0x0F,
  0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x3C, 0x0F, 0x80, 0x78, 0x07,
  0xC0, 0xF0, 0x03, 0xE3, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xC3, 0xE0, 0x1F, 0x01, 0xF0, 0x3C,
  0x00, 0xF8, 0x3C, 0x00, 0x78, 0x78, 0x00, 0x78, 0x70, 0x00, 0x78, 0xF0,
  0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0,
  0x00, 0xF0, 0xF8, 0x01, 0xF0, 0x7E, 0x07, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xF8, 0x1F, 0x83, 0xE0, 0x0F, 0x8F, 0x00,
  0x0F, 0x3E, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x7B, 0xC0, 0x00,
  0xF7, 0x80, 0x01, 0xEF, 0x00, 0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00, 0x1E,
  0x78, 0x00, 0x3C, 0xF8, 0x00, 0xF9, 0xF0, 0x03, 0xE1, 0xF0, 0x0F, 0xC3,
  0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x01, 0xFE, 0xF8, 0x00, 0x61, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0x81, 0xF8, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0x83, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0xFC, 0x3F, 0xC7, 0xF8, 0xFE, 0x1F,
  0xC1, 0xF0, 0x00, 0x00, 0x7C, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0x80, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x01, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x1F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFE, 0x00, 0x18, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07,
  0xE0, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x00, 0x78,
  0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x70, 0x3C,
  0x00, 0x03, 0xC1, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xE0, 0xF0, 0x00,
  0x07, 0x07, 0x00, 0x7F, 0x38, 0x38, 0x07, 0xFD, 0xC1, 0xC0, 0x7F, 0xEE,
  0x1E, 0x07, 0x81, 0xF0, 0xF0, 0x38, 0x07, 0x87, 0x83, 0xC0, 0x38, 0x38,
  0x1E, 0x01, 0xC1, 0xC0, 0xE0, 0x0E, 0x0E, 0x07, 0x00, 0xF0, 0xF0, 0x38,
  0x07, 0x87, 0x83, 0xC0, 0x3C, 0x3C, 0x1E, 0x01, 0xC1, 0xC0, 0xF0, 0x0E,
  0x0E, 0x07, 0x00, 0x70, 0x70, 0x38, 0x07, 0x87, 0x81, 0xE0, 0x3C, 0x3C,
  0x0F, 0x03, 0xE1, 0xE0, 0x7E, 0xFE, 0x0E, 0x01, 0xFF, 0x70, 0x70, 0x07,
  0xF3, 0x83, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xF7,
  0x00, 0x01, 0xEE, 0x00, 0x03, 0x9C, 0x00, 0x0F, 0x38, 0x00, 0x1C, 0x70,
  0x00, 0x78, 0xE0, 0x00, 0xF1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80,
  0x0E, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0x38, 0x03,
  0xC0, 0x70, 0x07, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x03, 0xC0, 0xF0,
  0x07, 0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x78, 0x00, 0x70, 0xF0, 0x00, 0xE3, 0xC0, 0x01, 0xC7, 0x80, 0x03,
  0x9E, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x78, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x07, 0x01, 0xFE, 0x0F, 0x00, 0x3E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1F,
  0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0E, 0x00, 0x0E, 0x1E, 0x00, 0x1E,
  0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x7C, 0x1E, 0x00, 0xF8,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3C, 0x0F, 0xF0,
  0x3C, 0x00, 0xF8, 0x3C, 0x00, 0x78, 0x38, 0x00, 0x3C, 0x38, 0x00, 0x3C,
  0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x38,
  0x78, 0x00, 0x78, 0x70, 0x00, 0x78, 0xF0, 0x00, 0xF0, 0xF0, 0x03, 0xF0,
  0xF0, 0x3F, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC,
  0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x1E, 0x07, 0x80, 0x1F, 0x0F, 0x00, 0x0F,
  0x0F, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78,
  0x78, 0x00, 0x78, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x7C, 0x01, 0xE0,
  0x3E, 0x07, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07, 0x03, 0xFC,
  0x0F, 0x00, 0x7C, 0x0F, 0x00, 0x3E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E,
  0x0F, 0x00, 0x1E, 0x0E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E,
  0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1C, 0x1C, 0x00, 0x3C,
  0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C,
  0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x38, 0x38, 0x00, 0x78, 0x78, 0x00, 0x78,
  0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x70, 0x78, 0x00, 0xF0,
  0x70, 0x01, 0xF0, 0xF0, 0x01, 0xE0, 0xF0, 0x07, 0xC0, 0xF0, 0x7F, 0x80,
  0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x80, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x1E, 0x07,
  0x80, 0x1F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x1E,
  0x00, 0x0F, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x1F, 0xFC, 0x3C, 0x1F, 0xFC, 0x3C, 0x1F, 0xFC, 0x38, 0x1F, 0xFC, 0x78,
  0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x38, 0x78, 0x00, 0x38, 0x78,
  0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0xF0, 0x78,
  0x00, 0xF0, 0x7C, 0x01, 0xE0, 0x3E, 0x07, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x07, 0x81,
  0xE0, 0x03, 0xC0, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x78,
  0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1C, 0x0F, 0x00, 0x1E, 0x07, 0x00, 0x0F,
  0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x00,
  0xE0, 0x78, 0x00, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0x80, 0x07, 0x03, 0xC0, 0x07, 0x81, 0xE0,
  0x03, 0xC0, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x3C,
  0x00, 0x3C, 0x1E, 0x00, 0x1C, 0x0F, 0x00, 0x1E, 0x07, 0x00, 0x0F, 0x07,
  0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xE0,
  0x78, 0x00, 0xF0, 0x38, 0x00, 0x78, 0x00, 0x03, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xE0, 0x78,
  0x00, 0x78, 0x1E, 0x00, 0x3E, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x0F, 0x80,
  0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0xF0, 0x00, 0xF8, 0x1E, 0x00, 0x1E, 0x03, 0x80, 0x07, 0x80,
  0xF0, 0x01, 0xF0, 0x1E, 0x00, 0x3C, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x1E, 0x00, 0x78, 0x07, 0xC0, 0x0F,
  0x00, 0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x0F, 0x80, 0x07, 0x81, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0xF8, 0x00, 0x78, 0x0F, 0x00,
  0x0E, 0x01, 0xE0, 0x03, 0xC0, 0x3E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x00, 0x1E, 0x01,
  0xE0, 0x03, 0xE0, 0x3C, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x80, 0xF0, 0x00,
  0xF8, 0x1E, 0x00, 0x0F, 0x03, 0x80, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xC0, 0x07, 0xC1, 0xF8, 0x03, 0xF0,
  0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x7F, 0x06, 0xE0, 0x1D, 0xC3, 0xB8, 0x07,
  0x70, 0xEE, 0x03, 0xB8, 0x39, 0xC0, 0xEE, 0x0E, 0x70, 0x73, 0x83, 0x9C,
  0x1C, 0xE0, 0xE7, 0x0E, 0x78, 0x79, 0xC3, 0x9E, 0x1E, 0x79, 0xC7, 0x07,
  0x8E, 0x71, 0xC1, 0xE3, 0xB8, 0xF0, 0x70, 0xEE, 0x3C, 0x1C, 0x3F, 0x0F,
  0x0F, 0x0F, 0xC3, 0xC3, 0xC1, 0xE0, 0xE0, 0xF0, 0x78, 0x38, 0x3C, 0x00,
  0x1E, 0x0F, 0x00, 0x07, 0x83, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0x78, 0x78,
  0x00, 0x1E, 0x1E, 0x00, 0x07, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0,
  0x78, 0x00, 0x3C, 0x1C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x03, 0xC0, 0xF8, 0x00, 0xE0, 0x3F, 0x00, 0x38, 0x1F, 0xC0, 0x1E,
  0x07, 0xF0, 0x07, 0x81, 0xFC, 0x01, 0xE0, 0x77, 0x00, 0x78, 0x1D, 0xE0,
  0x1E, 0x07, 0x38, 0x07, 0x03, 0xCE, 0x03, 0xC0, 0xF3, 0x80, 0xF0, 0x3C,
  0xE0, 0x3C, 0x0F, 0x3C, 0x0F, 0x03, 0xC7, 0x03, 0xC0, 0xE1, 0xC0, 0xE0,
  0x38, 0x70, 0x38, 0x1E, 0x1E, 0x1E, 0x07, 0x87, 0x87, 0x81, 0xE0, 0xE1,
  0xE0, 0x78, 0x38, 0x78, 0x1C, 0x0E, 0x1C, 0x07, 0x03, 0xC7, 0x03, 0xC0,
  0xF3, 0xC0, 0xF0, 0x1C, 0xF0, 0x3C, 0x07, 0x3C, 0x0F, 0x01, 0xCF, 0x03,
  0x80, 0x7B, 0x80, 0xE0, 0x1E, 0xE0, 0x78, 0x03, 0xB8, 0x1E, 0x00, 0xEE,
  0x07, 0x80, 0x3F, 0x81, 0xE0, 0x0F, 0xE0, 0x78, 0x01, 0xF8, 0x1C, 0x00,
  0x7C, 0x0F, 0x00, 0x1F, 0x00, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x1E, 0x07,
  0x80, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x1E,
  0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E,
  0x00, 0x1E, 0x1C, 0x00, 0x1E, 0x3C, 0x00, 0x1C, 0x3C, 0x00, 0x3C, 0x3C,
  0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x3C, 0x78,
  0x00, 0x38, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78,
  0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x78,
  0x01, 0xE0, 0x7C, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x1C, 0x03, 0xFC, 0x0F, 0x00, 0x1F, 0x03, 0xC0, 0x03,
  0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0x80,
  0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x07,
  0x80, 0x03, 0xC1, 0xE0, 0x01, 0xF0, 0x70, 0x00, 0xF8, 0x3C, 0x00, 0xFC,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03,
  0xE0, 0x7E, 0x07, 0xC0, 0x1E, 0x0F, 0x80, 0x1F, 0x0F, 0x00, 0x0F, 0x0E,
  0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x0E, 0x1E,
  0x00, 0x1E, 0x1C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C,
  0x00, 0x1E, 0x3C, 0x00, 0x1C, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x3C, 0x78,
  0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78,
  0x00, 0x78, 0x78, 0x00, 0x78, 0x70, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0,
  0x00, 0x78, 0xF0, 0x00, 0xF0, 0x78, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x7E,
  0x07, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0xE0, 0x1F, 0xC0, 0xF0, 0x01, 0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x3C,
  0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x00, 0x03, 0x87, 0x80, 0x03,
  0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0x78, 0x00,
  0xF8, 0x38, 0x00, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xC0, 0x78, 0x00, 0xE0,
  0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E,
  0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x00, 0x3E, 0x07, 0x80, 0x0F, 0x03,
  0xC0, 0x07, 0x81, 0xE0, 0x03, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x78,
  0x38, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x0F,
  0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x03, 0x87, 0x80, 0x03, 0xC3, 0xC0,
  0x01, 0xE1, 0xE0, 0x01, 0xE0, 0xF8, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03,
  0x81, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00,
  0x78, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0E, 0x00, 0x0E, 0x0F, 0x00,
  0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0,
  0x00, 0xF0, 0x78, 0x00, 0x70, 0x38, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E,
  0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0x81,
  0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x78,
  0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1C, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x0F,
  0x03, 0xC0, 0x0F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x3F, 0xFF,
  0x80, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3C, 0x70, 0x00, 0x3C, 0x70,
  0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x70, 0x78, 0x00, 0xF0, 0x78,
  0x00, 0xF0, 0x78, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x78, 0x03, 0xC0, 0x78,
  0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x3C, 0x07, 0x80, 0x3C,
  0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x3C, 0x0E, 0x00, 0x3C, 0x1E, 0x00, 0x3C,
  0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x1C, 0x3C, 0x00, 0x1C, 0x38, 0x00, 0x1C,
  0x78, 0x00, 0x1C, 0x70, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x38, 0x07, 0x80, 0xF3, 0x80, 0xF8, 0x0E,
  0x38, 0x0F, 0x80, 0xE3, 0x80, 0xF8, 0x1E, 0x38, 0x0F, 0x81, 0xE3, 0x81,
  0xF8, 0x1C, 0x38, 0x1B, 0x81, 0xC3, 0x81, 0xB8, 0x3C, 0x78, 0x3B, 0x83,
  0x87, 0x83, 0xB8, 0x38, 0x78, 0x33, 0x83, 0x87, 0x87, 0x38, 0x78, 0x78,
  0x73, 0x87, 0x07, 0x86, 0x38, 0x70, 0x78, 0x63, 0x0F, 0x07, 0x8E, 0x30,
  0xF0, 0x78, 0xE3, 0x0E, 0x07, 0x0C, 0x30, 0xE0, 0x71, 0xC3, 0x1E, 0x07,
  0x1C, 0x31, 0xC0, 0x71, 0x83, 0x1C, 0x07, 0x18, 0x31, 0xC0, 0x73, 0x83,
  0x3C, 0x07, 0x38, 0x33, 0x80, 0x73, 0x03, 0x38, 0x07, 0x70, 0x37, 0x80,
  0x77, 0x03, 0x70, 0x07, 0x60, 0x77, 0x00, 0x76, 0x07, 0x70, 0x07, 0xE0,
  0x7F, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xC0, 0x7E, 0x00, 0xFC, 0x07, 0xE0,
  0x0F, 0xC0, 0x7E, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x07, 0x80, 0x03, 0xC0, 0x1E, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x1F, 0x00, 0x07, 0x80, 0x78, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x38, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3B, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x07,
  0x80, 0x01, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x3C, 0x00, 0xF0,
  0x01, 0xF0, 0x01, 0xE0, 0x0F, 0x80, 0x07, 0x80, 0x3C, 0x00, 0x1F, 0x01,
  0xE0, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x07, 0xBC,
  0x00, 0x07, 0x9E, 0x00, 0x03, 0xCF, 0x00, 0x03, 0xC3, 0xC0, 0x03, 0xC1,
  0xE0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x78, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x78,
  0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xDE,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0E, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0x70, 0x00, 0xF7, 0x00, 0x0E, 0x70,
  0x01, 0xE7, 0x80, 0x3C, 0x38, 0x03, 0x83, 0x80, 0x78, 0x3C, 0x07, 0x01,
  0xC0, 0xF0, 0x1C, 0x1E, 0x01, 0xC1, 0xC0, 0x1E, 0x3C, 0x00, 0xE3, 0x80,
  0x0E, 0x78, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x70, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xF0, 0x78, 0x78, 0x3C, 0x1E, 0x1E,
  0x0F, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0x3C, 0x0F, 0xFF, 0x78, 0x3F, 0xFE,
  0xF0, 0xF8, 0x0F, 0xE3, 0xE0, 0x0F, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E,
  0x3C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xE3,
  0x80, 0x03, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78,
  0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xC3, 0xC0, 0x07, 0x87, 0x80,
  0x0F, 0x0F, 0x00, 0x3E, 0x1F, 0x00, 0xFC, 0x3F, 0x03, 0x78, 0x3F, 0xFE,
  0xE0, 0x3F, 0xF9, 0xC0, 0x3F, 0xC7, 0x80, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x0F, 0xC0, 0x1C, 0x7F, 0xE0,
  0x79, 0xFF, 0xE0, 0xF7, 0xFF, 0xC1, 0xF8, 0x07, 0xC3, 0xE0, 0x07, 0x87,
  0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0,
  0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x0E, 0x00,
  0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x01,
  0xE3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x1F, 0x00, 0x3E, 0x3F, 0x00, 0xF8,
  0x7F, 0x03, 0xE0, 0xF7, 0xFF, 0xC1, 0xEF, 0xFE, 0x03, 0x8F, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0xF8, 0x07, 0xC1, 0xE0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x0E, 0x3C,
  0x00, 0x1C, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x0F,
  0x0F, 0x00, 0x1E, 0x1F, 0x00, 0x78, 0x1F, 0x03, 0xF0, 0x3F, 0xFF, 0xC0,
  0x3F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x3E, 0x1E, 0x00, 0xFF,
  0xCF, 0x00, 0xFF, 0xF7, 0x80, 0xFF, 0xFB, 0xC0, 0xF8, 0x0F, 0xE0, 0xF8,
  0x03, 0xE0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E,
  0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0x80, 0x03, 0x83,
  0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x78,
  0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1C, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x0F,
  0x03, 0xC0, 0x0F, 0x81, 0xF0, 0x0F, 0xC0, 0xFC, 0x0D, 0xE0, 0x3F, 0xFE,
  0xE0, 0x0F, 0xFE, 0x70, 0x03, 0xFC, 0x78, 0x00, 0x00, 0x3F, 0x80, 0x03,
  0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFC, 0xFE, 0x0F, 0x80, 0x78, 0x3C, 0x00,
  0xF1, 0xE0, 0x03, 0xC7, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xF3,
  0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0x9E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x1E, 0x0F,
  0x01, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xFF,
  0x3C, 0x0F, 0xFF, 0x78, 0x3F, 0xFE, 0xF0, 0xF8, 0x0F, 0xE3, 0xE0, 0x0F,
  0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x78,
  0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0x87, 0x00, 0x0F, 0x1E,
  0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0,
  0x03, 0xC3, 0xC0, 0x0F, 0x87, 0xC0, 0x3F, 0x07, 0xE0, 0xFE, 0x0F, 0xFF,
  0xBC, 0x0F, 0xFE, 0x78, 0x07, 0xF0, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x0F, 0xC0, 0x1C, 0x7F, 0xE0, 0x79, 0xFF, 0xE0, 0xF7,
  0x9F, 0xC1, 0xF8, 0x07, 0xC3, 0xE0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00,
  0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x01,
  0xE3, 0xC0, 0x03, 0x87, 0x80, 0x0F, 0x0E, 0x00, 0x1E, 0x3C, 0x00, 0x3C,
  0x78, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0x87,
  0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0,
  0x00, 0xF1, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x07, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x87, 0x80, 0x07, 0x83, 0x80, 0x07, 0x83,
  0xC0, 0x07, 0x81, 0xE0, 0x07, 0xC0, 0xF0, 0x07, 0xC0, 0x78, 0x07, 0xC0,
  0x3C, 0x07, 0xC0, 0x1C, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x0F, 0x03, 0xE0,
  0x07, 0x83, 0xE0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0xF0, 0x3C, 0x00, 0x78, 0x1F, 0x00, 0x3C, 0x07, 0x80, 0x1E, 0x03,
  0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0x80, 0x1E, 0x03, 0xC0,
  0x0F, 0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xF0, 0x78, 0x00, 0x78, 0x3C,
  0x00, 0x3E, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFE, 0x00, 0x07,
  0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x3C, 0x1E, 0x03, 0xDF,
  0x8F, 0xE0, 0xEF, 0xF7, 0xF8, 0x3A, 0x3D, 0x1F, 0x0F, 0x07, 0x83, 0xC3,
  0x81, 0xC0, 0xF1, 0xE0, 0x70, 0x3C, 0x78, 0x1C, 0x0E, 0x1E, 0x07, 0x03,
  0x87, 0x83, 0xC0, 0xE1, 0xC0, 0xF0, 0x78, 0x70, 0x38, 0x1E, 0x3C, 0x0E,
  0x07, 0x8F, 0x03, 0x81, 0xE3, 0xC0, 0xE0, 0x70, 0xF0, 0x78, 0x1C, 0x38,
  0x1E, 0x0F, 0x0E, 0x07, 0x03, 0xC3, 0x81, 0xC0, 0xF1, 0xE0, 0x70, 0x3C,
  0x78, 0x1C, 0x0E, 0x1E, 0x07, 0x03, 0x87, 0x03, 0xC0, 0xE1, 0xC0, 0xE0,
  0x78, 0x70, 0x38, 0x1E, 0x3C, 0x0E, 0x07, 0x8F, 0x03, 0x81, 0xC0, 0x01,
  0x0F, 0xC0, 0x1C, 0x7F, 0xE0, 0x79, 0xFF, 0xE0, 0xF7, 0x9F, 0xC1, 0xF8,
  0x07, 0xC3, 0xE0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x3C, 0x00,
  0x3C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x03,
  0x87, 0x80, 0x0F, 0x0E, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x78,
  0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0x87, 0x00, 0x0F, 0x1E,
  0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0,
  0x01, 0xC3, 0x80, 0x07, 0x80, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x3F,
  0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0x80, 0x78, 0x3C, 0x01, 0xF1, 0xE0, 0x03,
  0xC7, 0x80, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xCF,
  0x00, 0x0F, 0x38, 0x00, 0x3D, 0xE0, 0x00, 0xE7, 0x80, 0x07, 0x9E, 0x00,
  0x1E, 0x78, 0x00, 0x79, 0xE0, 0x01, 0xE7, 0x80, 0x07, 0x9C, 0x00, 0x3C,
  0x78, 0x00, 0xF1, 0xE0, 0x07, 0x87, 0xC0, 0x3E, 0x1F, 0x81, 0xF0, 0x3F,
  0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x43, 0xF0, 0x01,
  0xC7, 0xFE, 0x01, 0xE7, 0xFF, 0x80, 0xF7, 0xDF, 0xC0, 0x7E, 0x01, 0xF0,
  0x3E, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x0F,
  0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x00,
  0xF0, 0x78, 0x00, 0x70, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E, 0x00,
  0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x07, 0x81, 0xE0,
  0x03, 0xC1, 0xF0, 0x03, 0xE0, 0xFC, 0x01, 0xE0, 0x7F, 0x03, 0xE0, 0x3D,
  0xFF, 0xF0, 0x1E, 0xFF, 0xF0, 0x0E, 0x3F, 0xE0, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0x3C, 0x0F, 0xFF, 0x78, 0x3F, 0xFE,
  0xF0, 0xF8, 0x0F, 0xE3, 0xE0, 0x0F, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E,
  0x3C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xC3,
  0x80, 0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78,
  0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x87, 0x80,
  0x0F, 0x0F, 0x00, 0x3E, 0x1F, 0x00, 0xFC, 0x3F, 0x03, 0x78, 0x3F, 0xFE,
  0xE0, 0x3F, 0xFB, 0xC0, 0x3F, 0xC7, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0,
  0x0F, 0x1F, 0xF0, 0x0F, 0x7F, 0xF8, 0x0F, 0x79, 0xFC, 0x0F, 0xC0, 0x3E,
  0x0F, 0x80, 0x1E, 0x0F, 0x00, 0x1E, 0x1F, 0x00, 0x1E, 0x1E, 0x00, 0x1E,
  0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xC0,
  0x7F, 0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0x80, 0x7C, 0x78, 0x00, 0xF1, 0xE0,
  0x01, 0xC7, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x7B, 0xC0, 0x03, 0xCF, 0x80, 0x1F, 0x1F, 0x00, 0xF8,
  0x7F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x7F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x1E,
  0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0,
  0x01, 0xE3, 0xC0, 0x03, 0x87, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00,
  0x3C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xC3, 0x80, 0x07,
  0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x78,
  0xF0, 0x00, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x1E, 0x0F,
  0x80, 0x7C, 0x0F, 0x81, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x79, 0xC0, 0x01, 0xE3, 0xC0,
  0x03, 0xC7, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x78, 0x1C, 0x00,
  0xF0, 0x38, 0x01, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0E, 0x01, 0xE0, 0x3C,
  0x03, 0xC0, 0x70, 0x03, 0x81, 0xE0, 0x07, 0x03, 0x80, 0x0F, 0x0F, 0x00,
  0x1E, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0x73, 0xC0, 0x00,
  0xE7, 0x80, 0x01, 0xDE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x3C, 0x07, 0xF0, 0x1E, 0x03, 0xB8,
  0x0F, 0x01, 0xDC, 0x0F, 0x81, 0xEE, 0x06, 0xC0, 0xE7, 0x03, 0x60, 0x73,
  0x83, 0xB0, 0x39, 0xC1, 0x98, 0x38, 0xE0, 0xCC, 0x1C, 0x70, 0xE6, 0x0E,
  0x38, 0x63, 0x0E, 0x1C, 0x31, 0x87, 0x0E, 0x38, 0xC3, 0x87, 0x18, 0x63,
  0x83, 0x8C, 0x31, 0xC1, 0xCE, 0x18, 0xE0, 0xE7, 0x0C, 0xE0, 0x73, 0x06,
  0x70, 0x3B, 0x83, 0x38, 0x1D, 0xC1, 0x98, 0x0E, 0xC0, 0xDC, 0x07, 0xE0,
  0x6E, 0x03, 0xF0, 0x37, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C,
  0x07, 0xC0, 0x00, 0x07, 0x80, 0x07, 0xC0, 0xF0, 0x03, 0xE0, 0x3C, 0x00,
  0xF0, 0x07, 0x80, 0x78, 0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x1F, 0x00, 0x0F,
  0x0F, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x78,
  0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x1F, 0x07, 0x80, 0x0F, 0x80, 0xF0, 0x07,
  0xC0, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x3C,
  0x3E, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00,
  0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xC3, 0xC0, 0x07, 0x8F, 0x00, 0x0F,
  0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xE1,
  0xE0, 0x03, 0xC3, 0x80, 0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x3C,
  0x00, 0x3C, 0x78, 0x00, 0xF8, 0xF0, 0x01, 0xE1, 0xE0, 0x07, 0xC3, 0xE0,
  0x1F, 0x83, 0xF0, 0xFF, 0x07, 0xFF, 0xDE, 0x07, 0xFF, 0x3C, 0x03, 0xF8,
  0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x1F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0x80, 0x0F, 0x0F, 0xE0, 0x0F, 0x3F, 0xF0, 0x0E, 0x3F, 0xF8, 0x0E, 0x78,
  0x7C, 0x1E, 0x78, 0x3E, 0x1E, 0x70, 0x1F, 0x3C, 0x70, 0x0F, 0xFC, 0xF0,
  0x0F, 0xF8, 0xF0, 0x03, 0xE0,
};

const GFXglyph JetBrainsMono_LightItalic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 11, 35, 29, 9, -35 },
  { 50, 16, 14, 29, 9, -35 },
  { 78, 28, 35, 29, 1, -35 },
  { 201, 25, 49, 29, 2, -42 },
  { 355, 32, 35, 29, -1, -35 },
  { 495, 26, 36, 29, 1, -36 },
  { 612, 6, 14, 29, 14, -35 },
  { 623, 20, 47, 29, 8, -41 },
  { 741, 20, 47, 29, 2, -41 },
  { 859, 25, 24, 29, 3, -29 },
  { 934, 23, 22, 29, 3, -27 },
  { 998, 12, 15, 29, 5, -7 },
  { 1021, 16, 4, 29, 7, -18 },
  { 1029, 8, 7, 29, 9, -7 },
  { 1036, 28, 45, 29, 1, -40 },
  { 1194, 24, 36, 29, 3, -36 },
  { 1302, 22, 35, 29, 2, -35 },
  { 1399, 25, 36, 29, 2, -36 },
  { 1512, 24, 35, 29, 3, -35 },
  { 1617, 23, 35, 29, 3, -35 },
  { 1718, 24, 35, 29, 3, -35 },
  { 1823, 22, 35, 29, 3, -35 },
  { 1920, 23, 35, 29, 6, -35 },
  { 2021, 24, 36, 29, 3, -36 },
  { 2129, 23, 36, 29, 5, -36 },
  { 2233, 11, 27, 29, 9, -27 },
  { 2271, 15, 35, 29, 5, -27 },
  { 2337, 23, 25, 29, 4, -28 },
  { 2409, 23, 15, 29, 3, -23 },
  { 2453, 22, 25, 29, 3, -28 },
  { 2522, 19, 35, 29, 7, -35 },
  { 2606, 29, 45, 29, 0, -36 },
  { 2770, 23, 35, 29, 1, -35 },
  { 2871, 24, 35, 29, 3, -35 },
  { 2976, 24, 36, 29, 3, -36 },
  { 3084, 24, 35, 29, 3, -35 },
  { 3189, 25, 35, 29, 3, -35 },
  { 3299, 26, 35, 29, 3, -35 },
  { 3413, 24, 36, 29, 3, -36 },
  { 3521, 25, 35, 29, 3, -35 },
  { 3631, 24, 35, 29, 3, -35 },
  { 3736, 26, 35, 29, 1, -35 },
  { 3850, 27, 35, 29, 3, -35 },
  { 3969, 21, 35, 29, 3, -35 },
  { 4061, 26, 35, 29, 2, -35 },
  { 4175, 26, 35, 29, 2, -35 },
  { 4289, 24, 36, 29, 3, -36 },
  { 4397, 26, 35, 29, 3, -35 },
  { 4511, 24, 45, 29, 3, -36 },
  { 4646, 25, 35, 29, 3, -35 },
  { 4756, 25, 36, 29, 2, -36 },
  { 4869, 24, 35, 29, 6, -35 },
  { 4974, 25, 35, 29, 3, -35 },
  { 5084, 24, 35, 29, 6, -35 },
  { 5189, 28, 35, 29, 3, -35 },
  { 5312, 30, 35, 29, 0, -35 },
  { 5444, 25, 35, 29, 5, -35 },
  { 5554, 26, 35, 29, 2, -35 },
  { 5668, 19, 45, 29, 7, -40 },
  { 5775, 14, 45, 29, 8, -40 },
  { 5854, 19, 45, 29, 4, -40 },
  { 5961, 20, 19, 29, 5, -35 },
  { 6009, 24, 3, 29, 0, 1 },
  { 6018, 8, 7, 29, 13, -38 },
  { 6025, 23, 27, 29, 3, -27 },
  { 6103, 23, 35, 29, 3, -35 },
  { 6204, 23, 27, 29, 3, -27 },
  { 6282, 25, 35, 29, 3, -35 },
  { 6392, 22, 27, 29, 3, -27 },
  { 6467, 32, 44, 29, -2, -35 },
  { 6643, 23, 36, 29, 3, -27 },
  { 6747, 23, 35, 29, 3, -35 },
  { 6848, 23, 37, 29, 2, -37 },
  { 6955, 24, 46, 29, 1, -37 },
  { 7093, 25, 35, 29, 3, -35 },
  { 7203, 20, 35, 29, 5, -35 },
  { 7291, 26, 27, 29, 1, -27 },
  { 7379, 23, 27, 29, 3, -27 },
  { 7457, 22, 27, 29, 3, -27 },
  { 7532, 25, 36, 29, 1, -27 },
  { 7645, 23, 36, 29, 3, -27 },
  { 7749, 24, 27, 29, 3, -27 },
  { 7830, 22, 27, 29, 3, -27 },
  { 7905, 23, 34, 29, 4, -34 },
  { 8003, 23, 26, 29, 3, -26 },
  { 8078, 23, 26, 29, 5, -26 },
  { 8153, 25, 26, 29, 4, -26 },
  { 8235, 26, 26, 29, 1, -26 },
  { 8320, 23, 35, 29, 3, -26 },
  { 8421, 24, 26, 29, 2, -26 },
  { 8499, 24, 45, 29, 5, -40 },
  { 8634, 11, 45, 29, 10, -40 },
  { 8696, 24, 45, 29, 1, -40 },
  { 8831, 24, 10, 29, 3, -22 },
};

const GFXfont JetBrainsMono_LightItalic48pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_LightItalic48pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_LightItalic48pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _JETBRAINSMONO_LIGHTITALIC48PT7B_H_
