#ifndef _JETBRAINSMONO_LIGHTITALIC26PT7B_H_
#define _JETBRAINSMONO_LIGHTITALIC26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-LightItalic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_LightItalic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x71, 0xC6, 0x18, 0x61, 0x8E, 0x30, 0xC3, 0x0C, 0x20, 0x00,
  0x00, 0x63, 0xCE, 0x00, 0x63, 0x63, 0xE3, 0xE3, 0xC3, 0xC6, 0xC6, 0xC6,
  0x03, 0x0C, 0x06, 0x18, 0x08, 0x20, 0x30, 0xC0, 0x61, 0x87, 0xFF, 0xCF,
  0xFF, 0x86, 0x18, 0x08, 0x20, 0x30, 0xC0, 0x61, 0x80, 0x82, 0x0F, 0xFF,
  0x9F, 0xFF, 0x08, 0x20, 0x30, 0xC0, 0x61, 0x80, 0x86, 0x03, 0x0C, 0x00,
  0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x03, 0xF0, 0x3F, 0xE1, 0xC9,
  0x86, 0x67, 0x19, 0x9C, 0xE6, 0x01, 0x90, 0x07, 0x40, 0x1F, 0x00, 0x1F,
  0x80, 0x3F, 0x00, 0xDC, 0x03, 0x30, 0x08, 0xC6, 0x23, 0x18, 0x8C, 0x66,
  0x61, 0xFF, 0x83, 0xF8, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x00,
  0x07, 0x80, 0xC3, 0xF0, 0x61, 0x8C, 0x30, 0x63, 0x18, 0x10, 0xCC, 0x04,
  0x32, 0x01, 0x99, 0x80, 0x7C, 0xC0, 0x0C, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x80, 0x04, 0xF8, 0x03, 0x63, 0x01, 0x90, 0xC0, 0xC4, 0x30, 0x63, 0x08,
  0x30, 0xC6, 0x08, 0x1F, 0x8C, 0x07, 0xC0, 0x07, 0xE0, 0x3F, 0xC1, 0xC3,
  0x06, 0x0C, 0x18, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x1E, 0x01, 0xF8,
  0x16, 0x71, 0x98, 0xCE, 0xC1, 0xB3, 0x07, 0x8C, 0x0C, 0x30, 0x78, 0xC3,
  0xE3, 0xFD, 0xC7, 0xE3, 0x80, 0x77, 0x66, 0x66, 0x6C, 0x00, 0x60, 0x3C,
  0x0E, 0x03, 0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0,
  0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x07, 0x00, 0x60, 0x0F, 0x00, 0xF0, 0x06, 0x00, 0x0C, 0x01, 0xC0, 0x1E,
  0x00, 0xC0, 0x1C, 0x01, 0x80, 0x30, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x80,
  0x60, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x00, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x61, 0x0F, 0xE5, 0xF3, 0xFF, 0x00, 0xC0, 0x07, 0x80, 0x37,
  0x01, 0x8C, 0x0E, 0x38, 0x70, 0x60, 0x01, 0x00, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xF0, 0x60, 0x06, 0x00, 0xE0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0x1C, 0xE3, 0x8C, 0x71, 0x8E, 0x30, 0xFF, 0x6F,
  0xFE, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0x0F, 0xE0, 0xFF, 0x8E, 0x0C, 0x60, 0x76, 0x03, 0xB0,
  0x19, 0x80, 0xCC, 0x06, 0x66, 0x37, 0x39, 0xB1, 0x8D, 0x80, 0xCC, 0x06,
  0x60, 0x33, 0x01, 0x98, 0x1C, 0xE0, 0xC3, 0xFC, 0x0F, 0xC0, 0x01, 0xE0,
  0x7C, 0x0E, 0xC1, 0xCC, 0x10, 0xC2, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x0F,
  0xFF, 0xFF, 0xF0, 0x07, 0xF0, 0x3F, 0xE1, 0xC1, 0x86, 0x06, 0x30, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xFF, 0xCF, 0xFF,
  0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xF8, 0x07, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x19,
  0x80, 0xCC, 0x0C, 0x60, 0xE3, 0xFE, 0x0F, 0xE0, 0x00, 0x70, 0x0E, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x18, 0x73, 0x06, 0x60,
  0x6E, 0x06, 0xC0, 0x6F, 0xFE, 0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x1F, 0xF9, 0xFF, 0x8C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x0D, 0xF8, 0x79, 0xE3, 0x83, 0x18, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x98, 0x18, 0xC0, 0xC3, 0xFC, 0x0F, 0xC0, 0x00, 0x60, 0x06, 0x00,
  0x70, 0x07, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0xB8, 0x1F, 0xE1, 0xC3,
  0x9C, 0x0C, 0xC0, 0x76, 0x03, 0xB0, 0x19, 0x80, 0xCC, 0x06, 0x60, 0x61,
  0xFE, 0x07, 0xE0, 0x7F, 0xFB, 0xFF, 0x98, 0x0D, 0xC0, 0xEC, 0x06, 0x00,
  0x70, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0xE0,
  0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x18, 0x00, 0x07, 0xF0,
  0x3F, 0xE1, 0xC1, 0x86, 0x06, 0x18, 0x18, 0x60, 0x61, 0x83, 0x07, 0x1C,
  0x0F, 0xC0, 0x1F, 0x01, 0xCE, 0x0C, 0x1C, 0x60, 0x31, 0x80, 0xC6, 0x03,
  0x18, 0x0C, 0x60, 0x61, 0xFF, 0x03, 0xF8, 0x00, 0x0F, 0xC3, 0xFE, 0x70,
  0x66, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x06, 0xC0, 0xEE, 0x1C, 0x7E,
  0xC3, 0x98, 0x03, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x70,
  0x00, 0x18, 0xF3, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0xF3, 0xCE,
  0x00, 0x06, 0x0F, 0x1F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x38, 0x38, 0x30, 0x70, 0x60, 0xE0, 0xC0, 0x00, 0x18, 0x03, 0x80,
  0x78, 0x1F, 0x03, 0xC0, 0x38, 0x03, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xE0, 0x03, 0xC0, 0x06, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x30, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x60, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00,
  0xE0, 0x0C, 0x00, 0x00, 0x3E, 0x1F, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x30,
  0x1C, 0x06, 0x03, 0x0F, 0x83, 0xC0, 0xC0, 0x30, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x3C, 0x0E, 0x00, 0x01, 0xF8, 0x07, 0x9C, 0x0C, 0x06, 0x18, 0x06,
  0x18, 0x02, 0x30, 0x02, 0x30, 0x26, 0x30, 0xFE, 0x31, 0x86, 0x31, 0x86,
  0x63, 0x06, 0x63, 0x06, 0x63, 0x0C, 0x63, 0x0C, 0x63, 0x0C, 0x63, 0x1C,
  0x43, 0xEC, 0xC0, 0x80, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x1F, 0x80, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x40, 0x33,
  0x01, 0x98, 0x0C, 0xC0, 0xC6, 0x06, 0x30, 0x61, 0x83, 0x0C, 0x38, 0x61,
  0xFF, 0x0F, 0xF8, 0xC0, 0x66, 0x03, 0x60, 0x1B, 0x00, 0xF8, 0x06, 0x1F,
  0xE0, 0x7F, 0xE1, 0x83, 0x86, 0x06, 0x18, 0x18, 0x60, 0x63, 0x01, 0x8C,
  0x0C, 0x3F, 0xE0, 0xFF, 0x83, 0x07, 0x0C, 0x0C, 0x60, 0x31, 0x80, 0xC6,
  0x03, 0x18, 0x0C, 0x60, 0xE1, 0xFF, 0x0F, 0xF8, 0x00, 0x07, 0xE0, 0xFF,
  0x8E, 0x0C, 0x60, 0x73, 0x03, 0xB0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x01, 0x98, 0x1C, 0xE0,
  0xC3, 0xFC, 0x0F, 0xC0, 0x1F, 0xE0, 0xFF, 0x86, 0x0E, 0x30, 0x31, 0x81,
  0x8C, 0x0C, 0xC0, 0x66, 0x03, 0x30, 0x19, 0x81, 0xCC, 0x0C, 0x60, 0x66,
  0x03, 0x30, 0x19, 0x80, 0xCC, 0x0C, 0x60, 0xE3, 0xFE, 0x3F, 0xC0, 0x1F,
  0xF9, 0xFF, 0xCC, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00,
  0x7F, 0xE3, 0xFF, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x07, 0xFF, 0x3F, 0xF0, 0x1F, 0xFE, 0x3F, 0xF8, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x7F,
  0xE0, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x80, 0x00, 0x07, 0xE0, 0xFF, 0x8E, 0x0C, 0x60,
  0x73, 0x03, 0xB0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x1F, 0x98, 0xFD,
  0xC8, 0xCC, 0x06, 0x60, 0x33, 0x01, 0x98, 0x1C, 0xE0, 0xC3, 0xFC, 0x0F,
  0xC0, 0x18, 0x0C, 0x60, 0x31, 0x81, 0xC6, 0x06, 0x18, 0x18, 0x60, 0x63,
  0x01, 0x8C, 0x06, 0x3F, 0xF8, 0xFF, 0xC3, 0x03, 0x0C, 0x0C, 0x60, 0x31,
  0x80, 0xC6, 0x03, 0x18, 0x18, 0x60, 0x61, 0x81, 0x8E, 0x06, 0x00, 0x1F,
  0xF9, 0xFF, 0x80, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x07, 0xFE, 0x3F, 0xF0, 0x01, 0xFC, 0x07, 0xE0, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xCC, 0x06, 0x30, 0x18, 0xE0, 0xC1,
  0xFF, 0x03, 0xF0, 0x00, 0x18, 0x0E, 0x30, 0x18, 0x60, 0x60, 0xC1, 0xC1,
  0x83, 0x03, 0x0C, 0x0C, 0x38, 0x18, 0x60, 0x3F, 0x80, 0x7F, 0x00, 0xC6,
  0x01, 0x8E, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x38, 0x30, 0x30, 0x60, 0x60,
  0xC0, 0xE3, 0x80, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x07, 0x00, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x1C, 0x1C, 0x70, 0x71, 0xC3,
  0xCD, 0x0F, 0x34, 0x6C, 0xD9, 0xB3, 0x6D, 0x8D, 0xB6, 0x32, 0x99, 0x8E,
  0x66, 0x31, 0x98, 0x06, 0x60, 0x31, 0x80, 0xC6, 0x03, 0x38, 0x0C, 0xC0,
  0x33, 0x00, 0xCC, 0x06, 0x00, 0x1C, 0x0C, 0x70, 0x31, 0xE0, 0xC7, 0x86,
  0x1E, 0x18, 0xD8, 0x63, 0x21, 0x8C, 0xC6, 0x33, 0x18, 0xCC, 0xE3, 0x33,
  0x0C, 0x6C, 0x61, 0xB1, 0x86, 0xC6, 0x1B, 0x18, 0x6C, 0x60, 0xE1, 0x83,
  0x8C, 0x0E, 0x00, 0x07, 0xE0, 0xFF, 0x8E, 0x0C, 0x60, 0x63, 0x03, 0x30,
  0x19, 0x80, 0xCC, 0x06, 0x60, 0x33, 0x03, 0x98, 0x19, 0xC0, 0xCC, 0x06,
  0x60, 0x33, 0x01, 0x98, 0x18, 0xE1, 0xC3, 0xFC, 0x0F, 0xC0, 0x1F, 0xF0,
  0x7F, 0xE1, 0x81, 0xC6, 0x03, 0x18, 0x0C, 0x60, 0x33, 0x00, 0xCC, 0x07,
  0x30, 0x38, 0xFF, 0xC3, 0xFC, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x00, 0x07, 0xE0, 0xFF, 0x8E,
  0x0C, 0x60, 0x67, 0x03, 0x30, 0x19, 0x80, 0xCC, 0x06, 0x60, 0x33, 0x01,
  0xB8, 0x1D, 0x80, 0xCC, 0x06, 0x60, 0x33, 0x01, 0x98, 0x1C, 0xE1, 0xC3,
  0xFC, 0x0F, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x1F,
  0xF0, 0x7F, 0xE1, 0x81, 0xC6, 0x03, 0x18, 0x0C, 0x60, 0x33, 0x01, 0xCC,
  0x06, 0x30, 0x38, 0xFF, 0x83, 0xF8, 0x0C, 0x60, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x38, 0x60, 0x61, 0x81, 0x8E, 0x07, 0x00, 0x03, 0xF0, 0x3F,
  0xE1, 0xC1, 0x86, 0x07, 0x18, 0x1C, 0x60, 0x01, 0x80, 0x07, 0x00, 0x0F,
  0x00, 0x1F, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xCE, 0x03, 0x18,
  0x0C, 0x60, 0x61, 0xFF, 0x83, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC1, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x19, 0x80, 0xCC, 0x06, 0x60, 0x63, 0x03, 0x38, 0x19,
  0x80, 0xCC, 0x06, 0x60, 0x33, 0x03, 0x98, 0x19, 0xC0, 0xCC, 0x06, 0x60,
  0x33, 0x01, 0x98, 0x18, 0xE1, 0xC3, 0xFC, 0x0F, 0xC0, 0xC0, 0x1F, 0x01,
  0x98, 0x0C, 0xC0, 0xE6, 0x06, 0x30, 0x31, 0x83, 0x0C, 0x18, 0x61, 0x83,
  0x0C, 0x18, 0x60, 0xC6, 0x03, 0x30, 0x1B, 0x00, 0xD8, 0x06, 0xC0, 0x3C,
  0x01, 0xE0, 0x0E, 0x00, 0x63, 0x86, 0x87, 0x19, 0x0E, 0x36, 0x1C, 0x6C,
  0x78, 0x98, 0xB3, 0x31, 0x66, 0x66, 0xCC, 0xCD, 0x91, 0x92, 0x63, 0x24,
  0xC6, 0xC9, 0x8D, 0x16, 0x1A, 0x2C, 0x3C, 0x58, 0x70, 0xA0, 0xE1, 0xC1,
  0xC3, 0x83, 0x87, 0x00, 0x1C, 0x07, 0x0C, 0x06, 0x0E, 0x0C, 0x06, 0x1C,
  0x06, 0x18, 0x03, 0x30, 0x03, 0x60, 0x03, 0x60, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0xC0, 0x07, 0xC0, 0x06, 0x60, 0x0C, 0x60, 0x1C, 0x70, 0x38, 0x30,
  0x30, 0x30, 0x60, 0x38, 0xE0, 0x18, 0xC0, 0x1E, 0x01, 0xD8, 0x0C, 0xC0,
  0xC6, 0x0E, 0x18, 0x60, 0xC6, 0x06, 0x70, 0x1B, 0x00, 0xF0, 0x07, 0x80,
  0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0xFF, 0xCF, 0xFE, 0x00, 0x0F,
  0xC3, 0xF1, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x30, 0x0C, 0x03, 0xF0, 0xFC, 0x00, 0xC0, 0x60, 0x60, 0x60, 0x60,
  0x70, 0x30, 0x30, 0x30, 0x30, 0x18, 0x18, 0x18, 0x18, 0x0C, 0x0C, 0x0C,
  0x0C, 0x0E, 0x06, 0x06, 0x06, 0x06, 0x03, 0x03, 0x0F, 0xC3, 0xF0, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03,
  0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80,
  0x61, 0xF8, 0xFE, 0x00, 0x03, 0x80, 0x38, 0x06, 0x80, 0x6C, 0x0C, 0xC1,
  0x84, 0x18, 0x63, 0x06, 0x70, 0x6E, 0x03, 0xFF, 0xF8, 0xE6, 0x30, 0x02,
  0x01, 0xFB, 0x38, 0xF7, 0x07, 0x60, 0x76, 0x06, 0x60, 0x6E, 0x06, 0xC0,
  0x6C, 0x06, 0xC0, 0x6C, 0x0E, 0xE1, 0xCF, 0xFC, 0x7E, 0xC0, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x8C, 0x0D, 0xF8, 0xD1, 0xC7, 0x07, 0x30,
  0x39, 0x81, 0xCC, 0x0C, 0x60, 0x66, 0x03, 0x30, 0x19, 0x80, 0xCC, 0x0C,
  0x70, 0x63, 0xFE, 0x3B, 0xE0, 0x02, 0x01, 0xFC, 0x38, 0xE7, 0x07, 0x60,
  0x36, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x6C, 0x0E, 0xE0,
  0xC7, 0xF8, 0x3F, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x23,
  0x0F, 0xD8, 0xE3, 0xCE, 0x0E, 0x60, 0x73, 0x03, 0x18, 0x19, 0xC0, 0xCC,
  0x06, 0x60, 0x33, 0x01, 0x98, 0x1C, 0xE1, 0xC7, 0xFE, 0x1F, 0xB0, 0x03,
  0x01, 0xFC, 0x38, 0xE7, 0x06, 0x60, 0x36, 0x07, 0x60, 0x6F, 0xFE, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x0E, 0xC0, 0xC7, 0xF8, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x3F, 0xC0, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x7F,
  0xFC, 0x3F, 0xFE, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x03, 0xF0, 0x01, 0xE0,
  0x00, 0x02, 0x01, 0xFB, 0x38, 0xF7, 0x07, 0x60, 0x76, 0x06, 0x60, 0x6E,
  0x06, 0xC0, 0x6C, 0x06, 0xC0, 0xEE, 0x1E, 0x7F, 0xC3, 0xEC, 0x00, 0xC0,
  0x0C, 0x01, 0xC0, 0x38, 0x7F, 0x0F, 0xC0, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x88, 0x0F, 0xF8, 0xD1, 0xC7, 0x07, 0x30, 0x39, 0x81, 0xCC,
  0x0C, 0x60, 0x66, 0x03, 0x30, 0x19, 0x80, 0xCC, 0x0E, 0x60, 0x63, 0x03,
  0x38, 0x18, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x81, 0xF8, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0xF0,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x38,
  0x1F, 0xC0, 0xFC, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x73, 0x83, 0x8C, 0x1C, 0x30, 0xE0, 0xC3, 0x03, 0x18, 0x0F,
  0xC0, 0x7F, 0x81, 0x86, 0x06, 0x1C, 0x18, 0x30, 0x60, 0xE1, 0x81, 0x8E,
  0x07, 0x00, 0xFC, 0x3F, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0F,
  0xF1, 0xFC, 0x02, 0x10, 0xFD, 0xE3, 0x39, 0x98, 0x46, 0x63, 0x19, 0x8C,
  0x66, 0x31, 0x98, 0xC6, 0x63, 0x19, 0x08, 0x6C, 0x63, 0x31, 0x8C, 0xC6,
  0x33, 0x18, 0xCC, 0x63, 0x00, 0x00, 0x81, 0xFF, 0x8D, 0x1C, 0x70, 0x73,
  0x03, 0x98, 0x1C, 0xC0, 0xC6, 0x06, 0x60, 0x33, 0x01, 0x98, 0x0C, 0xC0,
  0xE6, 0x06, 0x30, 0x33, 0x81, 0x80, 0x03, 0x01, 0xFC, 0x38, 0xE7, 0x06,
  0x60, 0x76, 0x07, 0x60, 0x6E, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0x6C, 0x0C,
  0xE0, 0xC7, 0xF8, 0x3F, 0x00, 0x00, 0xC1, 0xDF, 0x8D, 0x1C, 0x70, 0x73,
  0x03, 0x98, 0x1C, 0xC0, 0xC6, 0x06, 0x60, 0x33, 0x01, 0x98, 0x0C, 0xC0,
  0xC7, 0x06, 0x3F, 0xE3, 0xBE, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x00, 0x06, 0x01, 0xFB, 0x38, 0xF7, 0x07, 0x60, 0x76, 0x06, 0x60,
  0x6E, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0x6C, 0x0E, 0xE1, 0xCF, 0xFC, 0x7E,
  0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x03, 0x7E, 0x3C,
  0x73, 0x03, 0x70, 0x36, 0x03, 0x60, 0x36, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x03, 0x01, 0xFE, 0x38, 0xE7,
  0x03, 0x60, 0x06, 0x00, 0x78, 0x03, 0xF8, 0x07, 0xC0, 0x0E, 0x00, 0x6C,
  0x06, 0xC0, 0xCF, 0xFC, 0x7F, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x17, 0xFF, 0x7F, 0xF8, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x1F, 0xC0, 0x7E, 0x00,
  0x70, 0x36, 0x03, 0x60, 0x36, 0x03, 0x60, 0x76, 0x06, 0x60, 0x6C, 0x06,
  0xC0, 0x6C, 0x06, 0xC0, 0xCE, 0x1C, 0x7F, 0x83, 0xF0, 0xC0, 0x7C, 0x06,
  0xC0, 0x6C, 0x0C, 0x60, 0xC6, 0x18, 0x61, 0x86, 0x30, 0x63, 0x06, 0x60,
  0x36, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0xC3, 0x0F, 0x1C, 0x6C, 0x51, 0xB1,
  0x44, 0xCD, 0x33, 0x24, 0xCC, 0x92, 0x36, 0x58, 0xD1, 0x63, 0x45, 0x8F,
  0x14, 0x38, 0x70, 0xE1, 0xC3, 0x86, 0x00, 0x1C, 0x0E, 0x18, 0x30, 0x38,
  0xE0, 0x33, 0x80, 0x76, 0x00, 0x78, 0x00, 0x60, 0x01, 0xE0, 0x06, 0xC0,
  0x19, 0xC0, 0x71, 0x81, 0xC3, 0x83, 0x03, 0x1C, 0x07, 0x00, 0x70, 0x36,
  0x03, 0x60, 0x36, 0x03, 0x60, 0x66, 0x06, 0xE0, 0x6C, 0x06, 0xC0, 0x6C,
  0x0E, 0xE1, 0xC7, 0xFC, 0x3C, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x03, 0x87,
  0xF0, 0xFC, 0x00, 0x1F, 0xF9, 0xFF, 0xC0, 0x1C, 0x01, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x07, 0xFE,
  0x7F, 0xF0, 0x00, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x1C, 0x0F, 0x80, 0x7E,
  0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x0E, 0x00, 0x30, 0x01, 0xF0, 0x03, 0x80, 0x0C, 0x30, 0xC3, 0x18, 0x61,
  0x86, 0x18, 0x63, 0x8C, 0x30, 0xC3, 0x0C, 0x71, 0x86, 0x18, 0x61, 0x86,
  0x30, 0xC0, 0x0C, 0x00, 0xF8, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x01, 0xC0,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x1F, 0x81,
  0xFC, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x70, 0x1F, 0x00, 0xE0, 0x00, 0x38, 0x37, 0xC3, 0xC6, 0x3C,
  0x77, 0xC3, 0xE0,
};

const GFXglyph JetBrainsMono_LightItalic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 6, 19, 16, 5, -19 },
  { 16, 8, 8, 16, 5, -19 },
  { 24, 15, 19, 16, 1, -19 },
  { 60, 14, 27, 16, 1, -23 },
  { 108, 18, 19, 16, -1, -19 },
  { 151, 14, 19, 16, 1, -19 },
  { 185, 4, 8, 16, 7, -19 },
  { 189, 11, 25, 16, 4, -22 },
  { 224, 11, 25, 16, 1, -22 },
  { 259, 14, 14, 16, 1, -16 },
  { 284, 12, 13, 16, 2, -15 },
  { 304, 6, 8, 16, 3, -4 },
  { 310, 8, 1, 16, 4, -9 },
  { 311, 4, 4, 16, 5, -4 },
  { 313, 16, 25, 16, 0, -22 },
  { 363, 13, 19, 16, 2, -19 },
  { 394, 12, 19, 16, 1, -19 },
  { 423, 14, 19, 16, 1, -19 },
  { 457, 13, 19, 16, 1, -19 },
  { 488, 12, 19, 16, 2, -19 },
  { 517, 13, 19, 16, 2, -19 },
  { 548, 13, 19, 16, 1, -19 },
  { 579, 13, 19, 16, 3, -19 },
  { 610, 14, 19, 16, 1, -19 },
  { 644, 12, 19, 16, 3, -19 },
  { 673, 6, 15, 16, 5, -15 },
  { 685, 8, 19, 16, 3, -15 },
  { 704, 13, 13, 16, 2, -15 },
  { 726, 12, 8, 16, 2, -13 },
  { 738, 13, 13, 16, 1, -15 },
  { 760, 10, 19, 16, 4, -19 },
  { 784, 16, 24, 16, 0, -19 },
  { 832, 13, 19, 16, 0, -19 },
  { 863, 14, 19, 16, 1, -19 },
  { 897, 13, 19, 16, 2, -19 },
  { 928, 13, 19, 16, 1, -19 },
  { 959, 13, 19, 16, 2, -19 },
  { 990, 15, 19, 16, 1, -19 },
  { 1026, 13, 19, 16, 2, -19 },
  { 1057, 14, 19, 16, 1, -19 },
  { 1091, 13, 19, 16, 2, -19 },
  { 1122, 14, 19, 16, 1, -19 },
  { 1156, 15, 19, 16, 1, -19 },
  { 1192, 11, 19, 16, 2, -19 },
  { 1219, 14, 19, 16, 1, -19 },
  { 1253, 14, 19, 16, 1, -19 },
  { 1287, 13, 19, 16, 2, -19 },
  { 1318, 14, 19, 16, 1, -19 },
  { 1352, 13, 24, 16, 2, -19 },
  { 1391, 14, 19, 16, 1, -19 },
  { 1425, 14, 19, 16, 1, -19 },
  { 1459, 13, 19, 16, 3, -19 },
  { 1490, 13, 19, 16, 2, -19 },
  { 1521, 13, 19, 16, 3, -19 },
  { 1552, 15, 19, 16, 2, -19 },
  { 1588, 16, 19, 16, 0, -19 },
  { 1626, 13, 19, 16, 3, -19 },
  { 1657, 14, 19, 16, 1, -19 },
  { 1691, 10, 25, 16, 4, -22 },
  { 1723, 8, 25, 16, 4, -22 },
  { 1748, 10, 25, 16, 2, -22 },
  { 1780, 12, 10, 16, 2, -19 },
  { 1795, 13, 1, 16, 0, 1 },
  { 1797, 4, 3, 16, 7, -20 },
  { 1799, 12, 15, 16, 2, -15 },
  { 1822, 13, 19, 16, 1, -19 },
  { 1853, 12, 15, 16, 2, -15 },
  { 1876, 13, 19, 16, 2, -19 },
  { 1907, 12, 15, 16, 2, -15 },
  { 1930, 17, 24, 16, -1, -19 },
  { 1981, 12, 20, 16, 2, -15 },
  { 2011, 13, 19, 16, 1, -19 },
  { 2042, 12, 20, 16, 1, -20 },
  { 2072, 14, 25, 16, 0, -20 },
  { 2116, 14, 19, 16, 1, -19 },
  { 2150, 10, 19, 16, 3, -19 },
  { 2174, 14, 15, 16, 1, -15 },
  { 2201, 13, 15, 16, 1, -15 },
  { 2226, 12, 15, 16, 2, -15 },
  { 2249, 13, 20, 16, 1, -15 },
  { 2282, 12, 20, 16, 2, -15 },
  { 2312, 12, 15, 16, 2, -15 },
  { 2335, 12, 15, 16, 2, -15 },
  { 2358, 13, 18, 16, 2, -18 },
  { 2388, 12, 14, 16, 2, -14 },
  { 2409, 12, 14, 16, 3, -14 },
  { 2430, 14, 14, 16, 2, -14 },
  { 2455, 15, 14, 16, 0, -14 },
  { 2482, 12, 19, 16, 2, -14 },
  { 2511, 13, 14, 16, 1, -14 },
  { 2534, 13, 25, 16, 3, -22 },
  { 2575, 6, 25, 16, 5, -22 },
  { 2594, 13, 25, 16, 1, -22 },
  { 2635, 12, 5, 16, 2, -12 },
};

const GFXfont JetBrainsMono_LightItalic26pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_LightItalic26pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_LightItalic26pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _JETBRAINSMONO_LIGHTITALIC26PT7B_H_
