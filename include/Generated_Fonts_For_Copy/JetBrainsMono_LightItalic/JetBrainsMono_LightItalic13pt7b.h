#ifndef _JETBRAINSMONO_LIGHTITALIC13PT7B_H_
#define _JETBRAINSMONO_LIGHTITALIC13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-LightItalic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_LightItalic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0x92, 0x80, 0x40, 0x5A, 0xB4, 0x1B, 0x12, 0x7F, 0x24, 0x24,
  0xB6, 0x48, 0x48, 0x58, 0x08, 0x67, 0x55, 0x51, 0xC3, 0x8B, 0x26, 0xAF,
  0x08, 0x20, 0x20, 0xA8, 0x94, 0x8A, 0x86, 0x80, 0x80, 0x78, 0x54, 0x4A,
  0x47, 0x00, 0x08, 0x6C, 0x89, 0x03, 0x0A, 0x52, 0xA6, 0xCC, 0xEC, 0xE0,
  0x08, 0x88, 0x84, 0x21, 0x18, 0x86, 0x10, 0xC1, 0x00, 0x20, 0x86, 0x10,
  0x84, 0x42, 0x10, 0x89, 0x88, 0x00, 0x10, 0x23, 0x5B, 0xC3, 0x0B, 0x22,
  0x00, 0x10, 0x4F, 0xC8, 0x20, 0x80, 0x36, 0x4C, 0xF0, 0x78, 0x01, 0x02,
  0x02, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x20, 0x20, 0x40, 0xC0, 0x19, 0x94,
  0x51, 0x96, 0xD8, 0x63, 0x8B, 0xC0, 0x39, 0x41, 0x04, 0x10, 0x41, 0x0C,
  0xFC, 0x19, 0x94, 0x61, 0x04, 0x21, 0x18, 0xC3, 0xE0, 0x7C, 0x21, 0x0E,
  0x08, 0x18, 0xA2, 0xF0, 0x0C, 0x43, 0x08, 0x46, 0x2F, 0x82, 0x08, 0x7D,
  0x04, 0x1E, 0xC4, 0x10, 0xA2, 0xF0, 0x18, 0x42, 0x1E, 0xCE, 0x18, 0x62,
  0xF0, 0xFE, 0x20, 0x84, 0x30, 0x84, 0x10, 0x80, 0x19, 0x94, 0x51, 0x69,
  0xE8, 0xA1, 0x8B, 0xC0, 0x19, 0x94, 0x61, 0xC5, 0xF0, 0x84, 0x21, 0x00,
  0x64, 0x00, 0xB8, 0x31, 0x00, 0x03, 0x64, 0xC0, 0x04, 0x33, 0x30, 0x40,
  0xC0, 0x80, 0xFC, 0x00, 0x3F, 0x81, 0x81, 0x81, 0x19, 0x88, 0x00, 0x78,
  0x42, 0x26, 0x20, 0x00, 0xC0, 0x0C, 0x32, 0x21, 0x41, 0x4F, 0x52, 0x52,
  0x92, 0x9E, 0x80, 0x80, 0x70, 0x0C, 0x28, 0x51, 0x22, 0x47, 0x91, 0x22,
  0x86, 0x7D, 0x14, 0x52, 0xFA, 0x18, 0x62, 0xF0, 0x19, 0x94, 0x50, 0x42,
  0x08, 0x21, 0x89, 0xC0, 0x7D, 0x14, 0x51, 0x86, 0x18, 0xA2, 0xF0, 0x7E,
  0x81, 0x02, 0x27, 0x90, 0x20, 0x40, 0xF8, 0x7E, 0x81, 0x02, 0x04, 0x1F,
  0xA0, 0x40, 0x81, 0x00, 0x19, 0x94, 0x50, 0x42, 0x78, 0x61, 0x89, 0xC0,
  0x45, 0x14, 0x51, 0xFE, 0x38, 0xA2, 0x88, 0x7C, 0x41, 0x04, 0x10, 0x82,
  0x08, 0xF8, 0x0E, 0x04, 0x08, 0x10, 0x60, 0xB1, 0x22, 0x78, 0x46, 0x89,
  0x22, 0x8F, 0x12, 0x22, 0x44, 0x8C, 0x41, 0x04, 0x10, 0x43, 0x08, 0x20,
  0xFC, 0x33, 0x36, 0x56, 0x5A, 0x5A, 0x42, 0x42, 0x44, 0xC4, 0x66, 0xC9,
  0x93, 0x29, 0x52, 0xA6, 0x4C, 0x88, 0x19, 0x94, 0x51, 0x46, 0x18, 0x62,
  0x89, 0xC0, 0x7C, 0x85, 0x1A, 0x2F, 0x90, 0x20, 0x40, 0x80, 0x19, 0x94,
  0x51, 0x86, 0x18, 0x62, 0x89, 0xC1, 0x06, 0x7C, 0x89, 0x12, 0x2F, 0x92,
  0x26, 0x44, 0x88, 0x19, 0x94, 0x50, 0x60, 0x60, 0xC1, 0x8B, 0xC0, 0xFC,
  0x82, 0x08, 0x20, 0x84, 0x10, 0x41, 0x00, 0x46, 0x89, 0x12, 0x28, 0x50,
  0xA2, 0x44, 0x70, 0x86, 0x28, 0xA4, 0x92, 0x8A, 0x28, 0x40, 0x93, 0x26,
  0xCD, 0xAB, 0x5A, 0xB6, 0x6C, 0x98, 0x23, 0x36, 0x14, 0x18, 0x18, 0x18,
  0x24, 0x44, 0xC6, 0xC2, 0x89, 0x21, 0x43, 0x04, 0x08, 0x10, 0x20, 0x7C,
  0x30, 0x84, 0x20, 0x84, 0x20, 0xF8, 0x39, 0x18, 0x84, 0x21, 0x08, 0x44,
  0x21, 0xC0, 0x8C, 0x44, 0x44, 0x22, 0x22, 0x31, 0x38, 0x42, 0x10, 0x88,
  0x42, 0x10, 0x85, 0xC0, 0x18, 0xA2, 0x91, 0x84, 0xFC, 0x90, 0x7D, 0x18,
  0x61, 0x8A, 0x2F, 0x80, 0x41, 0x07, 0x91, 0x86, 0x18, 0xA2, 0xF0, 0x79,
  0x18, 0x20, 0x82, 0x27, 0x00, 0x04, 0x17, 0xD1, 0x86, 0x18, 0xA2, 0xF8,
  0x79, 0x18, 0x7F, 0x82, 0x27, 0x00, 0x07, 0x82, 0x02, 0x07, 0xE0, 0x80,
  0x40, 0x20, 0x10, 0x10, 0x08, 0x3C, 0x00, 0x7D, 0x18, 0x61, 0x8B, 0x62,
  0x82, 0xF0, 0x41, 0x07, 0x91, 0x86, 0x18, 0xA2, 0x88, 0x18, 0x40, 0x1C,
  0x10, 0x41, 0x08, 0x23, 0xF0, 0x06, 0x08, 0x01, 0xE0, 0x40, 0x81, 0x04,
  0x08, 0x10, 0x27, 0x80, 0x40, 0x85, 0x12, 0x49, 0x1E, 0x24, 0x44, 0x88,
  0xF0, 0x82, 0x08, 0x20, 0x82, 0x18, 0x3C, 0x7E, 0x95, 0x2A, 0x95, 0x2A,
  0x65, 0x00, 0x79, 0x18, 0x61, 0x8A, 0x28, 0x80, 0x79, 0x18, 0x61, 0x8A,
  0x27, 0x00, 0x3C, 0x45, 0x0A, 0x14, 0x48, 0x9E, 0x20, 0x80, 0x7D, 0x18,
  0x63, 0x8A, 0x2F, 0x82, 0x08, 0x7D, 0x14, 0x70, 0x82, 0x08, 0x00, 0x7D,
  0x14, 0x1E, 0x0A, 0x2F, 0x80, 0x10, 0x8F, 0xC8, 0x20, 0x82, 0x18, 0x38,
  0x45, 0x18, 0x61, 0x8A, 0x27, 0x00, 0xC6, 0x89, 0x22, 0x45, 0x0A, 0x08,
  0x00, 0x93, 0x6A, 0xD5, 0xAD, 0x9B, 0x26, 0x00, 0x62, 0x48, 0x60, 0xC2,
  0x8C, 0xB1, 0x00, 0x45, 0x18, 0x63, 0x8B, 0x62, 0x82, 0xF0, 0x7C, 0x21,
  0x08, 0x42, 0x0F, 0x80, 0x06, 0x10, 0x20, 0x81, 0x02, 0x38, 0x08, 0x10,
  0x40, 0x81, 0xC0, 0x69, 0x24, 0x94, 0x92, 0x40, 0x30, 0x10, 0x20, 0x41,
  0x02, 0x03, 0x88, 0x10, 0x20, 0x47, 0x00, 0x66, 0x59, 0x80,
};

const GFXglyph JetBrainsMono_LightItalic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 3, 9, 8, 2, -9 },
  { 5, 5, 3, 8, 2, -9 },
  { 7, 8, 9, 8, 0, -9 },
  { 16, 6, 13, 8, 1, -11 },
  { 26, 9, 10, 8, 0, -10 },
  { 38, 7, 10, 8, 0, -10 },
  { 47, 1, 3, 8, 4, -9 },
  { 48, 5, 13, 8, 2, -11 },
  { 57, 5, 13, 8, 1, -11 },
  { 66, 7, 7, 8, 1, -8 },
  { 73, 6, 6, 8, 1, -7 },
  { 78, 4, 4, 8, 1, -2 },
  { 80, 4, 1, 8, 2, -5 },
  { 81, 3, 2, 8, 2, -2 },
  { 82, 8, 12, 8, 0, -11 },
  { 94, 6, 10, 8, 1, -10 },
  { 102, 6, 9, 8, 1, -9 },
  { 109, 6, 10, 8, 1, -10 },
  { 117, 6, 9, 8, 1, -9 },
  { 124, 6, 9, 8, 1, -9 },
  { 131, 6, 9, 8, 1, -9 },
  { 138, 6, 9, 8, 1, -9 },
  { 145, 6, 9, 8, 2, -9 },
  { 152, 6, 10, 8, 1, -10 },
  { 160, 6, 10, 8, 1, -10 },
  { 168, 3, 7, 8, 2, -7 },
  { 171, 4, 9, 8, 1, -7 },
  { 176, 6, 7, 8, 1, -8 },
  { 182, 6, 4, 8, 1, -6 },
  { 185, 6, 7, 8, 1, -8 },
  { 191, 5, 9, 8, 2, -9 },
  { 197, 8, 12, 8, 0, -10 },
  { 209, 7, 9, 8, 0, -9 },
  { 217, 6, 9, 8, 1, -9 },
  { 224, 6, 10, 8, 1, -10 },
  { 232, 6, 9, 8, 1, -9 },
  { 239, 7, 9, 8, 1, -9 },
  { 247, 7, 10, 8, 1, -10 },
  { 256, 6, 10, 8, 1, -10 },
  { 264, 6, 9, 8, 1, -9 },
  { 271, 6, 9, 8, 1, -9 },
  { 278, 7, 9, 8, 0, -9 },
  { 286, 7, 9, 8, 1, -9 },
  { 294, 6, 9, 8, 1, -9 },
  { 301, 8, 9, 8, 0, -9 },
  { 310, 7, 9, 8, 1, -9 },
  { 318, 6, 10, 8, 1, -10 },
  { 326, 7, 9, 8, 1, -9 },
  { 334, 6, 12, 8, 1, -10 },
  { 343, 7, 9, 8, 1, -9 },
  { 351, 6, 10, 8, 1, -10 },
  { 359, 6, 10, 8, 2, -10 },
  { 367, 7, 9, 8, 1, -9 },
  { 375, 6, 9, 8, 2, -9 },
  { 382, 7, 9, 8, 1, -9 },
  { 390, 8, 9, 8, 0, -9 },
  { 399, 7, 9, 8, 1, -9 },
  { 407, 6, 9, 8, 1, -9 },
  { 414, 5, 12, 8, 2, -11 },
  { 422, 4, 12, 8, 2, -11 },
  { 428, 5, 12, 8, 1, -11 },
  { 436, 6, 5, 8, 1, -9 },
  { 440, 6, 1, 8, 0, 0 },
  { 441, 2, 2, 8, 4, -10 },
  { 442, 6, 7, 8, 1, -7 },
  { 448, 6, 9, 8, 1, -9 },
  { 455, 6, 7, 8, 1, -7 },
  { 461, 6, 9, 8, 1, -9 },
  { 468, 6, 7, 8, 1, -7 },
  { 474, 9, 11, 8, -1, -9 },
  { 487, 6, 9, 8, 1, -7 },
  { 494, 6, 9, 8, 1, -9 },
  { 501, 6, 10, 8, 1, -10 },
  { 509, 7, 12, 8, 0, -10 },
  { 520, 7, 9, 8, 1, -9 },
  { 528, 6, 9, 8, 1, -9 },
  { 535, 7, 7, 8, 0, -7 },
  { 542, 6, 7, 8, 1, -7 },
  { 548, 6, 7, 8, 1, -7 },
  { 554, 7, 9, 8, 0, -7 },
  { 562, 6, 9, 8, 1, -7 },
  { 569, 6, 7, 8, 1, -7 },
  { 575, 6, 7, 8, 1, -7 },
  { 581, 6, 9, 8, 1, -9 },
  { 588, 6, 7, 8, 1, -7 },
  { 594, 7, 7, 8, 1, -7 },
  { 601, 7, 7, 8, 1, -7 },
  { 608, 7, 7, 8, 0, -7 },
  { 615, 6, 9, 8, 1, -7 },
  { 622, 6, 7, 8, 1, -7 },
  { 628, 7, 12, 8, 1, -11 },
  { 639, 3, 12, 8, 3, -11 },
  { 644, 7, 12, 8, 0, -11 },
  { 655, 6, 3, 8, 1, -6 },
};

const GFXfont JetBrainsMono_LightItalic13pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_LightItalic13pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_LightItalic13pt7bGlyphs,
  0x20, 0x7E, 17
};

#endif // _JETBRAINSMONO_LIGHTITALIC13PT7B_H_
