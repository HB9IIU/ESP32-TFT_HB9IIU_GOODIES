#ifndef _JETBRAINSMONO_LIGHTITALIC40PT7B_H_
#define _JETBRAINSMONO_LIGHTITALIC40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-LightItalic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_LightItalic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0xC1, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x0E, 0x07,
  0x03, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0C, 0x06, 0x03, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x3E, 0x1F, 0x0F, 0x80, 0x78, 0x7B,
  0x83, 0x9C, 0x1D, 0xE0, 0xEF, 0x0F, 0x78, 0x7B, 0x83, 0x9C, 0x1C, 0xE0,
  0xE7, 0x07, 0x38, 0x39, 0x81, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x38,
  0x00, 0xC0, 0x70, 0x03, 0x80, 0xC0, 0x07, 0x03, 0x80, 0x0C, 0x07, 0x00,
  0x38, 0x0C, 0x00, 0x70, 0x38, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x07,
  0x03, 0x80, 0x0C, 0x06, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x38, 0x00, 0xC0,
  0x60, 0x03, 0x81, 0xC0, 0x07, 0x03, 0x80, 0x0C, 0x06, 0x00, 0x38, 0x1C,
  0x07, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x03, 0x81, 0xC0, 0x07, 0x03, 0x80,
  0x1C, 0x06, 0x00, 0x38, 0x1C, 0x00, 0x60, 0x38, 0x01, 0xC0, 0x60, 0x03,
  0x81, 0xC0, 0x06, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x03, 0xFF,
  0x00, 0x3F, 0xFC, 0x03, 0xED, 0xF0, 0x3C, 0xE7, 0x83, 0xC6, 0x1C, 0x1C,
  0x30, 0xE0, 0xE1, 0x87, 0x0F, 0x0C, 0x00, 0x78, 0x60, 0x03, 0xC7, 0x00,
  0x0F, 0x30, 0x00, 0x7D, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xDF, 0x00, 0x0C, 0x78, 0x00, 0x61, 0xC0,
  0x03, 0x0F, 0x00, 0x18, 0x79, 0xE1, 0xC3, 0x8F, 0x0E, 0x1C, 0x78, 0x60,
  0xE1, 0xC3, 0x0E, 0x0F, 0x18, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x03,
  0xFE, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x01, 0xF8, 0x00, 0xE0, 0xFF, 0x80,
  0x38, 0x1C, 0x78, 0x0E, 0x07, 0x07, 0x03, 0x80, 0xE0, 0xE0, 0x60, 0x18,
  0x1C, 0x18, 0x03, 0x03, 0x87, 0x00, 0xE0, 0x61, 0xC0, 0x1C, 0x1C, 0x70,
  0x03, 0x83, 0x9C, 0x00, 0x3D, 0xE7, 0x00, 0x07, 0xF8, 0xC0, 0x00, 0x3E,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0xFC, 0x00, 0x06, 0x3F, 0xC0, 0x01, 0x8E, 0x3C, 0x00, 0x73,
  0x83, 0x80, 0x1C, 0x70, 0x70, 0x07, 0x0C, 0x0E, 0x01, 0xC1, 0x81, 0x80,
  0x30, 0x70, 0x30, 0x0C, 0x0E, 0x0E, 0x03, 0x81, 0xC1, 0xC0, 0xE0, 0x3C,
  0x70, 0x38, 0x03, 0xFC, 0x0E, 0x00, 0x3F, 0x00, 0x00, 0x0C, 0x00, 0x01,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xF8, 0xF8, 0x03, 0x80, 0xE0, 0x1E, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFE,
  0x00, 0x07, 0xFC, 0x01, 0x3C, 0x70, 0x38, 0xE1, 0xE1, 0xC7, 0x83, 0x8F,
  0x1C, 0x0F, 0x38, 0x70, 0x1D, 0xC1, 0xC0, 0x7F, 0x07, 0x00, 0xF8, 0x1C,
  0x01, 0xC0, 0xF0, 0x0F, 0x83, 0xC0, 0x7E, 0x07, 0x03, 0xFC, 0x1F, 0xFE,
  0x70, 0x7F, 0xF1, 0xE0, 0x7F, 0x03, 0xC0, 0x39, 0xDE, 0xF7, 0xBD, 0xCE,
  0x73, 0x99, 0xC0, 0x00, 0x01, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x00, 0xC0, 0x02, 0x00, 0x03,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xE0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x00, 0xF0,
  0x00, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x20, 0x1C, 0x05, 0xE0, 0xC1, 0xEF, 0xC6, 0x3F,
  0xFF, 0xB7, 0xF8, 0xFF, 0xFE, 0x00, 0x7F, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x80, 0x01, 0xCE, 0x00, 0x1C, 0x70, 0x01, 0xE3, 0xC0, 0x1E, 0x0F, 0x01,
  0xE0, 0x78, 0x0E, 0x01, 0xE0, 0x30, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC1, 0xE0, 0xF8, 0x3C, 0x1E,
  0x07, 0x83, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x03, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x3C, 0xFD, 0xFF, 0xFF, 0xCF, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x07, 0xFC,
  0x00, 0x7F, 0xF8, 0x0F, 0xC7, 0xC0, 0x78, 0x0F, 0x07, 0x80, 0x38, 0x38,
  0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x87, 0x00, 0x1C,
  0x78, 0x00, 0xE3, 0xC0, 0x07, 0x1C, 0x38, 0x78, 0xE3, 0xE3, 0x87, 0x1F,
  0x1C, 0x38, 0x78, 0xE1, 0xC1, 0x07, 0x1E, 0x00, 0x38, 0xE0, 0x03, 0xC7,
  0x00, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x03,
  0x83, 0x80, 0x3C, 0x1E, 0x03, 0xC0, 0x7E, 0xFC, 0x01, 0xFF, 0xC0, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xB8, 0x0F,
  0x8E, 0x03, 0xC3, 0x80, 0xC1, 0xE0, 0x60, 0x78, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x07,
  0xFC, 0x00, 0xFF, 0xF8, 0x0F, 0x87, 0xC0, 0xF0, 0x0F, 0x07, 0x00, 0x38,
  0x78, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xCF, 0x00, 0x3C, 0xF0, 0x03,
  0x8F, 0x00, 0x38, 0x70, 0x07, 0x87, 0x80, 0xF0, 0x7F, 0x7E, 0x03, 0xFF,
  0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x01, 0xC3, 0x80, 0xF1,
  0xC0, 0x38, 0xF0, 0x0E, 0x78, 0x03, 0xBC, 0x00, 0xEF, 0x00, 0x3B, 0x80,
  0x1E, 0xFF, 0xFF, 0x3F, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x0F, 0xFF,
  0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF3, 0xF8,
  0x1D, 0xFF, 0x83, 0xFF, 0xF8, 0x7C, 0x0F, 0x0F, 0x00, 0xE3, 0xC0, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x01, 0xE7, 0x00, 0x38, 0xE0, 0x0F, 0x1E, 0x03, 0xC1,
  0xFB, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x9F, 0x00,
  0xEF, 0xF8, 0x3F, 0xFF, 0x87, 0x80, 0xF1, 0xE0, 0x0F, 0x38, 0x01, 0xEF,
  0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xBC,
  0x00, 0x73, 0x80, 0x1E, 0x70, 0x07, 0x8F, 0x01, 0xE0, 0xFD, 0xFC, 0x0F,
  0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xB8,
  0x00, 0xEF, 0x00, 0x1D, 0xC0, 0x07, 0x38, 0x01, 0xE7, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xE0, 0x3C, 0x3E, 0x07,
  0x80, 0xF0, 0xF0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x70,
  0xE0, 0x0E, 0x0E, 0x00, 0xE0, 0xF0, 0x1C, 0x07, 0x87, 0x80, 0x3F, 0xF0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x07, 0xDF, 0x00, 0xF0, 0x78, 0x1C, 0x03,
  0xC3, 0x80, 0x3C, 0x78, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00,
  0x1C, 0x70, 0x03, 0xC7, 0x00, 0x38, 0x78, 0x07, 0x87, 0xF7, 0xF0, 0x3F,
  0xFE, 0x00, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x7F, 0xC0, 0x1F, 0xFE, 0x0F,
  0xC7, 0xE3, 0xE0, 0x3C, 0x70, 0x03, 0x9E, 0x00, 0x7B, 0x80, 0x0F, 0x70,
  0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0x70, 0x00, 0xEF, 0x00, 0x3D, 0xE0,
  0x07, 0x1E, 0x01, 0xE3, 0xE0, 0xF8, 0x3F, 0xFF, 0x03, 0xFD, 0xC0, 0x3E,
  0x70, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x87, 0xF1, 0xFC, 0x7E, 0x1F, 0x81, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x1F, 0x07, 0xE3, 0xF8, 0xFE, 0x1F, 0x00, 0x01, 0xF0, 0x1F, 0xC0,
  0xFE, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x38,
  0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x0F, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x1F, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x20, 0x3F, 0xFF, 0xE7, 0xFF,
  0xFD, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF,
  0xC0, 0x10, 0x00, 0x03, 0x00, 0x00, 0x78, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x0C, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0xF8, 0x3F, 0xFC, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x7C, 0x01, 0xF8, 0x1F, 0xF0, 0x1F, 0xC0, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFC, 0x01, 0xF0,
  0x3C, 0x03, 0xC0, 0x0E, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x07, 0x0E, 0x00,
  0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x07,
  0xE6, 0x1C, 0x0F, 0xF6, 0x1C, 0x1E, 0x1E, 0x1C, 0x1C, 0x0E, 0x18, 0x38,
  0x0E, 0x38, 0x38, 0x0E, 0x38, 0x38, 0x0C, 0x38, 0x38, 0x1C, 0x38, 0x30,
  0x1C, 0x38, 0x70, 0x1C, 0x30, 0x70, 0x1C, 0x70, 0x70, 0x1C, 0x70, 0x70,
  0x3C, 0x70, 0x70, 0x38, 0x70, 0x7F, 0xD8, 0x70, 0x3F, 0xB8, 0x70, 0x0F,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xD8, 0x00, 0x1D, 0x80, 0x03, 0x9C, 0x00, 0x39, 0xC0, 0x03, 0x9C,
  0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x01, 0xE1,
  0xC0, 0x1C, 0x1C, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x70,
  0x0E, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xE0, 0x0E, 0x1C,
  0x00, 0xE1, 0xC0, 0x0E, 0x3C, 0x00, 0x73, 0x80, 0x07, 0x78, 0x00, 0x77,
  0x00, 0x07, 0xF0, 0x00, 0x70, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x03, 0xFF,
  0xF8, 0x1C, 0x03, 0xE0, 0xE0, 0x0F, 0x07, 0x00, 0x38, 0x38, 0x01, 0xC1,
  0xC0, 0x0E, 0x1E, 0x00, 0x70, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x38, 0x07,
  0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0x01, 0xF0, 0x38,
  0x03, 0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0x78, 0x70, 0x01, 0xC7, 0x80, 0x1E,
  0x38, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x78, 0x70, 0x07, 0x83, 0x80,
  0x7C, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7C, 0x7C, 0x0F, 0x01, 0xE1, 0xE0,
  0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x3C, 0x00, 0xE3, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x07,
  0x0F, 0x00, 0xF0, 0x70, 0x1E, 0x07, 0xEF, 0xE0, 0x3F, 0xF8, 0x01, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xE0, 0x1E, 0x0E,
  0x00, 0xF0, 0xE0, 0x0F, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x1E, 0x00, 0x71,
  0xC0, 0x0F, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x0E,
  0x3C, 0x00, 0xE3, 0x80, 0x1E, 0x38, 0x01, 0xE3, 0x80, 0x1C, 0x38, 0x01,
  0xC3, 0x80, 0x1C, 0x78, 0x01, 0xC7, 0x80, 0x3C, 0x70, 0x03, 0x87, 0x00,
  0x78, 0x70, 0x07, 0x07, 0x01, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xFF,
  0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xF8, 0x03,
  0xFF, 0xC0, 0x7C, 0x7C, 0x0F, 0x01, 0xE1, 0xE0, 0x0E, 0x1C, 0x00, 0xE1,
  0xC0, 0x0E, 0x3C, 0x00, 0xE3, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x07, 0xFC, 0x70, 0x7F,
  0xC7, 0x0F, 0xFC, 0x70, 0x01, 0xC7, 0x00, 0x3C, 0xF0, 0x03, 0x8E, 0x00,
  0x38, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x07, 0x0F, 0x00, 0xF0, 0x70,
  0x1E, 0x07, 0xEF, 0xE0, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x07, 0x00, 0x38,
  0x38, 0x01, 0xC3, 0xC0, 0x1E, 0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x07, 0x00,
  0x38, 0x38, 0x01, 0xC1, 0xC0, 0x0E, 0x1E, 0x00, 0xF0, 0xE0, 0x07, 0x07,
  0x00, 0x38, 0x38, 0x01, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x87, 0x00, 0x38, 0x38, 0x01, 0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0x70,
  0x03, 0x87, 0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xC0, 0x0E, 0x0E, 0x00, 0x70,
  0x70, 0x03, 0x83, 0x80, 0x1C, 0x1C, 0x00, 0xE1, 0xE0, 0x0F, 0x0E, 0x00,
  0x70, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x03, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC3, 0xC0, 0x07, 0x0F, 0x00, 0x1C, 0x3C, 0x00, 0xE0, 0x70, 0x07, 0x81,
  0xE0, 0x3C, 0x07, 0xF7, 0xE0, 0x0F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0x00, 0x1E, 0x1E, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0x70, 0x03, 0x80, 0xE0,
  0x0F, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x07, 0x01, 0xE0, 0x1E, 0x07,
  0x80, 0x38, 0x0E, 0x00, 0x70, 0x3C, 0x00, 0xE0, 0xF0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1C, 0x1E, 0x00, 0x38, 0x1C, 0x00,
  0x70, 0x3C, 0x00, 0xE0, 0x78, 0x01, 0xC0, 0x70, 0x07, 0x80, 0xF0, 0x0F,
  0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0xC0, 0x70, 0x07, 0x80, 0xE0,
  0x07, 0x01, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x0E, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0x80, 0x3E, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x7E, 0x03,
  0x60, 0xEC, 0x0F, 0xC1, 0xD8, 0x1B, 0x83, 0xB0, 0x77, 0x07, 0x70, 0xCC,
  0x0E, 0xE3, 0xB8, 0x19, 0xC6, 0x70, 0x71, 0x9C, 0xE0, 0xE3, 0x31, 0xC1,
  0xC6, 0xE3, 0x83, 0x8F, 0x8F, 0x07, 0x1F, 0x1C, 0x0E, 0x1C, 0x38, 0x3C,
  0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x07, 0x83, 0x80,
  0x0E, 0x07, 0x00, 0x1C, 0x1E, 0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x00,
  0xE0, 0xE0, 0x03, 0xC1, 0xC0, 0x07, 0x03, 0x80, 0x0E, 0x0F, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x38, 0x7C, 0x01, 0xC3, 0xE0, 0x0E, 0x1F, 0x80, 0xF0,
  0xFC, 0x07, 0x07, 0xE0, 0x38, 0x3F, 0x01, 0xC3, 0x9C, 0x0E, 0x1C, 0xE0,
  0x70, 0xE7, 0x07, 0x87, 0x38, 0x38, 0x38, 0xC1, 0xC1, 0xC7, 0x0E, 0x1E,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x31, 0xC1, 0xC1, 0xCE,
  0x0E, 0x0E, 0x70, 0x70, 0x73, 0x87, 0x03, 0x9C, 0x38, 0x0C, 0xE1, 0xC0,
  0x76, 0x0E, 0x03, 0xF0, 0x70, 0x1F, 0x83, 0x80, 0xFC, 0x3C, 0x03, 0xE1,
  0xC0, 0x1F, 0x0E, 0x00, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x3F, 0xE0, 0x0F,
  0xFF, 0x03, 0xE3, 0xE0, 0xF0, 0x1E, 0x3C, 0x01, 0xC7, 0x00, 0x38, 0xE0,
  0x07, 0x3C, 0x00, 0xE7, 0x00, 0x1C, 0xE0, 0x07, 0x9C, 0x00, 0xE3, 0x80,
  0x1C, 0x70, 0x03, 0x9E, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x01, 0xCE, 0x00,
  0x79, 0xC0, 0x0E, 0x38, 0x01, 0xCF, 0x00, 0x39, 0xC0, 0x07, 0x38, 0x00,
  0xE7, 0x00, 0x38, 0xE0, 0x07, 0x1E, 0x01, 0xE3, 0xC0, 0x78, 0x3F, 0x7E,
  0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0xFF, 0xFF, 0x03, 0x80, 0x3E, 0x0E, 0x00, 0x78, 0x38, 0x00, 0xE0, 0xE0,
  0x03, 0x83, 0x80, 0x0E, 0x1E, 0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0, 0x07,
  0x87, 0x00, 0x1C, 0x1C, 0x00, 0xF0, 0x70, 0x0F, 0x83, 0xFF, 0xFC, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0xFC, 0x7C,
  0x0F, 0x01, 0xE1, 0xE0, 0x0E, 0x1C, 0x00, 0xE3, 0xC0, 0x0E, 0x38, 0x00,
  0xE3, 0x80, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x0E, 0x78, 0x01, 0xE7, 0x00,
  0x1C, 0x70, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x1C, 0xF0,
  0x03, 0xCF, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x03, 0x8E,
  0x00, 0x78, 0xE0, 0x07, 0x0F, 0x00, 0xF0, 0xF0, 0x1E, 0x07, 0xEF, 0xC0,
  0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x07,
  0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x1C, 0x01, 0xE0, 0xE0, 0x07,
  0x87, 0x00, 0x3C, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x1E, 0x00, 0x78, 0xE0,
  0x03, 0xC7, 0x00, 0x1C, 0x38, 0x01, 0xE1, 0xC0, 0x1E, 0x0E, 0x0F, 0xE0,
  0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x38, 0x3C, 0x01, 0xC0, 0xE0, 0x0E, 0x07,
  0x00, 0x70, 0x3C, 0x07, 0x80, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x3C, 0x0E,
  0x00, 0xE0, 0x70, 0x07, 0x03, 0x80, 0x3C, 0x1C, 0x01, 0xE1, 0xE0, 0x07,
  0x0E, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8,
  0x07, 0xC7, 0xE0, 0x78, 0x0F, 0x07, 0x80, 0x38, 0x38, 0x01, 0xC1, 0xC0,
  0x0E, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xF3, 0xC0, 0x07, 0x1E, 0x00, 0x38, 0xF0, 0x01, 0xC7, 0x80, 0x1C,
  0x1E, 0x01, 0xE0, 0xFE, 0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x71, 0xE0, 0x07, 0x1C, 0x00, 0xF1, 0xC0, 0x0F, 0x1C, 0x00,
  0xE1, 0xC0, 0x0E, 0x1C, 0x00, 0xE3, 0xC0, 0x0E, 0x38, 0x00, 0xE3, 0x80,
  0x1E, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC7, 0x80, 0x1C, 0x78,
  0x01, 0xC7, 0x00, 0x3C, 0x70, 0x03, 0x87, 0x00, 0x38, 0x70, 0x03, 0x87,
  0x00, 0x38, 0xF0, 0x03, 0x8E, 0x00, 0x78, 0xE0, 0x07, 0x0E, 0x00, 0x70,
  0xF0, 0x0F, 0x07, 0x01, 0xE0, 0x7E, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xF0,
  0x00, 0xE0, 0x00, 0xFE, 0x00, 0x0E, 0xF0, 0x01, 0xEF, 0x00, 0x1C, 0x70,
  0x03, 0xC7, 0x00, 0x38, 0x70, 0x03, 0x87, 0x00, 0x70, 0x70, 0x07, 0x07,
  0x00, 0xF0, 0x70, 0x0E, 0x07, 0x00, 0xE0, 0x70, 0x1C, 0x07, 0x81, 0xC0,
  0x38, 0x38, 0x03, 0x83, 0x80, 0x38, 0x78, 0x03, 0x87, 0x00, 0x38, 0x70,
  0x03, 0x8E, 0x00, 0x38, 0xE0, 0x03, 0x9E, 0x00, 0x39, 0xC0, 0x01, 0xDC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0x70, 0x3C, 0x0E, 0xE0, 0x78, 0x39, 0xC1, 0xB0, 0x73, 0x83,
  0x60, 0xE7, 0x07, 0xC1, 0x8E, 0x0F, 0x07, 0x1C, 0x36, 0x0E, 0x38, 0x6C,
  0x1C, 0x70, 0xD8, 0x70, 0xC3, 0xB0, 0xE1, 0x86, 0x61, 0xC3, 0x0C, 0xC3,
  0x06, 0x19, 0x8E, 0x1C, 0x63, 0x1C, 0x38, 0xC6, 0x38, 0x71, 0x8C, 0x60,
  0xE7, 0x19, 0xC1, 0xCC, 0x33, 0x83, 0x98, 0x67, 0x07, 0x70, 0xCC, 0x0E,
  0xC1, 0xB8, 0x1D, 0x83, 0x70, 0x3B, 0x06, 0xC0, 0x7C, 0x0F, 0x80, 0xF8,
  0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x07, 0x81, 0xC0, 0x07, 0x00, 0xF0, 0x07, 0x80,
  0x38, 0x07, 0x80, 0x1C, 0x03, 0x80, 0x0F, 0x03, 0xC0, 0x03, 0x83, 0xC0,
  0x01, 0xC1, 0xC0, 0x00, 0x71, 0xC0, 0x00, 0x39, 0xE0, 0x00, 0x1E, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x39,
  0xC0, 0x00, 0x38, 0xF0, 0x00, 0x3C, 0x38, 0x00, 0x3C, 0x1C, 0x00, 0x1C,
  0x07, 0x00, 0x1E, 0x03, 0x80, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0x70, 0x0E,
  0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x7B,
  0x80, 0x03, 0x9E, 0x00, 0x3C, 0x70, 0x01, 0xC3, 0x80, 0x1C, 0x1E, 0x01,
  0xE0, 0x70, 0x0E, 0x03, 0x80, 0xE0, 0x1E, 0x0F, 0x00, 0x70, 0x70, 0x03,
  0x87, 0x00, 0x1C, 0x78, 0x00, 0x73, 0x80, 0x03, 0xB8, 0x00, 0x1D, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x1F,
  0xF8, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0,
  0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x0E, 0x07, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF8, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x0F, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3B, 0x80, 0x19, 0xC0, 0x1C, 0xE0, 0x1C, 0x30, 0x0E, 0x1C, 0x0E,
  0x0E, 0x0E, 0x03, 0x07, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x73, 0x80, 0x1B,
  0x80, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0xF0, 0xE0,
  0xE1, 0xE1, 0xE0, 0x03, 0xF8, 0xE1, 0xFF, 0xBC, 0x7E, 0x7F, 0x0F, 0x03,
  0xE3, 0xC0, 0x3C, 0x70, 0x07, 0x9E, 0x00, 0x73, 0x80, 0x1E, 0x70, 0x03,
  0xCE, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x01, 0xCF, 0x00, 0x39, 0xE0, 0x07,
  0x38, 0x01, 0xE7, 0x00, 0x38, 0xE0, 0x07, 0x1E, 0x01, 0xE3, 0xC0, 0x7C,
  0x3F, 0x7B, 0x87, 0xFE, 0xF0, 0x3F, 0x9E, 0x00, 0x07, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x73, 0xF8, 0x1E, 0xFF, 0xC3, 0xBD, 0xF8, 0x7C, 0x07, 0x8F, 0x00,
  0xF1, 0xC0, 0x0E, 0x38, 0x01, 0xCF, 0x00, 0x39, 0xC0, 0x0F, 0x38, 0x01,
  0xE7, 0x00, 0x38, 0xE0, 0x07, 0x1C, 0x00, 0xE7, 0x80, 0x1C, 0xF0, 0x03,
  0x9C, 0x00, 0xF3, 0xC0, 0x1C, 0x78, 0x07, 0x8F, 0x81, 0xE1, 0xFC, 0xFC,
  0x7B, 0xFF, 0x0E, 0x3F, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0x7E,
  0x0F, 0x01, 0xE3, 0xC0, 0x1C, 0x70, 0x03, 0x9E, 0x00, 0x73, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x1C, 0xE0, 0x07, 0x1E, 0x00, 0xE3,
  0xC0, 0x78, 0x3F, 0x7F, 0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x3F, 0x8E, 0x0F, 0xFD, 0xE1, 0xF9, 0xFE, 0x1E,
  0x07, 0xC3, 0xC0, 0x3C, 0x38, 0x03, 0xC7, 0x80, 0x1C, 0x70, 0x03, 0xC7,
  0x00, 0x3C, 0x70, 0x03, 0x87, 0x00, 0x38, 0x70, 0x03, 0x8F, 0x00, 0x38,
  0xF0, 0x03, 0x8E, 0x00, 0x78, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xF0, 0x0F,
  0x0F, 0x01, 0xF0, 0x7E, 0xF7, 0x07, 0xFE, 0xF0, 0x1F, 0xCF, 0x00, 0x03,
  0xFE, 0x01, 0xFF, 0xC0, 0xF8, 0xF8, 0x78, 0x0E, 0x3C, 0x03, 0xCE, 0x00,
  0x77, 0x80, 0x1D, 0xC0, 0x07, 0x70, 0x01, 0xDF, 0xFF, 0xF7, 0xFF, 0xF9,
  0xFF, 0xFE, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x07, 0x3C, 0x01, 0xC7, 0x00, 0xE1, 0xF0, 0xF8, 0x3F, 0xF8, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xF8, 0xE1, 0xFF, 0xBC, 0x7E, 0x7F, 0x0F, 0x03,
  0xE3, 0xC0, 0x3C, 0x70, 0x03, 0x9E, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x03,
  0xCE, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x01, 0xCF, 0x00, 0x39, 0xE0, 0x07,
  0x3C, 0x01, 0xE7, 0x80, 0x38, 0x78, 0x0F, 0x0F, 0x87, 0xE0, 0xFF, 0xDC,
  0x0F, 0xF3, 0x80, 0x20, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x03, 0x81, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFE, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x73, 0xF8, 0x1E, 0xFF, 0xC3, 0xB8, 0xF8,
  0x7C, 0x07, 0x8F, 0x00, 0xF1, 0xC0, 0x0E, 0x38, 0x01, 0xCF, 0x00, 0x39,
  0xC0, 0x0F, 0x38, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x07, 0x1C, 0x00, 0xE7,
  0x80, 0x1C, 0xE0, 0x07, 0x9C, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x03, 0x8E,
  0x00, 0x71, 0xC0, 0x0E, 0x78, 0x01, 0xCE, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xF0, 0x00,
  0x00, 0xE0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x0F, 0x1E, 0x00, 0xF0, 0xF0, 0x0F,
  0x07, 0x00, 0x70, 0x38, 0x07, 0x01, 0xC0, 0x78, 0x0E, 0x07, 0x80, 0x70,
  0x78, 0x07, 0x87, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x70, 0x70, 0x03, 0x83, 0xC0, 0x3C, 0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x01,
  0xC0, 0x70, 0x0F, 0x03, 0x80, 0x38, 0x1C, 0x01, 0xE1, 0xE0, 0x07, 0x0F,
  0x00, 0x3C, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xFF,
  0xE0, 0xFF, 0xE0, 0x3F, 0xF0, 0x1C, 0xF9, 0xF0, 0x77, 0xEF, 0xE1, 0xE3,
  0xA7, 0x87, 0x0F, 0x0E, 0x1C, 0x18, 0x38, 0x70, 0xE0, 0xE3, 0x83, 0x83,
  0x8E, 0x0E, 0x0E, 0x38, 0x38, 0x38, 0xE0, 0xE1, 0xC3, 0x83, 0x07, 0x0E,
  0x0C, 0x1C, 0x70, 0x70, 0x71, 0xC1, 0xC1, 0xC7, 0x07, 0x07, 0x1C, 0x1C,
  0x1C, 0x70, 0x60, 0xE1, 0xC1, 0x83, 0x87, 0x0E, 0x0E, 0x38, 0x38, 0x38,
  0xE0, 0xE0, 0xE3, 0x83, 0x83, 0x80, 0x1E, 0x7F, 0x03, 0xDF, 0xF8, 0x77,
  0x1F, 0x0F, 0x80, 0xF1, 0xE0, 0x1E, 0x38, 0x01, 0xC7, 0x00, 0x39, 0xE0,
  0x07, 0x38, 0x01, 0xE7, 0x00, 0x38, 0xE0, 0x07, 0x1C, 0x00, 0xE3, 0x80,
  0x1C, 0xF0, 0x03, 0x9C, 0x00, 0xF3, 0x80, 0x1C, 0x70, 0x03, 0x8E, 0x00,
  0x71, 0xC0, 0x0E, 0x38, 0x01, 0xCF, 0x00, 0x39, 0xC0, 0x0F, 0x00, 0x03,
  0xFE, 0x01, 0xFF, 0xC0, 0xFD, 0xF8, 0x78, 0x0F, 0x3C, 0x03, 0xCE, 0x00,
  0x77, 0x80, 0x1D, 0xC0, 0x07, 0x70, 0x03, 0xDC, 0x00, 0xF7, 0x00, 0x39,
  0xC0, 0x0E, 0xF0, 0x03, 0xB8, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x1C, 0xE0,
  0x07, 0x3C, 0x03, 0xCF, 0x01, 0xE1, 0xFB, 0xF0, 0x3F, 0xF8, 0x07, 0xFC,
  0x00, 0x0F, 0x3F, 0x80, 0xF7, 0xFE, 0x0E, 0xF7, 0xE0, 0xF8, 0x0F, 0x0F,
  0x00, 0xF0, 0xE0, 0x07, 0x0E, 0x00, 0x71, 0xE0, 0x07, 0x1C, 0x00, 0xF1,
  0xC0, 0x0F, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x00, 0xE3, 0xC0, 0x0E,
  0x3C, 0x00, 0xE3, 0x80, 0x1E, 0x3C, 0x01, 0xC3, 0xC0, 0x3C, 0x3E, 0x07,
  0x87, 0xF9, 0xF8, 0x7B, 0xFF, 0x07, 0x1F, 0xC0, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0xE1, 0xFF, 0xBC, 0x7E, 0x7F, 0x0F, 0x03, 0xE3,
  0xC0, 0x3C, 0x70, 0x07, 0x9E, 0x00, 0x73, 0x80, 0x1E, 0x70, 0x03, 0xCE,
  0x00, 0x71, 0xC0, 0x0E, 0x38, 0x01, 0xCF, 0x00, 0x39, 0xC0, 0x07, 0x38,
  0x01, 0xE7, 0x00, 0x38, 0xE0, 0x07, 0x1E, 0x01, 0xE3, 0xC0, 0x7C, 0x3F,
  0x7B, 0x87, 0xFE, 0xF0, 0x3F, 0x9C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x1C,
  0x7F, 0x03, 0xBF, 0xF0, 0x77, 0x3F, 0x0F, 0x80, 0xE1, 0xE0, 0x1E, 0x78,
  0x03, 0xCF, 0x00, 0x39, 0xC0, 0x0F, 0x38, 0x01, 0xE7, 0x00, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xF8, 0x3F, 0x1F, 0x87,
  0x00, 0xF1, 0xC0, 0x0E, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x03, 0xCE, 0x00, 0x71, 0xE0,
  0x1E, 0x3F, 0x1F, 0x83, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8,
  0x3C, 0x00, 0xE7, 0x00, 0x1C, 0xE0, 0x07, 0x9C, 0x00, 0xE3, 0x80, 0x1C,
  0x70, 0x03, 0x9E, 0x00, 0x73, 0xC0, 0x0E, 0x70, 0x03, 0xCE, 0x00, 0x71,
  0xC0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x39, 0xE0, 0x07, 0x38, 0x01, 0xE7,
  0x00, 0x38, 0xE0, 0x07, 0x1E, 0x01, 0xE1, 0xC0, 0x78, 0x3F, 0x7E, 0x03,
  0xFF, 0x80, 0x3F, 0xC0, 0x00, 0xF0, 0x00, 0xEE, 0x00, 0x39, 0xC0, 0x07,
  0x38, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x0E, 0x1E, 0x01, 0xC1, 0xC0, 0x70,
  0x38, 0x0E, 0x07, 0x03, 0xC0, 0xE0, 0x70, 0x1C, 0x1E, 0x03, 0x83, 0x80,
  0x38, 0xF0, 0x07, 0x1C, 0x00, 0xE7, 0x80, 0x1C, 0xE0, 0x03, 0xBC, 0x00,
  0x37, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0xE0, 0x70,
  0x3F, 0x03, 0x81, 0xF8, 0x3C, 0x0D, 0xC1, 0xE0, 0xEE, 0x0F, 0x07, 0x70,
  0xD8, 0x33, 0x86, 0xC3, 0x9C, 0x36, 0x1C, 0xE3, 0x30, 0xC7, 0x19, 0x8E,
  0x38, 0xCC, 0x71, 0xCC, 0x63, 0x0E, 0x63, 0x18, 0x73, 0x19, 0xC3, 0xB0,
  0xCC, 0x1D, 0x86, 0x60, 0xEC, 0x37, 0x07, 0xC1, 0xB0, 0x3E, 0x0D, 0x81,
  0xF0, 0x7C, 0x0F, 0x83, 0xC0, 0x78, 0x1E, 0x00, 0x0F, 0x00, 0x3C, 0x3C,
  0x01, 0xE0, 0x70, 0x0F, 0x01, 0xE0, 0x78, 0x03, 0x81, 0xC0, 0x0F, 0x0E,
  0x00, 0x1C, 0x78, 0x00, 0x3B, 0xC0, 0x00, 0xEE, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x07, 0x70, 0x00, 0x38,
  0xE0, 0x01, 0xE3, 0x80, 0x0F, 0x0F, 0x00, 0x78, 0x1E, 0x01, 0xC0, 0x78,
  0x0E, 0x00, 0xF0, 0x78, 0x03, 0xC3, 0xC0, 0x07, 0x80, 0x3C, 0x00, 0xE7,
  0x00, 0x3C, 0xE0, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x03, 0x9E,
  0x00, 0x73, 0xC0, 0x1E, 0x70, 0x03, 0xCE, 0x00, 0x71, 0xC0, 0x0E, 0x38,
  0x01, 0xC7, 0x00, 0x39, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x78, 0x78,
  0x1F, 0x0F, 0xCE, 0xE0, 0xFF, 0xDC, 0x0F, 0xE3, 0x80, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x81, 0xFF,
  0xF0, 0x3F, 0xFC, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x03, 0x81,
  0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x83, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x3C, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0xF0,
  0x70, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x3C, 0x1C, 0x0E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xFF, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0xE7, 0xF8, 0x1D, 0xFF, 0x03, 0xF8, 0xF0, 0x7E, 0x0F,
  0x1D, 0xC0, 0xFF, 0xB8, 0x0F, 0xE7, 0x00, 0xF0,
};

const GFXglyph JetBrainsMono_LightItalic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 9, 29, 24, 8, -29 },
  { 34, 13, 12, 24, 8, -29 },
  { 54, 23, 29, 24, 1, -29 },
  { 138, 21, 41, 24, 2, -35 },
  { 246, 27, 29, 24, -1, -29 },
  { 344, 22, 30, 24, 1, -30 },
  { 427, 5, 12, 24, 11, -29 },
  { 435, 16, 39, 24, 7, -34 },
  { 513, 16, 39, 24, 2, -34 },
  { 591, 21, 20, 24, 2, -24 },
  { 644, 19, 19, 24, 3, -23 },
  { 690, 10, 12, 24, 4, -6 },
  { 705, 13, 3, 24, 6, -15 },
  { 710, 7, 6, 24, 7, -6 },
  { 716, 23, 37, 24, 1, -33 },
  { 823, 21, 30, 24, 2, -30 },
  { 902, 18, 29, 24, 2, -29 },
  { 968, 21, 30, 24, 2, -30 },
  { 1047, 20, 29, 24, 2, -29 },
  { 1120, 18, 29, 24, 3, -29 },
  { 1186, 19, 29, 24, 3, -29 },
  { 1255, 19, 29, 24, 2, -29 },
  { 1324, 19, 29, 24, 5, -29 },
  { 1393, 20, 30, 24, 2, -30 },
  { 1468, 19, 30, 24, 4, -30 },
  { 1540, 10, 22, 24, 7, -22 },
  { 1568, 13, 28, 24, 4, -22 },
  { 1614, 19, 21, 24, 4, -24 },
  { 1664, 19, 12, 24, 3, -19 },
  { 1693, 19, 21, 24, 2, -24 },
  { 1743, 16, 29, 24, 6, -29 },
  { 1801, 24, 37, 24, 0, -30 },
  { 1912, 20, 29, 24, 0, -29 },
  { 1985, 21, 29, 24, 2, -29 },
  { 2062, 20, 30, 24, 3, -30 },
  { 2137, 20, 29, 24, 2, -29 },
  { 2210, 22, 29, 24, 2, -29 },
  { 2290, 22, 29, 24, 2, -29 },
  { 2370, 20, 30, 24, 3, -30 },
  { 2445, 21, 29, 24, 2, -29 },
  { 2522, 20, 29, 24, 3, -29 },
  { 2595, 22, 29, 24, 1, -29 },
  { 2675, 23, 29, 24, 2, -29 },
  { 2759, 17, 29, 24, 3, -29 },
  { 2821, 23, 29, 24, 1, -29 },
  { 2905, 21, 29, 24, 2, -29 },
  { 2982, 19, 30, 24, 3, -30 },
  { 3054, 22, 29, 24, 2, -29 },
  { 3134, 20, 37, 24, 3, -30 },
  { 3227, 21, 29, 24, 2, -29 },
  { 3304, 21, 30, 24, 2, -30 },
  { 3383, 20, 29, 24, 5, -29 },
  { 3456, 20, 29, 24, 3, -29 },
  { 3529, 20, 29, 24, 5, -29 },
  { 3602, 23, 29, 24, 3, -29 },
  { 3686, 25, 29, 24, 0, -29 },
  { 3777, 21, 29, 24, 4, -29 },
  { 3854, 21, 29, 24, 2, -29 },
  { 3931, 15, 37, 24, 6, -33 },
  { 4001, 11, 37, 24, 7, -33 },
  { 4052, 15, 37, 24, 4, -33 },
  { 4122, 17, 15, 24, 4, -29 },
  { 4154, 20, 3, 24, 0, 1 },
  { 4162, 7, 5, 24, 11, -31 },
  { 4167, 19, 22, 24, 3, -22 },
  { 4220, 19, 29, 24, 2, -29 },
  { 4289, 19, 22, 24, 3, -22 },
  { 4342, 20, 29, 24, 3, -29 },
  { 4415, 18, 22, 24, 3, -22 },
  { 4465, 27, 36, 24, -2, -29 },
  { 4587, 19, 29, 24, 3, -22 },
  { 4656, 19, 29, 24, 2, -29 },
  { 4725, 19, 31, 24, 2, -31 },
  { 4799, 20, 38, 24, 1, -31 },
  { 4894, 21, 29, 24, 2, -29 },
  { 4971, 17, 29, 24, 4, -29 },
  { 5033, 22, 22, 24, 1, -22 },
  { 5094, 19, 22, 24, 2, -22 },
  { 5147, 18, 22, 24, 3, -22 },
  { 5197, 20, 29, 24, 1, -22 },
  { 5270, 19, 29, 24, 3, -22 },
  { 5339, 19, 22, 24, 3, -22 },
  { 5392, 19, 22, 24, 2, -22 },
  { 5445, 18, 28, 24, 4, -28 },
  { 5508, 19, 22, 24, 3, -22 },
  { 5561, 19, 22, 24, 4, -22 },
  { 5614, 21, 22, 24, 3, -22 },
  { 5672, 22, 22, 24, 1, -22 },
  { 5733, 19, 29, 24, 3, -22 },
  { 5802, 20, 22, 24, 2, -22 },
  { 5857, 20, 37, 24, 4, -33 },
  { 5950, 9, 37, 24, 8, -33 },
  { 5992, 20, 37, 24, 1, -33 },
  { 6085, 19, 8, 24, 3, -18 },
};

const GFXfont JetBrainsMono_LightItalic40pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_LightItalic40pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_LightItalic40pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _JETBRAINSMONO_LIGHTITALIC40PT7B_H_
