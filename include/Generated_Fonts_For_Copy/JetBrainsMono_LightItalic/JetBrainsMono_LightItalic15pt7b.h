#ifndef _JETBRAINSMONO_LIGHTITALIC15PT7B_H_
#define _JETBRAINSMONO_LIGHTITALIC15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-LightItalic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_LightItalic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0xB4, 0x92, 0x1B, 0x00, 0xDC, 0xE5, 0x29, 0x00, 0x08, 0x84,
  0x82, 0x4F, 0xF1, 0x21, 0x10, 0x89, 0xFE, 0x44, 0x22, 0x12, 0x00, 0x08,
  0x08, 0x1E, 0x2A, 0x4A, 0x48, 0x70, 0x3C, 0x14, 0x16, 0x96, 0x94, 0x78,
  0x20, 0x20, 0x38, 0xD2, 0x24, 0x91, 0x28, 0x74, 0x02, 0x01, 0x70, 0x52,
  0x29, 0x12, 0x48, 0x70, 0x1E, 0x19, 0x88, 0x06, 0x01, 0x03, 0xC5, 0x24,
  0x9C, 0x44, 0x27, 0x1E, 0xC0, 0x5F, 0x80, 0x02, 0x18, 0x41, 0x82, 0x0C,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x06, 0x07, 0x04, 0x00, 0x20, 0xC0, 0x82,
  0x0C, 0x30, 0xC2, 0x08, 0x20, 0x84, 0x31, 0x88, 0x00, 0x08, 0x18, 0xD3,
  0x7E, 0x10, 0x28, 0xCC, 0x48, 0x18, 0x20, 0x47, 0xF1, 0x02, 0x0C, 0x00,
  0x6B, 0x40, 0xF8, 0xF0, 0x01, 0x80, 0x80, 0xC0, 0x40, 0x40, 0x20, 0x20,
  0x10, 0x10, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x00, 0x3E, 0x62, 0x42, 0x42,
  0x42, 0xDA, 0x82, 0x86, 0x84, 0xC4, 0x78, 0x1C, 0x71, 0x20, 0x40, 0x81,
  0x06, 0x08, 0x10, 0x23, 0xF8, 0x3E, 0xC5, 0x08, 0x10, 0x60, 0x82, 0x18,
  0x61, 0x83, 0xF0, 0x7E, 0x04, 0x30, 0xC1, 0xC0, 0x81, 0x82, 0x85, 0x19,
  0xE0, 0x06, 0x08, 0x20, 0x82, 0x0C, 0xF1, 0x7E, 0xFC, 0x08, 0x10, 0x3E,
  0xC1, 0x02, 0x07, 0xC8, 0xC0, 0x83, 0x05, 0x09, 0xE0, 0x0C, 0x10, 0x41,
  0x07, 0xCC, 0xF0, 0xC1, 0x87, 0x89, 0xE0, 0xFF, 0x0E, 0x10, 0x60, 0x83,
  0x04, 0x10, 0x20, 0x83, 0x00, 0x3E, 0x45, 0x0A, 0x12, 0x47, 0x11, 0x43,
  0x85, 0x09, 0xE0, 0x3E, 0x62, 0x43, 0x42, 0x42, 0x66, 0x3C, 0x08, 0x10,
  0x30, 0x60, 0x6C, 0x00, 0x36, 0x33, 0x00, 0x00, 0x64, 0xC8, 0x02, 0x0C,
  0xE3, 0x0C, 0x06, 0x03, 0x02, 0x7E, 0x00, 0x07, 0xF0, 0x40, 0xC0, 0x60,
  0x30, 0x63, 0x18, 0x40, 0x78, 0x30, 0x41, 0x0D, 0xE6, 0x10, 0x01, 0x0C,
  0x00, 0x1F, 0x18, 0xC8, 0x28, 0x14, 0xFA, 0x4D, 0x24, 0x92, 0xD9, 0x47,
  0xA0, 0x18, 0x06, 0x01, 0xC0, 0x04, 0x0E, 0x0A, 0x12, 0x12, 0x32, 0x22,
  0x3E, 0x42, 0x42, 0xC3, 0x7C, 0x85, 0x0A, 0x14, 0x6F, 0x91, 0xE1, 0x87,
  0x0B, 0xE0, 0x1E, 0x45, 0x0A, 0x04, 0x08, 0x30, 0x40, 0x87, 0x89, 0xE0,
  0x7C, 0x8D, 0x0A, 0x14, 0x28, 0x51, 0xE3, 0x85, 0x1B, 0xE0, 0x3F, 0x60,
  0x40, 0x40, 0x42, 0x7C, 0x40, 0xC0, 0x80, 0x80, 0xFC, 0x3F, 0x60, 0x40,
  0x40, 0x40, 0x7E, 0x40, 0xC0, 0x80, 0x80, 0x80, 0x1E, 0x45, 0x0A, 0x04,
  0x0B, 0xF7, 0xC3, 0x85, 0x89, 0xE0, 0x63, 0x62, 0x42, 0x42, 0x42, 0x7E,
  0x46, 0xC4, 0x84, 0x84, 0x84, 0x3E, 0x10, 0x20, 0xC1, 0x02, 0x04, 0x08,
  0x10, 0x63, 0xF0, 0x0F, 0x01, 0x01, 0x01, 0x01, 0x03, 0x02, 0x02, 0x42,
  0x46, 0x7C, 0x61, 0x42, 0x46, 0x44, 0x48, 0x78, 0x48, 0xC8, 0x8C, 0x84,
  0x86, 0x20, 0x41, 0x82, 0x04, 0x08, 0x10, 0x20, 0xC1, 0x87, 0xF0, 0x63,
  0x63, 0x66, 0x66, 0x5A, 0xDA, 0x82, 0x82, 0x86, 0x84, 0x84, 0x63, 0x62,
  0x52, 0x52, 0x52, 0x52, 0xD6, 0x8C, 0x8C, 0x8C, 0x8C, 0x1E, 0x45, 0x0A,
  0x14, 0x28, 0x71, 0xC3, 0x85, 0x89, 0xE0, 0x7E, 0x43, 0x41, 0x43, 0x42,
  0x7E, 0x40, 0xC0, 0x80, 0x80, 0x80, 0x3E, 0xC5, 0x0A, 0x14, 0x28, 0x70,
  0xC3, 0x85, 0x89, 0xE0, 0xC0, 0x81, 0x80, 0x7E, 0x42, 0x43, 0x42, 0x42,
  0x7C, 0x48, 0xC8, 0x8C, 0x84, 0x84, 0x1E, 0x22, 0x42, 0x40, 0x60, 0x3C,
  0x04, 0x06, 0x86, 0x84, 0x78, 0xFE, 0x20, 0x41, 0x82, 0x04, 0x08, 0x10,
  0x20, 0xC1, 0x80, 0x63, 0x42, 0x42, 0x42, 0x42, 0x42, 0xC6, 0xC4, 0x84,
  0xC4, 0x78, 0x83, 0x0E, 0x14, 0x2C, 0x99, 0x16, 0x28, 0x50, 0xC1, 0x80,
  0xC9, 0xE4, 0xA6, 0x53, 0x29, 0xA5, 0x52, 0xA9, 0x54, 0xCC, 0x66, 0x33,
  0x00, 0x20, 0x98, 0x84, 0x83, 0xC0, 0xC0, 0x40, 0x50, 0x28, 0x26, 0x21,
  0x30, 0xC0, 0x83, 0x86, 0xC4, 0x48, 0x58, 0x70, 0x20, 0x20, 0x20, 0x60,
  0x60, 0x7F, 0x02, 0x06, 0x0C, 0x08, 0x10, 0x30, 0x20, 0x40, 0x80, 0xFC,
  0x3C, 0x82, 0x08, 0x20, 0x86, 0x10, 0x41, 0x04, 0x10, 0xC3, 0xC0, 0xC2,
  0x10, 0xC2, 0x10, 0x84, 0x10, 0x84, 0x21, 0x84, 0x3C, 0x10, 0x43, 0x08,
  0x20, 0x82, 0x08, 0x61, 0x04, 0x13, 0xC0, 0x08, 0x28, 0x51, 0x24, 0x58,
  0x40, 0xFE, 0x8C, 0x3E, 0x8D, 0x0E, 0x38, 0x50, 0xB3, 0x3A, 0x60, 0x81,
  0x03, 0xE4, 0x28, 0x51, 0xE3, 0x85, 0x8A, 0xE0, 0x3C, 0x85, 0x06, 0x08,
  0x10, 0xB1, 0x3C, 0x03, 0x02, 0x02, 0x3E, 0x46, 0x42, 0xC6, 0x84, 0x84,
  0xCC, 0x74, 0x3C, 0x85, 0x0F, 0xF8, 0x10, 0x31, 0x3C, 0x03, 0xC1, 0x80,
  0x40, 0x10, 0x3F, 0x81, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x10, 0x38, 0x00, 0x3E, 0x8D, 0x0E, 0x38, 0x58, 0x9F, 0x02, 0x04, 0x13,
  0xC0, 0x60, 0x81, 0x03, 0xE4, 0x28, 0x51, 0xE2, 0x85, 0x0A, 0x10, 0x08,
  0x18, 0x00, 0x07, 0x81, 0x06, 0x08, 0x10, 0x20, 0x47, 0xF0, 0x02, 0x03,
  0x00, 0x00, 0x3E, 0x02, 0x02, 0x06, 0x04, 0x04, 0x04, 0x04, 0x0C, 0x18,
  0xF0, 0x20, 0x60, 0x41, 0x42, 0x44, 0x48, 0x78, 0xD8, 0x88, 0x8C, 0x84,
  0xE0, 0x82, 0x08, 0x21, 0x84, 0x10, 0x41, 0x07, 0xC0, 0x3F, 0x69, 0x49,
  0x49, 0x49, 0x49, 0x4B, 0xD2, 0x7C, 0x85, 0x0A, 0x3C, 0x50, 0xA1, 0x42,
  0x3C, 0x85, 0x0E, 0x38, 0x70, 0xB1, 0x3C, 0x3E, 0x21, 0x21, 0x63, 0x63,
  0x42, 0x62, 0x5C, 0x40, 0x40, 0xC0, 0x3E, 0x8D, 0x0E, 0x38, 0x50, 0xB3,
  0x3A, 0x04, 0x18, 0x20, 0x7E, 0xC5, 0x0A, 0x04, 0x18, 0x30, 0x40, 0x7E,
  0x85, 0x03, 0xC0, 0xC0, 0xA1, 0x3C, 0x10, 0x20, 0x47, 0xF1, 0x06, 0x08,
  0x10, 0x20, 0x40, 0xF0, 0x42, 0x85, 0x0E, 0x3C, 0x50, 0xB1, 0x3C, 0x87,
  0x0A, 0x24, 0x4D, 0x0A, 0x18, 0x30, 0x99, 0x9A, 0x9A, 0xAA, 0xAA, 0xAC,
  0xCC, 0xCC, 0x21, 0x89, 0x05, 0x01, 0x01, 0xC1, 0xA1, 0x99, 0x84, 0x42,
  0x85, 0x0E, 0x3C, 0x58, 0x9F, 0x02, 0x04, 0x13, 0xC0, 0x7E, 0x08, 0x20,
  0x83, 0x0C, 0x30, 0x7E, 0x07, 0x0C, 0x08, 0x08, 0x08, 0x08, 0xF0, 0x18,
  0x18, 0x10, 0x10, 0x10, 0x18, 0x0C, 0x24, 0x96, 0x92, 0x4B, 0x69, 0x00,
  0x38, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x07, 0x08, 0x10, 0x10, 0x10, 0x10,
  0x30, 0xC0, 0x63, 0xA6, 0x38,
};

const GFXglyph JetBrainsMono_LightItalic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 11, 9, 3, -11 },
  { 6, 5, 5, 9, 3, -11 },
  { 10, 9, 11, 9, 0, -11 },
  { 23, 8, 15, 9, 1, -13 },
  { 38, 10, 11, 9, 0, -11 },
  { 52, 9, 11, 9, 0, -11 },
  { 65, 2, 5, 9, 4, -11 },
  { 67, 7, 15, 9, 2, -13 },
  { 81, 6, 15, 9, 1, -13 },
  { 93, 8, 8, 9, 1, -9 },
  { 101, 7, 7, 9, 1, -8 },
  { 108, 3, 4, 9, 2, -2 },
  { 110, 5, 1, 9, 2, -5 },
  { 111, 2, 2, 9, 3, -2 },
  { 112, 9, 14, 9, 0, -12 },
  { 128, 8, 11, 9, 1, -11 },
  { 139, 7, 11, 9, 1, -11 },
  { 149, 7, 11, 9, 1, -11 },
  { 159, 7, 11, 9, 1, -11 },
  { 169, 7, 11, 9, 1, -11 },
  { 179, 7, 11, 9, 1, -11 },
  { 189, 7, 11, 9, 1, -11 },
  { 199, 7, 11, 9, 2, -11 },
  { 209, 7, 11, 9, 1, -11 },
  { 219, 8, 11, 9, 1, -11 },
  { 230, 3, 8, 9, 3, -8 },
  { 233, 4, 10, 9, 2, -8 },
  { 238, 7, 8, 9, 1, -9 },
  { 245, 7, 4, 9, 1, -7 },
  { 249, 7, 8, 9, 1, -9 },
  { 256, 6, 11, 9, 2, -11 },
  { 265, 9, 14, 9, 0, -11 },
  { 281, 8, 11, 9, 0, -11 },
  { 292, 7, 11, 9, 1, -11 },
  { 302, 7, 11, 9, 1, -11 },
  { 312, 7, 11, 9, 1, -11 },
  { 322, 8, 11, 9, 1, -11 },
  { 333, 8, 11, 9, 1, -11 },
  { 344, 7, 11, 9, 1, -11 },
  { 354, 8, 11, 9, 1, -11 },
  { 365, 7, 11, 9, 1, -11 },
  { 375, 8, 11, 9, 0, -11 },
  { 386, 8, 11, 9, 1, -11 },
  { 397, 7, 11, 9, 1, -11 },
  { 407, 8, 11, 9, 1, -11 },
  { 418, 8, 11, 9, 1, -11 },
  { 429, 7, 11, 9, 1, -11 },
  { 439, 8, 11, 9, 1, -11 },
  { 450, 7, 14, 9, 1, -11 },
  { 463, 8, 11, 9, 1, -11 },
  { 474, 8, 11, 9, 1, -11 },
  { 485, 7, 11, 9, 2, -11 },
  { 495, 8, 11, 9, 1, -11 },
  { 506, 7, 11, 9, 2, -11 },
  { 516, 9, 11, 9, 1, -11 },
  { 529, 9, 11, 9, 0, -11 },
  { 542, 8, 11, 9, 2, -11 },
  { 553, 8, 11, 9, 1, -11 },
  { 564, 6, 14, 9, 2, -12 },
  { 575, 5, 14, 9, 2, -12 },
  { 584, 6, 14, 9, 1, -12 },
  { 595, 7, 6, 9, 1, -11 },
  { 601, 7, 1, 9, 0, 0 },
  { 602, 3, 2, 9, 4, -12 },
  { 603, 7, 8, 9, 1, -8 },
  { 610, 7, 11, 9, 1, -11 },
  { 620, 7, 8, 9, 1, -8 },
  { 627, 8, 11, 9, 1, -11 },
  { 638, 7, 8, 9, 1, -8 },
  { 645, 10, 14, 9, -1, -11 },
  { 663, 7, 11, 9, 1, -8 },
  { 673, 7, 11, 9, 1, -11 },
  { 683, 7, 12, 9, 1, -12 },
  { 694, 8, 15, 9, 0, -12 },
  { 709, 8, 11, 9, 1, -11 },
  { 720, 6, 11, 9, 2, -11 },
  { 729, 8, 8, 9, 0, -8 },
  { 737, 7, 8, 9, 1, -8 },
  { 744, 7, 8, 9, 1, -8 },
  { 751, 8, 11, 9, 0, -8 },
  { 762, 7, 11, 9, 1, -8 },
  { 772, 7, 8, 9, 1, -8 },
  { 779, 7, 8, 9, 1, -8 },
  { 786, 7, 11, 9, 1, -11 },
  { 796, 7, 8, 9, 1, -8 },
  { 803, 7, 8, 9, 2, -8 },
  { 810, 8, 8, 9, 1, -8 },
  { 818, 9, 8, 9, 0, -8 },
  { 827, 7, 11, 9, 1, -8 },
  { 837, 7, 8, 9, 1, -8 },
  { 844, 8, 14, 9, 1, -12 },
  { 858, 3, 14, 9, 3, -12 },
  { 864, 8, 14, 9, 0, -12 },
  { 878, 7, 3, 9, 1, -7 },
};

const GFXfont JetBrainsMono_LightItalic15pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_LightItalic15pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_LightItalic15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _JETBRAINSMONO_LIGHTITALIC15PT7B_H_
