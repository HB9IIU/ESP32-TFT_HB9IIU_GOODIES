#ifndef _JETBRAINSMONO_LIGHTITALIC27PT7B_H_
#define _JETBRAINSMONO_LIGHTITALIC27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-LightItalic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_LightItalic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x31, 0xC7, 0x1C, 0x61, 0x86, 0x18, 0x63, 0x0C, 0x30, 0xC0,
  0x00, 0x01, 0xCF, 0x3C, 0x71, 0xB1, 0xD8, 0xEC, 0x66, 0x37, 0x1B, 0x0D,
  0x86, 0x01, 0x86, 0x06, 0x08, 0x0C, 0x30, 0x18, 0x60, 0x60, 0x80, 0xC3,
  0x0F, 0xFF, 0x86, 0x08, 0x0C, 0x30, 0x18, 0x60, 0x60, 0x80, 0xC3, 0x01,
  0x06, 0x1F, 0xFF, 0x3F, 0xFE, 0x10, 0x60, 0x61, 0x80, 0xC3, 0x01, 0x06,
  0x06, 0x18, 0x00, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x7C, 0x07, 0xF8,
  0x3B, 0x71, 0xC8, 0xC6, 0x23, 0x18, 0x80, 0x66, 0x01, 0x98, 0x07, 0xE0,
  0x0F, 0xC0, 0x0F, 0x80, 0x17, 0x00, 0xCE, 0x03, 0x18, 0x0C, 0x66, 0x31,
  0x98, 0x8C, 0x72, 0x71, 0xFF, 0x81, 0xF8, 0x01, 0x80, 0x06, 0x00, 0x10,
  0x00, 0x40, 0x00, 0x03, 0x80, 0x61, 0xF8, 0x18, 0x63, 0x06, 0x0C, 0x61,
  0x81, 0x8C, 0x60, 0x21, 0x98, 0x04, 0x32, 0x00, 0xFC, 0xC0, 0x0F, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xCF, 0x00, 0x13, 0xF0, 0x06, 0xC6,
  0x01, 0x98, 0xC0, 0x63, 0x18, 0x18, 0x63, 0x06, 0x08, 0x60, 0x81, 0xF8,
  0x70, 0x1E, 0x00, 0x03, 0xE0, 0x1F, 0xC0, 0xC3, 0x86, 0x06, 0x18, 0x18,
  0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0xF8, 0x07, 0x70, 0xD8, 0xC7,
  0x63, 0x9B, 0x86, 0xCC, 0x0E, 0x30, 0x38, 0xC0, 0xE3, 0x07, 0xCF, 0xF3,
  0x1F, 0x8E, 0x6F, 0xFD, 0xB6, 0x00, 0x30, 0x0E, 0x01, 0xC0, 0x70, 0x06,
  0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x70,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x70, 0x0C, 0x01, 0xE0, 0x1E,
  0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0,
  0x30, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1C, 0x00, 0x01, 0xC0, 0x03, 0x00,
  0x06, 0x02, 0x0C, 0x17, 0x19, 0xFF, 0xAF, 0x87, 0xFC, 0x01, 0x80, 0x07,
  0x80, 0x19, 0x80, 0x63, 0x81, 0xC3, 0x07, 0x07, 0x00, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x7F, 0xFF, 0xFF, 0xE0, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x1C, 0x00, 0x1E, 0x38, 0xE1, 0x87, 0x0C, 0x38, 0x60,
  0xFF, 0xFF, 0xC0, 0x77, 0xBD, 0xE0, 0x00, 0x06, 0x00, 0x18, 0x00, 0x70,
  0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01,
  0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x70, 0x00, 0xC0, 0x00, 0x07, 0xE0, 0x7F, 0x87, 0x0E, 0x60, 0x33,
  0x01, 0xB8, 0x0D, 0x80, 0x6C, 0x03, 0x60, 0x3B, 0x39, 0x99, 0xCD, 0xC4,
  0x6C, 0x03, 0x60, 0x1B, 0x01, 0xD8, 0x0C, 0xC0, 0x67, 0x06, 0x1F, 0xF0,
  0x7E, 0x00, 0x00, 0xE0, 0x1F, 0x01, 0xF8, 0x39, 0x81, 0x8C, 0x08, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x18, 0x1F, 0xFF, 0xFF, 0xE0, 0x03,
  0xF0, 0x1F, 0xE0, 0xC1, 0xC6, 0x03, 0x38, 0x0C, 0xC0, 0x30, 0x00, 0xC0,
  0x06, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x07, 0xFF, 0x3F, 0xFC, 0x0F, 0xFC,
  0x3F, 0xF1, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x03, 0xE0, 0x13, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03,
  0x18, 0x0C, 0x60, 0x71, 0xC1, 0x87, 0xFC, 0x07, 0xE0, 0x00, 0x30, 0x06,
  0x00, 0xE0, 0x1C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x1C, 0x03, 0x83,
  0x30, 0x36, 0x07, 0xE0, 0x6C, 0x06, 0xFF, 0xEF, 0xFE, 0x00, 0x60, 0x0E,
  0x00, 0xC0, 0x0C, 0x1F, 0xF8, 0xFF, 0xC6, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0xF8, 0x7F, 0xE3, 0xC3, 0x9C, 0x1C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x01, 0x80, 0x0C, 0xC0, 0x67, 0x06, 0x1F, 0xF0, 0x7E, 0x00,
  0x00, 0x70, 0x03, 0x00, 0x30, 0x03, 0x00, 0x38, 0x03, 0x80, 0x18, 0x01,
  0x80, 0x1F, 0xE1, 0xFF, 0x8E, 0x0E, 0xE0, 0x36, 0x01, 0xB0, 0x0D, 0x80,
  0x6C, 0x07, 0x60, 0x33, 0x83, 0x8F, 0xF8, 0x3F, 0x00, 0x7F, 0xFB, 0xFF,
  0xD8, 0x06, 0xC0, 0x6E, 0x03, 0x70, 0x30, 0x03, 0x80, 0x18, 0x01, 0xC0,
  0x0C, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x80, 0x18,
  0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0xE0, 0xE1, 0xC6,
  0x03, 0x18, 0x0C, 0x60, 0x31, 0x81, 0x87, 0x0E, 0x0E, 0x70, 0x1F, 0x00,
  0xFE, 0x07, 0x1C, 0x30, 0x31, 0xC0, 0xE6, 0x03, 0x98, 0x0C, 0x60, 0x31,
  0xC1, 0xC7, 0xFE, 0x07, 0xE0, 0x0F, 0xC0, 0xFF, 0x0E, 0x1C, 0xC0, 0x6E,
  0x03, 0x60, 0x1B, 0x00, 0xD8, 0x06, 0xC0, 0x77, 0x07, 0x3E, 0xF8, 0xFD,
  0x80, 0x18, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00,
  0xE0, 0x00, 0x1C, 0xF3, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0xF3,
  0xCF, 0x00, 0x0F, 0x0F, 0x0F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x02, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0x60, 0x60, 0xC0, 0x00, 0x08, 0x01,
  0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xC0, 0x1C, 0x00, 0x78, 0x00,
  0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x10, 0x7F, 0xFB, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xDF, 0xFE, 0x10, 0x01, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xE0, 0x07, 0x00, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x07, 0x00, 0x60, 0x00, 0x3C, 0x07, 0xF0, 0x0F,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0xF0, 0xF8, 0x18,
  0x03, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x03, 0xC0, 0x70, 0x00,
  0x00, 0xF8, 0x03, 0xFE, 0x06, 0x06, 0x0C, 0x03, 0x18, 0x03, 0x18, 0x03,
  0x30, 0x03, 0x30, 0x7B, 0x30, 0xEF, 0x31, 0x87, 0x31, 0x86, 0x61, 0x86,
  0x63, 0x06, 0x63, 0x06, 0x63, 0x06, 0x63, 0x0E, 0x63, 0x8C, 0x61, 0xFC,
  0xC0, 0x40, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x38, 0x00, 0x3F, 0x80,
  0x0F, 0x80, 0x00, 0x60, 0x03, 0xC0, 0x0F, 0x00, 0x6C, 0x01, 0xB0, 0x0E,
  0xC0, 0x33, 0x00, 0xCC, 0x06, 0x30, 0x18, 0xC0, 0xC1, 0x83, 0x06, 0x1C,
  0x18, 0x7F, 0xE1, 0xFF, 0x8C, 0x06, 0x30, 0x19, 0xC0, 0x66, 0x01, 0xB8,
  0x07, 0x0F, 0xC0, 0x7F, 0xE1, 0x83, 0xC6, 0x07, 0x18, 0x0C, 0x60, 0x31,
  0x81, 0xCE, 0x06, 0x30, 0x70, 0xFF, 0x83, 0xFF, 0x0C, 0x0E, 0x30, 0x19,
  0xC0, 0x66, 0x01, 0x98, 0x0E, 0x60, 0x31, 0x81, 0xC7, 0xFE, 0x3F, 0xE0,
  0x03, 0xE0, 0x7F, 0x87, 0x0E, 0x70, 0x33, 0x01, 0x98, 0x0D, 0xC0, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00,
  0x58, 0x0C, 0xC0, 0x67, 0x07, 0x1F, 0xF0, 0x7E, 0x00, 0x0F, 0xC0, 0x7F,
  0xC1, 0x83, 0x86, 0x07, 0x18, 0x0C, 0x60, 0x31, 0x80, 0xCE, 0x06, 0x30,
  0x18, 0xC0, 0x63, 0x01, 0x8C, 0x06, 0x30, 0x19, 0xC0, 0xE6, 0x03, 0x18,
  0x0C, 0x60, 0x71, 0x83, 0x87, 0xFC, 0x3F, 0xC0, 0x1F, 0xFC, 0x7F, 0xF3,
  0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01,
  0xFF, 0xC7, 0xFE, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0x1F, 0xFC, 0xFF, 0xF3, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x01, 0xFF,
  0xC7, 0xFF, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x03, 0xE0, 0x7F, 0x87, 0x0E, 0x70,
  0x33, 0x01, 0x98, 0x0D, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0xFC,
  0xC7, 0xEE, 0x03, 0x60, 0x1B, 0x01, 0xD8, 0x0C, 0xC0, 0x67, 0x07, 0x1F,
  0xF0, 0x7E, 0x00, 0x0C, 0x0E, 0x38, 0x18, 0x60, 0x30, 0xC0, 0x61, 0x80,
  0xC3, 0x01, 0x86, 0x07, 0x1C, 0x0C, 0x30, 0x18, 0x7F, 0xF0, 0xFF, 0xE1,
  0x80, 0xC3, 0x03, 0x8E, 0x06, 0x18, 0x0C, 0x30, 0x18, 0x60, 0x30, 0xC0,
  0x61, 0x81, 0xC7, 0x03, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x60, 0x07, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x3F, 0xF1,
  0xFF, 0x80, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00,
  0x30, 0x00, 0xCC, 0x03, 0x30, 0x0C, 0xC0, 0x63, 0x83, 0x87, 0xFC, 0x0F,
  0xC0, 0x0C, 0x07, 0x1C, 0x0E, 0x18, 0x0C, 0x18, 0x1C, 0x18, 0x38, 0x18,
  0x30, 0x18, 0x70, 0x38, 0xE0, 0x30, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x30,
  0xC0, 0x30, 0xC0, 0x70, 0xE0, 0x60, 0x60, 0x60, 0x60, 0x60, 0x70, 0x60,
  0x30, 0x60, 0x30, 0xE0, 0x38, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xFF, 0xFE, 0x1C,
  0x0E, 0x38, 0x3C, 0x50, 0x78, 0xA1, 0xA3, 0x63, 0x46, 0xC5, 0x8D, 0x9B,
  0x19, 0x26, 0x32, 0xCC, 0x65, 0x39, 0xCE, 0x63, 0x00, 0xC6, 0x01, 0x8C,
  0x03, 0x18, 0x06, 0x30, 0x1C, 0x60, 0x31, 0x80, 0x63, 0x00, 0xC6, 0x01,
  0x80, 0x1C, 0x0E, 0x3C, 0x18, 0x78, 0x30, 0xF0, 0x61, 0xE0, 0xC3, 0x41,
  0x86, 0xC7, 0x19, 0x8C, 0x33, 0x18, 0x66, 0x30, 0xC6, 0x61, 0x8C, 0xC3,
  0x19, 0x8C, 0x37, 0x18, 0x6C, 0x30, 0x78, 0x60, 0xF0, 0xC1, 0xE1, 0x83,
  0xC7, 0x07, 0x80, 0x07, 0xE0, 0x7F, 0x87, 0x0E, 0x70, 0x73, 0x01, 0x98,
  0x0D, 0xC0, 0x6C, 0x07, 0x60, 0x33, 0x01, 0x98, 0x0C, 0xC0, 0x6E, 0x03,
  0x60, 0x3B, 0x01, 0x98, 0x0C, 0xC0, 0x67, 0x06, 0x1F, 0xE0, 0x7E, 0x00,
  0x0F, 0xF0, 0x3F, 0xF0, 0x60, 0x70, 0xC0, 0x71, 0x80, 0x63, 0x00, 0xC6,
  0x03, 0x9C, 0x06, 0x30, 0x1C, 0x60, 0x70, 0xFF, 0xC1, 0xFE, 0x03, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07,
  0x00, 0x00, 0x07, 0xE0, 0x7F, 0x87, 0x0E, 0x60, 0x33, 0x01, 0xB8, 0x0D,
  0x80, 0x6C, 0x07, 0x60, 0x3B, 0x01, 0x98, 0x0D, 0xC0, 0x6C, 0x03, 0x60,
  0x1B, 0x01, 0xD8, 0x0C, 0xC0, 0x67, 0x06, 0x1F, 0xF0, 0x7E, 0x00, 0x30,
  0x01, 0xC0, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x0F, 0xE0, 0x3F, 0xF0, 0x60,
  0x70, 0xC0, 0x61, 0x80, 0xE3, 0x01, 0x86, 0x03, 0x1C, 0x06, 0x30, 0x18,
  0x61, 0xF0, 0xFF, 0x81, 0xFE, 0x03, 0x0C, 0x0E, 0x18, 0x18, 0x38, 0x30,
  0x30, 0x60, 0x60, 0xC0, 0xE1, 0x80, 0xC7, 0x01, 0x80, 0x03, 0xF0, 0x1F,
  0xE0, 0xE1, 0xC6, 0x03, 0x18, 0x0C, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1E,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0x98,
  0x0E, 0x60, 0x31, 0xC1, 0xC7, 0xFE, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0,
  0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x1C, 0xC0, 0x63, 0x01,
  0x8C, 0x06, 0x30, 0x18, 0xC0, 0x63, 0x03, 0x9C, 0x0C, 0x60, 0x31, 0x80,
  0xC6, 0x03, 0x18, 0x0C, 0x60, 0x73, 0x81, 0xCC, 0x06, 0x30, 0x18, 0xC0,
  0x63, 0x83, 0x07, 0xF8, 0x0F, 0xC0, 0xE0, 0x1D, 0x80, 0x66, 0x01, 0x98,
  0x0C, 0x60, 0x31, 0x81, 0x86, 0x06, 0x18, 0x38, 0x60, 0xC1, 0x83, 0x07,
  0x18, 0x0C, 0x60, 0x33, 0x80, 0xCC, 0x03, 0x30, 0x0D, 0x80, 0x36, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x61, 0x86, 0xC3, 0x0D, 0x8E, 0x1B, 0x14,
  0x26, 0x28, 0xD8, 0xD1, 0xB1, 0xA3, 0x62, 0x4C, 0xC4, 0x99, 0x99, 0x33,
  0x26, 0x66, 0x4D, 0x8D, 0x9B, 0x1B, 0x36, 0x34, 0x68, 0x78, 0xF0, 0xF1,
  0xE1, 0xC3, 0xC3, 0x87, 0x07, 0x0E, 0x00, 0x1C, 0x03, 0x86, 0x03, 0x83,
  0x81, 0x80, 0xC1, 0x80, 0x61, 0xC0, 0x18, 0xC0, 0x0C, 0xC0, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x76, 0x00, 0x33,
  0x00, 0x31, 0xC0, 0x38, 0x60, 0x38, 0x30, 0x18, 0x0C, 0x1C, 0x06, 0x1C,
  0x03, 0x80, 0xC0, 0x0F, 0x80, 0x66, 0x03, 0x98, 0x0C, 0x70, 0x60, 0xC3,
  0x83, 0x0C, 0x0E, 0x60, 0x19, 0x80, 0x6C, 0x01, 0xF0, 0x03, 0x80, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x1F, 0xFE, 0x3F, 0xF8, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0xE0, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0xFF,
  0xC7, 0xFF, 0x80, 0x0F, 0xC3, 0xF0, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0xF8, 0xFE, 0x00, 0xC1,
  0x83, 0x07, 0x06, 0x0C, 0x18, 0x30, 0x30, 0x60, 0xC1, 0x83, 0x83, 0x06,
  0x0C, 0x18, 0x18, 0x30, 0x60, 0xC1, 0xC1, 0x83, 0x06, 0x0F, 0xE1, 0xFC,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x70, 0x0C, 0x01, 0x83, 0xF0, 0xFE, 0x00, 0x03, 0x00, 0xE0, 0x1E,
  0x06, 0xC1, 0x98, 0x31, 0x8C, 0x31, 0x86, 0x60, 0x58, 0x0F, 0x01, 0x80,
  0xFF, 0xF8, 0xE3, 0x8C, 0x30, 0x0F, 0x98, 0xFF, 0xCE, 0x1C, 0xE0, 0x66,
  0x03, 0x30, 0x19, 0x80, 0xCC, 0x0E, 0xE0, 0x66, 0x03, 0x30, 0x19, 0x80,
  0xCE, 0x0E, 0x3F, 0xF0, 0xFB, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0D, 0xF0, 0x7F, 0xC7, 0x87, 0x38, 0x19, 0x80, 0xCC, 0x06,
  0x60, 0x33, 0x01, 0xB8, 0x1D, 0x80, 0xCC, 0x06, 0x60, 0x33, 0x83, 0x1F,
  0xF9, 0xDF, 0x00, 0x0F, 0xC0, 0xFF, 0x0E, 0x1C, 0xE0, 0x66, 0x03, 0x30,
  0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x19, 0x80, 0xCE, 0x0E,
  0x3F, 0xE0, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x3E, 0x61, 0xFF, 0x8E, 0x1C, 0x70, 0x31, 0x80, 0xC6, 0x03, 0x18,
  0x0C, 0x60, 0x73, 0x81, 0x8C, 0x06, 0x30, 0x18, 0xC0, 0x63, 0x83, 0x87,
  0xFE, 0x0F, 0xB8, 0x0F, 0xC1, 0xFE, 0x38, 0x77, 0x03, 0x60, 0x36, 0x03,
  0x7F, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x06, 0xE0, 0xC7, 0xFC,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x07, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x98, 0xFF, 0xCE, 0x1C, 0xE0, 0x66, 0x03, 0x30, 0x19, 0x80, 0xCC, 0x0E,
  0xE0, 0x66, 0x03, 0x38, 0x18, 0xC1, 0xC7, 0xF6, 0x1F, 0x30, 0x03, 0x80,
  0x18, 0x00, 0xC0, 0x0E, 0x1F, 0xE0, 0xFC, 0x00, 0x0C, 0x00, 0xE0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0D, 0xF0, 0x7F, 0xC7, 0x87, 0x38, 0x19, 0x80,
  0xCC, 0x06, 0x60, 0x33, 0x03, 0xB8, 0x1D, 0x80, 0xCC, 0x06, 0x60, 0x33,
  0x01, 0x98, 0x0D, 0xC0, 0xE0, 0x00, 0xE0, 0x0F, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC1,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0xE0, 0x7F, 0x03,
  0xF0, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x73, 0x03, 0x9C, 0x1C, 0x60, 0xE1, 0x87, 0x06, 0x18, 0x1F, 0xC0, 0x7F,
  0x01, 0x8C, 0x0E, 0x38, 0x30, 0x60, 0xC1, 0xC3, 0x03, 0x0C, 0x0E, 0x30,
  0x18, 0xFE, 0x1F, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x80, 0x30,
  0x07, 0x00, 0x7F, 0x87, 0xF0, 0x37, 0x38, 0xFF, 0xF3, 0x18, 0xDC, 0x63,
  0x61, 0x0D, 0x8C, 0x36, 0x31, 0x98, 0xC6, 0x63, 0x19, 0x8C, 0x6C, 0x31,
  0xB0, 0x86, 0xC6, 0x1B, 0x18, 0xCC, 0x63, 0x00, 0x1B, 0xE0, 0xFF, 0x8F,
  0x0E, 0x70, 0x33, 0x01, 0x98, 0x0C, 0xC0, 0x66, 0x07, 0x70, 0x3B, 0x01,
  0x98, 0x0C, 0xC0, 0x66, 0x03, 0x30, 0x1B, 0x81, 0xC0, 0x0F, 0xC1, 0xFE,
  0x38, 0x77, 0x03, 0x60, 0x36, 0x03, 0x60, 0x3E, 0x03, 0xC0, 0x7C, 0x06,
  0xC0, 0x6C, 0x06, 0xE0, 0xC7, 0xF8, 0x3F, 0x00, 0x1B, 0xE0, 0xFF, 0x8F,
  0x0E, 0x70, 0x33, 0x01, 0x98, 0x0C, 0xC0, 0x66, 0x03, 0x70, 0x3B, 0x01,
  0x98, 0x0C, 0xC0, 0x67, 0x06, 0x3F, 0xF3, 0xBE, 0x1C, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x00, 0x0F, 0x98, 0xFF, 0xCE, 0x1C, 0xE0, 0x66,
  0x03, 0x30, 0x19, 0x80, 0xDC, 0x0E, 0xC0, 0x66, 0x03, 0x30, 0x19, 0x81,
  0xCE, 0x0E, 0x3F, 0xB0, 0xFB, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x03, 0x80, 0x33, 0xE1, 0xBF, 0x8E, 0x0C, 0x60, 0x73, 0x01, 0xB8, 0x1D,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x00, 0x0F, 0xE3, 0xFF, 0x30, 0x37, 0x03, 0x60, 0x07, 0x00,
  0x3E, 0x01, 0xFC, 0x01, 0xE0, 0x06, 0x00, 0x6C, 0x06, 0xC0, 0xEF, 0xFC,
  0x7F, 0x80, 0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x07, 0xFF, 0xFF, 0xFC,
  0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x00, 0x1C, 0x00, 0xFF, 0x03, 0xF8, 0x30, 0x19, 0x81,
  0xDC, 0x0C, 0xC0, 0x66, 0x03, 0x30, 0x19, 0x80, 0xCC, 0x06, 0xE0, 0x76,
  0x03, 0x30, 0x19, 0x80, 0xCE, 0x0C, 0x3F, 0xC0, 0xFC, 0x00, 0xC0, 0x3E,
  0x01, 0xB0, 0x1D, 0xC0, 0xC6, 0x0E, 0x30, 0x61, 0x87, 0x0C, 0x30, 0x63,
  0x81, 0x98, 0x0D, 0xC0, 0x6C, 0x03, 0x60, 0x1E, 0x00, 0xF0, 0x00, 0xC3,
  0x0F, 0x0C, 0x3C, 0x70, 0xF1, 0x46, 0xC5, 0x1B, 0x34, 0x6C, 0xD3, 0x32,
  0x4C, 0xD9, 0x33, 0x64, 0x8D, 0x16, 0x3C, 0x58, 0xF1, 0x43, 0x87, 0x0E,
  0x1C, 0x00, 0x1C, 0x06, 0x18, 0x18, 0x38, 0x70, 0x31, 0xC0, 0x77, 0x00,
  0x6C, 0x00, 0xF0, 0x00, 0xC0, 0x03, 0xC0, 0x0D, 0xC0, 0x39, 0x80, 0xE3,
  0x81, 0x83, 0x06, 0x07, 0x38, 0x06, 0x00, 0x30, 0x1B, 0x81, 0xDC, 0x0C,
  0xC0, 0x66, 0x03, 0x30, 0x19, 0x80, 0xCC, 0x0E, 0xE0, 0x66, 0x03, 0x38,
  0x39, 0xC3, 0xC7, 0xF6, 0x1F, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E,
  0x1F, 0xE1, 0xFC, 0x00, 0x1F, 0xFC, 0x7F, 0xE0, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0E,
  0x00, 0x70, 0x01, 0xFF, 0xCF, 0xFF, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x60,
  0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01,
  0xC1, 0xFC, 0x0F, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xF0, 0x07, 0x80,
  0x0E, 0x18, 0x30, 0x60, 0xC3, 0x86, 0x0C, 0x18, 0x30, 0x61, 0xC3, 0x86,
  0x0C, 0x18, 0x30, 0x61, 0xC3, 0x06, 0x0C, 0x18, 0x30, 0xE0, 0x0F, 0x00,
  0xFC, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x07, 0xF0, 0x1F, 0x81, 0x80, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x1F,
  0x00, 0xF0, 0x00, 0x3C, 0x1B, 0xF0, 0xF1, 0xC7, 0x87, 0xEC, 0x1E, 0x00,
};

const GFXglyph JetBrainsMono_LightItalic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 6, 20, 16, 5, -20 },
  { 16, 9, 8, 16, 5, -20 },
  { 25, 15, 20, 16, 1, -20 },
  { 63, 14, 27, 16, 1, -23 },
  { 111, 19, 20, 16, -1, -20 },
  { 159, 14, 20, 16, 1, -20 },
  { 194, 3, 8, 16, 8, -20 },
  { 197, 12, 26, 16, 4, -23 },
  { 236, 11, 26, 16, 1, -23 },
  { 272, 15, 13, 16, 1, -16 },
  { 297, 13, 12, 16, 2, -15 },
  { 317, 7, 8, 16, 3, -4 },
  { 324, 9, 2, 16, 4, -10 },
  { 327, 5, 4, 16, 5, -4 },
  { 330, 15, 25, 16, 1, -22 },
  { 377, 13, 20, 16, 2, -20 },
  { 410, 13, 20, 16, 1, -20 },
  { 443, 14, 20, 16, 1, -20 },
  { 478, 14, 20, 16, 1, -20 },
  { 513, 12, 20, 16, 2, -20 },
  { 543, 13, 20, 16, 2, -20 },
  { 576, 13, 20, 16, 1, -20 },
  { 609, 13, 20, 16, 3, -20 },
  { 642, 14, 20, 16, 1, -20 },
  { 677, 13, 20, 16, 3, -20 },
  { 710, 6, 15, 16, 5, -15 },
  { 722, 8, 19, 16, 3, -15 },
  { 741, 13, 14, 16, 2, -16 },
  { 764, 13, 8, 16, 2, -13 },
  { 777, 13, 14, 16, 1, -16 },
  { 800, 11, 20, 16, 4, -20 },
  { 828, 16, 25, 16, 0, -20 },
  { 878, 14, 20, 16, 0, -20 },
  { 913, 14, 20, 16, 1, -20 },
  { 948, 13, 20, 16, 2, -20 },
  { 981, 14, 20, 16, 1, -20 },
  { 1016, 14, 20, 16, 2, -20 },
  { 1051, 14, 20, 16, 2, -20 },
  { 1086, 13, 20, 16, 2, -20 },
  { 1119, 15, 20, 16, 1, -20 },
  { 1157, 13, 20, 16, 2, -20 },
  { 1190, 14, 20, 16, 1, -20 },
  { 1225, 16, 20, 16, 1, -20 },
  { 1265, 12, 20, 16, 2, -20 },
  { 1295, 15, 20, 16, 1, -20 },
  { 1333, 15, 20, 16, 1, -20 },
  { 1371, 13, 20, 16, 2, -20 },
  { 1404, 15, 20, 16, 1, -20 },
  { 1442, 13, 25, 16, 2, -20 },
  { 1483, 15, 20, 16, 1, -20 },
  { 1521, 14, 20, 16, 1, -20 },
  { 1556, 14, 20, 16, 3, -20 },
  { 1591, 14, 20, 16, 2, -20 },
  { 1626, 14, 20, 16, 3, -20 },
  { 1661, 15, 20, 16, 2, -20 },
  { 1699, 17, 20, 16, 0, -20 },
  { 1742, 14, 20, 16, 3, -20 },
  { 1777, 15, 20, 16, 1, -20 },
  { 1815, 10, 25, 16, 4, -22 },
  { 1847, 7, 25, 16, 5, -22 },
  { 1869, 11, 25, 16, 2, -22 },
  { 1904, 11, 11, 16, 3, -20 },
  { 1920, 13, 1, 16, 0, 1 },
  { 1922, 5, 4, 16, 7, -21 },
  { 1925, 13, 15, 16, 2, -15 },
  { 1950, 13, 20, 16, 1, -20 },
  { 1983, 13, 15, 16, 2, -15 },
  { 2008, 14, 20, 16, 2, -20 },
  { 2043, 12, 15, 16, 2, -15 },
  { 2066, 18, 25, 16, -1, -20 },
  { 2123, 13, 20, 16, 2, -15 },
  { 2156, 13, 20, 16, 1, -20 },
  { 2189, 13, 21, 16, 1, -21 },
  { 2224, 14, 26, 16, 0, -21 },
  { 2270, 14, 20, 16, 2, -20 },
  { 2305, 11, 20, 16, 3, -20 },
  { 2333, 14, 15, 16, 1, -15 },
  { 2360, 13, 15, 16, 1, -15 },
  { 2385, 12, 15, 16, 2, -15 },
  { 2408, 13, 20, 16, 1, -15 },
  { 2441, 13, 20, 16, 2, -15 },
  { 2474, 13, 15, 16, 2, -15 },
  { 2499, 12, 15, 16, 2, -15 },
  { 2522, 13, 19, 16, 2, -19 },
  { 2553, 13, 15, 16, 2, -15 },
  { 2578, 13, 15, 16, 3, -15 },
  { 2603, 14, 15, 16, 2, -15 },
  { 2630, 15, 15, 16, 0, -15 },
  { 2659, 13, 20, 16, 2, -15 },
  { 2692, 14, 15, 16, 1, -15 },
  { 2719, 13, 25, 16, 3, -22 },
  { 2760, 7, 25, 16, 5, -22 },
  { 2782, 13, 25, 16, 1, -22 },
  { 2823, 13, 5, 16, 2, -12 },
};

const GFXfont JetBrainsMono_LightItalic27pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_LightItalic27pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_LightItalic27pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _JETBRAINSMONO_LIGHTITALIC27PT7B_H_
