#ifndef _JETBRAINSMONO_LIGHTITALIC43PT7B_H_
#define _JETBRAINSMONO_LIGHTITALIC43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-LightItalic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_LightItalic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xC0, 0x30, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC1, 0xF0,
  0xFC, 0x3F, 0x07, 0x80, 0x3C, 0x3D, 0xE0, 0xF7, 0x83, 0xDE, 0x0F, 0x78,
  0x39, 0xE0, 0xE7, 0x07, 0x9C, 0x1E, 0x70, 0x7B, 0xC1, 0xCE, 0x07, 0x38,
  0x1C, 0xE0, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x06, 0x03,
  0x80, 0x07, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x03, 0x80, 0xE0, 0x01, 0xC0,
  0x70, 0x00, 0xE0, 0x38, 0x0F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xE0, 0x38, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x03, 0x00, 0x0E,
  0x03, 0x80, 0x07, 0x01, 0xC0, 0x03, 0x80, 0xC0, 0x03, 0x80, 0xE0, 0x01,
  0xC0, 0x70, 0x00, 0xE0, 0x30, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC0,
  0x38, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x07, 0x00,
  0x0E, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x03, 0x01, 0xC0, 0x03, 0x80, 0xE0,
  0x01, 0xC0, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xFC, 0x03, 0xF6, 0xF8, 0x0F, 0x9C, 0x78, 0x1E, 0x38, 0xF0,
  0x78, 0x60, 0xE0, 0xF0, 0xC1, 0xC1, 0xC1, 0x83, 0x83, 0x83, 0x00, 0x07,
  0x8E, 0x00, 0x0F, 0x1C, 0x00, 0x1F, 0x38, 0x00, 0x1F, 0x60, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1D,
  0xF0, 0x00, 0x31, 0xF0, 0x00, 0x61, 0xE0, 0x00, 0xC3, 0xC0, 0x01, 0x83,
  0x80, 0x07, 0x07, 0x0E, 0x0E, 0x1E, 0x3C, 0x18, 0x3C, 0x38, 0x30, 0x70,
  0x78, 0x61, 0xE0, 0xF8, 0xCF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x0F, 0xE0, 0x01, 0xC0, 0xFF, 0x80, 0x1C, 0x0F, 0x1E, 0x01, 0xC0, 0x60,
  0x70, 0x1C, 0x07, 0x03, 0x81, 0xC0, 0x38, 0x1C, 0x1C, 0x01, 0xC0, 0xE1,
  0xC0, 0x0E, 0x06, 0x0E, 0x00, 0x60, 0x70, 0xE0, 0x03, 0x03, 0x8E, 0x00,
  0x1C, 0x3C, 0xE0, 0x00, 0xFF, 0xCE, 0x00, 0x03, 0xFC, 0xE0, 0x00, 0x07,
  0x87, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x1F, 0x80, 0x00, 0x71, 0xFF, 0x00, 0x07, 0x1F, 0xF8,
  0x00, 0x39, 0xC1, 0xC0, 0x03, 0x8E, 0x06, 0x00, 0x38, 0x70, 0x70, 0x03,
  0x83, 0x03, 0x80, 0x38, 0x38, 0x1C, 0x03, 0x81, 0xC0, 0xE0, 0x1C, 0x0E,
  0x07, 0x01, 0xC0, 0x70, 0x70, 0x1C, 0x03, 0xEF, 0x81, 0xC0, 0x0F, 0xF8,
  0x1C, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xF0, 0x01, 0xF1, 0xF0, 0x03, 0xC0, 0x78, 0x03, 0x80, 0x78, 0x03, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x78, 0x01, 0x3C, 0x78, 0x1E, 0x38, 0x3C,
  0x1C, 0x38, 0x3C, 0x38, 0x78, 0x1E, 0x78, 0x78, 0x0E, 0xF0, 0x78, 0x0F,
  0xE0, 0x70, 0x07, 0xE0, 0x70, 0x07, 0xC0, 0x70, 0x03, 0xC0, 0x70, 0x07,
  0xC0, 0x70, 0x0F, 0xE0, 0x78, 0x3E, 0xE0, 0x7F, 0xFC, 0xF0, 0x3F, 0xF0,
  0x78, 0x1F, 0xE0, 0x78, 0x3C, 0xE7, 0x9E, 0x79, 0xE7, 0x9C, 0x71, 0xCF,
  0x38, 0xE0, 0x00, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x78, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x0C, 0x07, 0x01, 0x3E, 0x0C, 0x1F, 0x7F, 0x19, 0xFF, 0xFF, 0xB7,
  0xF8, 0x3F, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x73, 0x80, 0x01, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x1E, 0x0F, 0x00,
  0x78, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x01, 0x00, 0x20, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0x80, 0x00, 0x03, 0xE0, 0xFC, 0x1F, 0x03, 0xC0, 0xF8,
  0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x08, 0xFB, 0xFF, 0xFF, 0xFF,
  0x9F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xC7, 0xE0, 0xF0, 0x0F,
  0x87, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0x80, 0x07, 0x3C, 0x00, 0x39, 0xE0,
  0x03, 0xCE, 0x00, 0x1E, 0x70, 0x00, 0xF3, 0x80, 0x07, 0x1C, 0x00, 0x39,
  0xE1, 0xC1, 0xCF, 0x1F, 0x0E, 0x78, 0xF8, 0xF3, 0x87, 0xC7, 0x9C, 0x1C,
  0x38, 0xE0, 0x01, 0xCF, 0x00, 0x0E, 0x78, 0x00, 0x73, 0xC0, 0x07, 0x9C,
  0x00, 0x3C, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x3C, 0x00, 0xF1, 0xE0, 0x0F,
  0x07, 0x80, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0x70, 0x07, 0xC7, 0x00,
  0xF8, 0x70, 0x0E, 0x07, 0x00, 0xC0, 0xF0, 0x10, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0xF8, 0x7E, 0x07, 0x80, 0x78, 0x3C, 0x00, 0xF0, 0xE0, 0x03,
  0xC7, 0x80, 0x0F, 0x1C, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x1C, 0x00, 0x38, 0x70, 0x01, 0xE1, 0xC0, 0x07, 0x07, 0x80, 0x3C, 0x1F,
  0x01, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x0E, 0x0F, 0x00,
  0xE1, 0xE0, 0x1E, 0x3C, 0x01, 0xE3, 0x80, 0x1E, 0x78, 0x01, 0xC7, 0x00,
  0x1C, 0xF0, 0x01, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF,
  0xFE, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x39, 0xFF,
  0x01, 0xDF, 0xFC, 0x1F, 0xE7, 0xE0, 0xF8, 0x0F, 0x87, 0x80, 0x3C, 0x38,
  0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0xE0, 0x03, 0xC7, 0x80,
  0x1E, 0x3C, 0x01, 0xE0, 0xF0, 0x1E, 0x07, 0xFF, 0xF0, 0x1F, 0xFE, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x7B,
  0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xE0, 0x3E, 0x3E, 0x00, 0xF1,
  0xE0, 0x03, 0x9E, 0x00, 0x1C, 0xF0, 0x00, 0xF7, 0x00, 0x07, 0x38, 0x00,
  0x39, 0xC0, 0x01, 0xCE, 0x00, 0x1E, 0x70, 0x00, 0xE3, 0xC0, 0x0F, 0x1E,
  0x00, 0xF0, 0x78, 0x0F, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xE0, 0x00, 0xE7,
  0x00, 0x0F, 0x38, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xF8, 0x3E, 0x07, 0x80,
  0x78, 0x1E, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0E, 0x00, 0x38,
  0x38, 0x00, 0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x3C, 0x07, 0x81, 0xE0, 0x0F,
  0x0F, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x00, 0x1F, 0xBE,
  0x00, 0xF0, 0x3C, 0x07, 0x80, 0x78, 0x3C, 0x00, 0xE0, 0xE0, 0x03, 0xC7,
  0x80, 0x0F, 0x1C, 0x00, 0x3C, 0x70, 0x00, 0xF1, 0xC0, 0x03, 0x87, 0x00,
  0x1E, 0x1E, 0x00, 0x70, 0x7C, 0x07, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F,
  0x8F, 0xC1, 0xE0, 0x1F, 0x1E, 0x00, 0x78, 0xE0, 0x01, 0xCF, 0x00, 0x0E,
  0x78, 0x00, 0x73, 0x80, 0x03, 0x9C, 0x00, 0x1C, 0xE0, 0x00, 0xEF, 0x00,
  0x0F, 0x38, 0x00, 0x71, 0xE0, 0x07, 0x8F, 0x00, 0x78, 0x7E, 0x0F, 0xC1,
  0xFF, 0xDC, 0x07, 0xFD, 0xE0, 0x0F, 0x9E, 0x00, 0x01, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0x83, 0xF1, 0xFC, 0x7F, 0x1F, 0x83, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC1, 0xF8, 0xFE, 0x3F, 0x8F, 0xC1, 0xF0, 0x01, 0xF0, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x78, 0x03, 0xC0,
  0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x08, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xE0, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x1F, 0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x01, 0xF0, 0x07, 0xF0, 0x1F, 0xF0,
  0x0F, 0xE0, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xE0, 0x7C, 0x01, 0xE0, 0x07,
  0x80, 0xF0, 0x00, 0xE0, 0x78, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x0F, 0x00,
  0x03, 0xC3, 0x80, 0x00, 0xF0, 0xE0, 0x00, 0x38, 0x38, 0x07, 0xCE, 0x1C,
  0x07, 0xFB, 0x87, 0x03, 0xFF, 0xE1, 0xC0, 0xE0, 0x78, 0x70, 0x78, 0x1E,
  0x1C, 0x1C, 0x07, 0x07, 0x07, 0x01, 0xC3, 0xC1, 0xC0, 0x70, 0xE0, 0xF0,
  0x1C, 0x38, 0x38, 0x07, 0x0E, 0x0E, 0x01, 0xC3, 0x83, 0x80, 0xF0, 0xE0,
  0xE0, 0x38, 0x78, 0x38, 0x0E, 0x1C, 0x0E, 0x07, 0x87, 0x03, 0xC3, 0xE1,
  0xC0, 0xFF, 0xB8, 0x70, 0x1F, 0xCE, 0x1C, 0x00, 0xC0, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x7B, 0x80, 0x01,
  0xCE, 0x00, 0x0F, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80, 0x07, 0x0E,
  0x00, 0x1C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0x81, 0xC0, 0x1E, 0x07, 0x00,
  0x70, 0x1C, 0x01, 0xC0, 0x70, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0,
  0x1C, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xF0, 0x07, 0x83, 0x80, 0x0E,
  0x1E, 0x00, 0x38, 0x70, 0x00, 0xE3, 0xC0, 0x03, 0x8F, 0x00, 0x0E, 0x38,
  0x00, 0x39, 0xE0, 0x00, 0xEF, 0x00, 0x03, 0xC0, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xC0, 0x1E, 0x07, 0x00, 0x3C, 0x3C, 0x00,
  0xF0, 0xF0, 0x03, 0xC3, 0x80, 0x0F, 0x0E, 0x00, 0x3C, 0x38, 0x00, 0xE0,
  0xE0, 0x07, 0x87, 0x80, 0x3C, 0x1E, 0x01, 0xE0, 0x7F, 0xFF, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0xF0, 0x1C, 0x07, 0xE0, 0xF0, 0x07, 0xC3, 0xC0, 0x0F,
  0x0E, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x0E,
  0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x07, 0x87, 0x00, 0x3E, 0x1C, 0x03,
  0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xC7, 0xE0, 0xF8, 0x0F, 0x87,
  0x80, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x3C, 0xF0, 0x01, 0xC7, 0x80, 0x0E, 0x3C, 0x00, 0xF0, 0xE0, 0x0F, 0x07,
  0x80, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xC0, 0x3E, 0x0F, 0x00, 0x78,
  0x3C, 0x00, 0xE0, 0xF0, 0x03, 0xC3, 0x80, 0x0F, 0x0E, 0x00, 0x38, 0x38,
  0x00, 0xE0, 0xE0, 0x03, 0x87, 0x80, 0x0E, 0x1E, 0x00, 0x78, 0x70, 0x01,
  0xE1, 0xC0, 0x07, 0x87, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0xF0, 0x01, 0xC3,
  0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x38, 0x00, 0xF0, 0xE0, 0x03, 0x83, 0x80,
  0x0E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x0F, 0x07, 0x00, 0x78,
  0x1C, 0x07, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xC7, 0xE0, 0xF8, 0x0F,
  0x87, 0x80, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x07, 0x1C, 0x00, 0x38, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x3F, 0xF3, 0xC1, 0xFF, 0x9E, 0x1F,
  0xF8, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x07, 0x9E,
  0x00, 0x3C, 0xF0, 0x01, 0xC7, 0x80, 0x0E, 0x3C, 0x00, 0xF0, 0xE0, 0x0F,
  0x07, 0x80, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x07,
  0x80, 0x1E, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x70,
  0x03, 0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x0F, 0x07, 0x00, 0x1C, 0x0E, 0x00,
  0x38, 0x1C, 0x00, 0x70, 0x38, 0x00, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x07,
  0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1C, 0x00, 0x70,
  0x78, 0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0x80, 0x0E, 0x07,
  0x00, 0x1C, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0xF0,
  0x03, 0xC1, 0xC0, 0x07, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x1C, 0x0E, 0x00,
  0x38, 0x3C, 0x00, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF,
  0xFE, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0x83,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x3C, 0x38, 0x00, 0x70,
  0x70, 0x01, 0xE0, 0xE0, 0x03, 0xC1, 0xE0, 0x0F, 0x03, 0xE0, 0x3C, 0x03,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x0F,
  0x83, 0x80, 0x0F, 0x01, 0xC0, 0x07, 0x80, 0xE0, 0x07, 0x80, 0xF0, 0x07,
  0x80, 0x78, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x1C, 0x03, 0xC0, 0x0E, 0x01,
  0xE0, 0x07, 0x01, 0xE0, 0x03, 0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xE0,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1C,
  0x1E, 0x00, 0x1E, 0x07, 0x00, 0x0F, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x03,
  0x80, 0x70, 0x01, 0xC0, 0x3C, 0x00, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x00,
  0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x3C,
  0x07, 0x00, 0x1E, 0x03, 0x80, 0x07, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x1F, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF0,
  0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3F, 0x01, 0xD8, 0x7E, 0x03, 0xF0,
  0xDC, 0x0E, 0xE1, 0xB8, 0x1D, 0xC7, 0x30, 0x73, 0x0E, 0x60, 0xEE, 0x1C,
  0xE3, 0x9C, 0x39, 0xC7, 0x38, 0x73, 0x8C, 0x70, 0xE7, 0x39, 0xE3, 0xC6,
  0x63, 0x87, 0x8D, 0xC7, 0x0E, 0x1F, 0x0E, 0x1C, 0x3E, 0x1C, 0x38, 0x78,
  0x78, 0x70, 0x00, 0xF0, 0xE0, 0x01, 0xC3, 0xC0, 0x03, 0x87, 0x80, 0x07,
  0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x3C, 0x38, 0x00, 0x78, 0x70, 0x00, 0xF1,
  0xE0, 0x01, 0xC3, 0xC0, 0x03, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x1E, 0x1C,
  0x00, 0x3C, 0x38, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x1E, 0x0F, 0x80, 0x3C,
  0x1F, 0x00, 0x70, 0x3F, 0x00, 0xE0, 0xEE, 0x01, 0xC1, 0xDC, 0x03, 0x83,
  0xB8, 0x0F, 0x07, 0x70, 0x1E, 0x0E, 0x70, 0x38, 0x1C, 0xE0, 0x70, 0x79,
  0xC0, 0xE0, 0xF3, 0x81, 0xC1, 0xC7, 0x07, 0x83, 0x87, 0x0F, 0x07, 0x0E,
  0x1C, 0x0E, 0x1C, 0x38, 0x3C, 0x38, 0x70, 0x78, 0x70, 0xE0, 0xE0, 0x71,
  0xC1, 0xC0, 0xE7, 0x83, 0x81, 0xCF, 0x07, 0x03, 0x9C, 0x0E, 0x07, 0xB8,
  0x3C, 0x07, 0x70, 0x78, 0x0E, 0xE0, 0xE0, 0x1D, 0xC1, 0xC0, 0x3B, 0x83,
  0x80, 0x3E, 0x07, 0x00, 0x7C, 0x1E, 0x00, 0xF8, 0x3C, 0x01, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xC7, 0xE0, 0xF8,
  0x0F, 0x07, 0x80, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1C, 0x00, 0x78,
  0xE0, 0x03, 0xCF, 0x00, 0x1C, 0x78, 0x00, 0xE3, 0xC0, 0x07, 0x1C, 0x00,
  0x78, 0xE0, 0x03, 0xC7, 0x00, 0x1E, 0x38, 0x00, 0xE3, 0xC0, 0x07, 0x1E,
  0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x1E, 0x38, 0x00, 0xF1, 0xC0, 0x07,
  0x1E, 0x00, 0x38, 0xF0, 0x01, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xE0, 0xE0,
  0x0F, 0x07, 0x80, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0x00, 0x3E,
  0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x0E, 0x0E, 0x00, 0x0E,
  0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x1E, 0x0E, 0x00, 0x1E, 0x1E, 0x00, 0x1C,
  0x1E, 0x00, 0x3C, 0x1C, 0x00, 0x78, 0x1C, 0x03, 0xF0, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xC7, 0xE0, 0xF8, 0x0F, 0x07, 0x00,
  0x3C, 0x78, 0x01, 0xE3, 0x80, 0x0F, 0x1C, 0x00, 0x79, 0xE0, 0x03, 0xCF,
  0x00, 0x1E, 0x78, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x01,
  0xCF, 0x00, 0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0x1C, 0x00, 0x38, 0xE0,
  0x01, 0xC7, 0x00, 0x0E, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x3C,
  0xE0, 0x01, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x0F, 0x07, 0x80,
  0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x38, 0x03, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x03, 0xC3,
  0xC0, 0x07, 0x87, 0x00, 0x0F, 0x0E, 0x00, 0x1E, 0x1C, 0x00, 0x38, 0x38,
  0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x07, 0x83, 0x80, 0x1E, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x78, 0x3C, 0x00, 0xF0, 0x38,
  0x01, 0xE0, 0x70, 0x03, 0x80, 0xF0, 0x07, 0x01, 0xE0, 0x0E, 0x01, 0xC0,
  0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x07, 0x01, 0xC0, 0x0F, 0x03,
  0x80, 0x1E, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0x8F, 0xC0,
  0x78, 0x03, 0xC0, 0xE0, 0x07, 0x83, 0xC0, 0x07, 0x07, 0x80, 0x0E, 0x0E,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x70, 0x00, 0xF1,
  0xE0, 0x01, 0xE1, 0xC0, 0x03, 0x83, 0xC0, 0x0F, 0x07, 0xC0, 0x7C, 0x07,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x38, 0x00, 0xF0,
  0xE0, 0x03, 0x83, 0x80, 0x0E, 0x1E, 0x00, 0x38, 0x78, 0x01, 0xE1, 0xE0,
  0x07, 0x87, 0x00, 0x1E, 0x1C, 0x00, 0x70, 0x70, 0x01, 0xC3, 0xC0, 0x07,
  0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xE0, 0x03, 0xC3, 0x80, 0x0E, 0x0E,
  0x00, 0x38, 0x78, 0x00, 0xE1, 0xE0, 0x03, 0x87, 0x80, 0x1E, 0x1C, 0x00,
  0x78, 0x70, 0x01, 0xE1, 0xC0, 0x07, 0x07, 0x00, 0x1C, 0x3C, 0x00, 0x70,
  0xF0, 0x03, 0xC3, 0xC0, 0x0E, 0x07, 0x00, 0x78, 0x1E, 0x03, 0xC0, 0x7F,
  0xFE, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x3D, 0xC0,
  0x01, 0xE7, 0x00, 0x07, 0x1C, 0x00, 0x3C, 0x70, 0x00, 0xE1, 0xC0, 0x03,
  0x87, 0x80, 0x1E, 0x1E, 0x00, 0x70, 0x78, 0x03, 0xC1, 0xE0, 0x0E, 0x03,
  0x80, 0x78, 0x0E, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x03, 0x80,
  0xE0, 0x0E, 0x07, 0x80, 0x3C, 0x1C, 0x00, 0xF0, 0x70, 0x03, 0xC3, 0xC0,
  0x07, 0x0E, 0x00, 0x1C, 0x78, 0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00, 0x07,
  0x38, 0x00, 0x1C, 0xE0, 0x00, 0x77, 0x80, 0x01, 0xDC, 0x00, 0x07, 0x70,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x70, 0x1E,
  0x07, 0xB8, 0x0F, 0x03, 0x9C, 0x0F, 0x81, 0xCE, 0x06, 0xC1, 0xE7, 0x03,
  0x60, 0xE3, 0x83, 0xB0, 0x71, 0xC1, 0xB8, 0x38, 0xE0, 0xDC, 0x38, 0x70,
  0x6E, 0x1C, 0x38, 0x77, 0x0E, 0x1C, 0x33, 0x87, 0x0E, 0x19, 0x87, 0x07,
  0x1C, 0xC3, 0x83, 0x8C, 0x61, 0xC1, 0xC6, 0x30, 0xE0, 0xE3, 0x18, 0xE0,
  0x73, 0x8C, 0x70, 0x39, 0x86, 0x38, 0x1C, 0xC3, 0x38, 0x0E, 0xE1, 0x9C,
  0x0E, 0x60, 0xCE, 0x07, 0x30, 0x67, 0x03, 0x98, 0x37, 0x01, 0xDC, 0x1B,
  0x80, 0xEC, 0x0D, 0xC0, 0x76, 0x06, 0xC0, 0x3F, 0x03, 0xE0, 0x1F, 0x01,
  0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x78, 0x03, 0xE0, 0x3C, 0x00, 0x07,
  0xC0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x1C, 0x00, 0x70, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x1E, 0x00, 0x38, 0x07, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xC1,
  0xE0, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x38, 0x00, 0x03, 0x9E, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xCE, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x78, 0x70, 0x00, 0x3C,
  0x1E, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x00, 0xE0, 0x03, 0xC0, 0x3C, 0x01,
  0xE0, 0x07, 0x00, 0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x0E,
  0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xE7, 0x00, 0x07,
  0x1C, 0x00, 0x3C, 0x78, 0x01, 0xE0, 0xE0, 0x07, 0x03, 0x80, 0x3C, 0x0F,
  0x00, 0xE0, 0x1C, 0x07, 0x00, 0x70, 0x3C, 0x01, 0xE0, 0xE0, 0x03, 0x87,
  0x80, 0x0E, 0x3C, 0x00, 0x3C, 0xE0, 0x00, 0x77, 0x80, 0x01, 0xDC, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0x78, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0xFF, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80,
  0x3C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01,
  0xC0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xF0,
  0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x03,
  0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x03, 0xFF, 0x81, 0xFF, 0x80,
  0xFF, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x77,
  0x00, 0x1E, 0xE0, 0x03, 0x9C, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x07, 0x07,
  0x01, 0xE0, 0x70, 0x38, 0x0E, 0x0E, 0x01, 0xC3, 0xC0, 0x38, 0x70, 0x03,
  0x9E, 0x00, 0x77, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xE1, 0xE1, 0xE1, 0xC3, 0xC3, 0xC0, 0x00, 0xFC, 0x78, 0x1F, 0xF3,
  0x83, 0xFF, 0xDC, 0x1E, 0x06, 0xE1, 0xE0, 0x1F, 0x1E, 0x00, 0x78, 0xF0,
  0x03, 0xC7, 0x00, 0x1C, 0x38, 0x00, 0xE3, 0xC0, 0x07, 0x1E, 0x00, 0x78,
  0xF0, 0x03, 0xC7, 0x00, 0x1E, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x1E, 0x00,
  0x38, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x0F, 0x87,
  0x80, 0xF8, 0x3F, 0xFD, 0xC0, 0xFF, 0xCE, 0x03, 0xFC, 0xF0, 0x07, 0x80,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xC3, 0xF0, 0x0E, 0x7F, 0xE0, 0x77, 0xFF,
  0x03, 0xF0, 0x7C, 0x3E, 0x01, 0xE1, 0xE0, 0x07, 0x0F, 0x00, 0x3C, 0x70,
  0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x71, 0xE0, 0x03, 0x8F, 0x00, 0x3C,
  0x78, 0x01, 0xE3, 0x80, 0x0F, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x8F, 0x00,
  0x1C, 0x78, 0x01, 0xE3, 0xC0, 0x0E, 0x1E, 0x00, 0xF0, 0xF8, 0x0F, 0x07,
  0x7F, 0xF8, 0x3B, 0xFF, 0x83, 0xCF, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x3F,
  0xF8, 0x07, 0xFF, 0xC0, 0xF8, 0x3E, 0x1E, 0x01, 0xE3, 0xC0, 0x0F, 0x3C,
  0x00, 0xF3, 0x80, 0x0F, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x01, 0xCF, 0x00, 0x1C, 0xF0, 0x03, 0xC7, 0x00, 0x78, 0x78, 0x0F,
  0x87, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x3F, 0x1E, 0x03, 0xFE, 0x70, 0x3F, 0xFD, 0xC0,
  0xF0, 0x37, 0x07, 0x80, 0x7C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0x80,
  0x0E, 0x0E, 0x00, 0x38, 0x78, 0x00, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1E,
  0x1C, 0x00, 0x78, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x0F, 0x00, 0x1C, 0x3C,
  0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x7C, 0x1E, 0x03,
  0xE0, 0x7F, 0xFB, 0x80, 0xFF, 0xCE, 0x01, 0xFE, 0x78, 0x00, 0x00, 0xFE,
  0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xF0, 0x3E, 0x1E, 0x01, 0xE3, 0xC0,
  0x0E, 0x38, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x00, 0xE7, 0x80, 0x0E, 0x7F,
  0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0x00, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x03, 0xC7, 0x00, 0x38,
  0x78, 0x0F, 0x87, 0xF7, 0xF0, 0x3F, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x78, 0x1F,
  0xF3, 0x83, 0xFF, 0xDC, 0x1E, 0x06, 0xE1, 0xE0, 0x1F, 0x1E, 0x00, 0x78,
  0xF0, 0x03, 0xC7, 0x00, 0x1C, 0x38, 0x00, 0xE3, 0xC0, 0x07, 0x1E, 0x00,
  0x38, 0xF0, 0x03, 0xC7, 0x00, 0x1E, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x0E,
  0x00, 0x38, 0x70, 0x03, 0xC3, 0xC0, 0x3E, 0x1E, 0x03, 0xF0, 0x7F, 0xF7,
  0x83, 0xFF, 0xB8, 0x0F, 0xF1, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xC3, 0xF0, 0x0E, 0x7F, 0xE0, 0x77, 0xFF, 0x03, 0xF0,
  0x7C, 0x3E, 0x01, 0xE1, 0xE0, 0x07, 0x0F, 0x00, 0x3C, 0x70, 0x01, 0xC3,
  0x80, 0x0E, 0x1C, 0x00, 0x71, 0xE0, 0x03, 0x8F, 0x00, 0x3C, 0x78, 0x01,
  0xE3, 0x80, 0x0F, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x8F, 0x00, 0x1C, 0x78,
  0x01, 0xE3, 0xC0, 0x0F, 0x1C, 0x00, 0x78, 0xE0, 0x03, 0x87, 0x00, 0x1C,
  0x38, 0x00, 0xE3, 0xC0, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0xFF, 0xF8, 0x04, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x0F,
  0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x0F, 0x0E, 0x00, 0x3C,
  0x1C, 0x00, 0xF0, 0x38, 0x03, 0xC0, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x03,
  0xC0, 0x78, 0x07, 0x01, 0xE0, 0x0E, 0x07, 0x80, 0x1C, 0x1E, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0x83, 0xC0, 0x07, 0x03,
  0xC0, 0x0E, 0x07, 0x80, 0x1C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x0F,
  0x01, 0xE0, 0x1E, 0x03, 0x80, 0x1E, 0x07, 0x00, 0x3C, 0x0E, 0x00, 0x3C,
  0x3C, 0x00, 0x78, 0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0,
  0x1F, 0xFC, 0x0E, 0x78, 0x78, 0x1D, 0xF9, 0xF8, 0x7F, 0xF7, 0xF8, 0xF0,
  0xF0, 0xF1, 0xE1, 0xE0, 0xE3, 0x83, 0x81, 0xC7, 0x07, 0x07, 0x8E, 0x0E,
  0x0F, 0x1C, 0x1C, 0x1C, 0x78, 0x38, 0x38, 0xE0, 0x70, 0x71, 0xC0, 0xC0,
  0xE3, 0x83, 0x81, 0xC7, 0x07, 0x07, 0x8E, 0x0E, 0x0E, 0x3C, 0x1C, 0x1C,
  0x70, 0x38, 0x38, 0xE0, 0x60, 0x71, 0xC1, 0xC0, 0xE3, 0x83, 0x83, 0xC7,
  0x07, 0x07, 0x9E, 0x0E, 0x0E, 0x3C, 0x1C, 0x1C, 0x70, 0x38, 0x38, 0x0E,
  0x1F, 0x80, 0x73, 0xFF, 0x03, 0xBF, 0xF8, 0x1F, 0x83, 0xE1, 0xF0, 0x0F,
  0x0F, 0x00, 0x38, 0x78, 0x01, 0xE3, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0xE0,
  0x03, 0x8F, 0x00, 0x1C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1C, 0x00, 0x78,
  0xE0, 0x03, 0x87, 0x00, 0x1C, 0x78, 0x00, 0xE3, 0xC0, 0x0F, 0x1E, 0x00,
  0x78, 0xE0, 0x03, 0xC7, 0x00, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x1E,
  0x00, 0x78, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xF8, 0x3E,
  0x1E, 0x01, 0xE3, 0xC0, 0x0E, 0x3C, 0x00, 0xE3, 0x80, 0x0F, 0x38, 0x00,
  0xE7, 0x80, 0x0E, 0x78, 0x00, 0xE7, 0x00, 0x1E, 0x70, 0x01, 0xE7, 0x00,
  0x1E, 0x70, 0x01, 0xCF, 0x00, 0x1C, 0xF0, 0x01, 0xCF, 0x00, 0x3C, 0xF0,
  0x03, 0x87, 0x00, 0x78, 0x78, 0x0F, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x00,
  0xFF, 0x80, 0x07, 0x0F, 0xC0, 0x1C, 0xFF, 0xC0, 0x77, 0xFF, 0x03, 0xF8,
  0x3E, 0x0F, 0x80, 0x78, 0x3C, 0x00, 0xE0, 0xF0, 0x03, 0xC3, 0x80, 0x0E,
  0x0E, 0x00, 0x38, 0x38, 0x00, 0xE1, 0xE0, 0x03, 0x87, 0x80, 0x1E, 0x1E,
  0x00, 0x78, 0x70, 0x01, 0xE1, 0xC0, 0x07, 0x07, 0x00, 0x1C, 0x3C, 0x00,
  0x70, 0xF0, 0x03, 0xC3, 0xC0, 0x0E, 0x0F, 0x80, 0x78, 0x3E, 0x03, 0xC0,
  0xEF, 0xFF, 0x07, 0xBF, 0xF8, 0x1E, 0x7F, 0x80, 0x78, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xFC, 0x70, 0x3F, 0xE7, 0x0F,
  0xFF, 0x70, 0xF0, 0x37, 0x1E, 0x01, 0xF3, 0xC0, 0x0F, 0x3C, 0x00, 0xF3,
  0x80, 0x0E, 0x38, 0x00, 0xE7, 0x80, 0x0E, 0x78, 0x01, 0xE7, 0x00, 0x1E,
  0x70, 0x01, 0xE7, 0x00, 0x1C, 0x70, 0x01, 0xCF, 0x00, 0x1C, 0xF0, 0x03,
  0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x78, 0x78, 0x0F, 0x87, 0xFF,
  0xB8, 0x3F, 0xF3, 0x81, 0xFE, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x0E, 0x3F, 0x80, 0x73, 0xFE, 0x07, 0xBF, 0xF8, 0x3F, 0x03,
  0xE1, 0xF0, 0x0F, 0x0F, 0x00, 0x38, 0x78, 0x01, 0xC3, 0x80, 0x0E, 0x3C,
  0x00, 0x71, 0xE0, 0x03, 0x8F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xFC, 0x0F, 0xFF,
  0xE1, 0xF0, 0x1E, 0x1E, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x03, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0xE0, 0x01, 0xCF, 0x00, 0x3C, 0xF0, 0x07, 0x8F, 0xFF, 0xF0,
  0x7F, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x1C, 0x00, 0x78, 0xE0,
  0x03, 0x87, 0x00, 0x1C, 0x78, 0x00, 0xE3, 0xC0, 0x07, 0x1E, 0x00, 0x78,
  0xE0, 0x03, 0xC7, 0x00, 0x1C, 0x38, 0x00, 0xE3, 0xC0, 0x07, 0x1E, 0x00,
  0x38, 0xF0, 0x03, 0xC7, 0x00, 0x1E, 0x38, 0x00, 0xF1, 0xC0, 0x07, 0x0E,
  0x00, 0x38, 0xF0, 0x01, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xE0, 0xE0, 0x0F,
  0x07, 0x80, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0xE0,
  0x00, 0xFE, 0x00, 0x0E, 0xE0, 0x01, 0xEF, 0x00, 0x1C, 0xF0, 0x03, 0xCF,
  0x00, 0x38, 0x70, 0x07, 0x87, 0x00, 0x70, 0x70, 0x0F, 0x07, 0x80, 0xE0,
  0x78, 0x1E, 0x03, 0x81, 0xC0, 0x38, 0x1C, 0x03, 0x83, 0x80, 0x38, 0x38,
  0x03, 0xC7, 0x00, 0x3C, 0x70, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x01, 0xDE,
  0x00, 0x1D, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0xE0,
  0x70, 0x1F, 0x81, 0xC0, 0x7C, 0x0F, 0x03, 0xB0, 0x3C, 0x0E, 0xC0, 0xF0,
  0x3B, 0x07, 0xC1, 0xCC, 0x1B, 0x07, 0x30, 0x6C, 0x1C, 0xC3, 0xB0, 0xE3,
  0x0C, 0xC3, 0x8C, 0x33, 0x0E, 0x31, 0xCC, 0x30, 0xC6, 0x31, 0xC3, 0x18,
  0xC7, 0x0C, 0xE3, 0x18, 0x33, 0x0E, 0xE0, 0xCC, 0x3B, 0x83, 0x70, 0xEC,
  0x0D, 0x83, 0xF0, 0x36, 0x0F, 0xC0, 0xF8, 0x3E, 0x03, 0xC0, 0xF8, 0x0F,
  0x03, 0xE0, 0x3C, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x07, 0x00, 0x1E, 0x07,
  0x80, 0x3C, 0x03, 0x80, 0x78, 0x03, 0xC0, 0xF0, 0x01, 0xC1, 0xE0, 0x01,
  0xE1, 0xE0, 0x00, 0xE3, 0xC0, 0x00, 0xF7, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xEE, 0x00, 0x01, 0xEF, 0x00, 0x03, 0xC7, 0x00, 0x07, 0x87, 0x80, 0x0F,
  0x03, 0x80, 0x1E, 0x03, 0xC0, 0x1E, 0x01, 0xC0, 0x3C, 0x01, 0xE0, 0x78,
  0x00, 0xF0, 0xF0, 0x00, 0xF0, 0x1C, 0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00,
  0x73, 0xC0, 0x07, 0x3C, 0x00, 0xF3, 0xC0, 0x0F, 0x38, 0x00, 0xF3, 0x80,
  0x0E, 0x38, 0x00, 0xE7, 0x80, 0x0E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x70,
  0x01, 0xE7, 0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x3C, 0x70, 0x03, 0xC7,
  0x80, 0x7C, 0x7C, 0x0F, 0xC7, 0xFF, 0xB8, 0x3F, 0xF3, 0x80, 0xFE, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x3E, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFC,
  0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xFF, 0xE3, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0x81, 0xC0,
  0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x0E, 0x07, 0x07, 0x83, 0xC1, 0xE0, 0xE0,
  0x70, 0x38, 0x1C, 0x1E, 0x0F, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0xF0, 0x78,
  0x3C, 0x1C, 0x0E, 0x07, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x1C,
  0x1E, 0x0F, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x39, 0xFF, 0x03, 0xDF, 0x78, 0x1C, 0xE1, 0xE0, 0xEF,
  0x07, 0x87, 0x70, 0x1F, 0xF3, 0x80, 0xFF, 0x9C, 0x01, 0xF0,
};

const GFXglyph JetBrainsMono_LightItalic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 10, 31, 26, 8, -31 },
  { 40, 14, 13, 26, 8, -31 },
  { 63, 25, 31, 26, 1, -31 },
  { 160, 23, 43, 26, 2, -37 },
  { 284, 29, 32, 26, -1, -32 },
  { 400, 24, 32, 26, 1, -32 },
  { 496, 6, 13, 26, 12, -31 },
  { 506, 18, 41, 26, 7, -36 },
  { 599, 18, 41, 26, 2, -36 },
  { 692, 23, 22, 26, 2, -26 },
  { 756, 21, 20, 26, 3, -24 },
  { 809, 11, 14, 26, 4, -7 },
  { 829, 14, 3, 26, 6, -16 },
  { 835, 7, 7, 26, 8, -7 },
  { 842, 25, 41, 26, 1, -36 },
  { 971, 21, 32, 26, 3, -32 },
  { 1055, 20, 31, 26, 2, -31 },
  { 1133, 22, 32, 26, 2, -32 },
  { 1221, 22, 31, 26, 2, -31 },
  { 1307, 20, 31, 26, 3, -31 },
  { 1385, 21, 31, 26, 3, -31 },
  { 1467, 21, 31, 26, 2, -31 },
  { 1549, 21, 31, 26, 5, -31 },
  { 1631, 22, 32, 26, 2, -32 },
  { 1719, 21, 32, 26, 4, -32 },
  { 1803, 10, 24, 26, 8, -24 },
  { 1833, 13, 31, 26, 5, -24 },
  { 1884, 20, 22, 26, 4, -25 },
  { 1939, 20, 13, 26, 3, -21 },
  { 1972, 21, 22, 26, 2, -25 },
  { 2030, 17, 31, 26, 6, -31 },
  { 2096, 26, 40, 26, 0, -32 },
  { 2226, 22, 31, 26, 0, -31 },
  { 2312, 22, 31, 26, 2, -31 },
  { 2398, 21, 32, 26, 3, -32 },
  { 2482, 22, 31, 26, 2, -31 },
  { 2568, 22, 31, 26, 3, -31 },
  { 2654, 24, 31, 26, 2, -31 },
  { 2747, 21, 32, 26, 3, -32 },
  { 2831, 23, 31, 26, 2, -31 },
  { 2921, 21, 31, 26, 3, -31 },
  { 3003, 23, 31, 26, 1, -31 },
  { 3093, 25, 31, 26, 2, -31 },
  { 3190, 19, 31, 26, 3, -31 },
  { 3264, 23, 31, 26, 2, -31 },
  { 3354, 23, 31, 26, 2, -31 },
  { 3444, 21, 32, 26, 3, -32 },
  { 3528, 24, 31, 26, 2, -31 },
  { 3621, 21, 40, 26, 3, -32 },
  { 3726, 23, 31, 26, 2, -31 },
  { 3816, 23, 32, 26, 2, -32 },
  { 3908, 21, 31, 26, 5, -31 },
  { 3990, 22, 31, 26, 3, -31 },
  { 4076, 22, 31, 26, 5, -31 },
  { 4162, 25, 31, 26, 3, -31 },
  { 4259, 26, 31, 26, 0, -31 },
  { 4360, 22, 31, 26, 5, -31 },
  { 4446, 23, 31, 26, 2, -31 },
  { 4536, 17, 41, 26, 6, -36 },
  { 4624, 13, 41, 26, 7, -36 },
  { 4691, 17, 41, 26, 4, -36 },
  { 4779, 19, 16, 26, 4, -31 },
  { 4817, 21, 3, 26, 0, 1 },
  { 4825, 7, 6, 26, 12, -34 },
  { 4831, 21, 24, 26, 3, -24 },
  { 4894, 21, 31, 26, 2, -31 },
  { 4976, 20, 24, 26, 3, -24 },
  { 5036, 22, 31, 26, 3, -31 },
  { 5122, 20, 24, 26, 3, -24 },
  { 5182, 29, 39, 26, -2, -31 },
  { 5324, 21, 32, 26, 3, -24 },
  { 5408, 21, 31, 26, 2, -31 },
  { 5490, 20, 33, 26, 2, -33 },
  { 5573, 22, 41, 26, 1, -33 },
  { 5686, 23, 31, 26, 2, -31 },
  { 5776, 18, 31, 26, 4, -31 },
  { 5846, 23, 24, 26, 1, -24 },
  { 5915, 21, 24, 26, 2, -24 },
  { 5978, 20, 24, 26, 3, -24 },
  { 6038, 22, 32, 26, 1, -24 },
  { 6126, 20, 32, 26, 3, -24 },
  { 6206, 21, 24, 26, 3, -24 },
  { 6269, 20, 24, 26, 3, -24 },
  { 6329, 20, 30, 26, 4, -30 },
  { 6404, 21, 24, 26, 3, -24 },
  { 6467, 20, 24, 26, 5, -24 },
  { 6527, 22, 24, 26, 4, -24 },
  { 6593, 24, 24, 26, 1, -24 },
  { 6665, 20, 32, 26, 3, -24 },
  { 6745, 21, 24, 26, 2, -24 },
  { 6808, 22, 41, 26, 4, -36 },
  { 6921, 9, 41, 26, 9, -36 },
  { 6968, 22, 41, 26, 1, -36 },
  { 7081, 21, 8, 26, 3, -19 },
};

const GFXfont JetBrainsMono_LightItalic43pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_LightItalic43pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_LightItalic43pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _JETBRAINSMONO_LIGHTITALIC43PT7B_H_
