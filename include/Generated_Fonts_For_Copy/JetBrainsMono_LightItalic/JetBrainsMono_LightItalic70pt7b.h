#ifndef _JETBRAINSMONO_LIGHTITALIC70PT7B_H_
#define _JETBRAINSMONO_LIGHTITALIC70PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-LightItalic.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_LightItalic70pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F,
  0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x3F, 0x00, 0x1F, 0x80, 0x7E, 0x3F, 0x00,
  0xFC, 0xFE, 0x01, 0xF9, 0xF8, 0x07, 0xF3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F,
  0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0xFC, 0x01, 0xF1,
  0xF8, 0x03, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F,
  0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xE0,
  0x07, 0xC7, 0xC0, 0x0F, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x01,
  0xE0, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0x01, 0xF0, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x0F,
  0x80, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xDE, 0xFF, 0x80, 0x07, 0xF0, 0xE1,
  0xFC, 0x00, 0x7E, 0x0F, 0x07, 0xF0, 0x07, 0xE0, 0x78, 0x1F, 0x80, 0x3F,
  0x03, 0xC0, 0xFC, 0x03, 0xF0, 0x1E, 0x03, 0xE0, 0x1F, 0x80, 0xF0, 0x1F,
  0x00, 0xF8, 0x07, 0x00, 0xF8, 0x07, 0xC0, 0x78, 0x0F, 0xC0, 0x3E, 0x03,
  0xC0, 0x00, 0x03, 0xF0, 0x1E, 0x00, 0x00, 0x1F, 0x80, 0xF0, 0x00, 0x00,
  0x7E, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x3C, 0x00, 0x00, 0x1F, 0xC3, 0xC0,
  0x00, 0x00, 0xFF, 0x1E, 0x00, 0x00, 0x03, 0xFC, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0x3F, 0xE0, 0x00, 0x00, 0x70, 0x7F, 0x00, 0x00, 0x07, 0x81,
  0xF8, 0x00, 0x00, 0x3C, 0x0F, 0xE0, 0x00, 0x01, 0xE0, 0x3F, 0x00, 0x00,
  0x0F, 0x01, 0xF8, 0x00, 0x00, 0x78, 0x0F, 0xC0, 0x00, 0x03, 0x80, 0x7E,
  0x00, 0x00, 0x3C, 0x03, 0xF0, 0x7E, 0x01, 0xE0, 0x1F, 0x83, 0xF0, 0x0F,
  0x00, 0xF8, 0x1F, 0x80, 0x78, 0x0F, 0xC0, 0xFC, 0x03, 0xC0, 0x7E, 0x07,
  0xE0, 0x1E, 0x07, 0xE0, 0x3F, 0x80, 0xE0, 0x3F, 0x00, 0xFE, 0x0F, 0x07,
  0xF0, 0x07, 0xF8, 0x78, 0x7F, 0x00, 0x1F, 0xFB, 0xDF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0xF8, 0x00, 0x7C, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0xF8,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xF0,
  0x07, 0xC0, 0x07, 0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x01, 0xE0,
  0x07, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x78, 0x00, 0x03, 0xE0,
  0x07, 0x80, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x00, 0x03, 0xE0,
  0x0F, 0x83, 0xE0, 0x00, 0x03, 0xE0, 0x0F, 0x87, 0xC0, 0x00, 0x03, 0xF0,
  0x1F, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x7E, 0x1F, 0x00, 0x00, 0x01, 0xFF,
  0xFE, 0x1E, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x3E, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7C, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0xF8, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xF0, 0xFE, 0x1F, 0x80, 0x00, 0x01,
  0xF0, 0xF8, 0x0F, 0xC0, 0x00, 0x03, 0xE1, 0xF0, 0x07, 0xC0, 0x00, 0x07,
  0xC1, 0xF0, 0x07, 0xC0, 0x00, 0x0F, 0x81, 0xE0, 0x07, 0xC0, 0x00, 0x1F,
  0x01, 0xE0, 0x07, 0xC0, 0x00, 0x1E, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x3E,
  0x03, 0xE0, 0x07, 0x80, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0x80, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x03, 0xE0,
  0x03, 0xC0, 0x0F, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7C, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0x81, 0xFE, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xBF, 0x00, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x3F, 0x1F,
  0x81, 0xF8, 0x01, 0xF8, 0x7E, 0x07, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC0,
  0x3E, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0xF8,
  0x00, 0xFC, 0x7E, 0x03, 0xE0, 0x03, 0xF1, 0xF0, 0x0F, 0x80, 0x07, 0xEF,
  0xC0, 0x7E, 0x00, 0x1F, 0xFE, 0x01, 0xF8, 0x00, 0x3F, 0xF0, 0x07, 0xE0,
  0x00, 0x7F, 0xC0, 0x1F, 0x80, 0x01, 0xFE, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x00, 0x7F, 0x80, 0x3F, 0x00,
  0x03, 0xFF, 0x00, 0xFC, 0x00, 0x1F, 0xFC, 0x01, 0xF8, 0x00, 0xFD, 0xF8,
  0x07, 0xF0, 0x0F, 0xE7, 0xE0, 0x1F, 0xF1, 0xFF, 0x0F, 0xC0, 0x3F, 0xFF,
  0xF8, 0x3F, 0x00, 0xFF, 0xFF, 0xC0, 0x7E, 0x01, 0xFF, 0xFC, 0x00, 0xFC,
  0x01, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x9F,
  0xCF, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0xFE, 0x7F, 0x3F, 0x1F, 0x8F, 0xC7,
  0xE3, 0xF1, 0xF0, 0xF8, 0xFC, 0x7E, 0x3E, 0x1F, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x08, 0x00, 0x3F, 0x00, 0x04, 0x78, 0x01, 0xF0, 0x01, 0xE7, 0xF0,
  0x0F, 0x80, 0x7F, 0x3F, 0xF0, 0x7C, 0x1F, 0xFB, 0xFF, 0xC1, 0xC3, 0xFF,
  0xDF, 0xFF, 0x8E, 0x3F, 0xFF, 0x3F, 0xFE, 0x67, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0xF0,
  0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x3F, 0x80,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x3F, 0x80, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x01,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x02, 0x01, 0xFC, 0x3F, 0xE7, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE,
  0xFF, 0xEF, 0xFC, 0x7F, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFC, 0x0F, 0xF8,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xC0, 0x00, 0xFC, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x70, 0x0F, 0xC1, 0xF8, 0x1F, 0x80, 0xFC, 0x1F, 0x83, 0xFC,
  0x0F, 0x81, 0xF0, 0x3F, 0xC0, 0xF8, 0x1F, 0x03, 0xFC, 0x0F, 0x81, 0xF0,
  0x3F, 0xC1, 0xF8, 0x3F, 0x01, 0xF8, 0x1F, 0x83, 0xF0, 0x1F, 0x81, 0xF8,
  0x3F, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00,
  0x7E, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x7F, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xF3, 0xE0, 0x00, 0x1F, 0xE7, 0xE0,
  0x00, 0x7F, 0x87, 0xE0, 0x00, 0xFF, 0x07, 0xE0, 0x01, 0xFC, 0x07, 0xE0,
  0x01, 0xF8, 0x07, 0xC0, 0x01, 0xE0, 0x07, 0xC0, 0x01, 0xC0, 0x07, 0xC0,
  0x03, 0x00, 0x0F, 0xC0, 0x02, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x3F, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0xF8,
  0x3F, 0x00, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x01, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x3E, 0x01, 0xF8,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x7E, 0x0F, 0xE0,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x7C, 0x3F, 0x00,
  0x00, 0xFC, 0x7F, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x7C, 0x00,
  0x00, 0xFC, 0x7C, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0xF8, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0xFC, 0x3F, 0xFC, 0x00, 0x3F,
  0x3F, 0xFF, 0x80, 0x0F, 0xDF, 0xFF, 0xF0, 0x03, 0xEF, 0xFF, 0xFE, 0x00,
  0xFB, 0xF0, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x10, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x0F,
  0xE0, 0x1F, 0xC0, 0x07, 0xF0, 0x07, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x80, 0x00, 0x1F, 0x8F, 0xFC, 0x00, 0x0F, 0xDF,
  0xFF, 0x80, 0x0F, 0xDF, 0xFF, 0xE0, 0x0F, 0xDF, 0xFF, 0xF8, 0x07, 0xFE,
  0x07, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x1F, 0xBE,
  0x00, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x03, 0xEF,
  0xC0, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0xFD,
  0xF8, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x3F,
  0x81, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFB, 0xE0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0xFC, 0xF8,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x3F,
  0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x01, 0xFC, 0x07,
  0xF0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x03, 0xF8, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x00,
  0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x00,
  0x00, 0x1F, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xE0,
  0x03, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xC0,
  0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x8F, 0xE0,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x3F, 0x7C,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x03, 0xF3,
  0xF8, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x01, 0xFC,
  0x3F, 0x80, 0x01, 0xFC, 0x0F, 0xF0, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0xFE,
  0x01, 0xFF, 0xFF, 0xBF, 0x00, 0x7F, 0xFF, 0xBF, 0x00, 0x1F, 0xFF, 0xBF,
  0x00, 0x03, 0xFF, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x01, 0xFE, 0x03, 0xFF, 0x07, 0xFF,
  0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x3F, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xE0,
  0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0x80, 0x0C, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x3F, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xE0, 0x06, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x03,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0x80, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x03, 0xE0,
  0x1F, 0x00, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x0F, 0x80,
  0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3F, 0x87, 0xC0,
  0xF8, 0x00, 0x7F, 0xF3, 0xE0, 0xF8, 0x00, 0xFF, 0xFD, 0xF0, 0x7C, 0x00,
  0xFF, 0xFE, 0xF8, 0x3E, 0x00, 0x7F, 0x07, 0x7C, 0x1F, 0x00, 0x7E, 0x00,
  0xFC, 0x0F, 0x80, 0x3E, 0x00, 0x7E, 0x07, 0xC0, 0x3F, 0x00, 0x1F, 0x07,
  0xE0, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x07,
  0xC0, 0x03, 0xE0, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x01,
  0xF0, 0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x00, 0x7C, 0x1F,
  0x00, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x3E,
  0x00, 0x1F, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x0F, 0x80, 0x07,
  0xC0, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x7C,
  0x01, 0xF0, 0x01, 0xF8, 0x3E, 0x00, 0xF8, 0x01, 0xFC, 0x1F, 0x00, 0x7E,
  0x00, 0xFC, 0x0F, 0x80, 0x3F, 0x81, 0xDE, 0x07, 0xC0, 0x0F, 0xFF, 0xDF,
  0x07, 0xE0, 0x07, 0xFF, 0xEF, 0x83, 0xE0, 0x01, 0xFF, 0xE7, 0xC1, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x01,
  0xF7, 0x80, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00,
  0x1F, 0x9F, 0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x03, 0xF1, 0xF0, 0x00,
  0x00, 0xF8, 0x7C, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x1F, 0x87, 0xC0,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x1F,
  0x80, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x07, 0xC0,
  0x3E, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x03,
  0xF0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xF8, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x3E, 0x0F, 0xC0,
  0x00, 0x0F, 0x83, 0xF0, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x00, 0xF8, 0x7E,
  0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x07, 0xFC,
  0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x1F, 0x00, 0x00, 0xFC, 0x01, 0xF0, 0x00,
  0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3E,
  0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0x7C,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x7C,
  0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x3F, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xF8,
  0x00, 0x3F, 0xC0, 0x1F, 0x80, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x1F, 0x00, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00,
  0x3F, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x03, 0xF0,
  0x3E, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x07, 0xC0,
  0x00, 0x1F, 0xC0, 0x7C, 0x00, 0x07, 0xF8, 0x07, 0xC0, 0x01, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x83,
  0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0xFC, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x0F,
  0x83, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0x1F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFF, 0x87, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x03, 0xE0, 0x01, 0xFF, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x0F, 0x80,
  0x00, 0xFE, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x00,
  0x00, 0x3F, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x1F,
  0x80, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC,
  0x0F, 0x80, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00,
  0x7C, 0x0F, 0xC0, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x01, 0xF8, 0x1F,
  0x00, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x3E,
  0x00, 0x03, 0xF8, 0x07, 0xC0, 0x01, 0xFE, 0x00, 0xF8, 0x00, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x83, 0xFF,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0xFC, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x0F, 0x83,
  0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0xFC, 0x1F, 0x80, 0x7F, 0xFF,
  0x83, 0xF0, 0x1F, 0xFF, 0xF0, 0x7E, 0x03, 0xFF, 0xFE, 0x0F, 0x80, 0x7F,
  0xFF, 0x81, 0xF0, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0x3E, 0x0F, 0xC0,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x1F,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x1F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01,
  0xFF, 0x87, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x1F, 0x80, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x1F, 0x00,
  0x00, 0x7E, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xF8, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x1F, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7C,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x7C, 0x00,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x01, 0xFC, 0x00,
  0x01, 0xF8, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x00, 0x1F, 0xC0, 0x0F, 0x80, 0x00,
  0x1F, 0x80, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x01, 0xFF, 0x01, 0xFF,
  0x00, 0x07, 0xBC, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x1E, 0xF0, 0x00, 0xF7,
  0x80, 0xFB, 0xC0, 0x07, 0xDE, 0x03, 0xEF, 0x00, 0x1E, 0x78, 0x0F, 0xBE,
  0x00, 0xFB, 0xE0, 0x3E, 0xF8, 0x03, 0xCF, 0x80, 0xF1, 0xE0, 0x1F, 0x3E,
  0x03, 0xC7, 0x80, 0x78, 0xF0, 0x1F, 0x1E, 0x03, 0xE7, 0xC0, 0x7C, 0x7C,
  0x0F, 0x1F, 0x01, 0xF1, 0xF0, 0x7C, 0x7C, 0x07, 0xC7, 0xC1, 0xE1, 0xF0,
  0x1F, 0x0F, 0x0F, 0x87, 0xC0, 0x7C, 0x3C, 0x3C, 0x3E, 0x01, 0xF0, 0xF1,
  0xF0, 0xF8, 0x0F, 0xC3, 0xE7, 0x83, 0xE0, 0x3E, 0x0F, 0x9E, 0x0F, 0x80,
  0xF8, 0x1E, 0xF0, 0x3E, 0x03, 0xE0, 0x7B, 0xC1, 0xF8, 0x0F, 0x81, 0xFE,
  0x07, 0xE0, 0x3E, 0x07, 0xF8, 0x1F, 0x01, 0xF8, 0x1F, 0xE0, 0x7C, 0x07,
  0xE0, 0x7F, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7C, 0x00, 0x00,
  0x3F, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x3F,
  0x00, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0xF8,
  0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x07,
  0xC0, 0x7E, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x07, 0xC0,
  0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x00, 0x3E,
  0x03, 0xF0, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0xF8, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF0, 0x1F,
  0xE0, 0x00, 0x1F, 0x01, 0xFF, 0x00, 0x01, 0xF0, 0x1F, 0xF0, 0x00, 0x3F,
  0x01, 0xFF, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x00, 0x3F, 0x01, 0xFF, 0x00,
  0x03, 0xE0, 0x3E, 0xF8, 0x00, 0x3E, 0x03, 0xEF, 0x80, 0x03, 0xE0, 0x3E,
  0xF8, 0x00, 0x7E, 0x03, 0xEF, 0x80, 0x07, 0xE0, 0x3E, 0x7C, 0x00, 0x7E,
  0x03, 0xE7, 0xC0, 0x07, 0xC0, 0x3E, 0x7C, 0x00, 0x7C, 0x07, 0xE7, 0xC0,
  0x07, 0xC0, 0x7E, 0x7C, 0x00, 0x7C, 0x07, 0xC3, 0xE0, 0x0F, 0xC0, 0x7C,
  0x3E, 0x00, 0xFC, 0x07, 0xC3, 0xE0, 0x0F, 0x80, 0x7C, 0x3E, 0x00, 0xF8,
  0x0F, 0xC3, 0xE0, 0x0F, 0x80, 0xFC, 0x1F, 0x00, 0xF8, 0x0F, 0x81, 0xF0,
  0x1F, 0x80, 0xF8, 0x1F, 0x01, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x00, 0xF8,
  0x0F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x1F, 0x01, 0xF8, 0x0F, 0x81, 0xF0,
  0x1F, 0x80, 0xF8, 0x3F, 0x01, 0xF0, 0x0F, 0x83, 0xF0, 0x1F, 0x00, 0x7C,
  0x3F, 0x01, 0xF0, 0x07, 0xC3, 0xE0, 0x3F, 0x00, 0x7C, 0x3E, 0x03, 0xF0,
  0x07, 0xC3, 0xE0, 0x3F, 0x00, 0x7C, 0x3E, 0x03, 0xE0, 0x03, 0xE7, 0xE0,
  0x3E, 0x00, 0x3E, 0x7E, 0x03, 0xE0, 0x03, 0xE7, 0xC0, 0x3E, 0x00, 0x3E,
  0x7C, 0x07, 0xE0, 0x03, 0xE7, 0xC0, 0x7E, 0x00, 0x1F, 0x7C, 0x07, 0xC0,
  0x01, 0xF7, 0xC0, 0x7C, 0x00, 0x1F, 0x7C, 0x07, 0xC0, 0x01, 0xF7, 0x80,
  0x7C, 0x00, 0x1F, 0xF8, 0x0F, 0xC0, 0x00, 0xFF, 0x80, 0xFC, 0x00, 0x0F,
  0xF8, 0x0F, 0xC0, 0x00, 0xFF, 0x80, 0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0x80,
  0x00, 0x7F, 0x80, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07,
  0xC0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xF8,
  0x3F, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07,
  0xE0, 0xF8, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00,
  0x1F, 0x07, 0xE0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x00, 0xFC, 0x1F, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x3E, 0x0F,
  0xC0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x07,
  0xC1, 0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00,
  0x3F, 0x07, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xE0, 0xFC, 0x00,
  0x00, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x07,
  0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xC0, 0x00, 0x7F, 0xC0, 0x1F,
  0x00, 0x00, 0x7F, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x03,
  0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0xF8,
  0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x00, 0x3F,
  0x01, 0xF0, 0x00, 0x01, 0xFC, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0xE0,
  0x0F, 0x80, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xE0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF0, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF0,
  0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x07, 0xC1,
  0xF8, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x1F, 0x83, 0xE0, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x0F, 0x83, 0xF0,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x0F, 0xC1,
  0xF0, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x07,
  0xC1, 0xF8, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x1F, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFF,
  0x83, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xF8, 0x00, 0x1F, 0xF0, 0x07, 0xC0,
  0x00, 0x3F, 0x80, 0x3E, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x3E, 0x00, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x7C, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0x3F, 0x00, 0x01, 0xFE, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x00, 0x3F, 0x80, 0x3E, 0x00,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x80,
  0xFC, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x1F, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00,
  0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0x0F, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00,
  0x7C, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x7E, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x3F,
  0x00, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00,
  0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x7E, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x03, 0xF0, 0x3E,
  0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x01, 0xF0,
  0x3F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01,
  0xF8, 0x1F, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0xFC, 0x00,
  0x00, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x03, 0xE0,
  0x7E, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0xF8, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x3F,
  0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x1F, 0x3F, 0x00, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x01, 0xF8, 0x7C, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x1F,
  0x80, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x3E, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x7C,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x01,
  0xF0, 0x0F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF0, 0x00,
  0x07, 0xE0, 0x7C, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0x0F, 0x87, 0xE0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0xF8, 0x7C,
  0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x03, 0xE7,
  0xE0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x3E, 0x00,
  0x3F, 0x00, 0x3F, 0x3E, 0x00, 0x7F, 0x00, 0x3E, 0x3E, 0x00, 0x7F, 0x00,
  0x3E, 0x3E, 0x00, 0x7F, 0x00, 0x3E, 0x3E, 0x00, 0xFF, 0x00, 0x7C, 0x3E,
  0x00, 0xFF, 0x00, 0x7C, 0x3E, 0x00, 0xFF, 0x00, 0x7C, 0x3E, 0x00, 0xEF,
  0x00, 0x7C, 0x3E, 0x01, 0xEF, 0x00, 0xF8, 0x3E, 0x01, 0xEF, 0x00, 0xF8,
  0x3E, 0x01, 0xCF, 0x00, 0xF8, 0x3E, 0x03, 0xCF, 0x01, 0xF8, 0x7E, 0x03,
  0xCF, 0x01, 0xF0, 0x7C, 0x03, 0xCF, 0x01, 0xF0, 0x7C, 0x03, 0x8F, 0x01,
  0xF0, 0x7C, 0x07, 0x8F, 0x03, 0xE0, 0x7C, 0x07, 0x8F, 0x03, 0xE0, 0x7C,
  0x07, 0x0E, 0x03, 0xE0, 0x7C, 0x0F, 0x0E, 0x03, 0xE0, 0x7C, 0x0F, 0x0E,
  0x07, 0xC0, 0x7C, 0x0F, 0x0E, 0x07, 0xC0, 0x7C, 0x0E, 0x0E, 0x07, 0xC0,
  0x7C, 0x1E, 0x0E, 0x07, 0x80, 0x7C, 0x1E, 0x0E, 0x0F, 0x80, 0x7C, 0x1C,
  0x0E, 0x0F, 0x80, 0x7C, 0x3C, 0x0E, 0x0F, 0x80, 0x7C, 0x3C, 0x0E, 0x1F,
  0x00, 0x7C, 0x3C, 0x0E, 0x1F, 0x00, 0x7C, 0x38, 0x1E, 0x1F, 0x00, 0x7C,
  0x78, 0x1E, 0x1F, 0x00, 0x7C, 0x78, 0x1E, 0x3E, 0x00, 0x7C, 0x70, 0x1E,
  0x3E, 0x00, 0x7C, 0xF0, 0x1E, 0x3E, 0x00, 0x78, 0xF0, 0x1E, 0x3C, 0x00,
  0x78, 0xF0, 0x1E, 0x7C, 0x00, 0x78, 0xE0, 0x1E, 0x7C, 0x00, 0x79, 0xE0,
  0x1E, 0x7C, 0x00, 0xF9, 0xE0, 0x1E, 0x78, 0x00, 0xF9, 0xC0, 0x1E, 0xF8,
  0x00, 0xFB, 0xC0, 0x1E, 0xF8, 0x00, 0xFB, 0xC0, 0x1E, 0xF0, 0x00, 0xFB,
  0xC0, 0x1E, 0xF0, 0x00, 0xFB, 0x80, 0x1D, 0xF0, 0x00, 0xFF, 0x80, 0x1D,
  0xF0, 0x00, 0xFF, 0x80, 0x1D, 0xE0, 0x00, 0xFF, 0x00, 0x1D, 0xE0, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xE0, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x00, 0x01, 0xF0, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00,
  0x00, 0x7C, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF7, 0xC0,
  0x00, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0x00, 0x07, 0xE1, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x03, 0xF8,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00,
  0x3E, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00,
  0xF9, 0xF0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x7C,
  0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x7C, 0x07,
  0x80, 0x03, 0xE0, 0x1F, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x7C, 0x00, 0xF0,
  0x03, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x7C, 0x00, 0x3E, 0x03,
  0xF0, 0x00, 0x78, 0x0F, 0x80, 0x01, 0xF0, 0x7E, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0xF9, 0xF0, 0x00,
  0x03, 0xEF, 0xC0, 0x00, 0x07, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0x7C, 0x07,
  0xE0, 0x3F, 0x00, 0x07, 0xFC, 0x0F, 0x80, 0x1F, 0xFF, 0x87, 0xC0, 0x1F,
  0xFF, 0xE7, 0xE0, 0x1F, 0xFF, 0xF3, 0xF0, 0x1F, 0xFF, 0xFD, 0xF8, 0x1F,
  0xE0, 0x1E, 0xFC, 0x1F, 0xC0, 0x03, 0xFC, 0x0F, 0xC0, 0x00, 0xFE, 0x0F,
  0xC0, 0x00, 0x7F, 0x07, 0xC0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x01, 0xF0,
  0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E,
  0x1F, 0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F,
  0x87, 0xE0, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03,
  0xF0, 0xF8, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00,
  0x7C, 0x3F, 0x00, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x0F, 0xE0, 0xFC, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x0E, 0xF8, 0x0F, 0xF8,
  0x3F, 0xFC, 0x07, 0xFF, 0xFF, 0x7E, 0x01, 0xFF, 0xFF, 0x3F, 0x00, 0x7F,
  0xFF, 0x1F, 0x00, 0x1F, 0xFE, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3E, 0x03, 0xFC, 0x00, 0x1F, 0x0F, 0xFF, 0x80, 0x1F, 0x8F, 0xFF,
  0xF0, 0x0F, 0xCF, 0xFF, 0xF8, 0x07, 0xEF, 0xFF, 0xFE, 0x03, 0xEF, 0x00,
  0x7F, 0x81, 0xF7, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x03, 0xF0, 0x7F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x07, 0xC3, 0xF0, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0x7E, 0x1F,
  0x00, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x0F, 0x87,
  0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x03, 0xF0,
  0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x7F,
  0x07, 0xF8, 0x00, 0x7F, 0x03, 0xFE, 0x00, 0x7F, 0x83, 0xF7, 0xC0, 0xFF,
  0x81, 0xFB, 0xFF, 0xFF, 0x80, 0xFC, 0xFF, 0xFF, 0x80, 0x7E, 0x3F, 0xFF,
  0x00, 0x3E, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x1F,
  0xC0, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE1,
  0xF0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x1F, 0x80, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x0F, 0x87, 0xE0, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0x7F, 0x00,
  0x07, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x03, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x7F, 0xC0, 0xF8, 0x00, 0x7F, 0xFE, 0x1F, 0x00, 0x1F, 0xFF, 0xE7,
  0xE0, 0x07, 0xFF, 0xFC, 0xFC, 0x01, 0xFF, 0xFF, 0xDF, 0x80, 0x7F, 0x80,
  0x7B, 0xF0, 0x1F, 0xC0, 0x03, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0xFC,
  0x00, 0x07, 0xF0, 0x1F, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x7C, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x0F,
  0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x3E, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7F, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x3B, 0xE0, 0x0F, 0xF8, 0x3F, 0xFC, 0x01, 0xFF, 0xFF, 0xDF,
  0x80, 0x1F, 0xFF, 0xF3, 0xF0, 0x01, 0xFF, 0xFC, 0x7C, 0x00, 0x1F, 0xFE,
  0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFC, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x07,
  0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x3E, 0x3E,
  0x00, 0x00, 0x3E, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0x7E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0x7E,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F,
  0xC0, 0x7F, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x0F, 0x80, 0x0F, 0xFF, 0x87, 0xC0,
  0x1F, 0xFF, 0xE7, 0xE0, 0x1F, 0xFF, 0xFB, 0xF0, 0x1F, 0xFF, 0xFD, 0xF8,
  0x1F, 0xE0, 0x1E, 0xFC, 0x1F, 0xC0, 0x03, 0xFC, 0x0F, 0xC0, 0x00, 0xFE,
  0x0F, 0xC0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x01,
  0xF0, 0xFC, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0x7E, 0x1F, 0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x0F, 0x87, 0xE0, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0xC0, 0xFE, 0x00, 0x7F, 0xE0, 0x7F,
  0xE1, 0xFB, 0xE0, 0x1F, 0xFF, 0xF9, 0xF0, 0x07, 0xFF, 0xF8, 0xF8, 0x01,
  0xFF, 0xF8, 0xFC, 0x00, 0x3F, 0xF0, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x07, 0xFC, 0x00, 0x1F, 0x0F, 0xFF, 0x80,
  0x1F, 0x8F, 0xFF, 0xF0, 0x0F, 0xCF, 0xFF, 0xFC, 0x07, 0xEF, 0xEF, 0xFE,
  0x03, 0xFF, 0x00, 0x7F, 0x81, 0xF6, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xC0, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x3E, 0x00,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE1, 0xF0,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x7E,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x0F,
  0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07, 0xC3,
  0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8,
  0x7C, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x81, 0xF0, 0x00, 0x03, 0xF8, 0x0F,
  0x80, 0x00, 0x3F, 0x80, 0x7C, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x3F, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0x80,
  0x01, 0xFC, 0x00, 0x7C, 0x00, 0x1F, 0xC0, 0x03, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x0F, 0xE0, 0x00, 0x1F,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF8,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x3E, 0x00,
  0x01, 0xF8, 0x01, 0xF0, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00,
  0x3F, 0x80, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x03, 0xE3, 0xF8, 0x1F, 0xC0,
  0x1F, 0x3F, 0xE1, 0xFF, 0x00, 0xF3, 0xFF, 0x1F, 0xFC, 0x0F, 0xBF, 0xFD,
  0xFF, 0xE0, 0x7D, 0x87, 0xEC, 0x3F, 0x83, 0xF0, 0x1F, 0xC0, 0xFC, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0xF8, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x3E, 0x00,
  0xF8, 0x7E, 0x01, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x80, 0x7E, 0x1F, 0x00,
  0x7C, 0x03, 0xE0, 0xF8, 0x03, 0xC0, 0x1F, 0x07, 0xC0, 0x1E, 0x00, 0xF8,
  0x3E, 0x01, 0xF0, 0x07, 0xC3, 0xF0, 0x0F, 0x80, 0x3E, 0x1F, 0x80, 0x7C,
  0x03, 0xF0, 0xF8, 0x03, 0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x3E,
  0x00, 0xF0, 0x07, 0xC1, 0xF0, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x7C, 0x01,
  0xF0, 0xFC, 0x03, 0xE0, 0x1F, 0x87, 0xC0, 0x1F, 0x00, 0xFC, 0x3E, 0x00,
  0xF8, 0x07, 0xC1, 0xF0, 0x07, 0x80, 0x3E, 0x0F, 0x80, 0x3C, 0x01, 0xF0,
  0x7C, 0x03, 0xE0, 0x0F, 0x87, 0xE0, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8,
  0x07, 0xE1, 0xF0, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x7C,
  0x01, 0xE0, 0x0F, 0x83, 0xE0, 0x1F, 0x00, 0x7C, 0x3F, 0x00, 0xF8, 0x03,
  0xE1, 0xF8, 0x07, 0xC0, 0x3F, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x7C, 0x01,
  0xE0, 0x0F, 0x83, 0xE0, 0x0F, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x7F, 0xC0,
  0x01, 0xF0, 0xFF, 0xF8, 0x01, 0xF8, 0xFF, 0xFF, 0x00, 0xFC, 0xFF, 0xFF,
  0xC0, 0x7E, 0xFE, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xF8, 0x1F, 0x60, 0x01,
  0xFC, 0x0F, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x01, 0xF8, 0x7C, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x3F, 0x00,
  0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xE1, 0xF8,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFC, 0x03,
  0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00,
  0x3F, 0x1F, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0x3E, 0x3F, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00,
  0x7E, 0x3E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x7C, 0x7E, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00,
  0xFC, 0x7C, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00,
  0xF8, 0xFC, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x0F,
  0xE0, 0x7F, 0x80, 0x1F, 0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x1F, 0xF0, 0x00, 0x1F, 0x0F,
  0xFF, 0x80, 0x07, 0xE3, 0xFF, 0xFC, 0x00, 0xFC, 0xFF, 0xFF, 0xC0, 0x1F,
  0xBF, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x7D, 0xC0, 0x07, 0xF0,
  0x0F, 0xE0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x7E, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x3F,
  0x00, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00,
  0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x7E, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x03, 0xF0, 0x3E,
  0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x07,
  0xF0, 0x1F, 0xE0, 0x01, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0xFD, 0xF0,
  0x3F, 0xE0, 0x1F, 0xBF, 0xFF, 0xF8, 0x03, 0xF3, 0xFF, 0xFE, 0x00, 0x7C,
  0x3F, 0xFF, 0x00, 0x0F, 0x83, 0xFF, 0xC0, 0x01, 0xF0, 0x0F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x0F, 0x80, 0x1F, 0xFF,
  0x8F, 0xC0, 0x1F, 0xFF, 0xE7, 0xE0, 0x1F, 0xFF, 0xF3, 0xF0, 0x1F, 0xFF,
  0xFD, 0xF8, 0x1F, 0xE0, 0x1E, 0xF8, 0x1F, 0xC0, 0x03, 0x7C, 0x1F, 0xC0,
  0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x7F, 0x07, 0xC0, 0x00, 0x3F, 0x87, 0xE0,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xE1, 0xF8,
  0x00, 0x01, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x3E,
  0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x1F, 0x0F,
  0xC0, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x0E,
  0xF8, 0x1F, 0xF8, 0x3E, 0xFC, 0x07, 0xFF, 0xFF, 0x7E, 0x01, 0xFF, 0xFF,
  0x3F, 0x00, 0x7F, 0xFE, 0x1F, 0x00, 0x1F, 0xFE, 0x0F, 0x80, 0x00, 0xF0,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x7F, 0xE0, 0x00, 0xF8, 0x7F, 0xFE,
  0x00, 0x3E, 0x3F, 0xFF, 0xC0, 0x0F, 0x9F, 0xFF, 0xF8, 0x07, 0xEF, 0xFF,
  0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x7F, 0xC0, 0x03, 0xF8, 0x1F, 0xE0,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0xFE,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x7E,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xE0, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x03, 0xF0, 0xF8, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x87, 0xE0, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x00, 0xFC, 0x3E,
  0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x1F, 0x0F,
  0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x07, 0xE1,
  0xF0, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00, 0xF8,
  0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F,
  0x0F, 0x80, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07,
  0xC3, 0xF0, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01,
  0xF8, 0x7C, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x1F, 0x83, 0xE0, 0x00,
  0x0F, 0x81, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0x7F, 0x00,
  0x0F, 0xE0, 0x3F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xDF,
  0x00, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0xFC,
  0x7E, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x07,
  0xE0, 0xF8, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0x00,
  0x03, 0xF0, 0x07, 0xC0, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x00,
  0xF8, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x3F, 0x00,
  0x03, 0xE0, 0x0F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0xFC, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x1F,
  0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0xF8,
  0xF8, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0x80, 0x1F, 0xF8, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0x80, 0x1E, 0xF8,
  0x03, 0xF8, 0x03, 0xEF, 0x80, 0x3F, 0x80, 0x3E, 0xF8, 0x07, 0xF8, 0x03,
  0xCF, 0x00, 0x7F, 0x80, 0x7C, 0xF0, 0x07, 0x78, 0x07, 0xCF, 0x00, 0xF7,
  0x80, 0x78, 0xF0, 0x0F, 0x78, 0x0F, 0x8F, 0x00, 0xE7, 0x80, 0xF8, 0xF0,
  0x1E, 0x78, 0x0F, 0x0F, 0x01, 0xE7, 0x81, 0xF0, 0xF0, 0x1C, 0x78, 0x1F,
  0x0F, 0x03, 0xC7, 0x81, 0xE0, 0xF0, 0x3C, 0x78, 0x3E, 0x0F, 0x03, 0x87,
  0x83, 0xE0, 0xF0, 0x78, 0x78, 0x3C, 0x0F, 0x07, 0x87, 0x83, 0xC0, 0xF0,
  0x70, 0x78, 0x7C, 0x0F, 0x0F, 0x07, 0x87, 0x80, 0xF0, 0xF0, 0x78, 0x78,
  0x0F, 0x0E, 0x07, 0x8F, 0x80, 0xF1, 0xE0, 0x78, 0xF0, 0x0F, 0x1E, 0x07,
  0x8F, 0x00, 0xF1, 0xC0, 0x79, 0xF0, 0x0F, 0x3C, 0x07, 0x9E, 0x00, 0xF3,
  0xC0, 0x79, 0xE0, 0x0F, 0x38, 0x07, 0xBE, 0x00, 0xF7, 0x80, 0x7B, 0xC0,
  0x0F, 0x78, 0x07, 0xBC, 0x00, 0xF7, 0x00, 0x7B, 0xC0, 0x0F, 0xF0, 0x07,
  0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0xFE,
  0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0xFE, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0xFC, 0x00, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x00,
  0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x3E, 0x1F, 0x80, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC3, 0xE0, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0xFC, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0x3F, 0x0F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x87, 0xE0,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x83,
  0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0xF7, 0xC0, 0x7F, 0xFF, 0xFB, 0xE0,
  0x1F, 0xFF, 0xF9, 0xF0, 0x07, 0xFF, 0xF9, 0xF8, 0x01, 0xFF, 0xF0, 0xFC,
  0x00, 0x3F, 0xE0, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01,
  0xF0, 0xFF, 0xF0, 0x00, 0xFC, 0x7F, 0xFE, 0x00, 0x3E, 0x3F, 0xFF, 0xC0,
  0x0F, 0x8F, 0xC3, 0xF8, 0x03, 0xE7, 0xE0, 0x7E, 0x00, 0xF9, 0xF0, 0x0F,
  0xC0, 0x7E, 0x7C, 0x01, 0xF8, 0x1F, 0x3F, 0x00, 0x7F, 0x9F, 0xCF, 0x80,
  0x0F, 0xFF, 0xE3, 0xE0, 0x01, 0xFF, 0xF0, 0xF8, 0x00, 0x3F, 0xF8, 0x3E,
  0x00, 0x07, 0xF8, 0x00,
};

const GFXglyph JetBrainsMono_LightItalic70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 42, 0, -1 },
  { 1, 16, 51, 42, 13, -51 },
  { 103, 23, 21, 42, 13, -51 },
  { 164, 40, 51, 42, 2, -51 },
  { 419, 37, 71, 42, 3, -61 },
  { 748, 48, 51, 42, -2, -51 },
  { 1054, 38, 53, 42, 2, -52 },
  { 1306, 9, 21, 42, 20, -51 },
  { 1330, 29, 68, 42, 11, -59 },
  { 1577, 28, 68, 42, 4, -59 },
  { 1815, 37, 36, 42, 4, -43 },
  { 1982, 33, 33, 42, 5, -40 },
  { 2119, 18, 22, 42, 7, -11 },
  { 2169, 23, 5, 42, 10, -26 },
  { 2184, 12, 12, 42, 13, -11 },
  { 2202, 41, 66, 42, 1, -58 },
  { 2541, 36, 53, 42, 4, -52 },
  { 2780, 32, 51, 42, 3, -51 },
  { 2984, 36, 52, 42, 3, -52 },
  { 3218, 35, 52, 42, 4, -51 },
  { 3446, 32, 51, 42, 5, -51 },
  { 3650, 34, 52, 42, 5, -51 },
  { 3871, 33, 52, 42, 4, -51 },
  { 4086, 33, 51, 42, 9, -51 },
  { 4297, 35, 53, 42, 4, -52 },
  { 4529, 33, 52, 42, 7, -52 },
  { 4744, 16, 40, 42, 13, -39 },
  { 4824, 22, 50, 42, 7, -39 },
  { 4962, 33, 36, 42, 6, -41 },
  { 5111, 33, 22, 42, 5, -34 },
  { 5202, 33, 36, 42, 4, -41 },
  { 5351, 28, 51, 42, 10, -51 },
  { 5530, 41, 65, 42, 1, -52 },
  { 5864, 34, 51, 42, 1, -51 },
  { 6081, 36, 51, 42, 4, -51 },
  { 6311, 35, 53, 42, 5, -52 },
  { 6543, 35, 51, 42, 4, -51 },
  { 6767, 37, 51, 42, 4, -51 },
  { 7003, 38, 51, 42, 4, -51 },
  { 7246, 35, 53, 42, 5, -52 },
  { 7478, 36, 51, 42, 4, -51 },
  { 7708, 34, 51, 42, 5, -51 },
  { 7925, 37, 52, 42, 2, -51 },
  { 8166, 39, 51, 42, 4, -51 },
  { 8415, 30, 51, 42, 5, -51 },
  { 8607, 38, 51, 42, 3, -51 },
  { 8850, 36, 51, 42, 4, -51 },
  { 9080, 34, 53, 42, 5, -52 },
  { 9306, 38, 51, 42, 4, -51 },
  { 9549, 35, 65, 42, 4, -52 },
  { 9834, 37, 51, 42, 4, -51 },
  { 10070, 37, 53, 42, 3, -52 },
  { 10316, 35, 51, 42, 8, -51 },
  { 10540, 35, 52, 42, 5, -51 },
  { 10768, 34, 51, 42, 9, -51 },
  { 10985, 40, 51, 42, 5, -51 },
  { 11240, 43, 51, 42, 0, -51 },
  { 11515, 36, 51, 42, 8, -51 },
  { 11745, 37, 51, 42, 3, -51 },
  { 11981, 28, 66, 42, 10, -58 },
  { 12212, 20, 66, 42, 12, -58 },
  { 12377, 27, 66, 42, 6, -58 },
  { 12600, 30, 27, 42, 7, -51 },
  { 12702, 34, 4, 42, 0, 2 },
  { 12719, 12, 10, 42, 19, -55 },
  { 12734, 33, 40, 42, 5, -39 },
  { 12899, 33, 52, 42, 4, -51 },
  { 13114, 33, 40, 42, 5, -39 },
  { 13279, 35, 52, 42, 5, -51 },
  { 13507, 32, 40, 42, 5, -39 },
  { 13667, 47, 64, 42, -3, -51 },
  { 14043, 33, 52, 42, 5, -39 },
  { 14258, 33, 51, 42, 4, -51 },
  { 14469, 33, 54, 42, 3, -54 },
  { 14692, 36, 67, 42, 1, -54 },
  { 14994, 37, 51, 42, 4, -51 },
  { 15230, 29, 51, 42, 7, -51 },
  { 15415, 37, 39, 42, 2, -39 },
  { 15596, 33, 39, 42, 4, -39 },
  { 15757, 32, 40, 42, 5, -39 },
  { 15917, 35, 52, 42, 2, -39 },
  { 16145, 33, 52, 42, 5, -39 },
  { 16360, 34, 39, 42, 5, -39 },
  { 16526, 33, 40, 42, 4, -39 },
  { 16691, 33, 49, 42, 6, -49 },
  { 16894, 33, 40, 42, 5, -39 },
  { 17059, 34, 39, 42, 7, -39 },
  { 17225, 36, 39, 42, 6, -39 },
  { 17401, 39, 39, 42, 1, -39 },
  { 17592, 33, 52, 42, 5, -39 },
  { 17807, 35, 39, 42, 3, -39 },
  { 17978, 35, 66, 42, 7, -58 },
  { 18267, 16, 66, 42, 14, -58 },
  { 18399, 35, 66, 42, 2, -58 },
  { 18688, 34, 14, 42, 5, -32 },
};

const GFXfont JetBrainsMono_LightItalic70pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_LightItalic70pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_LightItalic70pt7bGlyphs,
  0x20, 0x7E, 92
};

#endif // _JETBRAINSMONO_LIGHTITALIC70PT7B_H_
