#ifndef _JETBRAINSMONO_LIGHTITALIC32PT7B_H_
#define _JETBRAINSMONO_LIGHTITALIC32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-LightItalic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_LightItalic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0x87, 0x0E, 0x1C, 0x38, 0x60, 0xC1,
  0x83, 0x06, 0x18, 0x00, 0x00, 0x01, 0x8F, 0x9F, 0x3C, 0x00, 0x70, 0xEE,
  0x39, 0xC7, 0x30, 0xE6, 0x1D, 0xC3, 0x38, 0x67, 0x0C, 0xC1, 0x80, 0x00,
  0xC1, 0xC0, 0x30, 0x60, 0x1C, 0x18, 0x06, 0x0E, 0x01, 0x83, 0x00, 0xC0,
  0xC3, 0xFF, 0xFC, 0xFF, 0xFF, 0x06, 0x06, 0x01, 0x83, 0x00, 0x60, 0xC0,
  0x30, 0x30, 0x0C, 0x18, 0x03, 0x06, 0x01, 0x81, 0x83, 0xFF, 0xFC, 0xFF,
  0xFF, 0x0C, 0x1C, 0x03, 0x06, 0x01, 0xC1, 0x80, 0x60, 0xE0, 0x18, 0x30,
  0x0E, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00,
  0xF0, 0x03, 0xFC, 0x0F, 0xFE, 0x0E, 0x47, 0x1C, 0x47, 0x18, 0xC7, 0x38,
  0xC7, 0x38, 0xC0, 0x38, 0xC0, 0x1C, 0xC0, 0x1F, 0x80, 0x0F, 0xE0, 0x07,
  0xF0, 0x01, 0xF8, 0x01, 0x9C, 0x01, 0x9C, 0x01, 0x0C, 0x03, 0x0C, 0xE3,
  0x0C, 0xE3, 0x1C, 0xE3, 0x18, 0xF3, 0x78, 0x7F, 0xF0, 0x3F, 0xC0, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x80, 0x04, 0x1F, 0x80,
  0x60, 0xFF, 0x03, 0x03, 0x0C, 0x1C, 0x1C, 0x30, 0x60, 0x60, 0xC3, 0x01,
  0x83, 0x18, 0x06, 0x1C, 0xC0, 0x18, 0x66, 0x00, 0x7F, 0xB8, 0x00, 0xF9,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x84, 0x00, 0x0C, 0xFC,
  0x00, 0x67, 0x38, 0x03, 0x98, 0x60, 0x0C, 0xE1, 0x80, 0x63, 0x06, 0x03,
  0x0C, 0x18, 0x18, 0x30, 0x60, 0xC0, 0xC3, 0x07, 0x03, 0xFC, 0x38, 0x07,
  0xC0, 0x00, 0x70, 0x01, 0xFE, 0x01, 0xFF, 0x81, 0xC1, 0xC0, 0xE0, 0x60,
  0x60, 0x30, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x03, 0xF0, 0x03, 0xB8, 0x1B, 0x8E, 0x1D, 0xC7, 0x1C, 0xC1, 0xDC, 0x60,
  0x6C, 0x70, 0x3E, 0x38, 0x0E, 0x1C, 0x07, 0x0E, 0x07, 0xC7, 0x8F, 0xE1,
  0xFF, 0x38, 0x7E, 0x0E, 0x77, 0x77, 0x6E, 0xEE, 0xE0, 0x00, 0x08, 0x03,
  0xC0, 0x3E, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x01, 0x80, 0x1C, 0x00,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x01, 0xC0, 0x0E, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xC0, 0x06, 0x00,
  0x0C, 0x00, 0x78, 0x03, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60,
  0x07, 0x00, 0x30, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x0F, 0x80, 0x78,
  0x02, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x1C, 0x02, 0x0E, 0x0B, 0xE6, 0x3D, 0xFB, 0x7F, 0x3F, 0xFC, 0x00, 0xC0,
  0x00, 0xB0, 0x01, 0xDC, 0x01, 0xCE, 0x00, 0xE3, 0x80, 0xE1, 0xC0, 0xE0,
  0x70, 0x20, 0x20, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x0F, 0x0F,
  0x1E, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0x70, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC,
  0x37, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xF0, 0x03, 0xFC, 0x0F, 0xFE, 0x1E, 0x0F, 0x1C, 0x07,
  0x38, 0x07, 0x38, 0x07, 0x30, 0x07, 0x30, 0x07, 0x30, 0x06, 0x70, 0x86,
  0x73, 0xC6, 0x73, 0xCE, 0x61, 0x8E, 0x60, 0x0E, 0x60, 0x0C, 0xE0, 0x0C,
  0xE0, 0x0C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0x70, 0x70, 0x7F, 0xE0,
  0x1F, 0xC0, 0x01, 0xF0, 0x0F, 0xC0, 0xF7, 0x07, 0x9C, 0x18, 0x60, 0xC1,
  0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0x83, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x07, 0xFC, 0x0F,
  0xFE, 0x1C, 0x0E, 0x18, 0x07, 0x38, 0x07, 0x30, 0x07, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0x1F, 0xFF, 0x1F, 0xFF, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03,
  0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x1C, 0x20, 0x1C, 0xC0, 0x1C, 0xE0, 0x18, 0xE0, 0x38, 0xF0,
  0x70, 0x7F, 0xE0, 0x3F, 0xC0, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x04,
  0x70, 0x30, 0xC0, 0x63, 0x80, 0xCE, 0x03, 0x98, 0x07, 0x7F, 0xFE, 0xFF,
  0xFD, 0xFF, 0xF0, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x0F, 0xFF, 0x1F, 0xFF, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x3B, 0xF8, 0x3F, 0xFC, 0x3C, 0x1C, 0x38,
  0x1C, 0x30, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x1C, 0xE0, 0x18, 0xE0, 0x38, 0x70, 0x70, 0x7F, 0xE0, 0x1F, 0xC0, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x0C, 0x00, 0x3F, 0xF0, 0xFF, 0xF1, 0xC0, 0xE7, 0x00, 0xEC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0D, 0x80, 0x1B, 0x80, 0x77, 0x01,
  0xC7, 0x07, 0x8F, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0xFE, 0xFF, 0xFF, 0x80,
  0x3F, 0x00, 0x6E, 0x01, 0xDC, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x60,
  0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x03,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xFC, 0x0F, 0xFE, 0x0E, 0x0E, 0x1C,
  0x07, 0x18, 0x07, 0x18, 0x06, 0x38, 0x06, 0x18, 0x0E, 0x1C, 0x1C, 0x0F,
  0x78, 0x07, 0xE0, 0x07, 0xE0, 0x1E, 0x78, 0x38, 0x38, 0x70, 0x1C, 0x60,
  0x0C, 0xE0, 0x0C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0x70, 0x78, 0x7F,
  0xF0, 0x3F, 0xC0, 0x01, 0xE0, 0x0F, 0xF0, 0x7F, 0xF1, 0xE0, 0xF3, 0x00,
  0xEE, 0x01, 0xD8, 0x01, 0xB0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x73,
  0x80, 0xE7, 0x87, 0x87, 0xFF, 0x07, 0xDC, 0x00, 0x70, 0x00, 0xC0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x1E, 0x7C, 0xF9, 0xF1, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x7C, 0xF9, 0xE0, 0x03, 0xC1, 0xF0, 0x7C, 0x1F, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x38,
  0x1C, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x0E, 0x00, 0x00, 0x02, 0x00,
  0x1C, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0x78, 0x00,
  0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1C, 0x00, 0x08, 0x3F, 0xFE, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0xFF, 0xFC, 0x20, 0x00,
  0x70, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x06, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x00, 0x60, 0x00, 0x80, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0xE0, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x03, 0xC3, 0xF8,
  0x3E, 0x03, 0x80, 0x30, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xF0, 0x0F, 0x8F,
  0x03, 0x80, 0x60, 0xE0, 0x0E, 0x18, 0x00, 0xC7, 0x00, 0x18, 0xC0, 0x03,
  0x18, 0x04, 0x67, 0x07, 0xFC, 0xE1, 0xCF, 0x98, 0x70, 0x63, 0x0E, 0x0C,
  0x61, 0x81, 0x8C, 0x30, 0x31, 0x86, 0x0E, 0x71, 0xC1, 0xCE, 0x38, 0x31,
  0x87, 0x06, 0x30, 0xE1, 0xC6, 0x0F, 0xD8, 0xC1, 0xF3, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x6C, 0x00,
  0x6C, 0x00, 0xEC, 0x00, 0xCC, 0x01, 0xCC, 0x01, 0x8C, 0x03, 0x8E, 0x03,
  0x8E, 0x03, 0x0E, 0x07, 0x0E, 0x06, 0x06, 0x0E, 0x06, 0x0F, 0xFE, 0x0F,
  0xFE, 0x1F, 0xFE, 0x18, 0x06, 0x38, 0x07, 0x30, 0x07, 0x70, 0x07, 0x70,
  0x07, 0xE0, 0x07, 0x1F, 0xFC, 0x1F, 0xFE, 0x18, 0x0E, 0x18, 0x07, 0x18,
  0x07, 0x38, 0x07, 0x38, 0x06, 0x38, 0x06, 0x38, 0x0E, 0x30, 0x3C, 0x3F,
  0xF0, 0x3F, 0xF8, 0x70, 0x3C, 0x70, 0x1C, 0x70, 0x0E, 0x60, 0x0E, 0x60,
  0x0C, 0x60, 0x0C, 0xE0, 0x1C, 0xE0, 0x38, 0xE0, 0xF8, 0xFF, 0xF0, 0xFF,
  0xC0, 0x00, 0xF0, 0x03, 0xFC, 0x0F, 0xFE, 0x0E, 0x0F, 0x1C, 0x07, 0x18,
  0x07, 0x38, 0x07, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xE0, 0x1C, 0xE0, 0x1C, 0x60, 0x38, 0x70, 0x70, 0x3F, 0xE0, 0x1F,
  0xC0, 0x1F, 0xF8, 0x1F, 0xFC, 0x18, 0x1E, 0x18, 0x0E, 0x18, 0x06, 0x38,
  0x07, 0x38, 0x06, 0x38, 0x06, 0x38, 0x06, 0x30, 0x0E, 0x30, 0x0E, 0x30,
  0x0E, 0x70, 0x0C, 0x70, 0x0C, 0x70, 0x0C, 0x60, 0x1C, 0x60, 0x1C, 0x60,
  0x1C, 0xE0, 0x38, 0xE0, 0x78, 0xE1, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0x0F,
  0xFF, 0x8F, 0xFF, 0xC7, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0x07, 0xFF,
  0x83, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x47, 0xFF, 0xC3, 0xFF, 0xE0,
  0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0F, 0xFF, 0x87,
  0xFF, 0x87, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xF0, 0x03, 0xFC, 0x0F, 0xFE, 0x0E, 0x0F, 0x1C, 0x07, 0x18,
  0x07, 0x38, 0x07, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x71, 0xFE, 0x71, 0xFE, 0x71, 0xFE, 0x60, 0x0C, 0x60, 0x0C, 0x60,
  0x0C, 0xE0, 0x1C, 0xE0, 0x1C, 0x60, 0x38, 0x70, 0x70, 0x3F, 0xE0, 0x1F,
  0xC0, 0x1C, 0x03, 0x1C, 0x03, 0x1C, 0x07, 0x18, 0x07, 0x18, 0x07, 0x38,
  0x06, 0x38, 0x06, 0x38, 0x06, 0x38, 0x0E, 0x30, 0x0E, 0x3F, 0xFE, 0x3F,
  0xFC, 0x70, 0x0C, 0x70, 0x0C, 0x70, 0x1C, 0x60, 0x1C, 0x60, 0x1C, 0x60,
  0x1C, 0xE0, 0x18, 0xE0, 0x18, 0xE0, 0x18, 0xE0, 0x38, 0xC0, 0x38, 0x0F,
  0xFF, 0x1F, 0xFF, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03,
  0x00, 0x07, 0x00, 0x07, 0x00, 0xFF, 0xF8, 0xFF, 0xF0, 0x00, 0x7F, 0x80,
  0x7F, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0xE0, 0x0C, 0x70, 0x06, 0x38,
  0x07, 0x1C, 0x07, 0x07, 0x07, 0x83, 0xFF, 0x80, 0x7F, 0x00, 0x1C, 0x03,
  0xC7, 0x00, 0xE1, 0x80, 0x70, 0x60, 0x38, 0x18, 0x0E, 0x0E, 0x07, 0x03,
  0x83, 0x80, 0xE0, 0xE0, 0x38, 0x70, 0x0C, 0x38, 0x03, 0xFE, 0x00, 0xFF,
  0x00, 0x70, 0xE0, 0x1C, 0x38, 0x07, 0x06, 0x01, 0x81, 0xC0, 0x60, 0x70,
  0x18, 0x0C, 0x0E, 0x03, 0x83, 0x80, 0xE0, 0xE0, 0x1C, 0x30, 0x07, 0x0C,
  0x01, 0xC0, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0x60, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x03, 0xC2, 0xC0, 0xF1,
  0xB0, 0x68, 0x6C, 0x1E, 0x1B, 0x0D, 0x86, 0xC3, 0x61, 0xB1, 0x98, 0x66,
  0x6E, 0x39, 0xB3, 0x8E, 0x6C, 0xC3, 0x9E, 0x30, 0xC7, 0x8C, 0x31, 0xC7,
  0x0C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x18, 0x70, 0x06, 0x1C, 0x01, 0x86,
  0x00, 0xE1, 0x80, 0x38, 0x60, 0x0E, 0x38, 0x03, 0x0E, 0x00, 0xC0, 0x1E,
  0x03, 0x1E, 0x03, 0x1E, 0x03, 0x1F, 0x07, 0x1B, 0x07, 0x3B, 0x07, 0x3B,
  0x06, 0x3B, 0x06, 0x33, 0x86, 0x31, 0x8E, 0x31, 0x8E, 0x71, 0x8E, 0x71,
  0x8C, 0x71, 0xCC, 0x60, 0xCC, 0x60, 0xDC, 0x60, 0xDC, 0xE0, 0xDC, 0xE0,
  0xF8, 0xE0, 0x78, 0xE0, 0x78, 0xC0, 0x78, 0xC0, 0x78, 0x00, 0xF0, 0x03,
  0xFC, 0x0F, 0xFE, 0x0E, 0x0E, 0x1C, 0x07, 0x18, 0x07, 0x38, 0x07, 0x38,
  0x06, 0x38, 0x06, 0x30, 0x06, 0x30, 0x0E, 0x30, 0x0E, 0x70, 0x0E, 0x70,
  0x0E, 0x70, 0x0C, 0x60, 0x0C, 0x60, 0x1C, 0x60, 0x1C, 0xE0, 0x1C, 0xE0,
  0x18, 0x60, 0x38, 0x70, 0x70, 0x3F, 0xE0, 0x1F, 0xC0, 0x1F, 0xFC, 0x0F,
  0xFF, 0x86, 0x01, 0xC3, 0x00, 0x71, 0x80, 0x39, 0xC0, 0x1C, 0xE0, 0x0E,
  0x70, 0x06, 0x38, 0x07, 0x18, 0x03, 0x8C, 0x07, 0x87, 0xFF, 0x87, 0xFF,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x00, 0xF0,
  0x03, 0xFC, 0x0F, 0xFE, 0x1E, 0x0E, 0x1C, 0x07, 0x38, 0x07, 0x38, 0x07,
  0x38, 0x07, 0x30, 0x06, 0x30, 0x06, 0x70, 0x06, 0x70, 0x0E, 0x70, 0x0E,
  0x70, 0x0E, 0x60, 0x0E, 0x60, 0x0C, 0x60, 0x0C, 0xE0, 0x1C, 0xE0, 0x1C,
  0xE0, 0x18, 0xE0, 0x38, 0x70, 0x70, 0x7F, 0xE0, 0x1F, 0xC0, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x1F, 0xFC,
  0x0F, 0xFF, 0x06, 0x03, 0xC3, 0x00, 0xE1, 0x80, 0x31, 0xC0, 0x18, 0xE0,
  0x0C, 0x70, 0x0E, 0x38, 0x07, 0x18, 0x07, 0x0C, 0x1F, 0x07, 0xFF, 0x07,
  0xFE, 0x03, 0x87, 0x01, 0xC3, 0x80, 0xC0, 0xC0, 0x60, 0x70, 0x30, 0x38,
  0x38, 0x0C, 0x1C, 0x07, 0x0E, 0x03, 0x86, 0x00, 0xC3, 0x00, 0x70, 0x00,
  0xF0, 0x03, 0xFC, 0x0F, 0xFE, 0x0E, 0x0F, 0x1C, 0x07, 0x18, 0x07, 0x38,
  0x07, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0xE0,
  0x0C, 0xE0, 0x1C, 0xE0, 0x18, 0xF0, 0x78, 0x7F, 0xF0, 0x3F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFE, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x03, 0x1C,
  0x03, 0x18, 0x07, 0x18, 0x07, 0x18, 0x07, 0x38, 0x07, 0x38, 0x06, 0x38,
  0x06, 0x30, 0x06, 0x30, 0x0E, 0x30, 0x0E, 0x70, 0x0E, 0x70, 0x0C, 0x70,
  0x0C, 0x70, 0x0C, 0x60, 0x1C, 0x60, 0x1C, 0xE0, 0x1C, 0xE0, 0x18, 0x60,
  0x38, 0x70, 0x70, 0x3F, 0xE0, 0x1F, 0xC0, 0xE0, 0x07, 0xE0, 0x0E, 0xE0,
  0x0E, 0xE0, 0x0C, 0x60, 0x1C, 0x60, 0x18, 0x60, 0x38, 0x60, 0x30, 0x60,
  0x70, 0x70, 0x70, 0x70, 0x60, 0x70, 0xE0, 0x70, 0xC0, 0x71, 0xC0, 0x31,
  0x80, 0x31, 0x80, 0x33, 0x80, 0x33, 0x00, 0x37, 0x00, 0x36, 0x00, 0x36,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x70, 0xE0, 0xEC, 0x1C, 0x19, 0x82, 0x87,
  0x30, 0xD0, 0xE6, 0x1A, 0x18, 0xC3, 0xC3, 0x18, 0x58, 0xE3, 0x1B, 0x18,
  0x63, 0x63, 0x0C, 0x4C, 0x61, 0x99, 0x9C, 0x33, 0x33, 0x06, 0x66, 0x60,
  0xC8, 0xDC, 0x1B, 0x1B, 0x03, 0x63, 0x60, 0x68, 0x6C, 0x1F, 0x0F, 0x83,
  0xE1, 0xE0, 0x7C, 0x3C, 0x0D, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x1C, 0x00,
  0x0E, 0x00, 0xF0, 0x70, 0x0C, 0x07, 0x01, 0xC0, 0x30, 0x38, 0x03, 0x87,
  0x00, 0x38, 0x70, 0x01, 0x8E, 0x00, 0x1D, 0xC0, 0x00, 0xD8, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x03,
  0xB8, 0x00, 0x71, 0x80, 0x06, 0x1C, 0x00, 0xE0, 0xC0, 0x1C, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x06, 0x07, 0x00, 0x70, 0xE0, 0x07, 0x00, 0xC0, 0x07,
  0xE0, 0x0E, 0xE0, 0x0C, 0x60, 0x1C, 0x70, 0x38, 0x70, 0x30, 0x30, 0x70,
  0x38, 0x60, 0x38, 0xE0, 0x19, 0xC0, 0x1D, 0x80, 0x1F, 0x80, 0x0F, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0x87, 0xFF,
  0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0xFF, 0xE3, 0xFF, 0xF0, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00,
  0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00,
  0xE0, 0x0E, 0x00, 0xFF, 0x0F, 0xF0, 0xFE, 0x00, 0xE0, 0x18, 0x06, 0x01,
  0xC0, 0x70, 0x1C, 0x03, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0x80, 0x60, 0x1C,
  0x07, 0x00, 0xC0, 0x30, 0x0E, 0x03, 0x80, 0xE0, 0x18, 0x06, 0x01, 0xC0,
  0x70, 0x0C, 0x03, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0x80, 0x60, 0x1C, 0x07,
  0xF0, 0xFF, 0x0F, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x30, 0x03, 0x00, 0x70, 0xFF, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xC0,
  0x07, 0x80, 0x36, 0x01, 0xD8, 0x06, 0x70, 0x38, 0xC0, 0xC3, 0x06, 0x0C,
  0x38, 0x38, 0xC0, 0x67, 0x01, 0xB8, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0xE3,
  0x1C, 0x70, 0x03, 0xC7, 0x0F, 0xF6, 0x1E, 0x36, 0x38, 0x1E, 0x38, 0x0E,
  0x30, 0x0E, 0x70, 0x0E, 0x70, 0x0C, 0x70, 0x0C, 0x60, 0x0C, 0x60, 0x1C,
  0x60, 0x1C, 0xE0, 0x1C, 0xE0, 0x18, 0x60, 0x38, 0x70, 0x58, 0x7F, 0xF8,
  0x3F, 0xB8, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07,
  0x1E, 0x0E, 0xFF, 0x1F, 0x1E, 0x3C, 0x0E, 0x70, 0x1C, 0xC0, 0x39, 0x80,
  0x77, 0x00, 0xEE, 0x01, 0x9C, 0x03, 0x30, 0x0E, 0x60, 0x1C, 0xC0, 0x3B,
  0x80, 0x67, 0x01, 0xCF, 0x07, 0x1B, 0xFE, 0x33, 0xF0, 0x00, 0x03, 0xF0,
  0x1F, 0xF0, 0x7C, 0xF1, 0xE0, 0x73, 0x80, 0xE6, 0x01, 0xDC, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x01, 0xDC, 0x03,
  0x98, 0x0E, 0x38, 0x38, 0x3F, 0xF0, 0x3F, 0x80, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x03, 0xC7, 0x0F, 0xF6, 0x1E, 0x36,
  0x38, 0x1E, 0x38, 0x0E, 0x30, 0x0E, 0x70, 0x0E, 0x70, 0x0C, 0x70, 0x0C,
  0x60, 0x0C, 0x60, 0x1C, 0x60, 0x1C, 0xE0, 0x1C, 0xE0, 0x18, 0x60, 0x38,
  0x70, 0x58, 0x7F, 0xF8, 0x3F, 0xB8, 0x03, 0xF0, 0x1F, 0xF0, 0x78, 0xF0,
  0xC0, 0x63, 0x80, 0xE6, 0x01, 0xDC, 0x03, 0xB8, 0x06, 0x7F, 0xFC, 0xFF,
  0xF9, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x0E, 0x38, 0x3C,
  0x3F, 0xF0, 0x3F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x01, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE7, 0x0F,
  0xF6, 0x1E, 0x36, 0x38, 0x1E, 0x38, 0x0E, 0x30, 0x0E, 0x70, 0x0E, 0x70,
  0x0C, 0x70, 0x0C, 0x70, 0x0C, 0x60, 0x1C, 0x60, 0x1C, 0x60, 0x1C, 0x70,
  0x38, 0x7C, 0xD8, 0x3F, 0xD8, 0x1F, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x70, 0x7F, 0xE0, 0x7F, 0xC0, 0x7F, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x3E, 0x0E, 0xFF, 0x1F, 0x1E,
  0x3C, 0x0E, 0x70, 0x1C, 0xC0, 0x39, 0x80, 0x77, 0x00, 0xCE, 0x01, 0x9C,
  0x03, 0x30, 0x0E, 0x60, 0x1C, 0xC0, 0x3B, 0x80, 0x67, 0x00, 0xCE, 0x01,
  0x98, 0x07, 0x30, 0x0E, 0x00, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x1C, 0x07, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x1C, 0xE0,
  0x1C, 0x70, 0x1C, 0x38, 0x1C, 0x18, 0x1C, 0x0C, 0x1C, 0x06, 0x1C, 0x07,
  0x1E, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xE3, 0x80, 0x60, 0xE0, 0x30, 0x70,
  0x38, 0x1C, 0x1C, 0x0E, 0x0E, 0x03, 0x87, 0x01, 0xC3, 0x00, 0x70, 0x7F,
  0x87, 0xF8, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0,
  0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x07, 0xFC, 0x1F,
  0xE0, 0x1B, 0x8F, 0x1F, 0xEF, 0x8E, 0x34, 0xE7, 0x1C, 0x73, 0x0C, 0x39,
  0x86, 0x1C, 0xC3, 0x0C, 0xE1, 0x86, 0x70, 0xC3, 0x38, 0xE1, 0x98, 0x61,
  0xCC, 0x30, 0xE6, 0x18, 0x67, 0x0C, 0x33, 0x86, 0x19, 0xC3, 0x0C, 0xC3,
  0x8E, 0x61, 0x87, 0x00, 0x39, 0xF0, 0x77, 0xF8, 0xF8, 0xF1, 0xE0, 0x73,
  0x80, 0xE6, 0x01, 0xCC, 0x03, 0xB8, 0x06, 0x70, 0x0C, 0xE0, 0x19, 0x80,
  0x73, 0x00, 0xE6, 0x01, 0xDC, 0x03, 0x38, 0x06, 0x70, 0x0C, 0xC0, 0x39,
  0x80, 0x70, 0x03, 0xF0, 0x1F, 0xF0, 0x7C, 0xF1, 0xC0, 0x63, 0x80, 0xE6,
  0x01, 0xDC, 0x03, 0xB8, 0x07, 0x70, 0x0C, 0xC0, 0x19, 0x80, 0x73, 0x00,
  0xEE, 0x01, 0xDC, 0x03, 0x18, 0x0E, 0x38, 0x38, 0x3F, 0xE0, 0x3F, 0x80,
  0x1C, 0x78, 0x1D, 0xFE, 0x1F, 0x1E, 0x1E, 0x07, 0x1C, 0x07, 0x18, 0x07,
  0x18, 0x07, 0x38, 0x07, 0x38, 0x06, 0x38, 0x06, 0x30, 0x0E, 0x30, 0x0E,
  0x30, 0x0E, 0x70, 0x0C, 0x78, 0x1C, 0x78, 0x38, 0x6F, 0xF8, 0x67, 0xE0,
  0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00,
  0x03, 0xC6, 0x1F, 0xEC, 0x78, 0xD9, 0xC0, 0xF3, 0x80, 0xE6, 0x01, 0xDC,
  0x03, 0xB8, 0x06, 0x70, 0x0C, 0xC0, 0x39, 0x80, 0x73, 0x00, 0xEE, 0x01,
  0xDC, 0x03, 0x38, 0x0E, 0x38, 0x2C, 0x7F, 0xF8, 0x7E, 0x70, 0x00, 0xE0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x1C, 0xF8, 0x1B,
  0xFC, 0x1B, 0x1E, 0x1C, 0x0E, 0x38, 0x06, 0x38, 0x06, 0x38, 0x06, 0x30,
  0x06, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x03, 0xF0, 0x1F,
  0xF8, 0x78, 0x79, 0xC0, 0x73, 0x80, 0xE6, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x1F, 0xE0, 0x0F, 0xF0, 0x01, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xB8,
  0x06, 0x78, 0x1C, 0x7F, 0xF0, 0x7F, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C,
  0x00, 0x38, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0x00, 0x06, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0x38, 0x07, 0x38, 0x06, 0x38, 0x06, 0x30, 0x06, 0x30, 0x0E, 0x30,
  0x0E, 0x70, 0x0E, 0x70, 0x0C, 0x70, 0x0C, 0x70, 0x0C, 0x60, 0x1C, 0x60,
  0x1C, 0x60, 0x1C, 0x60, 0x18, 0x60, 0x38, 0x70, 0x70, 0x3F, 0xE0, 0x1F,
  0xC0, 0xE0, 0x07, 0x60, 0x0E, 0x60, 0x0E, 0x60, 0x1C, 0x70, 0x1C, 0x70,
  0x38, 0x70, 0x38, 0x30, 0x70, 0x30, 0x70, 0x30, 0x60, 0x38, 0xE0, 0x38,
  0xC0, 0x19, 0xC0, 0x19, 0x80, 0x1B, 0x80, 0x1B, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0xC1, 0x83, 0xC3, 0x83, 0xC3, 0x87, 0xC2, 0x86, 0xC6, 0x86, 0xC6,
  0x86, 0xC4, 0x8C, 0xCC, 0x8C, 0xCC, 0x8C, 0xC8, 0x98, 0xD8, 0x98, 0xD8,
  0x98, 0xD0, 0xB0, 0xF0, 0xB0, 0xF0, 0xB0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0x1C, 0x03, 0x8E, 0x03, 0x83, 0x81, 0xC1, 0xC1, 0xC0, 0x71, 0xC0,
  0x39, 0xC0, 0x0C, 0xC0, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF8,
  0x00, 0xEC, 0x00, 0xE7, 0x00, 0xE1, 0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x70,
  0x1C, 0x70, 0x07, 0x00, 0x38, 0x06, 0x70, 0x0C, 0xE0, 0x19, 0x80, 0x73,
  0x00, 0xE6, 0x01, 0xDC, 0x03, 0xB8, 0x06, 0x70, 0x0C, 0xE0, 0x39, 0x80,
  0x73, 0x00, 0xE6, 0x01, 0xCE, 0x07, 0x1F, 0x76, 0x1F, 0xCC, 0x0E, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F,
  0x80, 0x1F, 0xFE, 0x7F, 0xFC, 0xFF, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xFF, 0xF9, 0xFF, 0xF0, 0x00,
  0x03, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01,
  0xC0, 0x01, 0x80, 0xFF, 0x80, 0xFC, 0x00, 0xFF, 0x00, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0xF0, 0x03, 0xF0, 0x00,
  0x20, 0x07, 0x06, 0x06, 0x06, 0x0E, 0x0E, 0x0E, 0x0E, 0x0C, 0x0C, 0x0C,
  0x1C, 0x1C, 0x1C, 0x18, 0x18, 0x18, 0x38, 0x38, 0x38, 0x38, 0x30, 0x30,
  0x70, 0x70, 0x70, 0x70, 0x60, 0x60, 0x60, 0xE0, 0x06, 0x00, 0x0F, 0xC0,
  0x0F, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x00, 0xFF, 0x00, 0x3F, 0x01, 0xFF, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0xC0, 0x00, 0x3F, 0x07,
  0x7F, 0x87, 0x63, 0x86, 0xE1, 0xCE, 0xE0, 0xFC, 0xE0, 0x78,
};

const GFXglyph JetBrainsMono_LightItalic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 7, 23, 19, 6, -23 },
  { 22, 11, 9, 19, 6, -23 },
  { 35, 18, 23, 19, 1, -23 },
  { 87, 16, 32, 19, 2, -28 },
  { 151, 22, 24, 19, -1, -24 },
  { 217, 17, 24, 19, 1, -24 },
  { 268, 4, 9, 19, 9, -23 },
  { 273, 13, 31, 19, 5, -27 },
  { 324, 13, 31, 19, 2, -27 },
  { 375, 17, 17, 19, 2, -20 },
  { 412, 16, 15, 19, 2, -18 },
  { 442, 8, 10, 19, 3, -5 },
  { 452, 10, 3, 19, 5, -12 },
  { 456, 5, 5, 19, 6, -5 },
  { 460, 18, 31, 19, 1, -27 },
  { 530, 16, 24, 19, 2, -24 },
  { 578, 14, 23, 19, 2, -23 },
  { 619, 16, 24, 19, 2, -24 },
  { 667, 16, 23, 19, 2, -23 },
  { 713, 15, 23, 19, 2, -23 },
  { 757, 16, 23, 19, 2, -23 },
  { 803, 15, 23, 19, 2, -23 },
  { 847, 15, 23, 19, 4, -23 },
  { 891, 16, 24, 19, 2, -24 },
  { 939, 15, 24, 19, 3, -24 },
  { 984, 7, 18, 19, 6, -18 },
  { 1000, 10, 23, 19, 3, -18 },
  { 1029, 15, 17, 19, 3, -19 },
  { 1061, 15, 9, 19, 2, -15 },
  { 1078, 15, 17, 19, 2, -19 },
  { 1110, 12, 23, 19, 5, -23 },
  { 1145, 19, 30, 19, 0, -24 },
  { 1217, 16, 23, 19, 0, -23 },
  { 1263, 16, 23, 19, 2, -23 },
  { 1309, 16, 24, 19, 2, -24 },
  { 1357, 16, 23, 19, 2, -23 },
  { 1403, 17, 23, 19, 2, -23 },
  { 1452, 17, 23, 19, 2, -23 },
  { 1501, 16, 24, 19, 2, -24 },
  { 1549, 16, 23, 19, 2, -23 },
  { 1595, 16, 23, 19, 2, -23 },
  { 1641, 17, 23, 19, 1, -23 },
  { 1690, 18, 23, 19, 2, -23 },
  { 1742, 14, 23, 19, 2, -23 },
  { 1783, 18, 23, 19, 1, -23 },
  { 1835, 16, 23, 19, 2, -23 },
  { 1881, 16, 24, 19, 2, -24 },
  { 1929, 17, 23, 19, 2, -23 },
  { 1978, 16, 30, 19, 2, -24 },
  { 2038, 17, 23, 19, 2, -23 },
  { 2087, 16, 24, 19, 2, -24 },
  { 2135, 16, 23, 19, 4, -23 },
  { 2181, 16, 23, 19, 2, -23 },
  { 2227, 16, 23, 19, 4, -23 },
  { 2273, 19, 23, 19, 2, -23 },
  { 2328, 20, 23, 19, 0, -23 },
  { 2386, 16, 23, 19, 4, -23 },
  { 2432, 17, 23, 19, 1, -23 },
  { 2481, 12, 31, 19, 5, -27 },
  { 2528, 10, 31, 19, 5, -27 },
  { 2567, 12, 31, 19, 3, -27 },
  { 2614, 14, 12, 19, 3, -23 },
  { 2635, 16, 2, 19, 0, 1 },
  { 2639, 5, 4, 19, 9, -25 },
  { 2642, 16, 18, 19, 2, -18 },
  { 2678, 15, 23, 19, 2, -23 },
  { 2722, 15, 18, 19, 2, -18 },
  { 2756, 16, 23, 19, 2, -23 },
  { 2802, 15, 18, 19, 2, -18 },
  { 2836, 21, 29, 19, -1, -23 },
  { 2913, 16, 24, 19, 2, -18 },
  { 2961, 15, 23, 19, 2, -23 },
  { 3005, 15, 25, 19, 1, -25 },
  { 3052, 17, 31, 19, 0, -25 },
  { 3118, 17, 23, 19, 2, -23 },
  { 3167, 13, 23, 19, 3, -23 },
  { 3205, 17, 18, 19, 1, -18 },
  { 3244, 15, 18, 19, 2, -18 },
  { 3278, 15, 18, 19, 2, -18 },
  { 3312, 16, 24, 19, 1, -18 },
  { 3360, 15, 24, 19, 2, -18 },
  { 3405, 16, 18, 19, 2, -18 },
  { 3441, 15, 18, 19, 2, -18 },
  { 3475, 15, 22, 19, 3, -22 },
  { 3517, 16, 18, 19, 2, -18 },
  { 3553, 16, 18, 19, 3, -18 },
  { 3589, 16, 18, 19, 3, -18 },
  { 3625, 17, 18, 19, 1, -18 },
  { 3664, 15, 24, 19, 2, -18 },
  { 3709, 15, 18, 19, 2, -18 },
  { 3743, 16, 31, 19, 3, -27 },
  { 3805, 8, 31, 19, 6, -27 },
  { 3836, 16, 31, 19, 1, -27 },
  { 3898, 16, 6, 19, 2, -14 },
};

const GFXfont JetBrainsMono_LightItalic32pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_LightItalic32pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_LightItalic32pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _JETBRAINSMONO_LIGHTITALIC32PT7B_H_
