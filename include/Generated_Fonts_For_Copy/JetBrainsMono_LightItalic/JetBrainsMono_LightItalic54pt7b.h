#ifndef _JETBRAINSMONO_LIGHTITALIC54PT7B_H_
#define _JETBRAINSMONO_LIGHTITALIC54PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-LightItalic.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_LightItalic54pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F,
  0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0xC0, 0xFE, 0x0F,
  0xF0, 0x3F, 0x81, 0xF8, 0x00, 0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x78,
  0xF0, 0x1E, 0x7C, 0x0F, 0x9F, 0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x3C, 0x78,
  0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0E, 0x3C, 0x07,
  0x8F, 0x01, 0xE3, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x07, 0x80, 0x38, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x07, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x1E, 0x01,
  0xE1, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x78, 0x03, 0x80, 0x00, 0x78, 0x07,
  0x80, 0x00, 0x70, 0x07, 0x80, 0x00, 0xF0, 0x07, 0x00, 0x00, 0xE0, 0x0F,
  0x00, 0x00, 0xE0, 0x0F, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x01, 0xC0, 0x1E,
  0x00, 0x03, 0xC0, 0x1E, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x70, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0xE0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1C, 0x01, 0xE0,
  0x00, 0x3C, 0x01, 0xC0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x38, 0x03, 0xC0,
  0x00, 0x78, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0x9C, 0xFC, 0x03,
  0xE1, 0xC3, 0xE0, 0x3C, 0x1C, 0x3E, 0x07, 0xC1, 0xC1, 0xE0, 0x78, 0x1C,
  0x1E, 0x07, 0x83, 0x81, 0xE0, 0xF8, 0x38, 0x1E, 0x0F, 0x83, 0x80, 0x00,
  0xF8, 0x38, 0x00, 0x0F, 0x83, 0x80, 0x00, 0x7C, 0x38, 0x00, 0x07, 0xC7,
  0x00, 0x00, 0x7F, 0x70, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0E, 0x7F, 0x00, 0x00, 0xE1, 0xF0, 0x00, 0x0E, 0x0F,
  0x00, 0x00, 0xE0, 0xF8, 0x00, 0x0E, 0x0F, 0x80, 0x01, 0xC0, 0xF8, 0x00,
  0x1C, 0x0F, 0x8F, 0x81, 0xC0, 0xF0, 0xF8, 0x1C, 0x0F, 0x0F, 0x81, 0xC1,
  0xF0, 0xF8, 0x1C, 0x1E, 0x07, 0xC3, 0x83, 0xE0, 0x7E, 0x38, 0x7C, 0x07,
  0xFB, 0xBF, 0x80, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x03, 0xC0, 0x3F, 0xFC, 0x00, 0x3C, 0x03, 0xFF, 0xE0, 0x03,
  0xC0, 0x1E, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x3C, 0x01, 0xC0, 0x0F, 0x01,
  0xE0, 0x1C, 0x00, 0x70, 0x0F, 0x01, 0xE0, 0x03, 0x80, 0x70, 0x1E, 0x00,
  0x1C, 0x03, 0x81, 0xE0, 0x01, 0xE0, 0x1C, 0x1E, 0x00, 0x0F, 0x01, 0xE0,
  0xE0, 0x00, 0x78, 0x0F, 0x0E, 0x00, 0x03, 0xC0, 0x70, 0xF0, 0x00, 0x1F,
  0x0F, 0x8F, 0x00, 0x00, 0x7F, 0xF8, 0xF0, 0x00, 0x03, 0xFF, 0x8F, 0x00,
  0x00, 0x07, 0xF8, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0x78, 0x7F, 0xC0, 0x00, 0x03, 0x8F,
  0xFF, 0x00, 0x00, 0x38, 0xFF, 0xF8, 0x00, 0x03, 0xC7, 0x81, 0xE0, 0x00,
  0x3C, 0x78, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x78, 0x00, 0x3C, 0x1C, 0x03,
  0xC0, 0x03, 0xC0, 0xE0, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0xE0, 0x01, 0xC0,
  0x78, 0x07, 0x00, 0x1E, 0x03, 0xC0, 0x78, 0x01, 0xE0, 0x1E, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0x07, 0xC3, 0xE0, 0x0E, 0x00, 0x1F,
  0xFE, 0x00, 0xE0, 0x00, 0x7F, 0xE0, 0x1F, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x7C, 0x0F, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xDF, 0x00, 0x04, 0x7C, 0x3E, 0x01, 0xE1, 0xE0, 0xF8,
  0x0F, 0x0F, 0x81, 0xF0, 0x7C, 0x3C, 0x07, 0xC1, 0xE0, 0xF0, 0x0F, 0x8F,
  0x03, 0xC0, 0x1E, 0x7C, 0x0F, 0x00, 0x7F, 0xE0, 0x3C, 0x00, 0xFF, 0x01,
  0xF0, 0x03, 0xF8, 0x07, 0xC0, 0x07, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x7E, 0x01, 0xE0, 0x03, 0xF8, 0x07, 0xC0, 0x1F, 0xF0, 0x1F, 0x00,
  0xFB, 0xE0, 0x7F, 0x1F, 0xCF, 0x80, 0xFF, 0xFE, 0x1F, 0x01, 0xFF, 0xE0,
  0x3C, 0x03, 0xFF, 0x00, 0xF8, 0x01, 0x80, 0x00, 0x00, 0x3E, 0x7C, 0xF9,
  0xF3, 0xE7, 0x9F, 0x3E, 0x7C, 0xF9, 0xE3, 0xC7, 0x8F, 0x1C, 0x78, 0x00,
  0x00, 0x04, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80,
  0x01, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8,
  0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x3C, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x30, 0x07, 0x80, 0x37, 0xE0,
  0x70, 0x1F, 0x7F, 0x87, 0x0F, 0xFF, 0xFC, 0x73, 0xFF, 0x3F, 0xF6, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1F, 0x3E,
  0x00, 0x03, 0xE1, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0xC1, 0xF8, 0x01,
  0xF8, 0x0F, 0x80, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0xC0, 0x1C, 0x00,
  0x30, 0x00, 0x80, 0x02, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80,
  0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x01,
  0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x3F, 0x3F, 0x9F,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFC, 0xFC, 0x18, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x01, 0xF8,
  0x0F, 0xC0, 0x3E, 0x00, 0x7E, 0x07, 0xC0, 0x03, 0xE0, 0x78, 0x00, 0x3E,
  0x0F, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x1E, 0x1F, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x03,
  0xE1, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0xF0, 0x3C, 0x3E,
  0x1F, 0x83, 0xC3, 0xE1, 0xF8, 0x7C, 0x3C, 0x1F, 0x87, 0xC3, 0xC1, 0xF8,
  0x78, 0x3C, 0x0F, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x87,
  0xC0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x87, 0x80, 0x00, 0xF8, 0x78, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xF0,
  0x78, 0x00, 0x1E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x07, 0xE0,
  0x0F, 0xC0, 0x3F, 0x87, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFC, 0xF0, 0x03,
  0xF8, 0xF0, 0x07, 0xE0, 0xF0, 0x07, 0xC1, 0xF0, 0x07, 0x01, 0xF0, 0x0E,
  0x01, 0xE0, 0x08, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xC0,
  0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0xFC, 0x07, 0xC0,
  0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x3C, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x00,
  0x3C, 0x3E, 0x00, 0x07, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3C, 0x0F,
  0x80, 0x0F, 0x81, 0xF8, 0x07, 0xE0, 0x1F, 0xE3, 0xF8, 0x03, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x0F, 0x03, 0xE0, 0x07, 0x81, 0xF0, 0x07, 0xC1, 0xF0,
  0x03, 0xE1, 0xF0, 0x01, 0xE1, 0xF0, 0x00, 0xF1, 0xF0, 0x00, 0x78, 0xF0,
  0x00, 0x3C, 0x78, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC3, 0xF8, 0x01, 0xE3,
  0xFF, 0x80, 0x7B, 0xFF, 0xF0, 0x1E, 0xFF, 0xFE, 0x07, 0xF0, 0x1F, 0x81,
  0xF8, 0x03, 0xE0, 0xFC, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x8F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x7C,
  0x3E, 0x00, 0x3E, 0x0F, 0xC0, 0x1F, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x3F, 0xC0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0x0F,
  0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x00, 0x1F, 0x8F, 0x80, 0x03, 0xE3, 0xC0,
  0x00, 0xF9, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xEF,
  0x80, 0x00, 0x7B, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03,
  0xCF, 0x80, 0x00, 0xF3, 0xE0, 0x00, 0x7C, 0x78, 0x00, 0x3E, 0x1F, 0x00,
  0x1F, 0x07, 0xE0, 0x0F, 0xC0, 0xFE, 0x1F, 0xE0, 0x1F, 0xFF, 0xF0, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x7F, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0xF8, 0x00,
  0x0F, 0xBE, 0x00, 0x03, 0xCF, 0x80, 0x01, 0xF3, 0xC0, 0x00, 0xF8, 0xF0,
  0x00, 0x3C, 0x3C, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x0F,
  0x80, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xE0, 0xF0,
  0x00, 0x7C, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x7C,
  0x0F, 0x00, 0x0F, 0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xF0,
  0x7E, 0x00, 0x3F, 0xBF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xF7, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x7C, 0x03,
  0xF0, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0xF0, 0x00, 0x3C, 0x3E,
  0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x03,
  0xC7, 0xC0, 0x00, 0x78, 0xF8, 0x00, 0x1F, 0x0F, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0xF8, 0x3F, 0x00, 0x7E, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x07, 0xE0, 0x3F, 0x03, 0xE0, 0x07, 0xE1, 0xF0, 0x00, 0xF8, 0x78, 0x00,
  0x1E, 0x3E, 0x00, 0x07, 0xCF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7D, 0xE0,
  0x00, 0x1F, 0x78, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x79,
  0xE0, 0x00, 0x3E, 0x78, 0x00, 0x0F, 0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x03,
  0xF1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0xFE, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xF7, 0x80, 0x3F, 0xFB, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x3F,
  0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0x80, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x7F, 0x07, 0xFC, 0x3F, 0xE1, 0xFE, 0x0F, 0xF0, 0x3F, 0x00, 0x60, 0x00,
  0x00, 0x3E, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF0, 0x07,
  0xF8, 0x03, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x00, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0x08, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x01,
  0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xEF, 0xF8, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x3C, 0x03,
  0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x1E, 0x1E, 0x00, 0x7F, 0x1E, 0x1E, 0x00, 0xFF, 0x9E, 0x1E,
  0x01, 0xFF, 0xDC, 0x1E, 0x03, 0xE0, 0xFC, 0x1E, 0x03, 0xC0, 0x7C, 0x1C,
  0x07, 0x80, 0x3C, 0x3C, 0x07, 0x80, 0x3C, 0x3C, 0x07, 0x00, 0x3C, 0x3C,
  0x0F, 0x00, 0x38, 0x3C, 0x0F, 0x00, 0x78, 0x3C, 0x0F, 0x00, 0x78, 0x3C,
  0x0F, 0x00, 0x78, 0x78, 0x0F, 0x00, 0x78, 0x78, 0x0F, 0x00, 0x78, 0x78,
  0x1E, 0x00, 0x70, 0x78, 0x1E, 0x00, 0xF0, 0x78, 0x1E, 0x00, 0xF0, 0x78,
  0x1E, 0x00, 0xF0, 0x70, 0x1F, 0x01, 0xF0, 0xF0, 0x0F, 0x87, 0xF0, 0xF0,
  0x0F, 0xFE, 0xF0, 0xF0, 0x07, 0xFC, 0xE0, 0xF0, 0x03, 0xF0, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x79, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x9E, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0xF1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x87,
  0x80, 0x03, 0xC1, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x0F, 0x00, 0x1E,
  0x03, 0xC0, 0x0F, 0x80, 0xF0, 0x03, 0xC0, 0x3C, 0x01, 0xF0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x0F,
  0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0x00,
  0x07, 0x83, 0xC0, 0x01, 0xE1, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x3E,
  0x00, 0x07, 0x8F, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x0F,
  0x78, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3C, 0x03, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x3C, 0x07, 0xFC,
  0x07, 0xC0, 0x0F, 0xC0, 0x78, 0x00, 0x3E, 0x07, 0x80, 0x03, 0xE0, 0x78,
  0x00, 0x3E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x0F, 0x80, 0x03,
  0xE0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x7C, 0x0F,
  0x00, 0x0F, 0x80, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0xFE, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1E, 0x01, 0xFE, 0x01,
  0xE0, 0x03, 0xF0, 0x1E, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x3C, 0x00,
  0x0F, 0x83, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x78,
  0x3C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80,
  0x01, 0xF0, 0x78, 0x00, 0x3E, 0x07, 0x80, 0x07, 0xE0, 0x78, 0x01, 0xFC,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x81,
  0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x78, 0x7C, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87,
  0x80, 0x01, 0xF0, 0xF8, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x03,
  0xE0, 0x3E, 0x00, 0xFC, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x03, 0xE0, 0x7F, 0xC0,
  0x7C, 0x00, 0xFC, 0x0F, 0x00, 0x0F, 0x81, 0xE0, 0x01, 0xF0, 0x3C, 0x00,
  0x1E, 0x07, 0x80, 0x03, 0xE0, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87,
  0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0xF0, 0x78, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF0, 0x78,
  0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x1F,
  0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07, 0x80,
  0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xF0,
  0xF8, 0x00, 0x3C, 0x1F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xF0, 0x78, 0x00,
  0x7C, 0x0F, 0x00, 0x1F, 0x01, 0xE0, 0x0F, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x1F, 0x81, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x1E, 0x0F, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x78, 0x7C, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0xFF, 0xF8, 0x78, 0x1F, 0xFE, 0x1F, 0x03, 0xFF, 0xC3,
  0xE0, 0xFF, 0xF8, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xE1, 0xE0, 0x00,
  0x7C, 0x3C, 0x00, 0x0F, 0x0F, 0x80, 0x01, 0xE1, 0xF0, 0x00, 0x3C, 0x3C,
  0x00, 0x07, 0x87, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x3C, 0x1F, 0x00, 0x0F,
  0x83, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0xFC, 0x07, 0xF8, 0xFF, 0x00, 0x7F,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x1F, 0x03, 0xC0, 0x01, 0xF0,
  0x3C, 0x00, 0x1E, 0x07, 0xC0, 0x01, 0xE0, 0x7C, 0x00, 0x1E, 0x07, 0x80,
  0x01, 0xE0, 0x78, 0x00, 0x3E, 0x07, 0x80, 0x03, 0xE0, 0x78, 0x00, 0x3C,
  0x0F, 0x80, 0x03, 0xC0, 0xF8, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x3C, 0x0F, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x78, 0x1F, 0x00, 0x07,
  0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x81, 0xE0, 0x00, 0xF8, 0x1E, 0x00, 0x0F, 0x03, 0xE0, 0x00,
  0xF0, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x1F, 0x03,
  0xC0, 0x01, 0xF0, 0x3C, 0x00, 0x1E, 0x07, 0xC0, 0x01, 0xE0, 0x7C, 0x00,
  0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x3E, 0x07, 0x80, 0x03, 0xE0,
  0x78, 0x00, 0x3C, 0x0F, 0x80, 0x03, 0xC0, 0xF8, 0x00, 0x3C, 0x0F, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x03,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF8, 0x3C, 0x00,
  0x07, 0xC1, 0xE0, 0x00, 0x3C, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x1E,
  0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0x7F, 0x87, 0xF0, 0x01,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x03, 0xE0, 0x3C, 0x00,
  0x0F, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x1E, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x7C, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x03, 0xE0, 0x0F, 0x00, 0x0F,
  0x00, 0x7C, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xC0,
  0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0x80,
  0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x3C, 0x01, 0xF0, 0x00,
  0xF0, 0x07, 0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x1E, 0x00,
  0x1F, 0x00, 0x78, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0xF8, 0x07, 0x80, 0x03,
  0xE0, 0x3E, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x7C,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xF0,
  0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xF0, 0x3F, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0xFE, 0x07, 0xF8, 0x03, 0xB8, 0x1F, 0xE0, 0x1E, 0xE0, 0x7B, 0x80, 0x77,
  0x81, 0xCE, 0x03, 0xDE, 0x07, 0x38, 0x0E, 0x78, 0x1C, 0xF0, 0x79, 0xC0,
  0xF3, 0xC1, 0xCF, 0x03, 0xC7, 0x0F, 0x3C, 0x0F, 0x1C, 0x38, 0xF0, 0x3C,
  0x71, 0xE3, 0xC0, 0xF1, 0xC7, 0x0F, 0x03, 0xC7, 0xBC, 0x78, 0x1F, 0x1E,
  0xE1, 0xE0, 0x78, 0x3B, 0x87, 0x81, 0xE0, 0xFC, 0x1E, 0x07, 0x83, 0xF0,
  0x78, 0x1E, 0x0F, 0x83, 0xE0, 0x78, 0x3E, 0x0F, 0x81, 0xE0, 0x00, 0x3C,
  0x0F, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xF0,
  0x00, 0x1E, 0x07, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0xF0, 0x3E, 0x00, 0x03,
  0xC0, 0xF8, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0xF0, 0x3F, 0x00, 0x0F, 0x03, 0xF0, 0x00, 0xF0,
  0x7F, 0x80, 0x1F, 0x07, 0xF8, 0x01, 0xE0, 0x7F, 0x80, 0x1E, 0x07, 0xF8,
  0x01, 0xE0, 0x7B, 0x80, 0x1E, 0x07, 0xBC, 0x01, 0xE0, 0xF3, 0xC0, 0x3E,
  0x0F, 0x3C, 0x03, 0xC0, 0xF3, 0xC0, 0x3C, 0x0F, 0x1C, 0x03, 0xC0, 0xF1,
  0xE0, 0x3C, 0x0F, 0x1E, 0x03, 0xC1, 0xF1, 0xE0, 0x7C, 0x1E, 0x1E, 0x07,
  0x81, 0xE0, 0xE0, 0x78, 0x1E, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x78, 0x1E,
  0x0F, 0x07, 0x81, 0xE0, 0x70, 0x78, 0x3E, 0x07, 0x8F, 0x83, 0xC0, 0x78,
  0xF0, 0x3C, 0x07, 0x8F, 0x03, 0xC0, 0x78, 0xF0, 0x3C, 0x03, 0x8F, 0x03,
  0xC0, 0x3C, 0xF0, 0x7C, 0x03, 0xDF, 0x07, 0x80, 0x3D, 0xE0, 0x78, 0x03,
  0xDE, 0x07, 0x80, 0x1D, 0xE0, 0x78, 0x01, 0xFE, 0x07, 0x80, 0x1F, 0xE0,
  0xF8, 0x01, 0xFE, 0x0F, 0x00, 0x1F, 0xC0, 0xF0, 0x00, 0xFC, 0x0F, 0x00,
  0x0F, 0xC0, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xF0, 0x1F, 0x81, 0xF0,
  0x03, 0xE0, 0x78, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x00, 0x07, 0xC3,
  0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x78, 0x00, 0x1F, 0x1E, 0x00, 0x07,
  0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0xF8, 0x00, 0x1E, 0x3E, 0x00,
  0x0F, 0x8F, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C,
  0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0xF1, 0xF0, 0x00, 0x7C,
  0x78, 0x00, 0x1F, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00,
  0x78, 0xF8, 0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x8F, 0x00, 0x03, 0xE3, 0xC0,
  0x00, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1E, 0x0F, 0x80, 0x0F, 0x81,
  0xF0, 0x07, 0xC0, 0x7F, 0x8F, 0xE0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x7F, 0xC0, 0x7C,
  0x00, 0x3F, 0x03, 0xC0, 0x00, 0xF8, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x1F, 0x07, 0x80, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E,
  0x1F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF8, 0x3C,
  0x00, 0x07, 0xC1, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xE0, 0xF8, 0x00,
  0x7E, 0x07, 0x80, 0x1F, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0x80, 0xFC, 0x07,
  0xC0, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0x80, 0x01,
  0xE1, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0xF0,
  0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x1E,
  0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x1F, 0x0F, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x78, 0x7C, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x87, 0x80, 0x01, 0xF1, 0xF0, 0x00,
  0x3C, 0x3E, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x1E,
  0x00, 0x07, 0xC3, 0xC0, 0x00, 0xF8, 0x78, 0x00, 0x1E, 0x0F, 0x80, 0x07,
  0xC1, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x03, 0xFC, 0x7F, 0x80, 0x3F,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x2F, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7C, 0x03, 0xFE, 0x07, 0xC0, 0x07,
  0xE0, 0x78, 0x00, 0x3F, 0x07, 0x80, 0x01, 0xF0, 0x78, 0x00, 0x1F, 0x07,
  0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x0F, 0x80, 0x01, 0xF0, 0xF0, 0x00,
  0x1F, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xE0,
  0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0xC1, 0xF0, 0x03, 0xF8, 0x1F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00,
  0x3E, 0x03, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x3C, 0x03, 0xE0, 0x03, 0xC0,
  0x1E, 0x00, 0x3C, 0x01, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF0,
  0x07, 0xC0, 0x0F, 0x80, 0x78, 0x00, 0xF8, 0x07, 0x80, 0x07, 0x80, 0x78,
  0x00, 0x7C, 0x07, 0x80, 0x07, 0xC0, 0x78, 0x00, 0x3C, 0x0F, 0x80, 0x03,
  0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x00, 0x3E, 0x03, 0xC0, 0x03,
  0xE0, 0x7C, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x0F,
  0x80, 0x01, 0xE0, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xE0, 0x7C,
  0x00, 0x3E, 0x07, 0xE0, 0x07, 0xC0, 0x7F, 0xC7, 0xF8, 0x03, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x87, 0xC0,
  0x01, 0xF0, 0xF8, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0,
  0x78, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00,
  0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07,
  0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0x80, 0x01,
  0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x78,
  0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x1E,
  0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x1F, 0x0F, 0x80,
  0x03, 0xE1, 0xF0, 0x00, 0x78, 0x3E, 0x00, 0x0F, 0x07, 0xC0, 0x03, 0xE0,
  0xF8, 0x00, 0x78, 0x0F, 0x00, 0x1F, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0xC7,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x02, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7B, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0x3E, 0x00, 0x07, 0xC7, 0x80,
  0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x07,
  0x80, 0x07, 0xC1, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0x78, 0x1F, 0x00, 0x3C,
  0x07, 0xC0, 0x0F, 0x01, 0xF0, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0xF8, 0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x07, 0xC0, 0x0F,
  0x01, 0xE0, 0x03, 0xC0, 0xF8, 0x00, 0xF0, 0x3C, 0x00, 0x3E, 0x0F, 0x00,
  0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0xF8, 0x00, 0x1E, 0x3C,
  0x00, 0x07, 0x8F, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x1E,
  0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x78, 0x03,
  0xE0, 0x1E, 0xF0, 0x0F, 0x80, 0x79, 0xE0, 0x1F, 0x00, 0xF3, 0xC0, 0x36,
  0x01, 0xE7, 0x80, 0xEC, 0x07, 0x8F, 0x01, 0xD8, 0x0F, 0x1E, 0x03, 0xF0,
  0x1E, 0x3C, 0x06, 0xE0, 0x3C, 0x78, 0x1D, 0xC0, 0xF0, 0xF0, 0x3B, 0x81,
  0xE1, 0xE0, 0x77, 0x03, 0xC3, 0xC1, 0xCE, 0x07, 0x07, 0x83, 0x9C, 0x1E,
  0x0F, 0x07, 0x38, 0x3C, 0x1E, 0x1C, 0x70, 0x78, 0x3C, 0x38, 0xE1, 0xE0,
  0x78, 0x71, 0xC3, 0xC0, 0xF0, 0xC3, 0x87, 0x81, 0xC3, 0x87, 0x0E, 0x03,
  0x87, 0x0E, 0x3C, 0x07, 0x0E, 0x1C, 0x78, 0x0E, 0x38, 0x38, 0xF0, 0x3C,
  0x70, 0x71, 0xC0, 0x78, 0xE0, 0xE7, 0x80, 0xF1, 0x81, 0xCF, 0x01, 0xE7,
  0x03, 0x9E, 0x03, 0xCE, 0x06, 0x38, 0x07, 0x9C, 0x0C, 0xF0, 0x0F, 0x70,
  0x19, 0xE0, 0x1E, 0xE0, 0x33, 0x80, 0x3D, 0xC0, 0x6F, 0x00, 0x7B, 0x00,
  0xDE, 0x00, 0xFE, 0x03, 0xBC, 0x01, 0xFC, 0x07, 0x70, 0x03, 0xF8, 0x0F,
  0xE0, 0x07, 0x60, 0x1F, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x3E, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x78,
  0x00, 0x0F, 0x80, 0x3E, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0xF0, 0x03, 0xC0, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F, 0x03, 0xE0, 0x00,
  0x07, 0xC1, 0xE0, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x00, 0xF1, 0xF0, 0x00,
  0x00, 0x7C, 0xF0, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x1F, 0x03,
  0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0x80,
  0x3C, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xC0, 0x07, 0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x78, 0x03, 0xE0,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x01, 0xF7, 0x80, 0x00, 0x3E, 0x78, 0x00, 0x03, 0xC7, 0xC0, 0x00,
  0x7C, 0x3C, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0xF0, 0x3E, 0x00, 0x1F, 0x01,
  0xE0, 0x01, 0xE0, 0x1E, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x00,
  0x78, 0x00, 0xF0, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x00, 0x78, 0x1E, 0x00,
  0x07, 0x83, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x3C,
  0xF8, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF,
  0xE0, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x3F, 0xFE, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0,
  0x03, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xEE, 0x00,
  0x03, 0xDE, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x38, 0x00, 0x78, 0x70, 0x00,
  0xF0, 0xF0, 0x03, 0xC1, 0xE0, 0x0F, 0x01, 0xC0, 0x1E, 0x03, 0xC0, 0x78,
  0x07, 0x80, 0xF0, 0x07, 0x03, 0xC0, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00,
  0x3C, 0x78, 0x00, 0x39, 0xF0, 0x00, 0x7B, 0xC0, 0x00, 0xFF, 0x00, 0x01,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xE0, 0xF8, 0x3C, 0x1F, 0x07, 0xC1, 0xE0, 0xF8, 0x3E, 0x00,
  0x7F, 0x87, 0xC0, 0x7F, 0xF9, 0xE0, 0x3F, 0xFE, 0x78, 0x1F, 0xFF, 0xDE,
  0x0F, 0xC0, 0x37, 0x87, 0xE0, 0x07, 0xE1, 0xF0, 0x01, 0xF8, 0x78, 0x00,
  0x3C, 0x3E, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0,
  0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE1,
  0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x8F, 0x80, 0x03,
  0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x80,
  0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0xFC, 0x1F, 0x00, 0x7F, 0x07,
  0xF0, 0xFF, 0x80, 0xFF, 0xFD, 0xE0, 0x3F, 0xFE, 0x78, 0x03, 0xFE, 0x1E,
  0x00, 0x08, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE1, 0xFE,
  0x00, 0xF9, 0xFF, 0xE0, 0x3C, 0xFF, 0xFC, 0x0F, 0x7F, 0xFF, 0x03, 0xF8,
  0x07, 0xE0, 0xFC, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0x87,
  0xC0, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07,
  0x87, 0x80, 0x01, 0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x3C, 0x00,
  0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C,
  0x00, 0x1F, 0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xE1, 0xF0, 0x00, 0xF8,
  0x7C, 0x00, 0x3E, 0x1F, 0x80, 0x1F, 0x07, 0xE0, 0x0F, 0xC3, 0xFE, 0x1F,
  0xE0, 0xFB, 0xFF, 0xF0, 0x3C, 0xFF, 0xF8, 0x0F, 0x0F, 0xF8, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0xFC, 0x03, 0xF0, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0x3C,
  0x3C, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x9E, 0x00, 0x07, 0xCF, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xE7, 0x80, 0x01, 0xF3, 0xE0,
  0x00, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0xFC, 0x1F,
  0xE3, 0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0xF0,
  0xF8, 0x07, 0xFF, 0x9E, 0x01, 0xFF, 0xF3, 0xC0, 0x7F, 0xFF, 0x78, 0x1F,
  0x80, 0x6F, 0x07, 0xE0, 0x07, 0xE0, 0xF8, 0x00, 0xFC, 0x1E, 0x00, 0x0F,
  0x07, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC0,
  0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0,
  0x78, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x7C, 0x00,
  0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07,
  0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x81, 0xF0, 0x07,
  0xF0, 0x3F, 0x87, 0xFC, 0x03, 0xFF, 0xF7, 0x80, 0x7F, 0xFC, 0xF0, 0x03,
  0xFE, 0x1E, 0x00, 0x04, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x1F, 0xC0, 0xFC, 0x03, 0xE0, 0x78, 0x00,
  0xF8, 0x7C, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x1E, 0x00,
  0x07, 0x8F, 0x00, 0x03, 0xCF, 0x80, 0x01, 0xE7, 0xC0, 0x00, 0xF3, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x78,
  0x3E, 0x00, 0x7C, 0x1F, 0xC1, 0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x87, 0xC0, 0x7F, 0xF9, 0xE0, 0x3F, 0xFF, 0x78, 0x1F, 0xFF,
  0xDE, 0x0F, 0xC0, 0x37, 0x87, 0xE0, 0x07, 0xE1, 0xF0, 0x01, 0xF8, 0x78,
  0x00, 0x3C, 0x3E, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0,
  0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0x87, 0x80, 0x01,
  0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87, 0x80,
  0x03, 0xE1, 0xE0, 0x00, 0xF8, 0x78, 0x00, 0x7C, 0x1E, 0x00, 0x1F, 0x07,
  0xC0, 0x0F, 0xC1, 0xF8, 0x0E, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xDF,
  0x00, 0xFF, 0xC7, 0x80, 0x1F, 0xC1, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE1, 0xFE, 0x00, 0xF9, 0xFF, 0xE0, 0x3C, 0xFF,
  0xFC, 0x0F, 0x7C, 0xFF, 0x03, 0xF8, 0x07, 0xE0, 0xFC, 0x00, 0xF8, 0x3E,
  0x00, 0x3E, 0x1F, 0x00, 0x07, 0x87, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0x78,
  0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x03, 0xE3, 0xE0, 0x00,
  0xF8, 0xF8, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0xF0, 0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0x87,
  0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x0F,
  0x87, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x3C, 0x3C, 0x00,
  0x0F, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x1F, 0x07, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x7E,
  0x0F, 0x80, 0x07, 0xC0, 0xF0, 0x00, 0xF8, 0x0F, 0x00, 0x1F, 0x00, 0xF0,
  0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x01, 0xF8,
  0x01, 0xE0, 0x1F, 0x00, 0x1E, 0x03, 0xE0, 0x01, 0xE0, 0x7C, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF8,
  0x00, 0x3C, 0x07, 0xC0, 0x03, 0xC0, 0x7C, 0x00, 0x3C, 0x03, 0xE0, 0x03,
  0xC0, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x00,
  0xF8, 0x07, 0x80, 0x0F, 0x80, 0x78, 0x00, 0x7C, 0x07, 0x80, 0x07, 0xC0,
  0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xF0, 0x00, 0x1F, 0x00, 0xFF,
  0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x07,
  0x9F, 0x87, 0xE0, 0x3D, 0xFE, 0x7F, 0x81, 0xFF, 0xF7, 0xFE, 0x0E, 0x8F,
  0xB1, 0xF0, 0xF8, 0x3E, 0x07, 0x87, 0x80, 0xF0, 0x3C, 0x3C, 0x07, 0x01,
  0xE1, 0xE0, 0x38, 0x0F, 0x0F, 0x03, 0xC0, 0x78, 0x78, 0x1E, 0x07, 0xC7,
  0x80, 0xF0, 0x3C, 0x3C, 0x07, 0x81, 0xE1, 0xE0, 0x38, 0x0F, 0x0F, 0x01,
  0xC0, 0x78, 0x78, 0x1E, 0x03, 0xC3, 0xC0, 0xF0, 0x1E, 0x3E, 0x07, 0x81,
  0xE1, 0xE0, 0x3C, 0x0F, 0x0F, 0x01, 0xC0, 0x78, 0x78, 0x0E, 0x03, 0xC3,
  0xC0, 0x70, 0x1E, 0x1E, 0x07, 0x80, 0xF0, 0xF0, 0x3C, 0x0F, 0x0F, 0x01,
  0xE0, 0x78, 0x78, 0x0F, 0x03, 0xC3, 0xC0, 0x70, 0x1E, 0x1E, 0x03, 0x80,
  0xF0, 0xF0, 0x3C, 0x07, 0x87, 0x81, 0xE0, 0x3C, 0x78, 0x0F, 0x03, 0xC0,
  0x07, 0x87, 0xF8, 0x03, 0xE7, 0xFF, 0x80, 0xFB, 0xFF, 0xF0, 0x3D, 0xF3,
  0xFC, 0x0F, 0xE0, 0x1F, 0x83, 0xF0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x7C,
  0x00, 0x1E, 0x1F, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78,
  0x78, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x00,
  0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0,
  0x01, 0xF0, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87,
  0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x3E, 0x1E, 0x00, 0x0F,
  0x8F, 0x80, 0x03, 0xC3, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00,
  0x0F, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0xFC, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0x7C,
  0x3C, 0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x8F, 0x00, 0x03,
  0xCF, 0x80, 0x01, 0xE7, 0xC0, 0x00, 0xF3, 0xE0, 0x00, 0xF9, 0xE0, 0x00,
  0x7C, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x3E, 0x00,
  0x07, 0x9F, 0x00, 0x07, 0xCF, 0x00, 0x03, 0xE7, 0x80, 0x01, 0xE3, 0xE0,
  0x01, 0xF1, 0xF0, 0x00, 0xF0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x1F,
  0xE3, 0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0x00, 0x00, 0x01, 0xE1, 0xFE, 0x00, 0x3E, 0x7F, 0xF8, 0x03, 0xCF,
  0xFF, 0xC0, 0x3D, 0xFF, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0x3E,
  0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x1E, 0x07, 0xC0, 0x01, 0xE0, 0x78,
  0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01,
  0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x0F,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC1, 0xF0, 0x00,
  0x7C, 0x1F, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x78, 0x1F, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0xF8, 0x1F, 0x80, 0x1F, 0x01, 0xF8, 0x03, 0xE0, 0x3F, 0xE1,
  0xFE, 0x03, 0xEF, 0xFF, 0xC0, 0x3C, 0x7F, 0xF8, 0x03, 0xC3, 0xFE, 0x00,
  0x3C, 0x02, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0x87, 0x80, 0xFF, 0xF3, 0xC0, 0xFF, 0xF9, 0xE0, 0xFF, 0xFE, 0xF0,
  0xFC, 0x03, 0x78, 0xFC, 0x00, 0xFC, 0x7C, 0x00, 0x7E, 0x7C, 0x00, 0x1E,
  0x3E, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xC7, 0x80, 0x03,
  0xE7, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0xF1, 0xE0, 0x00, 0x78, 0xF0, 0x00,
  0x3C, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x9F, 0x00,
  0x07, 0x8F, 0x00, 0x03, 0xC7, 0x80, 0x01, 0xE3, 0xE0, 0x01, 0xF1, 0xF0,
  0x00, 0xF8, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0xFC, 0x1F, 0xC3, 0xDE, 0x07,
  0xFF, 0xEF, 0x03, 0xFF, 0xE7, 0x80, 0x7F, 0xC3, 0xC0, 0x02, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x0F, 0x87, 0xF8, 0x03, 0xE7, 0xFF, 0x80, 0xF3,
  0xFF, 0xF0, 0x3D, 0xF1, 0xFC, 0x0F, 0xE0, 0x1F, 0x83, 0xF0, 0x03, 0xE0,
  0xF8, 0x00, 0x78, 0x7C, 0x00, 0x1E, 0x1F, 0x00, 0x07, 0xC7, 0x80, 0x01,
  0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xC0, 0x0F, 0x83, 0xE0,
  0x01, 0xE0, 0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x78,
  0x78, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0x00,
  0x07, 0xC7, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x1E,
  0x00, 0x07, 0x87, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3C,
  0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00,
  0x3C, 0x3C, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xE1, 0xE0,
  0x00, 0x78, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x03, 0xE3,
  0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3C, 0x3E, 0x00, 0x0F, 0x0F, 0x80, 0x07,
  0xC3, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x07, 0xF0,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00,
  0x04, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xDF, 0x00, 0x03, 0xE7, 0x80, 0x01, 0xE3, 0xC0, 0x01, 0xF1, 0xE0, 0x00,
  0xF0, 0xF0, 0x00, 0xF8, 0x78, 0x00, 0x78, 0x3E, 0x00, 0x7C, 0x0F, 0x00,
  0x3C, 0x07, 0x80, 0x3E, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x1F, 0x00, 0xF0,
  0x0F, 0x00, 0x7C, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x07,
  0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE1, 0xE0, 0x00, 0xF8, 0xF0, 0x00,
  0x3C, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xBC, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0xF0, 0x0F, 0x80, 0x7F, 0x80, 0x7C, 0x07, 0xBC, 0x03, 0xE0, 0x3D,
  0xE0, 0x3F, 0x01, 0xEF, 0x01, 0xF8, 0x0E, 0x78, 0x0D, 0xC0, 0xF3, 0xC0,
  0xEE, 0x07, 0x9E, 0x07, 0x70, 0x38, 0xF0, 0x33, 0x83, 0xC7, 0x83, 0x9C,
  0x1E, 0x3C, 0x1C, 0xE0, 0xE1, 0xE0, 0xE7, 0x0F, 0x0F, 0x0E, 0x38, 0x78,
  0x78, 0x71, 0xC3, 0x83, 0xC3, 0x8E, 0x3C, 0x1E, 0x38, 0x71, 0xE0, 0xF1,
  0xC3, 0x8E, 0x07, 0x8E, 0x1C, 0x70, 0x3C, 0xE0, 0xE7, 0x81, 0xE7, 0x07,
  0x38, 0x0F, 0x38, 0x39, 0xC0, 0x3B, 0x81, 0xDE, 0x01, 0xDC, 0x0E, 0xE0,
  0x0E, 0xE0, 0x77, 0x00, 0x7E, 0x03, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x1F,
  0x80, 0xFC, 0x00, 0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0x3E, 0x00,
  0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x1F,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x3E, 0x00,
  0x00, 0xF8, 0xF0, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x07, 0xBE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xDF,
  0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xC1, 0xE0,
  0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x00, 0x0F, 0x80, 0x3E, 0x00,
  0x3E, 0x00, 0x78, 0x01, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xC0, 0x7C,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x07, 0x8F, 0x80,
  0x03, 0xC7, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0xF8, 0xF0,
  0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x1E,
  0x00, 0x07, 0x8F, 0x00, 0x03, 0xC7, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xF3,
  0xE0, 0x00, 0xF1, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x1E,
  0x3C, 0x00, 0x1F, 0x1E, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0x8F, 0x80, 0x07,
  0xC3, 0xC0, 0x03, 0xE1, 0xF0, 0x03, 0xF0, 0xFC, 0x07, 0xF8, 0x3F, 0xFF,
  0x7C, 0x0F, 0xFF, 0x3C, 0x03, 0xFF, 0x1E, 0x00, 0x7E, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFC, 0x07,
  0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF0, 0x0F, 0x01, 0xF0,
  0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01,
  0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07,
  0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0x01, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x03, 0xC7, 0xFE, 0x00, 0xF3,
  0xFF, 0xC0, 0x3D, 0xF1, 0xF0, 0x1E, 0x78, 0x3E, 0x07, 0xBE, 0x07, 0xC1,
  0xEF, 0x01, 0xF8, 0xFB, 0xC0, 0x3F, 0xFC, 0xF0, 0x07, 0xFE, 0x3C, 0x00,
  0xFE, 0x00,
};

const GFXglyph JetBrainsMono_LightItalic54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 13, 39, 32, 10, -39 },
  { 65, 18, 16, 32, 10, -39 },
  { 101, 32, 39, 32, 1, -39 },
  { 257, 28, 55, 32, 3, -47 },
  { 450, 37, 40, 32, -2, -40 },
  { 635, 30, 41, 32, 1, -40 },
  { 789, 7, 16, 32, 15, -39 },
  { 803, 22, 53, 32, 9, -46 },
  { 949, 22, 53, 32, 3, -46 },
  { 1095, 28, 28, 32, 3, -33 },
  { 1193, 26, 26, 32, 4, -31 },
  { 1278, 14, 17, 32, 5, -8 },
  { 1308, 18, 4, 32, 8, -20 },
  { 1317, 9, 9, 32, 10, -8 },
  { 1328, 32, 51, 32, 1, -45 },
  { 1532, 28, 41, 32, 3, -40 },
  { 1676, 24, 39, 32, 3, -39 },
  { 1793, 27, 40, 32, 3, -40 },
  { 1928, 27, 40, 32, 3, -39 },
  { 2063, 25, 39, 32, 4, -39 },
  { 2185, 26, 40, 32, 4, -39 },
  { 2315, 26, 40, 32, 3, -39 },
  { 2445, 26, 39, 32, 7, -39 },
  { 2572, 27, 41, 32, 3, -40 },
  { 2711, 26, 40, 32, 5, -40 },
  { 2841, 13, 31, 32, 10, -30 },
  { 2892, 17, 39, 32, 6, -30 },
  { 2975, 25, 28, 32, 5, -32 },
  { 3063, 25, 16, 32, 4, -26 },
  { 3113, 26, 28, 32, 3, -32 },
  { 3204, 21, 39, 32, 8, -39 },
  { 3307, 32, 50, 32, 1, -40 },
  { 3507, 26, 39, 32, 1, -39 },
  { 3634, 28, 39, 32, 3, -39 },
  { 3771, 27, 41, 32, 4, -40 },
  { 3910, 27, 39, 32, 3, -39 },
  { 4042, 29, 39, 32, 3, -39 },
  { 4184, 29, 39, 32, 3, -39 },
  { 4326, 27, 41, 32, 4, -40 },
  { 4465, 28, 39, 32, 3, -39 },
  { 4602, 26, 39, 32, 4, -39 },
  { 4729, 29, 40, 32, 1, -39 },
  { 4874, 30, 39, 32, 3, -39 },
  { 5021, 23, 39, 32, 4, -39 },
  { 5134, 30, 39, 32, 2, -39 },
  { 5281, 28, 39, 32, 3, -39 },
  { 5418, 26, 41, 32, 4, -40 },
  { 5552, 29, 39, 32, 3, -39 },
  { 5694, 27, 50, 32, 3, -40 },
  { 5863, 28, 39, 32, 3, -39 },
  { 6000, 28, 41, 32, 3, -40 },
  { 6144, 27, 39, 32, 6, -39 },
  { 6276, 27, 40, 32, 4, -39 },
  { 6411, 26, 39, 32, 7, -39 },
  { 6538, 31, 39, 32, 4, -39 },
  { 6690, 33, 39, 32, 0, -39 },
  { 6851, 28, 39, 32, 6, -39 },
  { 6988, 29, 39, 32, 2, -39 },
  { 7130, 21, 51, 32, 8, -45 },
  { 7264, 16, 51, 32, 9, -45 },
  { 7366, 21, 51, 32, 5, -45 },
  { 7500, 23, 21, 32, 5, -39 },
  { 7561, 27, 4, 32, 0, 1 },
  { 7575, 9, 7, 32, 15, -42 },
  { 7583, 26, 31, 32, 4, -30 },
  { 7684, 26, 40, 32, 3, -39 },
  { 7814, 25, 31, 32, 4, -30 },
  { 7911, 27, 40, 32, 4, -39 },
  { 8046, 25, 31, 32, 4, -30 },
  { 8143, 36, 49, 32, -2, -39 },
  { 8364, 26, 40, 32, 4, -30 },
  { 8494, 26, 39, 32, 3, -39 },
  { 8621, 26, 42, 32, 2, -42 },
  { 8758, 27, 52, 32, 1, -42 },
  { 8934, 28, 39, 32, 3, -39 },
  { 9071, 22, 39, 32, 6, -39 },
  { 9179, 29, 30, 32, 1, -30 },
  { 9288, 26, 30, 32, 3, -30 },
  { 9386, 25, 31, 32, 4, -30 },
  { 9483, 28, 40, 32, 1, -30 },
  { 9623, 25, 40, 32, 4, -30 },
  { 9748, 26, 30, 32, 4, -30 },
  { 9846, 26, 31, 32, 3, -30 },
  { 9947, 25, 38, 32, 5, -38 },
  { 10066, 26, 31, 32, 4, -30 },
  { 10167, 25, 30, 32, 6, -30 },
  { 10261, 29, 30, 32, 4, -30 },
  { 10370, 30, 30, 32, 1, -30 },
  { 10483, 25, 40, 32, 4, -30 },
  { 10608, 26, 30, 32, 3, -30 },
  { 10706, 27, 51, 32, 5, -45 },
  { 10879, 12, 51, 32, 11, -45 },
  { 10956, 27, 51, 32, 2, -45 },
  { 11129, 26, 10, 32, 4, -24 },
};

const GFXfont JetBrainsMono_LightItalic54pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_LightItalic54pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_LightItalic54pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _JETBRAINSMONO_LIGHTITALIC54PT7B_H_
