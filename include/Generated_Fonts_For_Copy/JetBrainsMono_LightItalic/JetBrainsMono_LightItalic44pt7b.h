#ifndef _JETBRAINSMONO_LIGHTITALIC44PT7B_H_
#define _JETBRAINSMONO_LIGHTITALIC44PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-LightItalic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_LightItalic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xF0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x7E, 0x1F, 0x87, 0xE1, 0xF0, 0x3C, 0x1E, 0x78, 0x38, 0xE0, 0xF3, 0xC1,
  0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x0F, 0x38, 0x1C, 0x70, 0x38, 0xE0, 0x71,
  0xC0, 0xE3, 0x83, 0xCE, 0x07, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x01,
  0xC0, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x0E,
  0x03, 0x80, 0x03, 0x00, 0xE0, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x1C, 0x03,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x43, 0x80, 0xE0, 0x01, 0xC0, 0x38,
  0x00, 0x70, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x01, 0x80, 0x03, 0x80,
  0xE0, 0x00, 0xE0, 0x38, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC0, 0x38, 0x0E, 0x00,
  0x1C, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0x38,
  0x00, 0x38, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x01, 0xC0,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xFC, 0x01, 0xFF, 0xFC, 0x07, 0x8C, 0x78, 0x1E, 0x18, 0x70, 0x38, 0x70,
  0xF0, 0xF0, 0xE1, 0xE1, 0xE1, 0xC3, 0xC3, 0xC3, 0x00, 0x07, 0x86, 0x00,
  0x0F, 0x0C, 0x00, 0x1E, 0x18, 0x00, 0x1E, 0x70, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x39, 0xF0, 0x00, 0x71, 0xE0, 0x00, 0xE3, 0xC0, 0x01, 0x83, 0xC0, 0x03,
  0x07, 0x80, 0x06, 0x0E, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x78, 0x70, 0x70,
  0xF0, 0xF0, 0xC3, 0xC1, 0xF1, 0x8F, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x3C, 0x0F, 0xF8, 0x01, 0xE0, 0x7C, 0xF0, 0x07, 0x01, 0xC1, 0xC0, 0x38,
  0x0E, 0x07, 0x01, 0xC0, 0x38, 0x1C, 0x0E, 0x00, 0xE0, 0x70, 0x70, 0x03,
  0x81, 0xC3, 0x80, 0x0E, 0x07, 0x0E, 0x00, 0x38, 0x38, 0x70, 0x00, 0xE0,
  0xE3, 0x80, 0x03, 0xC7, 0x9C, 0x00, 0x0F, 0xFC, 0xE0, 0x00, 0x1F, 0xC7,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x30, 0x00, 0x01, 0xC7, 0xF0, 0x00, 0x0E, 0x3F, 0xE0,
  0x00, 0x71, 0xE3, 0xC0, 0x01, 0xCF, 0x07, 0x00, 0x0E, 0x38, 0x1C, 0x00,
  0x70, 0xE0, 0x70, 0x03, 0x83, 0x81, 0xC0, 0x1C, 0x0E, 0x07, 0x00, 0xE0,
  0x30, 0x18, 0x03, 0x81, 0xC0, 0xE0, 0x1C, 0x07, 0x83, 0x80, 0xE0, 0x0F,
  0xFC, 0x07, 0x00, 0x3F, 0xE0, 0x38, 0x00, 0x3F, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xE0, 0x78,
  0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x1E, 0x78, 0x0F, 0x3C, 0x3C, 0x0E, 0x38, 0x3C, 0x1C, 0x38, 0x1E, 0x3C,
  0x78, 0x1E, 0x78, 0x78, 0x0F, 0x70, 0x78, 0x07, 0xF0, 0x70, 0x07, 0xE0,
  0x70, 0x03, 0xC0, 0x70, 0x03, 0xC0, 0x70, 0x07, 0xE0, 0x70, 0x0F, 0xE0,
  0x78, 0x1E, 0xF0, 0x7F, 0xFC, 0x70, 0x3F, 0xF8, 0x78, 0x1F, 0xE0, 0x3C,
  0x7B, 0xDE, 0xFF, 0x7B, 0xDE, 0xF7, 0x39, 0xCE, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x00, 0x78, 0x00, 0x1F, 0x80, 0x0B, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01,
  0xF8, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x20, 0x1C, 0x02, 0x38, 0x1C, 0x0E, 0x7E,
  0x18, 0x7E, 0xFF, 0x99, 0xFF, 0x3F, 0xDF, 0xF8, 0x07, 0xFF, 0xE0, 0x00,
  0x38, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xCE, 0x00, 0x03,
  0xCF, 0x00, 0x07, 0x87, 0x80, 0x0F, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x1C, 0x01, 0x80, 0x08, 0x01, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x1F,
  0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x00,
  0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xF0, 0x18, 0x7E, 0x7E, 0xFE, 0xFE, 0xFE,
  0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x03, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0x80, 0xF8, 0x3C, 0x01, 0xE1, 0xE0,
  0x03, 0xC7, 0x80, 0x0F, 0x1C, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x03,
  0x8F, 0x00, 0x0E, 0x38, 0x00, 0x38, 0xE0, 0x01, 0xE3, 0x83, 0x07, 0x9E,
  0x1E, 0x1E, 0x78, 0xF8, 0x71, 0xE3, 0xE1, 0xC7, 0x07, 0x87, 0x1C, 0x00,
  0x3C, 0x70, 0x00, 0xF1, 0xC0, 0x03, 0xCF, 0x00, 0x0E, 0x3C, 0x00, 0x38,
  0xF0, 0x00, 0xE3, 0x80, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0xF0, 0xF0,
  0x07, 0xC1, 0xF0, 0x3E, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x03,
  0xE7, 0x80, 0xFC, 0x78, 0x0F, 0x07, 0x80, 0xE0, 0x70, 0x08, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x00,
  0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7C, 0x07, 0xC0,
  0xF0, 0x07, 0x83, 0xC0, 0x07, 0x07, 0x00, 0x0E, 0x1E, 0x00, 0x1C, 0x3C,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x38, 0x00, 0x78, 0x70, 0x00, 0xE0, 0xE0, 0x03, 0xC1, 0xC0,
  0x07, 0x83, 0xC0, 0x1E, 0x07, 0xC0, 0x78, 0x07, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC1, 0xE0, 0x1E, 0x1E, 0x00,
  0xE1, 0xE0, 0x07, 0x1E, 0x00, 0x38, 0xF0, 0x03, 0xC7, 0x00, 0x1E, 0x78,
  0x00, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x83, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x1F,
  0xC0, 0x1D, 0xFF, 0xC0, 0x77, 0xFF, 0x83, 0xF8, 0x3E, 0x0F, 0x80, 0x78,
  0x3C, 0x00, 0xF0, 0xE0, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE3, 0xC0, 0x07, 0x0F, 0x00, 0x3C, 0x3C, 0x01, 0xE0, 0x78, 0x0F, 0x81,
  0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0xF0, 0x03, 0xBF, 0xE0, 0x3F, 0xFF, 0x83,
  0xF8, 0x7E, 0x1F, 0x00, 0xF1, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0xF0, 0x00,
  0xF7, 0x80, 0x07, 0xB8, 0x00, 0x3D, 0xC0, 0x01, 0xEE, 0x00, 0x0F, 0x70,
  0x00, 0x73, 0x80, 0x07, 0x9E, 0x00, 0x78, 0xF0, 0x03, 0xC3, 0xE0, 0x7C,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xFD, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0x9E, 0x00, 0x1E, 0x78, 0x00, 0x71, 0xC0, 0x03,
  0xC7, 0x00, 0x0E, 0x1C, 0x00, 0x78, 0x80, 0x01, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x3C, 0x07, 0xC0, 0xF0, 0x07, 0x81, 0xC0, 0x07, 0x07, 0x80, 0x0E, 0x0F,
  0x00, 0x1C, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x78, 0x03, 0xC0, 0x78,
  0x0F, 0x00, 0xF8, 0x3C, 0x00, 0xF9, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xFF, 0x00, 0x1F, 0x1F, 0x00, 0x78, 0x0F, 0x01, 0xE0, 0x0F,
  0x07, 0x80, 0x1E, 0x0E, 0x00, 0x1C, 0x3C, 0x00, 0x38, 0x78, 0x00, 0x70,
  0xE0, 0x00, 0xE1, 0xC0, 0x03, 0xC3, 0xC0, 0x07, 0x07, 0x80, 0x1E, 0x0F,
  0x80, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x00,
  0x0C, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xF0, 0x1F,
  0x0F, 0x00, 0x78, 0xF0, 0x01, 0xE7, 0x00, 0x0F, 0x78, 0x00, 0x7B, 0xC0,
  0x03, 0xDC, 0x00, 0x1E, 0xE0, 0x00, 0xF7, 0x00, 0x07, 0x38, 0x00, 0x79,
  0xE0, 0x03, 0xCF, 0x00, 0x3C, 0x7C, 0x03, 0xE1, 0xF8, 0xFE, 0x0F, 0xFF,
  0xF0, 0x1F, 0xEF, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0x03, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xE0, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x7E, 0x3F, 0x8F, 0xE3, 0xF8, 0x7C, 0x00, 0x00, 0x60,
  0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x3E,
  0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0E, 0x00, 0x78,
  0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3E, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xC0, 0x00, 0x02, 0x00, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x00, 0x08, 0x00, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0x70, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xC0,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x1F, 0xFE, 0x0F,
  0xFF, 0x80, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0xF0, 0x01, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xE0, 0x07, 0x00, 0x03,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0xF0, 0x03, 0xF0, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x70, 0x00, 0xF0, 0x38,
  0x00, 0x3C, 0x1E, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x70,
  0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E, 0x03, 0xF9, 0xC7, 0x81, 0xFF,
  0x71, 0xC0, 0xF8, 0xD8, 0x70, 0x38, 0x1E, 0x1C, 0x1E, 0x03, 0x87, 0x07,
  0x00, 0xE1, 0xC1, 0xC0, 0x38, 0xF0, 0x70, 0x1E, 0x38, 0x1C, 0x07, 0x8E,
  0x0F, 0x01, 0xC3, 0x83, 0x80, 0x70, 0xE0, 0xE0, 0x1C, 0x38, 0x38, 0x07,
  0x1E, 0x0E, 0x03, 0xC7, 0x03, 0x80, 0xF1, 0xC0, 0xF0, 0x78, 0x70, 0x1F,
  0xFE, 0x1C, 0x07, 0xFB, 0x87, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x01, 0xEE,
  0x00, 0x07, 0x38, 0x00, 0x3C, 0xF0, 0x00, 0xE3, 0xC0, 0x03, 0x87, 0x00,
  0x1E, 0x1C, 0x00, 0x70, 0x70, 0x03, 0xC1, 0xC0, 0x0E, 0x07, 0x00, 0x78,
  0x1C, 0x01, 0xE0, 0x70, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1E,
  0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xC0, 0x0E, 0x0E,
  0x00, 0x38, 0x78, 0x00, 0xE1, 0xC0, 0x03, 0x8F, 0x00, 0x0F, 0x3C, 0x00,
  0x3C, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xFC, 0x00, 0x07, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x38, 0x07, 0xE0, 0x70, 0x03, 0xC0,
  0xE0, 0x07, 0x83, 0xC0, 0x07, 0x07, 0x80, 0x0E, 0x0F, 0x00, 0x1C, 0x1C,
  0x00, 0x78, 0x38, 0x00, 0xF0, 0x70, 0x03, 0xC1, 0xE0, 0x0F, 0x03, 0xC0,
  0x7C, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x38, 0x03,
  0xE0, 0x70, 0x03, 0xC1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x00, 0x0F,
  0x0E, 0x00, 0x1E, 0x1C, 0x00, 0x3C, 0x38, 0x00, 0x70, 0xF0, 0x01, 0xE1,
  0xE0, 0x03, 0xC3, 0xC0, 0x1F, 0x07, 0x00, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x00, 0x04, 0x00, 0x01, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0xFF, 0xFC, 0x07, 0x80, 0xF8, 0x3C, 0x01, 0xE0, 0xE0, 0x03,
  0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x70, 0x00, 0xF1, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0,
  0x00, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0xF0, 0x78, 0x03,
  0xC1, 0xF0, 0x3E, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xC0, 0x3E, 0x07,
  0x00, 0x7C, 0x1C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x07, 0x0F, 0x00,
  0x1C, 0x38, 0x00, 0xF0, 0xE0, 0x03, 0xC3, 0x80, 0x0F, 0x1E, 0x00, 0x38,
  0x78, 0x00, 0xE1, 0xE0, 0x03, 0x87, 0x00, 0x1E, 0x1C, 0x00, 0x78, 0x70,
  0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1C, 0x3C, 0x00, 0x70, 0xF0, 0x01,
  0xC3, 0x80, 0x0F, 0x0E, 0x00, 0x3C, 0x38, 0x00, 0xE1, 0xE0, 0x07, 0x87,
  0x80, 0x1C, 0x1E, 0x01, 0xF0, 0x70, 0x1F, 0x81, 0xFF, 0xFC, 0x07, 0xFF,
  0xC0, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF8, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07,
  0x80, 0xF8, 0x3C, 0x01, 0xE0, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00,
  0x3C, 0x70, 0x00, 0xF1, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0xFF, 0xC7, 0x83, 0xFF, 0x1E, 0x0F, 0xFC, 0x78, 0x00, 0xF1, 0xC0, 0x03,
  0xC7, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0xF0, 0x00, 0xE3, 0xC0, 0x07, 0x8F,
  0x00, 0x1E, 0x3C, 0x00, 0xF0, 0x78, 0x03, 0xC1, 0xF0, 0x3E, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x07, 0x80, 0x0E, 0x0F, 0x00,
  0x1C, 0x1E, 0x00, 0x78, 0x38, 0x00, 0xF0, 0x70, 0x01, 0xE0, 0xE0, 0x03,
  0x83, 0xC0, 0x07, 0x07, 0x80, 0x0E, 0x0F, 0x00, 0x3C, 0x1C, 0x00, 0x78,
  0x38, 0x00, 0xF0, 0x70, 0x01, 0xC1, 0xE0, 0x03, 0x83, 0xC0, 0x07, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x38, 0x00, 0xE0, 0x70,
  0x01, 0xC1, 0xE0, 0x03, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x0E, 0x00,
  0x3C, 0x1C, 0x00, 0x78, 0x38, 0x00, 0xE0, 0xF0, 0x01, 0xC1, 0xE0, 0x03,
  0x83, 0xC0, 0x0F, 0x07, 0x00, 0x1E, 0x0E, 0x00, 0x3C, 0x1C, 0x00, 0x70,
  0x78, 0x00, 0xE0, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x80,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x03, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x70, 0x00, 0xF0, 0x70, 0x00, 0xF0, 0x70, 0x00,
  0xE0, 0x78, 0x01, 0xE0, 0x78, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0x80, 0x07, 0x83, 0xC0,
  0x07, 0x81, 0xE0, 0x07, 0x80, 0xE0, 0x03, 0xC0, 0x70, 0x03, 0xC0, 0x38,
  0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0F, 0x01, 0xE0, 0x07,
  0x00, 0xF0, 0x03, 0x80, 0xF0, 0x01, 0xC0, 0xF0, 0x01, 0xE0, 0x78, 0x00,
  0xF0, 0x78, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x0E, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0x78,
  0x01, 0xE0, 0x3C, 0x00, 0xE0, 0x1E, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03,
  0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x3C, 0x07, 0x00,
  0x1E, 0x03, 0x80, 0x07, 0x81, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x1F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F,
  0x0F, 0xC0, 0x76, 0x0F, 0xC0, 0x76, 0x0F, 0xC0, 0x6E, 0x0C, 0xC0, 0xEE,
  0x1C, 0xE0, 0xEE, 0x1C, 0xE1, 0xCE, 0x1C, 0xE1, 0xDE, 0x1C, 0xE3, 0x9C,
  0x1C, 0x63, 0x9C, 0x1C, 0x67, 0x1C, 0x1C, 0x77, 0x1C, 0x3C, 0x7E, 0x3C,
  0x3C, 0x7E, 0x3C, 0x38, 0x7C, 0x38, 0x38, 0x3C, 0x38, 0x38, 0x00, 0x38,
  0x38, 0x00, 0x38, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x70,
  0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0xF0, 0x00, 0xF0,
  0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xE0,
  0xE0, 0x00, 0xE0, 0x07, 0xC0, 0x0E, 0x0F, 0x80, 0x1C, 0x1F, 0x80, 0x38,
  0x3F, 0x00, 0xF0, 0x7E, 0x01, 0xE1, 0xFC, 0x03, 0xC3, 0xF8, 0x07, 0x07,
  0x38, 0x0E, 0x0E, 0x70, 0x1C, 0x1C, 0xE0, 0x78, 0x39, 0xC0, 0xF0, 0xF3,
  0x81, 0xE1, 0xE3, 0x83, 0x83, 0xC7, 0x07, 0x07, 0x0E, 0x0E, 0x0E, 0x1C,
  0x1C, 0x1C, 0x38, 0x78, 0x38, 0x38, 0xF0, 0xF0, 0x71, 0xC1, 0xE0, 0xE3,
  0x83, 0x81, 0xC7, 0x07, 0x03, 0xCE, 0x0E, 0x03, 0xBC, 0x1C, 0x07, 0x78,
  0x78, 0x0E, 0xE0, 0xF0, 0x1D, 0xC1, 0xE0, 0x3F, 0x83, 0x80, 0x3F, 0x07,
  0x00, 0x7E, 0x0E, 0x00, 0xFC, 0x3C, 0x01, 0xF8, 0x78, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0x80,
  0xF8, 0x3C, 0x01, 0xE0, 0xE0, 0x03, 0x87, 0x80, 0x0E, 0x1E, 0x00, 0x38,
  0x70, 0x00, 0xE1, 0xC0, 0x07, 0x87, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0,
  0x01, 0xC3, 0xC0, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x03,
  0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xE1, 0xC0, 0x03, 0x87,
  0x00, 0x0E, 0x1C, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00,
  0x1C, 0x3C, 0x00, 0xF0, 0x78, 0x07, 0x81, 0xF0, 0x3E, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF8,
  0x07, 0xFF, 0xFC, 0x07, 0x00, 0x7E, 0x07, 0x00, 0x1E, 0x07, 0x00, 0x0F,
  0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0E, 0x00, 0x0F,
  0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x3C,
  0x1E, 0x00, 0x78, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x3F, 0xFC, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0x80, 0xF8, 0x3C, 0x01, 0xE1, 0xE0,
  0x03, 0x87, 0x80, 0x0E, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xE3, 0xC0, 0x03,
  0x8F, 0x00, 0x0E, 0x3C, 0x00, 0x78, 0xE0, 0x01, 0xE3, 0x80, 0x07, 0x8E,
  0x00, 0x1C, 0x78, 0x00, 0x71, 0xE0, 0x01, 0xC7, 0x80, 0x0F, 0x1E, 0x00,
  0x3C, 0x70, 0x00, 0xF1, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x3C, 0x00, 0x38,
  0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1C, 0x3C, 0x00, 0xF0, 0xF8,
  0x07, 0x81, 0xF0, 0x3E, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x07,
  0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0x00, 0x7C, 0x07,
  0x00, 0x3E, 0x07, 0x00, 0x1E, 0x0F, 0x00, 0x0E, 0x0F, 0x00, 0x0E, 0x0F,
  0x00, 0x0E, 0x0E, 0x00, 0x1E, 0x0E, 0x00, 0x1E, 0x0E, 0x00, 0x1C, 0x1E,
  0x00, 0x3C, 0x1E, 0x00, 0x78, 0x1E, 0x01, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3C, 0x0E, 0x00, 0x3C, 0x0F, 0x00, 0x3C,
  0x0F, 0x00, 0x38, 0x07, 0x00, 0x38, 0x07, 0x80, 0x38, 0x07, 0x80, 0x38,
  0x03, 0x80, 0x78, 0x03, 0xC0, 0x78, 0x03, 0xC0, 0x78, 0x03, 0xC0, 0x70,
  0x01, 0xE0, 0x70, 0x01, 0xE0, 0x70, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x00,
  0x03, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3C,
  0x03, 0xC0, 0xF0, 0x03, 0x81, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0xE1, 0xC0, 0x03, 0xC3, 0x80, 0x07, 0x87, 0x80, 0x1E, 0x0F, 0x80,
  0x78, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x1C, 0x3C, 0x00, 0x70, 0xE0, 0x03, 0xC3, 0x80,
  0x0F, 0x0E, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0x87, 0x80, 0x0E,
  0x1C, 0x00, 0x38, 0x70, 0x01, 0xE1, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C,
  0x00, 0x70, 0xF0, 0x01, 0xC3, 0xC0, 0x07, 0x0E, 0x00, 0x3C, 0x38, 0x00,
  0xF0, 0xE0, 0x03, 0xC7, 0x80, 0x0E, 0x1E, 0x00, 0x38, 0x78, 0x00, 0xE1,
  0xC0, 0x07, 0x87, 0x00, 0x1E, 0x1C, 0x00, 0x78, 0xF0, 0x01, 0xC3, 0xC0,
  0x07, 0x0F, 0x00, 0x3C, 0x1E, 0x01, 0xE0, 0x7C, 0x0F, 0x80, 0xFF, 0xFC,
  0x03, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xB8,
  0x00, 0x3D, 0xC0, 0x01, 0xEF, 0x00, 0x0E, 0x78, 0x00, 0xF3, 0xC0, 0x07,
  0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC3, 0x80, 0x1C, 0x1C, 0x01, 0xE0, 0xE0,
  0x0E, 0x07, 0x00, 0xF0, 0x38, 0x07, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xC0,
  0x78, 0x1C, 0x03, 0xC1, 0xE0, 0x0E, 0x0E, 0x00, 0x70, 0xF0, 0x03, 0x87,
  0x00, 0x1C, 0x38, 0x00, 0xE3, 0xC0, 0x07, 0x1C, 0x00, 0x39, 0xE0, 0x01,
  0xEE, 0x00, 0x0F, 0x70, 0x00, 0x7F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x1E, 0x03, 0xBC, 0x0F, 0x01,
  0xDE, 0x07, 0x81, 0xEE, 0x07, 0xC0, 0xE7, 0x03, 0x60, 0x73, 0x81, 0xB0,
  0x39, 0xC0, 0xD8, 0x38, 0xE0, 0xEC, 0x1C, 0x70, 0x66, 0x0E, 0x38, 0x33,
  0x0F, 0x1C, 0x39, 0x87, 0x0E, 0x18, 0xC3, 0x87, 0x0C, 0x61, 0xC3, 0x86,
  0x31, 0xE1, 0xC7, 0x18, 0xE0, 0xE3, 0x1C, 0x70, 0x71, 0x8E, 0x38, 0x39,
  0xC7, 0x38, 0x1C, 0xC3, 0x9C, 0x0E, 0x61, 0xCE, 0x07, 0x30, 0xE7, 0x03,
  0xB8, 0x77, 0x03, 0xD8, 0x33, 0x81, 0xCC, 0x19, 0xC0, 0xEE, 0x0D, 0xC0,
  0x76, 0x06, 0xE0, 0x3B, 0x03, 0x70, 0x1D, 0x81, 0xB8, 0x0F, 0xC0, 0xF8,
  0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x78, 0x00, 0x78, 0x07, 0x00, 0x1E, 0x00, 0xF0, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x07, 0x00, 0x03, 0x81,
  0xE0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x1E, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x78, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00, 0xF0,
  0x1E, 0x00, 0x3C, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0x80,
  0x78, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x79, 0xC0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x0F,
  0x07, 0x00, 0x1C, 0x0F, 0x00, 0x78, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0x80,
  0x3C, 0x0F, 0x00, 0x78, 0x3C, 0x00, 0x70, 0x70, 0x00, 0xF1, 0xE0, 0x01,
  0xE7, 0x80, 0x01, 0xCE, 0x00, 0x03, 0xBC, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x81, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0xF0, 0x03, 0x80, 0x1C,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x78, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03,
  0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x3C,
  0x00, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xC0,
  0x0F, 0x00, 0x78, 0x01, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0,
  0x7F, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0E, 0x60, 0x03,
  0xCE, 0x00, 0x71, 0xC0, 0x1C, 0x38, 0x07, 0x83, 0x80, 0xE0, 0x70, 0x3C,
  0x0E, 0x07, 0x01, 0xC1, 0xC0, 0x1C, 0x78, 0x03, 0x8E, 0x00, 0x73, 0xC0,
  0x07, 0xF0, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0x80, 0xF0, 0xE1, 0xE1, 0xC1, 0xC3, 0xC3, 0x80, 0x00, 0x70, 0x00, 0x0F,
  0xF3, 0xC1, 0xFF, 0xDE, 0x1F, 0xDF, 0xF1, 0xF0, 0x1F, 0x0F, 0x00, 0x78,
  0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x38, 0x00, 0xF1, 0xC0, 0x07, 0x9E, 0x00,
  0x3C, 0xF0, 0x01, 0xC7, 0x80, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x07, 0x8E,
  0x00, 0x3C, 0x70, 0x01, 0xE7, 0x80, 0x0E, 0x3C, 0x00, 0xF1, 0xE0, 0x07,
  0x87, 0x80, 0x7C, 0x3C, 0x07, 0xE1, 0xFF, 0xEF, 0x07, 0xFF, 0x70, 0x1F,
  0xE3, 0x80, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC1, 0xC0,
  0x0F, 0x3F, 0xC0, 0x39, 0xFF, 0xC0, 0xEF, 0x7F, 0x03, 0xE0, 0x3E, 0x1F,
  0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1C, 0x00,
  0x78, 0x70, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1C, 0x3C, 0x00, 0x70,
  0xF0, 0x01, 0xC3, 0x80, 0x0F, 0x0E, 0x00, 0x3C, 0x38, 0x00, 0xF1, 0xE0,
  0x03, 0x87, 0x80, 0x1E, 0x1F, 0x00, 0xF0, 0x76, 0x07, 0xC1, 0xDF, 0xFE,
  0x07, 0x7F, 0xF0, 0x3C, 0x7F, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0xFC, 0x00,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xF0, 0x1F, 0x0F, 0x00, 0x78, 0xF0, 0x01,
  0xC7, 0x80, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x0F, 0x3C, 0x00, 0x79, 0xE0, 0x07, 0x87, 0x80,
  0x3C, 0x3E, 0x07, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x1C, 0x0E, 0x01, 0xFE,
  0x78, 0x1F, 0xFD, 0xE0, 0xFE, 0xFF, 0x87, 0xC0, 0x7E, 0x1E, 0x00, 0xF0,
  0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0E, 0x00, 0x3C, 0x38, 0x00, 0xF1, 0xE0,
  0x03, 0xC7, 0x80, 0x0E, 0x1E, 0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0, 0x07,
  0x87, 0x00, 0x1E, 0x1C, 0x00, 0x78, 0xF0, 0x01, 0xC3, 0xC0, 0x0F, 0x0F,
  0x00, 0x3C, 0x1E, 0x01, 0xF0, 0x78, 0x0F, 0xC1, 0xFF, 0xEF, 0x03, 0xFF,
  0xB8, 0x07, 0xF8, 0xE0, 0x00, 0x18, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0,
  0xFE, 0x7E, 0x0F, 0x01, 0xE1, 0xE0, 0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x07,
  0x38, 0x00, 0xF3, 0x80, 0x0F, 0x78, 0x00, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF,
  0xE7, 0xFF, 0xFE, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x3C, 0x70, 0x03, 0xC7, 0x80, 0x78, 0x3F,
  0xFF, 0x03, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x0F, 0xF3, 0xC1, 0xFF, 0xDE, 0x1F, 0xDF, 0xF1,
  0xF0, 0x1F, 0x0F, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x38, 0x00,
  0xF1, 0xC0, 0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x01, 0xC7, 0x80, 0x0E, 0x3C,
  0x00, 0x71, 0xC0, 0x07, 0x8E, 0x00, 0x3C, 0x70, 0x01, 0xE3, 0x80, 0x1E,
  0x1E, 0x00, 0xF0, 0xF8, 0x1B, 0x83, 0xFF, 0xFC, 0x1F, 0xFD, 0xE0, 0x3F,
  0xCF, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x81, 0xFF, 0xF8, 0x0F, 0xFF,
  0x80, 0x7F, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC1, 0xC0, 0x0F, 0x3F, 0xC0, 0x39, 0xFF, 0xC0, 0xEF, 0x3F, 0x03, 0xE0,
  0x3E, 0x1F, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x00, 0x1E,
  0x1C, 0x00, 0x78, 0x70, 0x01, 0xE3, 0xC0, 0x07, 0x0F, 0x00, 0x1C, 0x3C,
  0x00, 0x70, 0xE0, 0x03, 0xC3, 0x80, 0x0F, 0x0E, 0x00, 0x3C, 0x38, 0x00,
  0xE1, 0xE0, 0x03, 0x87, 0x80, 0x0E, 0x1E, 0x00, 0x38, 0x70, 0x01, 0xE1,
  0xC0, 0x07, 0x87, 0x00, 0x1E, 0x3C, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x1F,
  0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x01, 0x0F, 0x00,
  0x1E, 0x0F, 0x00, 0x3C, 0x0E, 0x00, 0x78, 0x0E, 0x00, 0xF0, 0x0E, 0x01,
  0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x1C, 0x0F,
  0x00, 0x1C, 0x1E, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3C, 0x1E, 0x00, 0x38, 0x1E, 0x00, 0x38, 0x0F, 0x00, 0x38, 0x0F,
  0x00, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x78, 0x03,
  0xC0, 0x70, 0x01, 0xE0, 0x70, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0xFF, 0xE0,
  0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x03, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0x30,
  0x10, 0x0E, 0xFC, 0xFC, 0x0F, 0xFE, 0xFE, 0x1F, 0x1F, 0x1E, 0x1E, 0x0E,
  0x0E, 0x1E, 0x0E, 0x0E, 0x1C, 0x0E, 0x0E, 0x1C, 0x0E, 0x0E, 0x1C, 0x1C,
  0x0E, 0x1C, 0x1C, 0x0E, 0x3C, 0x1C, 0x1E, 0x3C, 0x1C, 0x1E, 0x38, 0x1C,
  0x1C, 0x38, 0x1C, 0x1C, 0x38, 0x38, 0x1C, 0x38, 0x38, 0x1C, 0x78, 0x38,
  0x3C, 0x78, 0x38, 0x3C, 0x70, 0x38, 0x38, 0x70, 0x38, 0x38, 0x70, 0x30,
  0x38, 0x70, 0x70, 0x38, 0xF0, 0x70, 0x38, 0xF0, 0x70, 0x78, 0xE0, 0x70,
  0x78, 0x00, 0x07, 0x00, 0x3C, 0xFF, 0x00, 0xE7, 0xFF, 0x03, 0xBC, 0xFC,
  0x0F, 0x80, 0xF8, 0x7C, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1C,
  0x00, 0x78, 0x70, 0x01, 0xE1, 0xC0, 0x07, 0x8F, 0x00, 0x1C, 0x3C, 0x00,
  0x70, 0xF0, 0x01, 0xC3, 0x80, 0x0F, 0x0E, 0x00, 0x3C, 0x38, 0x00, 0xF1,
  0xE0, 0x03, 0x87, 0x80, 0x0E, 0x1E, 0x00, 0x38, 0x78, 0x00, 0xE1, 0xC0,
  0x07, 0x87, 0x00, 0x1E, 0x1C, 0x00, 0x78, 0xF0, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0xFE, 0xFE, 0x0F, 0x01, 0xE1, 0xE0,
  0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x0F, 0x38, 0x00, 0xF3, 0x80, 0x0F, 0x78,
  0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xE7,
  0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xCF, 0x00, 0x3C,
  0x78, 0x07, 0x87, 0xC0, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0x80, 0x0F, 0x3F, 0xE0, 0x1C, 0xFF, 0xE0, 0x3B, 0xDF,
  0xC0, 0x7C, 0x07, 0xC1, 0xF0, 0x07, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x1E,
  0x0F, 0x00, 0x3C, 0x1C, 0x00, 0x78, 0x38, 0x00, 0xF0, 0xF0, 0x01, 0xE1,
  0xE0, 0x03, 0x83, 0xC0, 0x07, 0x07, 0x80, 0x0E, 0x0E, 0x00, 0x3C, 0x1C,
  0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xC1, 0xE0, 0x07, 0x83, 0xE0,
  0x1E, 0x07, 0x60, 0x7C, 0x0E, 0xFF, 0xF0, 0x1C, 0xFF, 0xC0, 0x78, 0xFE,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x1F, 0xF3, 0xC1, 0xFF, 0xDE, 0x1F, 0xDF, 0xF1, 0xF0,
  0x1F, 0x0F, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x38, 0x00, 0xF1,
  0xC0, 0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x01, 0xC7, 0x80, 0x0E, 0x38, 0x00,
  0xF1, 0xC0, 0x07, 0x8E, 0x00, 0x3C, 0xF0, 0x01, 0xE7, 0x80, 0x0E, 0x3C,
  0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x80, 0x7C, 0x3C, 0x07, 0xE1, 0xFF, 0xEF,
  0x07, 0xFF, 0x70, 0x1F, 0xE3, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x38, 0xFF, 0x00, 0xEF, 0xFE, 0x03,
  0xBC, 0xFC, 0x1F, 0x80, 0xF8, 0x7C, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80,
  0x1E, 0x1C, 0x00, 0x78, 0x70, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0xFE, 0x7F, 0x1E, 0x00,
  0xF1, 0xC0, 0x07, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xEE,
  0x00, 0x1C, 0xF0, 0x03, 0xCF, 0x80, 0x7C, 0x7F, 0xFF, 0x87, 0xFF, 0xF0,
  0x1F, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x80, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFC,
  0x00, 0x1E, 0x00, 0x38, 0xE0, 0x03, 0xC7, 0x00, 0x1E, 0x78, 0x00, 0xF3,
  0xC0, 0x07, 0x1E, 0x00, 0x38, 0xF0, 0x01, 0xC7, 0x00, 0x1E, 0x38, 0x00,
  0xF1, 0xC0, 0x07, 0x9E, 0x00, 0x38, 0xF0, 0x01, 0xC7, 0x80, 0x0E, 0x38,
  0x00, 0xF1, 0xC0, 0x07, 0x8E, 0x00, 0x3C, 0xF0, 0x01, 0xC7, 0x80, 0x0E,
  0x1C, 0x00, 0xF0, 0xF0, 0x0F, 0x07, 0xC0, 0xF8, 0x1F, 0xFF, 0x80, 0xFF,
  0xF8, 0x01, 0xFF, 0x00, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x01, 0xEF,
  0x00, 0x1E, 0x70, 0x01, 0xC7, 0x00, 0x3C, 0x70, 0x03, 0x87, 0x00, 0x78,
  0x78, 0x07, 0x07, 0x80, 0xF0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x38, 0x1C,
  0x03, 0x83, 0xC0, 0x3C, 0x38, 0x03, 0xC7, 0x80, 0x1C, 0x70, 0x01, 0xCF,
  0x00, 0x1C, 0xE0, 0x01, 0xDE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0xE0, 0x78, 0x1F, 0xC0, 0xF0, 0x3B, 0x83, 0xE0,
  0x77, 0x06, 0xC1, 0xCE, 0x0D, 0x83, 0x9C, 0x3B, 0x07, 0x38, 0x66, 0x1C,
  0x70, 0xCC, 0x38, 0xE3, 0x98, 0x71, 0xC6, 0x30, 0xC3, 0x8C, 0x63, 0x87,
  0x38, 0xC7, 0x0C, 0x61, 0x8C, 0x18, 0xC3, 0x38, 0x33, 0x86, 0x70, 0x66,
  0x0C, 0xC0, 0xCC, 0x1B, 0x81, 0xB8, 0x37, 0x03, 0x70, 0x6C, 0x06, 0xC0,
  0xF8, 0x0D, 0x81, 0xF0, 0x1F, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F,
  0x00, 0x0F, 0x00, 0x1F, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x3C, 0x03, 0xC0,
  0x78, 0x01, 0xC0, 0xF0, 0x01, 0xE1, 0xF0, 0x00, 0xE1, 0xE0, 0x00, 0xF3,
  0xC0, 0x00, 0x77, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xEF, 0x00, 0x01, 0xE7,
  0x00, 0x03, 0xC7, 0x80, 0x07, 0x83, 0x80, 0x0F, 0x03, 0xC0, 0x1E, 0x01,
  0xC0, 0x1E, 0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0xF0, 0x00,
  0x78, 0x1E, 0x00, 0x78, 0xE0, 0x03, 0xC7, 0x00, 0x1E, 0x78, 0x00, 0xE3,
  0xC0, 0x07, 0x1E, 0x00, 0x38, 0xF0, 0x03, 0xC7, 0x00, 0x1E, 0x38, 0x00,
  0xF3, 0xC0, 0x07, 0x1E, 0x00, 0x38, 0xF0, 0x01, 0xC7, 0x80, 0x0E, 0x38,
  0x00, 0xF1, 0xC0, 0x07, 0x8E, 0x00, 0x3C, 0x70, 0x03, 0xC3, 0xC0, 0x3E,
  0x1F, 0x03, 0x70, 0x7F, 0xFF, 0x83, 0xFF, 0xBC, 0x07, 0xF1, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x0E,
  0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0,
  0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x38, 0xFF, 0x01, 0xCF, 0xF8, 0x0E,
  0xF1, 0xE0, 0x77, 0x07, 0x87, 0xF8, 0x3E, 0x3B, 0xC0, 0xFF, 0xDC, 0x03,
  0xFC, 0xE0, 0x0F, 0x80,
};

const GFXglyph JetBrainsMono_LightItalic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 10, 32, 26, 8, -32 },
  { 41, 15, 13, 26, 8, -32 },
  { 66, 26, 32, 26, 1, -32 },
  { 170, 23, 44, 26, 2, -38 },
  { 297, 30, 32, 26, -1, -32 },
  { 417, 24, 33, 26, 1, -33 },
  { 516, 5, 13, 26, 13, -32 },
  { 525, 18, 43, 26, 7, -37 },
  { 622, 18, 43, 26, 2, -37 },
  { 719, 24, 23, 26, 2, -27 },
  { 788, 21, 21, 26, 3, -25 },
  { 844, 11, 14, 26, 4, -7 },
  { 864, 15, 3, 26, 6, -16 },
  { 870, 8, 7, 26, 8, -7 },
  { 877, 26, 42, 26, 1, -37 },
  { 1014, 22, 33, 26, 3, -33 },
  { 1105, 20, 32, 26, 2, -32 },
  { 1185, 23, 33, 26, 2, -33 },
  { 1280, 23, 32, 26, 2, -32 },
  { 1372, 21, 32, 26, 3, -32 },
  { 1456, 22, 32, 26, 3, -32 },
  { 1544, 21, 32, 26, 2, -32 },
  { 1628, 22, 32, 26, 5, -32 },
  { 1716, 23, 33, 26, 2, -33 },
  { 1811, 21, 33, 26, 4, -33 },
  { 1898, 10, 25, 26, 8, -25 },
  { 1930, 14, 32, 26, 5, -25 },
  { 1986, 21, 23, 26, 4, -26 },
  { 2047, 21, 13, 26, 3, -21 },
  { 2082, 21, 23, 26, 2, -26 },
  { 2143, 17, 32, 26, 7, -32 },
  { 2211, 26, 41, 26, 0, -33 },
  { 2345, 22, 32, 26, 0, -32 },
  { 2433, 23, 32, 26, 2, -32 },
  { 2525, 22, 33, 26, 3, -33 },
  { 2616, 22, 32, 26, 2, -32 },
  { 2704, 23, 32, 26, 3, -32 },
  { 2796, 24, 32, 26, 2, -32 },
  { 2892, 22, 33, 26, 3, -33 },
  { 2983, 23, 32, 26, 2, -32 },
  { 3075, 22, 32, 26, 3, -32 },
  { 3163, 24, 32, 26, 1, -32 },
  { 3259, 25, 32, 26, 2, -32 },
  { 3359, 19, 32, 26, 3, -32 },
  { 3435, 24, 32, 26, 2, -32 },
  { 3531, 23, 32, 26, 2, -32 },
  { 3623, 22, 33, 26, 3, -33 },
  { 3714, 24, 32, 26, 2, -32 },
  { 3810, 22, 41, 26, 3, -33 },
  { 3923, 24, 32, 26, 2, -32 },
  { 4019, 23, 33, 26, 2, -33 },
  { 4114, 22, 32, 26, 5, -32 },
  { 4202, 22, 32, 26, 3, -32 },
  { 4290, 21, 32, 26, 6, -32 },
  { 4374, 25, 32, 26, 3, -32 },
  { 4474, 27, 32, 26, 0, -32 },
  { 4582, 23, 32, 26, 5, -32 },
  { 4674, 23, 32, 26, 2, -32 },
  { 4766, 17, 42, 26, 7, -37 },
  { 4856, 13, 42, 26, 7, -37 },
  { 4925, 17, 42, 26, 4, -37 },
  { 5015, 19, 17, 26, 4, -32 },
  { 5056, 22, 3, 26, 0, 1 },
  { 5065, 7, 7, 26, 12, -35 },
  { 5072, 21, 25, 26, 3, -25 },
  { 5138, 22, 32, 26, 2, -32 },
  { 5226, 21, 25, 26, 3, -25 },
  { 5292, 22, 32, 26, 3, -32 },
  { 5380, 20, 25, 26, 3, -25 },
  { 5443, 30, 40, 26, -2, -32 },
  { 5593, 21, 33, 26, 3, -25 },
  { 5680, 22, 32, 26, 2, -32 },
  { 5768, 21, 34, 26, 2, -34 },
  { 5858, 22, 42, 26, 1, -34 },
  { 5974, 24, 32, 26, 2, -32 },
  { 6070, 18, 32, 26, 5, -32 },
  { 6142, 24, 25, 26, 1, -25 },
  { 6217, 22, 25, 26, 2, -25 },
  { 6286, 20, 25, 26, 3, -25 },
  { 6349, 23, 33, 26, 1, -25 },
  { 6444, 21, 33, 26, 3, -25 },
  { 6531, 22, 25, 26, 3, -25 },
  { 6600, 20, 25, 26, 3, -25 },
  { 6663, 21, 31, 26, 4, -31 },
  { 6745, 21, 24, 26, 3, -24 },
  { 6808, 20, 24, 26, 5, -24 },
  { 6868, 23, 24, 26, 4, -24 },
  { 6937, 24, 24, 26, 1, -24 },
  { 7009, 21, 32, 26, 3, -24 },
  { 7093, 22, 24, 26, 2, -24 },
  { 7159, 22, 42, 26, 4, -37 },
  { 7275, 10, 42, 26, 9, -37 },
  { 7328, 22, 42, 26, 1, -37 },
  { 7444, 21, 9, 26, 3, -20 },
};

const GFXfont JetBrainsMono_LightItalic44pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_LightItalic44pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_LightItalic44pt7bGlyphs,
  0x20, 0x7E, 58
};

#endif // _JETBRAINSMONO_LIGHTITALIC44PT7B_H_
