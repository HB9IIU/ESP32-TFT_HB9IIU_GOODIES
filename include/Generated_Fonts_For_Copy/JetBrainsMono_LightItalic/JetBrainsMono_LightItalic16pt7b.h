#ifndef _JETBRAINSMONO_LIGHTITALIC16PT7B_H_
#define _JETBRAINSMONO_LIGHTITALIC16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-LightItalic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_LightItalic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x22, 0x22, 0x64, 0x40, 0xCC, 0x4E, 0x73, 0x39, 0x00, 0x04,
  0x82, 0x20, 0x88, 0x24, 0x3F, 0xC4, 0x41, 0x20, 0x88, 0xFF, 0x09, 0x04,
  0x41, 0x30, 0x04, 0x04, 0x1E, 0x3B, 0x69, 0x48, 0x68, 0x38, 0x1E, 0x12,
  0x12, 0x92, 0xD6, 0x7C, 0x10, 0x20, 0x38, 0x6D, 0x91, 0x22, 0x24, 0x84,
  0xA0, 0x68, 0x02, 0x00, 0xBC, 0x34, 0x84, 0x91, 0x12, 0x43, 0x80, 0x0E,
  0x09, 0x8C, 0x46, 0x01, 0x01, 0xC1, 0xA2, 0x9A, 0x47, 0x23, 0x11, 0x8F,
  0x20, 0xEA, 0x80, 0x04, 0x31, 0x08, 0x41, 0x04, 0x30, 0x82, 0x08, 0x20,
  0x83, 0x06, 0x0C, 0x20, 0xC0, 0x83, 0x04, 0x10, 0x41, 0x0C, 0x30, 0x82,
  0x18, 0xC6, 0x20, 0x08, 0x08, 0x08, 0xEF, 0x3C, 0x18, 0x2C, 0xC4, 0x08,
  0x08, 0x08, 0xFF, 0x10, 0x10, 0x10, 0x76, 0xC8, 0x80, 0xFC, 0xF8, 0x00,
  0xC0, 0x60, 0x10, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x30, 0x08, 0x04, 0x01,
  0x00, 0x80, 0x20, 0x10, 0x0C, 0x00, 0x1E, 0x33, 0x61, 0x41, 0x43, 0x5B,
  0xDA, 0xC2, 0x82, 0x82, 0xC4, 0x78, 0x0C, 0x29, 0xB2, 0x60, 0x81, 0x02,
  0x04, 0x08, 0x30, 0x47, 0xF0, 0x1E, 0x33, 0x41, 0x41, 0x03, 0x02, 0x04,
  0x08, 0x30, 0x60, 0xC0, 0xFE, 0x3F, 0x03, 0x06, 0x0C, 0x10, 0x1C, 0x02,
  0x02, 0x02, 0x86, 0xC4, 0x78, 0x03, 0x06, 0x0C, 0x08, 0x10, 0x22, 0x62,
  0xC2, 0xFE, 0x06, 0x04, 0x04, 0x3F, 0x20, 0x20, 0x60, 0x4C, 0x76, 0x42,
  0x02, 0x02, 0x82, 0xC4, 0x78, 0x06, 0x18, 0x20, 0x82, 0x0F, 0xD0, 0xE1,
  0x83, 0x07, 0x13, 0xC0, 0xFF, 0xFE, 0x82, 0x04, 0x04, 0x08, 0x18, 0x10,
  0x30, 0x20, 0x60, 0xC0, 0x1E, 0x33, 0x61, 0x63, 0x62, 0x3C, 0x3C, 0x46,
  0x82, 0x82, 0xC6, 0x7C, 0x3C, 0xCF, 0x0C, 0x18, 0x30, 0xFF, 0x14, 0x18,
  0x60, 0x86, 0x00, 0x67, 0x00, 0x00, 0x0E, 0xC0, 0x39, 0xC0, 0x00, 0x00,
  0x4C, 0x62, 0x21, 0x00, 0x03, 0x0C, 0x30, 0x40, 0xE0, 0x38, 0x0E, 0x02,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x60, 0x70, 0x38, 0x10, 0x67, 0x38, 0x40,
  0x78, 0xF8, 0x18, 0x30, 0x41, 0x8E, 0x10, 0x60, 0x01, 0x87, 0x00, 0x0F,
  0x06, 0x62, 0x08, 0x83, 0x47, 0x93, 0x24, 0x89, 0x22, 0x48, 0x92, 0x68,
  0xF2, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x06, 0x06, 0x0A, 0x0A, 0x1A, 0x12,
  0x12, 0x23, 0x3F, 0x61, 0x41, 0xC1, 0x3C, 0x27, 0x61, 0x41, 0x42, 0x7C,
  0x7E, 0x42, 0xC2, 0x82, 0x86, 0xF8, 0x1E, 0x33, 0x61, 0x41, 0x40, 0x40,
  0x40, 0xC0, 0xC0, 0xC2, 0xC4, 0x78, 0x3C, 0x26, 0x63, 0x43, 0x43, 0x42,
  0x42, 0x42, 0xC2, 0xC6, 0x8C, 0xF8, 0x3F, 0x20, 0x60, 0x60, 0x40, 0x7E,
  0x40, 0x40, 0x40, 0xC0, 0x80, 0xFE, 0x3F, 0x90, 0x18, 0x0C, 0x04, 0x02,
  0x01, 0xF8, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x00, 0x1E, 0x33, 0x61, 0x41,
  0x40, 0x40, 0x4E, 0xC2, 0xC2, 0xC2, 0xC4, 0x78, 0x21, 0x21, 0x61, 0x43,
  0x43, 0x7E, 0x7E, 0x42, 0xC2, 0xC6, 0x86, 0x84, 0x3F, 0x08, 0x08, 0x08,
  0x08, 0x18, 0x18, 0x10, 0x10, 0x10, 0x10, 0xFC, 0x07, 0x80, 0x40, 0x60,
  0x30, 0x10, 0x08, 0x04, 0x02, 0x03, 0x21, 0x11, 0x8F, 0x80, 0x21, 0x90,
  0x98, 0x88, 0xC4, 0x43, 0xC1, 0xE0, 0x98, 0xC4, 0x62, 0x21, 0x90, 0x40,
  0x20, 0x40, 0x81, 0x06, 0x08, 0x10, 0x20, 0x40, 0x83, 0x07, 0xF0, 0x61,
  0x63, 0x63, 0x55, 0x55, 0x5B, 0xDA, 0xC2, 0x82, 0x82, 0x82, 0x86, 0x21,
  0x71, 0x51, 0x53, 0x53, 0x52, 0x4A, 0x4A, 0xCA, 0x8A, 0x8E, 0x84, 0x1E,
  0x33, 0x63, 0x43, 0x43, 0x42, 0x42, 0xC2, 0xC2, 0xC6, 0xC4, 0x78, 0x3E,
  0x11, 0x98, 0x48, 0x24, 0x12, 0x19, 0xF8, 0x80, 0xC0, 0x60, 0x20, 0x10,
  0x00, 0x1E, 0x33, 0x61, 0x41, 0x43, 0x43, 0x42, 0xC2, 0x82, 0x82, 0xC4,
  0x78, 0x08, 0x0C, 0x04, 0x3C, 0x27, 0x61, 0x41, 0x41, 0x42, 0x7C, 0x48,
  0xCC, 0xC4, 0x84, 0x86, 0x1E, 0x33, 0x61, 0x40, 0x60, 0x30, 0x0C, 0x02,
  0x02, 0x82, 0xC6, 0x7C, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x30, 0x20,
  0x20, 0x20, 0x20, 0x60, 0x21, 0x61, 0x61, 0x43, 0x43, 0x42, 0x42, 0x42,
  0xC2, 0xC6, 0xC4, 0x78, 0x83, 0x82, 0xC2, 0xC6, 0xC4, 0x4C, 0x48, 0x48,
  0x50, 0x50, 0x70, 0x60, 0x4C, 0xA6, 0x53, 0x3A, 0xAD, 0x56, 0xAA, 0x9D,
  0x54, 0xAA, 0x55, 0x33, 0x19, 0x80, 0x30, 0xC4, 0x21, 0x10, 0x6C, 0x0A,
  0x03, 0x00, 0xC0, 0x70, 0x16, 0x08, 0x86, 0x33, 0x04, 0x81, 0x82, 0xC6,
  0x44, 0x48, 0x78, 0x30, 0x20, 0x20, 0x20, 0x20, 0x60, 0x3F, 0x41, 0x02,
  0x06, 0x0C, 0x08, 0x10, 0x30, 0x20, 0x40, 0x80, 0xFE, 0x1E, 0x60, 0xC1,
  0x02, 0x04, 0x08, 0x10, 0x60, 0x81, 0x02, 0x04, 0x08, 0x3C, 0x00, 0x88,
  0xC4, 0x44, 0x46, 0x22, 0x23, 0x11, 0x10, 0x1E, 0x08, 0x10, 0x20, 0x41,
  0x83, 0x04, 0x08, 0x10, 0x20, 0x41, 0x82, 0x3C, 0x00, 0x18, 0x62, 0x9B,
  0x46, 0x18, 0x40, 0xFF, 0xC8, 0x80, 0x3F, 0x67, 0x42, 0x42, 0x42, 0xC2,
  0xC6, 0xC6, 0x7C, 0x20, 0x20, 0x60, 0x5E, 0x62, 0x42, 0x42, 0x42, 0xC2,
  0xC6, 0xC4, 0xB8, 0x1C, 0x62, 0x42, 0x40, 0xC0, 0xC0, 0xC2, 0xC4, 0x78,
  0x01, 0x01, 0x01, 0x3F, 0x67, 0x42, 0x42, 0x42, 0xC2, 0xC6, 0xC6, 0x7C,
  0x1C, 0xC5, 0x0A, 0x1F, 0xF8, 0x20, 0x63, 0x78, 0x01, 0xE0, 0x60, 0x18,
  0x03, 0x03, 0xFC, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x04,
  0x00, 0x80, 0x30, 0x3C, 0x00, 0x3F, 0x67, 0x42, 0x42, 0x42, 0xC2, 0xC6,
  0x7E, 0x04, 0x04, 0x0C, 0xF8, 0x20, 0x20, 0x60, 0x5E, 0x62, 0x42, 0x42,
  0x42, 0xC2, 0xC2, 0x86, 0x84, 0x0C, 0x08, 0x03, 0xC0, 0x81, 0x02, 0x0C,
  0x18, 0x20, 0x47, 0xF0, 0x03, 0x01, 0x00, 0x3F, 0x02, 0x02, 0x02, 0x02,
  0x06, 0x06, 0x04, 0x04, 0x04, 0x08, 0xF0, 0x20, 0x20, 0x60, 0x61, 0x42,
  0x44, 0x4C, 0x78, 0xC8, 0xCC, 0x84, 0x86, 0xF0, 0xC2, 0x08, 0x20, 0x82,
  0x18, 0x41, 0x04, 0x0F, 0x3B, 0x92, 0x59, 0x29, 0xB4, 0x92, 0x49, 0x24,
  0x92, 0xC9, 0x00, 0x7E, 0x62, 0x42, 0x42, 0x42, 0xC2, 0xC2, 0x86, 0x84,
  0x1C, 0xC5, 0x0A, 0x1C, 0x38, 0x71, 0xE2, 0x78, 0x3F, 0x18, 0x88, 0x44,
  0x22, 0x13, 0x09, 0x8C, 0xC4, 0x5C, 0x20, 0x10, 0x18, 0x00, 0x3F, 0x67,
  0x42, 0x42, 0xC2, 0xC2, 0xC6, 0xC6, 0x7C, 0x04, 0x04, 0x04, 0x7E, 0x63,
  0x63, 0x43, 0x40, 0x40, 0x40, 0xC0, 0x80, 0x3E, 0xC5, 0x03, 0x03, 0xC0,
  0xC0, 0xE3, 0x7C, 0x18, 0x18, 0x7F, 0x90, 0x10, 0x10, 0x30, 0x30, 0x20,
  0x20, 0x1E, 0x43, 0x43, 0x42, 0x42, 0x42, 0xC2, 0xC6, 0xC4, 0x78, 0x83,
  0x0E, 0x16, 0x6C, 0x8B, 0x14, 0x38, 0x60, 0x89, 0xCC, 0xA6, 0x53, 0x2A,
  0xA5, 0x52, 0xA9, 0x98, 0xCC, 0x00, 0x21, 0x88, 0x84, 0x81, 0x80, 0xC0,
  0xE0, 0xD8, 0xC4, 0xC3, 0x00, 0x43, 0x43, 0x42, 0x42, 0x42, 0xC2, 0xC6,
  0x7E, 0x04, 0x04, 0x0C, 0xF8, 0x7F, 0x02, 0x04, 0x0C, 0x18, 0x30, 0x60,
  0xC0, 0xFE, 0x0F, 0x08, 0x08, 0x18, 0x18, 0x18, 0x10, 0xE0, 0x10, 0x10,
  0x30, 0x20, 0x20, 0x30, 0x18, 0x33, 0x22, 0x22, 0x66, 0x44, 0x44, 0x4C,
  0xC0, 0x1C, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x0C, 0x07, 0x08, 0x18, 0x18,
  0x10, 0x10, 0x30, 0xE0, 0x71, 0xDB, 0x8E,
};

const GFXglyph JetBrainsMono_LightItalic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 4, 12, 10, 3, -12 },
  { 7, 5, 5, 10, 3, -12 },
  { 11, 10, 12, 10, 0, -12 },
  { 26, 8, 16, 10, 1, -14 },
  { 42, 11, 12, 10, 0, -12 },
  { 59, 9, 12, 10, 0, -12 },
  { 73, 2, 5, 10, 5, -12 },
  { 75, 6, 16, 10, 3, -14 },
  { 87, 6, 16, 10, 1, -14 },
  { 99, 8, 8, 10, 1, -10 },
  { 107, 8, 7, 10, 1, -9 },
  { 114, 4, 5, 10, 2, -2 },
  { 117, 6, 1, 10, 2, -6 },
  { 118, 3, 2, 10, 3, -2 },
  { 119, 10, 15, 10, 0, -13 },
  { 138, 8, 12, 10, 1, -12 },
  { 150, 7, 12, 10, 1, -12 },
  { 161, 8, 12, 10, 1, -12 },
  { 173, 8, 12, 10, 1, -12 },
  { 185, 8, 12, 10, 1, -12 },
  { 197, 8, 12, 10, 1, -12 },
  { 209, 7, 12, 10, 1, -12 },
  { 220, 8, 12, 10, 2, -12 },
  { 232, 8, 12, 10, 1, -12 },
  { 244, 7, 12, 10, 2, -12 },
  { 255, 4, 9, 10, 3, -9 },
  { 260, 5, 12, 10, 2, -9 },
  { 268, 8, 8, 10, 1, -9 },
  { 276, 8, 5, 10, 1, -8 },
  { 281, 7, 8, 10, 1, -9 },
  { 288, 7, 12, 10, 2, -12 },
  { 299, 10, 15, 10, 0, -12 },
  { 318, 8, 12, 10, 0, -12 },
  { 330, 8, 12, 10, 1, -12 },
  { 342, 8, 12, 10, 1, -12 },
  { 354, 8, 12, 10, 1, -12 },
  { 366, 8, 12, 10, 1, -12 },
  { 378, 9, 12, 10, 1, -12 },
  { 392, 8, 12, 10, 1, -12 },
  { 404, 8, 12, 10, 1, -12 },
  { 416, 8, 12, 10, 1, -12 },
  { 428, 9, 12, 10, 0, -12 },
  { 442, 9, 12, 10, 1, -12 },
  { 456, 7, 12, 10, 1, -12 },
  { 467, 8, 12, 10, 1, -12 },
  { 479, 8, 12, 10, 1, -12 },
  { 491, 8, 12, 10, 1, -12 },
  { 503, 9, 12, 10, 1, -12 },
  { 517, 8, 15, 10, 1, -12 },
  { 532, 8, 12, 10, 1, -12 },
  { 544, 8, 12, 10, 1, -12 },
  { 556, 8, 12, 10, 2, -12 },
  { 568, 8, 12, 10, 1, -12 },
  { 580, 8, 12, 10, 2, -12 },
  { 592, 9, 12, 10, 1, -12 },
  { 606, 10, 12, 10, 0, -12 },
  { 621, 8, 12, 10, 2, -12 },
  { 633, 8, 12, 10, 1, -12 },
  { 645, 7, 15, 10, 2, -13 },
  { 659, 4, 15, 10, 3, -13 },
  { 667, 7, 15, 10, 1, -13 },
  { 681, 6, 7, 10, 2, -12 },
  { 687, 8, 1, 10, 0, 0 },
  { 688, 3, 3, 10, 4, -13 },
  { 690, 8, 9, 10, 1, -9 },
  { 699, 8, 12, 10, 1, -12 },
  { 711, 8, 9, 10, 1, -9 },
  { 720, 8, 12, 10, 1, -12 },
  { 732, 7, 9, 10, 1, -9 },
  { 740, 11, 15, 10, -1, -12 },
  { 761, 8, 12, 10, 1, -9 },
  { 773, 8, 12, 10, 1, -12 },
  { 785, 7, 12, 10, 1, -12 },
  { 796, 8, 15, 10, 0, -12 },
  { 811, 8, 12, 10, 1, -12 },
  { 823, 6, 12, 10, 2, -12 },
  { 832, 9, 9, 10, 0, -9 },
  { 843, 8, 9, 10, 1, -9 },
  { 852, 7, 9, 10, 1, -9 },
  { 860, 9, 12, 10, 0, -9 },
  { 874, 8, 12, 10, 1, -9 },
  { 886, 8, 9, 10, 1, -9 },
  { 895, 7, 9, 10, 1, -9 },
  { 903, 8, 11, 10, 1, -11 },
  { 914, 8, 9, 10, 1, -9 },
  { 923, 7, 9, 10, 2, -9 },
  { 931, 9, 9, 10, 1, -9 },
  { 942, 9, 9, 10, 0, -9 },
  { 953, 8, 12, 10, 1, -9 },
  { 965, 8, 9, 10, 1, -9 },
  { 974, 8, 15, 10, 2, -13 },
  { 989, 4, 15, 10, 3, -13 },
  { 997, 8, 15, 10, 0, -13 },
  { 1012, 8, 3, 10, 1, -7 },
};

const GFXfont JetBrainsMono_LightItalic16pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_LightItalic16pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_LightItalic16pt7bGlyphs,
  0x20, 0x7E, 21
};

#endif // _JETBRAINSMONO_LIGHTITALIC16PT7B_H_
