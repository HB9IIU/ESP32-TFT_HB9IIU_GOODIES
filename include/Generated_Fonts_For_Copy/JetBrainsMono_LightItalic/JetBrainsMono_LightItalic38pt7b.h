#ifndef _JETBRAINSMONO_LIGHTITALIC38PT7B_H_
#define _JETBRAINSMONO_LIGHTITALIC38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-LightItalic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_LightItalic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x3C, 0x1E, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x38, 0x1C, 0x0E, 0x06, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x3E, 0x3F, 0x0F, 0x00, 0x38, 0x7B, 0xC3,
  0x9E, 0x1C, 0xE0, 0xE7, 0x07, 0x38, 0x39, 0xC3, 0xCE, 0x1C, 0x60, 0xE7,
  0x07, 0x38, 0x39, 0xC1, 0x80, 0x00, 0x38, 0x18, 0x00, 0xC0, 0xE0, 0x07,
  0x03, 0x80, 0x1C, 0x0C, 0x00, 0x60, 0x70, 0x03, 0x81, 0xC0, 0x0C, 0x06,
  0x00, 0x30, 0x38, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0x18, 0x1C, 0x00,
  0xE0, 0x60, 0x03, 0x01, 0x80, 0x1C, 0x0E, 0x00, 0x70, 0x30, 0x01, 0x80,
  0xC0, 0x0E, 0x07, 0x00, 0x38, 0x18, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8,
  0x1C, 0x0C, 0x00, 0x60, 0x70, 0x03, 0x81, 0xC0, 0x0E, 0x06, 0x00, 0x30,
  0x38, 0x01, 0xC0, 0xE0, 0x07, 0x03, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07,
  0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0x19, 0xE0, 0xE1, 0x8E, 0x0E,
  0x38, 0xE1, 0xC3, 0x0E, 0x1C, 0x30, 0x01, 0xC3, 0x00, 0x1E, 0x30, 0x01,
  0xE3, 0x00, 0x0F, 0x70, 0x00, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x00, 0x06, 0x78, 0x00, 0x63, 0x80, 0x0C, 0x38, 0x00, 0xC3,
  0xC0, 0x0C, 0x38, 0xE0, 0xC3, 0x8E, 0x0C, 0x38, 0xF0, 0xC7, 0x87, 0x1C,
  0xF0, 0x7F, 0xBE, 0x03, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0xF0, 0x01,
  0xC0, 0xFE, 0x00, 0xE0, 0x7B, 0xC0, 0x70, 0x38, 0x70, 0x18, 0x0C, 0x0C,
  0x0C, 0x03, 0x07, 0x07, 0x00, 0xC1, 0xC3, 0x80, 0x70, 0x71, 0xC0, 0x1C,
  0x18, 0xE0, 0x07, 0x0E, 0x30, 0x00, 0xFF, 0x98, 0x00, 0x3F, 0xCC, 0x00,
  0x03, 0xC7, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE1,
  0x80, 0x00, 0x31, 0xF8, 0x00, 0x18, 0xFF, 0x00, 0x0E, 0x70, 0xE0, 0x07,
  0x38, 0x38, 0x03, 0x8E, 0x0E, 0x01, 0xC3, 0x83, 0x00, 0x60, 0xC0, 0xC0,
  0x30, 0x30, 0x30, 0x18, 0x0C, 0x1C, 0x0E, 0x03, 0x8E, 0x07, 0x00, 0xFF,
  0x03, 0x80, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0,
  0x07, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x7C, 0x00, 0x0F, 0xF0, 0x00, 0xF3, 0x81, 0xE7, 0x1E, 0x0E, 0x70, 0x70,
  0xE3, 0x83, 0xCE, 0x1C, 0x0E, 0x70, 0xE0, 0x3F, 0x07, 0x01, 0xF0, 0x38,
  0x07, 0x83, 0x80, 0x3C, 0x1C, 0x03, 0xE0, 0xF0, 0x3F, 0x83, 0xC7, 0x9C,
  0x1F, 0xF8, 0x70, 0x7F, 0x83, 0xC0, 0x7B, 0x9C, 0xE7, 0x7B, 0xDC, 0xE7,
  0x39, 0xC0, 0x00, 0x03, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xE0,
  0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xC0,
  0x01, 0xC0, 0x00, 0x40, 0x03, 0x00, 0x07, 0x80, 0x1F, 0x80, 0x0F, 0x80,
  0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0x80, 0x08,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x04, 0x07, 0x01, 0x78, 0x70, 0xFF, 0xE6, 0x7F, 0x7F, 0x6F,
  0xE0, 0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x1B, 0x00, 0x03, 0xB8, 0x00, 0x73,
  0x80, 0x0F, 0x3C, 0x01, 0xE1, 0xE0, 0x3C, 0x1E, 0x07, 0x80, 0xF0, 0x10,
  0x0C, 0x00, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0x07, 0x87, 0xC3, 0xC3, 0xE1, 0xE0, 0xE0,
  0xF0, 0x70, 0x78, 0x38, 0x3C, 0x1C, 0x00, 0x7F, 0xFB, 0xFF, 0xFF, 0xFE,
  0x39, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F,
  0xF8, 0x07, 0xFF, 0xC0, 0xF0, 0x1E, 0x0E, 0x00, 0xE1, 0xE0, 0x0E, 0x1C,
  0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x00, 0xE3,
  0x80, 0x0E, 0x38, 0xF1, 0xC3, 0x8F, 0x1C, 0x38, 0xF1, 0xC7, 0x0F, 0x1C,
  0x70, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x03, 0x87, 0x00, 0x38, 0x70, 0x03,
  0x87, 0x00, 0x38, 0x70, 0x07, 0x87, 0x00, 0x70, 0x78, 0x0F, 0x03, 0xE7,
  0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x7F,
  0x80, 0x7B, 0x80, 0xF9, 0xC0, 0xF0, 0xE0, 0x70, 0x70, 0x20, 0x38, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x1F,
  0xFF, 0x07, 0x80, 0xF0, 0xE0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x39, 0xC0,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF,
  0x80, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x39, 0xC0, 0x0F, 0x38, 0x01, 0xC7, 0x80, 0x78, 0x70, 0x1E,
  0x0F, 0xCF, 0x80, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x03,
  0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x38,
  0xF0, 0x38, 0xF0, 0x1C, 0xF0, 0x0E, 0x70, 0x07, 0x70, 0x03, 0xB8, 0x01,
  0xDF, 0xFF, 0xEF, 0xFF, 0xE7, 0xFF, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x0F, 0xFF, 0xC3, 0xFF,
  0xF1, 0xFF, 0xFC, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x9F, 0xC0, 0xEF, 0xF8, 0x3F,
  0xBF, 0x0F, 0x03, 0xC7, 0x80, 0x71, 0xC0, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xCE, 0x00, 0xE3,
  0x80, 0x38, 0xF0, 0x1C, 0x3F, 0x3F, 0x07, 0xFF, 0x80, 0x7F, 0x80, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x39, 0xF8, 0x1F, 0xFF, 0x07, 0xF7, 0xE3, 0xC0, 0x78, 0xE0, 0x0F, 0x78,
  0x01, 0xDC, 0x00, 0x77, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00,
  0xEF, 0x00, 0x39, 0xC0, 0x1C, 0x78, 0x0F, 0x1F, 0x9F, 0x83, 0xFF, 0xC0,
  0x3F, 0xC0, 0x7F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0E, 0xE0,
  0x03, 0xB8, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x38, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xFF,
  0x03, 0x80, 0xF0, 0xE0, 0x0E, 0x1C, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x07,
  0x1C, 0x01, 0xC1, 0xC0, 0x38, 0x38, 0x0E, 0x03, 0xC7, 0x80, 0x3F, 0xE0,
  0x03, 0xF0, 0x00, 0xFF, 0x00, 0x78, 0xF0, 0x1E, 0x0F, 0x07, 0x00, 0xF1,
  0xE0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x39, 0xC0, 0x07, 0x3C, 0x00, 0xE3,
  0x80, 0x38, 0x78, 0x0F, 0x0F, 0xCF, 0xC0, 0xFF, 0xF0, 0x0F, 0xF8, 0x00,
  0x01, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0xF0, 0xF0, 0x1E, 0x38, 0x03, 0x9C,
  0x00, 0xE7, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x03, 0xB8, 0x00, 0xEE, 0x00,
  0x3B, 0x80, 0x1E, 0xF0, 0x07, 0x3C, 0x03, 0xC7, 0xC3, 0xE0, 0xFF, 0xF8,
  0x1F, 0xDC, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x0F, 0x0F, 0xC7, 0xE3, 0xE1, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x7E, 0x3F,
  0x1F, 0x87, 0x80, 0x01, 0xE0, 0x3F, 0x03, 0xF0, 0x7F, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0xC0,
  0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x78, 0x00, 0x18, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xC0, 0x00, 0x20, 0x7F, 0xFF, 0xDF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xCF, 0xFF, 0xF0, 0x18, 0x00, 0x07, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x00, 0x3F,
  0x80, 0x7F, 0xE0, 0xFF, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x0F, 0x03,
  0xFE, 0x07, 0xF0, 0x0F, 0x80, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x07, 0xC3,
  0xE0, 0x1E, 0x01, 0xE0, 0x78, 0x01, 0xC0, 0xE0, 0x01, 0x83, 0x80, 0x03,
  0x87, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x18, 0x70, 0x3F, 0x30,
  0xE0, 0xFF, 0x61, 0x83, 0xC3, 0xC3, 0x07, 0x03, 0x8E, 0x0C, 0x07, 0x1C,
  0x38, 0x0C, 0x38, 0x70, 0x18, 0x70, 0xE0, 0x70, 0xC1, 0xC0, 0xE1, 0x83,
  0x81, 0xC7, 0x06, 0x03, 0x8E, 0x0C, 0x07, 0x1C, 0x1C, 0x1C, 0x38, 0x3C,
  0xD8, 0x70, 0x7F, 0xB0, 0xC0, 0x3C, 0xE1, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xB8, 0x00, 0x77, 0x00,
  0x0C, 0xE0, 0x03, 0x9C, 0x00, 0x73, 0x80, 0x1C, 0x70, 0x03, 0x8E, 0x00,
  0xE1, 0xC0, 0x1C, 0x18, 0x03, 0x83, 0x80, 0xE0, 0x70, 0x1C, 0x0E, 0x07,
  0x01, 0xC0, 0xE0, 0x38, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xE0, 0x1C, 0x38,
  0x03, 0x87, 0x00, 0x31, 0xC0, 0x07, 0x38, 0x00, 0xEF, 0x00, 0x1D, 0xC0,
  0x03, 0xF8, 0x00, 0x70, 0x0F, 0xFC, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07,
  0x01, 0xF0, 0xE0, 0x1E, 0x1C, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x07, 0x1C,
  0x00, 0xE3, 0x80, 0x38, 0x70, 0x07, 0x0E, 0x03, 0xC3, 0xFF, 0xF0, 0x7F,
  0xF8, 0x0F, 0xFF, 0xC1, 0xC0, 0x3C, 0x38, 0x03, 0x87, 0x00, 0x78, 0xE0,
  0x07, 0x38, 0x00, 0xE7, 0x00, 0x3C, 0xE0, 0x07, 0x1C, 0x00, 0xE3, 0x80,
  0x38, 0x70, 0x0F, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0x81, 0xE1, 0xC0, 0x1C, 0x38,
  0x03, 0x8E, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x71, 0xC0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x70, 0xF0, 0x1E, 0x0F, 0x9F,
  0x81, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F,
  0xFE, 0x07, 0x03, 0xE0, 0xE0, 0x1C, 0x1C, 0x03, 0xC7, 0x00, 0x38, 0xE0,
  0x07, 0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x07, 0x0E, 0x00, 0xE3, 0x80,
  0x1C, 0x70, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x03, 0x87, 0x00,
  0x70, 0xE0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x0E, 0x1C, 0x01,
  0xC3, 0x80, 0x78, 0x70, 0x1E, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xE0,
  0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xFF, 0x81, 0xFF, 0xF8,
  0x3F, 0xFF, 0x83, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0x81, 0xE1, 0xC0,
  0x1C, 0x38, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x3F,
  0xE3, 0x87, 0xFC, 0x70, 0xFF, 0x8E, 0x00, 0x73, 0x80, 0x1C, 0x70, 0x03,
  0x8E, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x70, 0xF0, 0x1E,
  0x0F, 0x9F, 0x81, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x0E, 0x00, 0x70, 0xE0,
  0x07, 0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x1C,
  0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x01, 0xE1, 0xC0, 0x1C, 0x1C, 0x01, 0xC1,
  0xC0, 0x1C, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0x80, 0x38,
  0x38, 0x03, 0x83, 0x80, 0x38, 0x38, 0x03, 0x87, 0x00, 0x38, 0x70, 0x03,
  0x87, 0x00, 0x70, 0x70, 0x07, 0x07, 0x00, 0x70, 0x70, 0x07, 0x0E, 0x00,
  0x70, 0xE0, 0x07, 0x0E, 0x00, 0xF0, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F,
  0xFF, 0x80, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0x38, 0xF0, 0x03, 0x8E, 0x00, 0x38, 0xF0, 0x07, 0x87, 0x00,
  0x70, 0x78, 0x0F, 0x07, 0xE7, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x00, 0x0E,
  0x00, 0x38, 0x70, 0x03, 0xC3, 0x80, 0x1C, 0x1C, 0x01, 0xC0, 0xE0, 0x1E,
  0x07, 0x00, 0xE0, 0x70, 0x0E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x00, 0xE0,
  0x70, 0x07, 0x07, 0x80, 0x38, 0x38, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x38, 0x01, 0xC0, 0xE0, 0x0E, 0x07,
  0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x3C, 0x0E,
  0x00, 0xE0, 0x70, 0x07, 0x07, 0x00, 0x3C, 0x38, 0x00, 0xE1, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x7C,
  0x1E, 0x01, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x36, 0x0D, 0xC1, 0xF8, 0x37,
  0x06, 0xE0, 0xDC, 0x3B, 0x83, 0x30, 0xCC, 0x1C, 0xC7, 0x30, 0x73, 0x19,
  0xC1, 0xCE, 0xE7, 0x07, 0x3B, 0x1C, 0x1C, 0x6C, 0x70, 0x71, 0xE3, 0x81,
  0x87, 0x8E, 0x0E, 0x1C, 0x38, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80,
  0x0E, 0x0E, 0x00, 0x70, 0x38, 0x01, 0xC1, 0xC0, 0x07, 0x07, 0x00, 0x1C,
  0x1C, 0x00, 0x70, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x07, 0x00, 0x38, 0x38,
  0x00, 0xE0, 0x0F, 0x00, 0x70, 0xF8, 0x07, 0x0F, 0x80, 0x70, 0xF8, 0x0E,
  0x0D, 0x80, 0xE1, 0xD8, 0x0E, 0x1D, 0xC0, 0xE1, 0xDC, 0x0E, 0x1D, 0xC0,
  0xE1, 0xCC, 0x0C, 0x1C, 0xE1, 0xC1, 0x8E, 0x1C, 0x38, 0xE1, 0xC3, 0x8E,
  0x1C, 0x38, 0x61, 0xC3, 0x87, 0x1C, 0x38, 0x73, 0x83, 0x87, 0x38, 0x70,
  0x33, 0x87, 0x03, 0x38, 0x70, 0x3B, 0x87, 0x03, 0xB8, 0x70, 0x3B, 0x07,
  0x01, 0xB0, 0xE0, 0x1F, 0x0E, 0x01, 0xF0, 0xE0, 0x1F, 0x0E, 0x01, 0xF0,
  0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3C, 0x0F, 0x1C, 0x03, 0xC7,
  0x00, 0x73, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x01, 0xCE, 0x00, 0x73, 0x80,
  0x39, 0xC0, 0x0E, 0x70, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x0E,
  0x70, 0x07, 0x1C, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x07, 0x38,
  0x01, 0xCE, 0x00, 0xE3, 0x80, 0x38, 0xF0, 0x1C, 0x1F, 0x3F, 0x07, 0xFF,
  0x80, 0x7F, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1C,
  0x03, 0xE0, 0xE0, 0x0F, 0x07, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x0E,
  0x1C, 0x00, 0x70, 0xE0, 0x03, 0x87, 0x00, 0x3C, 0x38, 0x01, 0xC3, 0x80,
  0x1E, 0x1C, 0x07, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x1F, 0xFF,
  0x03, 0xC0, 0xF0, 0xE0, 0x0E, 0x3C, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x07,
  0x1C, 0x00, 0xE3, 0x80, 0x1C, 0xE0, 0x03, 0x9C, 0x00, 0xE3, 0x80, 0x1C,
  0x70, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x0E, 0x70, 0x01, 0xCE, 0x00, 0x79,
  0xC0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x07, 0x1C, 0x01, 0xC3,
  0x80, 0x38, 0x78, 0x0E, 0x07, 0xCF, 0xC0, 0xFF, 0xF0, 0x07, 0xF8, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0xE0, 0x1E, 0x0E, 0x00, 0xF0, 0xE0, 0x0F, 0x1C, 0x00, 0x71, 0xC0,
  0x07, 0x1C, 0x00, 0xF1, 0xC0, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x1E, 0x38,
  0x03, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x38, 0x38, 0x03,
  0x83, 0x80, 0x38, 0x3C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xE0,
  0x70, 0x0E, 0x07, 0x00, 0xE0, 0x70, 0x0F, 0x0E, 0x00, 0x70, 0xE0, 0x07,
  0x0E, 0x00, 0x78, 0x00, 0x7F, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x70,
  0x1E, 0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x03,
  0x8F, 0x00, 0x78, 0x70, 0x0F, 0x07, 0xE3, 0xE0, 0x3F, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0xE3, 0x80,
  0x1C, 0x70, 0x03, 0x8E, 0x00, 0xE1, 0xC0, 0x1C, 0x78, 0x03, 0x8E, 0x00,
  0x71, 0xC0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x70, 0xE0, 0x0E, 0x1C, 0x01,
  0xC7, 0x00, 0x38, 0xE0, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x3C, 0x70, 0x07,
  0x0E, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x1E,
  0x38, 0x03, 0x87, 0x00, 0x70, 0xF0, 0x1C, 0x0F, 0x9F, 0x81, 0xFF, 0xE0,
  0x0F, 0xF0, 0x00, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0E,
  0xE0, 0x03, 0xB8, 0x01, 0xCE, 0x00, 0x71, 0xC0, 0x38, 0x70, 0x0E, 0x1C,
  0x07, 0x87, 0x01, 0xC1, 0xC0, 0x70, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x07,
  0x01, 0xC1, 0xC0, 0x70, 0x70, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0xE7, 0x00,
  0x39, 0xC0, 0x0E, 0x70, 0x03, 0xB8, 0x00, 0xEE, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x70, 0x78, 0x1B, 0x83, 0xC1, 0xDC,
  0x1E, 0x0E, 0xC0, 0xF0, 0x76, 0x0D, 0x83, 0x30, 0x6C, 0x39, 0x83, 0x61,
  0xCC, 0x33, 0x0C, 0xE1, 0x98, 0xE7, 0x0C, 0x87, 0x38, 0x6C, 0x39, 0xC6,
  0x61, 0x8E, 0x33, 0x1C, 0x71, 0x98, 0xE3, 0x98, 0xC6, 0x1C, 0xC6, 0x30,
  0xE6, 0x33, 0x87, 0x31, 0x9C, 0x3B, 0x0C, 0xC1, 0xD8, 0x6E, 0x0E, 0xC3,
  0x70, 0x7C, 0x1B, 0x83, 0x60, 0xD8, 0x1B, 0x07, 0xC0, 0xD8, 0x3E, 0x07,
  0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x00, 0x0E, 0x0F,
  0x00, 0x3C, 0x0E, 0x00, 0xF0, 0x1C, 0x01, 0xC0, 0x1C, 0x07, 0x00, 0x38,
  0x1E, 0x00, 0x70, 0x38, 0x00, 0x70, 0xE0, 0x00, 0xE3, 0x80, 0x00, 0xE7,
  0x00, 0x01, 0xDC, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xDC, 0x00,
  0x07, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x78, 0x70, 0x00, 0xE0, 0x70, 0x03,
  0x80, 0xE0, 0x0F, 0x01, 0xE0, 0x3C, 0x01, 0xC0, 0x70, 0x03, 0x81, 0xE0,
  0x03, 0x87, 0x80, 0x07, 0x80, 0xE0, 0x00, 0x77, 0x00, 0x0E, 0x70, 0x01,
  0xE7, 0x00, 0x1C, 0x38, 0x03, 0x83, 0x80, 0x78, 0x38, 0x07, 0x01, 0xC0,
  0xE0, 0x1C, 0x0E, 0x01, 0xC1, 0xC0, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x0E,
  0x70, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xC0, 0x07, 0x00, 0x3C, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xFE,
  0x0F, 0xF8, 0x3F, 0xE0, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xF0,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0xFF, 0x81, 0xFF, 0x07,
  0xFE, 0x00, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xB8, 0x03, 0xB8,
  0x03, 0x18, 0x07, 0x18, 0x0E, 0x1C, 0x0E, 0x1C, 0x1C, 0x0C, 0x38, 0x0E,
  0x38, 0x0E, 0x70, 0x06, 0x70, 0x06, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0x00, 0xF0, 0xE0, 0xE1, 0xE1, 0xE0, 0x01, 0xF8, 0xE0,
  0xFF, 0x9C, 0x3F, 0x7F, 0x0F, 0x01, 0xE1, 0xC0, 0x3C, 0x78, 0x03, 0x8E,
  0x00, 0x71, 0xC0, 0x0E, 0x38, 0x03, 0x87, 0x00, 0x70, 0xE0, 0x0E, 0x38,
  0x01, 0xC7, 0x00, 0x38, 0xE0, 0x07, 0x1C, 0x01, 0xE3, 0x80, 0x38, 0x70,
  0x07, 0x0F, 0x01, 0xE1, 0xF8, 0xDC, 0x1F, 0xFB, 0x81, 0xFC, 0xF0, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0x71, 0xF8, 0x1D, 0xFF, 0x87, 0xF3, 0xE1, 0xE0, 0x3C,
  0x70, 0x07, 0x3C, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x07, 0x38,
  0x03, 0x8E, 0x00, 0xE3, 0x80, 0x39, 0xC0, 0x0E, 0x70, 0x03, 0x9C, 0x00,
  0xE7, 0x00, 0x71, 0xC0, 0x1C, 0x78, 0x0E, 0x3B, 0x8F, 0x8E, 0xFF, 0xC3,
  0x9F, 0xC0, 0x03, 0xFC, 0x03, 0xFF, 0x81, 0xFB, 0xF0, 0x70, 0x1E, 0x38,
  0x03, 0x9E, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x73,
  0x80, 0x3C, 0xE0, 0x0E, 0x3C, 0x07, 0x87, 0xC7, 0xC1, 0xFF, 0xE0, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x1F, 0x8E, 0x07, 0xFC,
  0xE0, 0xFD, 0xFC, 0x1E, 0x03, 0xC1, 0xC0, 0x3C, 0x3C, 0x01, 0xC3, 0x80,
  0x1C, 0x38, 0x01, 0xC3, 0x80, 0x38, 0x38, 0x03, 0x83, 0x80, 0x38, 0x70,
  0x03, 0x87, 0x00, 0x38, 0x70, 0x03, 0x87, 0x00, 0x78, 0x70, 0x07, 0x07,
  0x00, 0x70, 0x78, 0x0F, 0x07, 0xE3, 0x70, 0x3F, 0xF7, 0x01, 0xFC, 0xF0,
  0x03, 0xFC, 0x07, 0xFF, 0x07, 0xC7, 0xC3, 0x80, 0xE3, 0x80, 0x39, 0xC0,
  0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x03, 0xBF, 0xFF, 0xBF, 0xFF, 0xDC,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x0E,
  0x78, 0x0F, 0x1E, 0x1F, 0x0F, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF1, 0xC3, 0xFE, 0x71, 0xFB, 0xF8, 0xF0, 0x1E,
  0x38, 0x07, 0x9E, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x0E, 0x70, 0x07, 0x1C,
  0x01, 0xC7, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x03, 0xCE, 0x00,
  0xF3, 0xC0, 0x78, 0x78, 0x3E, 0x1F, 0xFB, 0x83, 0xFC, 0xE0, 0x18, 0x38,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x1F,
  0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x71, 0xF8,
  0x1D, 0xFF, 0x87, 0xE3, 0xE1, 0xE0, 0x3C, 0x70, 0x0F, 0x3C, 0x01, 0xCE,
  0x00, 0x73, 0x80, 0x1C, 0xE0, 0x0F, 0x38, 0x03, 0x8E, 0x00, 0xE3, 0x80,
  0x39, 0xC0, 0x0E, 0x70, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0x71, 0xC0, 0x1C,
  0x70, 0x07, 0x38, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x1C, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x1F, 0xFC, 0x03,
  0xFF, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x0F, 0x1C, 0x01, 0xE1, 0xC0, 0x3C, 0x1C, 0x03, 0x81, 0xC0, 0x70, 0x1C,
  0x0F, 0x03, 0x81, 0xE0, 0x38, 0x3C, 0x03, 0x87, 0x80, 0x3F, 0xF0, 0x03,
  0xFF, 0x00, 0x3F, 0xF0, 0x07, 0x87, 0x80, 0x70, 0x38, 0x07, 0x03, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xE0, 0x70, 0x0E, 0x07, 0x00, 0xF0, 0xE0, 0x07,
  0x0E, 0x00, 0x78, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0x0F, 0xFE, 0x03, 0xFE, 0x1D,
  0xF3, 0xE1, 0xFF, 0x7F, 0x1E, 0x7C, 0x71, 0xC3, 0x87, 0x18, 0x38, 0x73,
  0x83, 0x07, 0x38, 0x30, 0x73, 0x83, 0x07, 0x38, 0x70, 0x63, 0x87, 0x0E,
  0x30, 0x70, 0xE7, 0x07, 0x0E, 0x70, 0x60, 0xE7, 0x06, 0x0E, 0x70, 0xE0,
  0xE7, 0x0E, 0x0C, 0x60, 0xE1, 0xCE, 0x0E, 0x1C, 0xE0, 0xC1, 0xCE, 0x0C,
  0x1C, 0xE1, 0xC1, 0xC0, 0x1C, 0x7E, 0x07, 0x7F, 0xE1, 0xF8, 0xF8, 0x78,
  0x0F, 0x1C, 0x03, 0xCF, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x03,
  0xCE, 0x00, 0xE3, 0x80, 0x39, 0xE0, 0x0E, 0x70, 0x03, 0x9C, 0x00, 0xE7,
  0x00, 0x39, 0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x01, 0xCE, 0x00, 0x73, 0x80,
  0x1C, 0xE0, 0x07, 0x00, 0x03, 0xFC, 0x07, 0xFF, 0x07, 0xEF, 0xC3, 0x80,
  0xE3, 0x80, 0x3B, 0xC0, 0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x03, 0xB8,
  0x03, 0xBC, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x1D,
  0xC0, 0x1C, 0xE0, 0x0E, 0x78, 0x0E, 0x1F, 0x3F, 0x0F, 0xFF, 0x01, 0xFE,
  0x00, 0x0E, 0x3F, 0x01, 0xDF, 0xF8, 0x3F, 0x9F, 0x07, 0x80, 0xF0, 0xE0,
  0x0E, 0x3C, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x07, 0x1C, 0x00, 0xE3, 0x80,
  0x38, 0x70, 0x07, 0x1E, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x03, 0x8E, 0x00,
  0x71, 0xC0, 0x1C, 0x38, 0x03, 0x87, 0x80, 0xE1, 0xDC, 0x7C, 0x3B, 0xFF,
  0x07, 0x3F, 0x80, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x00, 0x01, 0xF8, 0xE0, 0xFF,
  0x9C, 0x3F, 0x7F, 0x0F, 0x01, 0xE1, 0xC0, 0x3C, 0x78, 0x03, 0x8E, 0x00,
  0x71, 0xC0, 0x0E, 0x38, 0x03, 0x87, 0x00, 0x71, 0xE0, 0x0E, 0x38, 0x01,
  0xC7, 0x00, 0x38, 0xE0, 0x07, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x0F,
  0x0F, 0x01, 0xE1, 0xF0, 0xDC, 0x1F, 0xFB, 0x81, 0xFC, 0x70, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x1C, 0xFE, 0x07, 0x7F, 0xC1, 0xF8, 0xF8, 0xF8, 0x0E,
  0x3C, 0x03, 0xCE, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x03, 0x8E,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xF8, 0xFC, 0x78, 0x07,
  0x1C, 0x01, 0xC7, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1F, 0x00, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0xF0, 0x07, 0x1C, 0x01, 0xC7, 0xC1, 0xE0, 0xFF, 0xF8,
  0x1F, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x07, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x3F, 0xE0, 0x38, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x38, 0xE0,
  0x0E, 0x38, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x0E, 0x70, 0x03,
  0x9C, 0x01, 0xC7, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x01, 0xCE,
  0x00, 0xF3, 0x80, 0x38, 0xE0, 0x0E, 0x3C, 0x07, 0x07, 0xCF, 0x80, 0xFF,
  0xC0, 0x1F, 0xE0, 0x00, 0xE0, 0x01, 0xF8, 0x00, 0xEE, 0x00, 0x39, 0xC0,
  0x1C, 0x70, 0x07, 0x1C, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x70, 0x30, 0x1C,
  0x0E, 0x0E, 0x03, 0x83, 0x80, 0xE1, 0xC0, 0x38, 0x70, 0x0E, 0x38, 0x01,
  0x8E, 0x00, 0x77, 0x00, 0x1D, 0xC0, 0x07, 0x60, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0xE0, 0x7E, 0x0E, 0x07, 0xE0, 0xE0, 0x6E,
  0x1B, 0x0E, 0xE1, 0xB0, 0xEE, 0x1B, 0x0C, 0xE3, 0x31, 0xCE, 0x33, 0x1C,
  0xE3, 0x31, 0x8E, 0x63, 0x38, 0xE6, 0x33, 0x8E, 0x63, 0x30, 0xEC, 0x37,
  0x0E, 0xC3, 0x70, 0xEC, 0x36, 0x0F, 0x83, 0x60, 0xF8, 0x3E, 0x0F, 0x83,
  0xC0, 0xD0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x00, 0x1E, 0x00, 0x78,
  0x78, 0x07, 0x81, 0xC0, 0x78, 0x0E, 0x07, 0x80, 0x38, 0x38, 0x01, 0xC3,
  0x80, 0x07, 0x38, 0x00, 0x3B, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xCE, 0x00, 0x1C, 0x70,
  0x01, 0xE1, 0xC0, 0x1E, 0x0F, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0xE0, 0xE0,
  0x07, 0x0F, 0x00, 0x3C, 0x00, 0x38, 0x01, 0xCE, 0x00, 0xF3, 0x80, 0x38,
  0xE0, 0x0E, 0x78, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x0E, 0x70,
  0x07, 0x1C, 0x01, 0xC7, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x03,
  0xCE, 0x00, 0xE3, 0xC0, 0x78, 0x78, 0x7E, 0x1F, 0xFB, 0x83, 0xFC, 0xE0,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x38, 0x1F, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0xC7, 0xFF,
  0xF1, 0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0F, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x70, 0x70,
  0x70, 0x70, 0x70, 0x70, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x03, 0x80,
  0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x01, 0xDF, 0xE0, 0x77, 0x3C, 0x1F, 0x87, 0x87, 0xE0, 0xE3, 0xB8,
  0x3F, 0xEE, 0x07, 0xE0,
};

const GFXglyph JetBrainsMono_LightItalic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 9, 28, 23, 7, -28 },
  { 33, 13, 12, 23, 7, -28 },
  { 53, 22, 28, 23, 1, -28 },
  { 130, 20, 38, 23, 2, -33 },
  { 225, 26, 28, 23, -1, -28 },
  { 316, 21, 28, 23, 1, -28 },
  { 390, 5, 12, 23, 11, -28 },
  { 398, 16, 37, 23, 6, -32 },
  { 472, 15, 37, 23, 2, -32 },
  { 542, 20, 19, 23, 2, -23 },
  { 590, 18, 17, 23, 3, -21 },
  { 629, 9, 12, 23, 4, -6 },
  { 643, 13, 3, 23, 5, -14 },
  { 648, 6, 6, 23, 7, -6 },
  { 653, 22, 36, 23, 1, -32 },
  { 752, 20, 28, 23, 2, -28 },
  { 822, 17, 28, 23, 2, -28 },
  { 882, 19, 28, 23, 2, -28 },
  { 949, 19, 28, 23, 2, -28 },
  { 1016, 17, 28, 23, 3, -28 },
  { 1076, 18, 28, 23, 3, -28 },
  { 1139, 18, 28, 23, 2, -28 },
  { 1202, 18, 28, 23, 5, -28 },
  { 1265, 19, 28, 23, 2, -28 },
  { 1332, 18, 28, 23, 4, -28 },
  { 1395, 9, 21, 23, 7, -21 },
  { 1419, 12, 27, 23, 4, -21 },
  { 1460, 18, 19, 23, 3, -22 },
  { 1503, 18, 11, 23, 3, -18 },
  { 1528, 18, 19, 23, 2, -22 },
  { 1571, 15, 28, 23, 6, -28 },
  { 1624, 23, 35, 23, 0, -28 },
  { 1725, 19, 28, 23, 0, -28 },
  { 1792, 19, 28, 23, 2, -28 },
  { 1859, 19, 28, 23, 3, -28 },
  { 1926, 19, 28, 23, 2, -28 },
  { 1993, 20, 28, 23, 2, -28 },
  { 2063, 21, 28, 23, 2, -28 },
  { 2137, 19, 28, 23, 3, -28 },
  { 2204, 20, 28, 23, 2, -28 },
  { 2274, 19, 28, 23, 2, -28 },
  { 2341, 20, 28, 23, 1, -28 },
  { 2411, 21, 28, 23, 2, -28 },
  { 2485, 16, 28, 23, 3, -28 },
  { 2541, 22, 28, 23, 1, -28 },
  { 2618, 20, 28, 23, 2, -28 },
  { 2688, 18, 28, 23, 3, -28 },
  { 2751, 21, 28, 23, 2, -28 },
  { 2825, 19, 35, 23, 2, -28 },
  { 2909, 20, 28, 23, 2, -28 },
  { 2979, 20, 28, 23, 2, -28 },
  { 3049, 19, 28, 23, 4, -28 },
  { 3116, 19, 28, 23, 3, -28 },
  { 3183, 18, 28, 23, 5, -28 },
  { 3246, 21, 28, 23, 3, -28 },
  { 3320, 23, 28, 23, 0, -28 },
  { 3401, 20, 28, 23, 4, -28 },
  { 3471, 20, 28, 23, 2, -28 },
  { 3541, 14, 36, 23, 6, -32 },
  { 3604, 11, 36, 23, 6, -32 },
  { 3654, 15, 36, 23, 3, -32 },
  { 3722, 16, 15, 23, 4, -28 },
  { 3752, 19, 3, 23, 0, 1 },
  { 3760, 7, 5, 23, 10, -30 },
  { 3765, 19, 21, 23, 2, -21 },
  { 3815, 18, 28, 23, 2, -28 },
  { 3878, 18, 21, 23, 3, -21 },
  { 3926, 20, 28, 23, 2, -28 },
  { 3996, 17, 21, 23, 3, -21 },
  { 4041, 26, 35, 23, -2, -28 },
  { 4155, 18, 28, 23, 3, -21 },
  { 4218, 18, 28, 23, 2, -28 },
  { 4281, 18, 29, 23, 2, -29 },
  { 4347, 19, 36, 23, 1, -29 },
  { 4433, 20, 28, 23, 2, -28 },
  { 4503, 16, 28, 23, 4, -28 },
  { 4559, 20, 21, 23, 1, -21 },
  { 4612, 18, 21, 23, 2, -21 },
  { 4660, 17, 21, 23, 3, -21 },
  { 4705, 19, 28, 23, 1, -21 },
  { 4772, 19, 28, 23, 2, -21 },
  { 4839, 18, 21, 23, 3, -21 },
  { 4887, 18, 21, 23, 2, -21 },
  { 4935, 18, 27, 23, 3, -27 },
  { 4996, 18, 21, 23, 3, -21 },
  { 5044, 18, 21, 23, 4, -21 },
  { 5092, 20, 21, 23, 3, -21 },
  { 5145, 21, 21, 23, 1, -21 },
  { 5201, 18, 28, 23, 3, -21 },
  { 5264, 18, 21, 23, 2, -21 },
  { 5312, 19, 36, 23, 4, -32 },
  { 5398, 8, 36, 23, 8, -32 },
  { 5434, 19, 36, 23, 1, -32 },
  { 5520, 18, 7, 23, 3, -17 },
};

const GFXfont JetBrainsMono_LightItalic38pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_LightItalic38pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_LightItalic38pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _JETBRAINSMONO_LIGHTITALIC38PT7B_H_
