#ifndef _JETBRAINSMONO_LIGHTITALIC69PT7B_H_
#define _JETBRAINSMONO_LIGHTITALIC69PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-LightItalic.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_LightItalic69pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC0, 0x7F, 0x80, 0x7F, 0x00, 0x1F, 0x80, 0xFE, 0x7E, 0x01, 0xF8, 0xFC,
  0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0,
  0x7F, 0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07,
  0xE3, 0xF0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C,
  0x3E, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87,
  0xC0, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x07, 0xC0,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xCF, 0x3F, 0xC0, 0x07, 0xF0, 0xF0,
  0xFE, 0x00, 0x7E, 0x0F, 0x07, 0xE0, 0x0F, 0xC0, 0xF0, 0x3E, 0x00, 0xF8,
  0x0E, 0x03, 0xF0, 0x1F, 0x81, 0xE0, 0x3F, 0x01, 0xF0, 0x1E, 0x03, 0xF0,
  0x1F, 0x01, 0xE0, 0x3F, 0x03, 0xF0, 0x1E, 0x00, 0x00, 0x3F, 0x01, 0xE0,
  0x00, 0x03, 0xF0, 0x1E, 0x00, 0x00, 0x3F, 0x01, 0xC0, 0x00, 0x03, 0xF8,
  0x3C, 0x00, 0x00, 0x1F, 0x83, 0xC0, 0x00, 0x01, 0xFC, 0x3C, 0x00, 0x00,
  0x1F, 0xE3, 0xC0, 0x00, 0x00, 0xFF, 0xBC, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xF3, 0xFE, 0x00, 0x00, 0x0F, 0x0F,
  0xE0, 0x00, 0x00, 0xF0, 0x7F, 0x00, 0x00, 0x0F, 0x03, 0xF0, 0x00, 0x00,
  0xF0, 0x3F, 0x00, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x00, 0xE0, 0x1F, 0x00,
  0x00, 0x1E, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x1F, 0x07, 0xE0, 0x1E, 0x01,
  0xF0, 0x7E, 0x01, 0xE0, 0x3F, 0x07, 0xE0, 0x1E, 0x03, 0xF0, 0x7E, 0x01,
  0xC0, 0x3E, 0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x7F, 0x03, 0xC0, 0xFC, 0x03,
  0xF8, 0x3C, 0x1F, 0xC0, 0x3F, 0xC3, 0xC3, 0xF8, 0x01, 0xFF, 0xBD, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xF0, 0x01, 0xFF,
  0xFC, 0x00, 0x07, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x03,
  0xE0, 0x03, 0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0x07, 0x80, 0x1F, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x3C,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x00, 0x7C, 0x00, 0xF0,
  0x1E, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x07, 0xC1,
  0xF0, 0x00, 0x03, 0xE0, 0x0F, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x3E, 0x1F,
  0x00, 0x00, 0x0F, 0xC0, 0xF8, 0x7C, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0xC3, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0xF8, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC1, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3C, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0xF0, 0xFF, 0x7F, 0x80, 0x00, 0x03, 0xE1, 0xF0, 0x1F, 0x00,
  0x00, 0x0F, 0x87, 0xC0, 0x3E, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x1E, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0xF8, 0x03, 0xE0, 0x00, 0x1E, 0x01, 0xF0, 0x07, 0xC0, 0x00,
  0x7C, 0x03, 0xC0, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x07,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x7C, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0,
  0x00, 0xFC, 0x1F, 0x80, 0x0F, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x3E, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x87, 0xE0,
  0x03, 0xE1, 0xF8, 0x1F, 0x80, 0x3F, 0x0F, 0x80, 0x7E, 0x03, 0xF0, 0xFC,
  0x03, 0xF0, 0x1F, 0x07, 0xC0, 0x0F, 0xC1, 0xF8, 0x3E, 0x00, 0x7E, 0x1F,
  0x81, 0xF0, 0x01, 0xF9, 0xF8, 0x0F, 0x80, 0x0F, 0xCF, 0x80, 0xFC, 0x00,
  0x3F, 0xFC, 0x07, 0xE0, 0x00, 0xFF, 0xC0, 0x3F, 0x00, 0x07, 0xFC, 0x01,
  0xF0, 0x00, 0x1F, 0xE0, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x03, 0xFE, 0x01, 0xF8,
  0x00, 0x3F, 0xF8, 0x07, 0xE0, 0x03, 0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0x3F,
  0x01, 0xFF, 0x1F, 0xF1, 0xF8, 0x07, 0xFF, 0xFF, 0x07, 0xE0, 0x3F, 0xFF,
  0xF0, 0x3F, 0x80, 0xFF, 0xFE, 0x00, 0xFC, 0x01, 0xFF, 0xC0, 0x03, 0xF0,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x7F, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0xFC, 0xFC, 0xFC, 0xFC, 0xF8, 0xF8, 0xF8,
  0xF8, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x30, 0x00, 0xF8, 0x00, 0x63, 0xE0, 0x0F, 0x80, 0x3E, 0x7F, 0xC0, 0xF0,
  0x1F, 0xF7, 0xFF, 0x0F, 0x07, 0xFF, 0xFF, 0xF8, 0xF1, 0xFF, 0xF7, 0xFF,
  0xEE, 0x7F, 0xFE, 0x0F, 0xFF, 0xEF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x01, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0,
  0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0,
  0x03, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0x0F, 0xC1, 0xFE, 0x3F, 0xF7, 0xFF, 0x7F,
  0xF7, 0xFF, 0x7F, 0xF7, 0xFE, 0x7F, 0xE3, 0xF8, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x3F,
  0x80, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03,
  0xF0, 0x7C, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x01, 0xF0, 0x7E, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0xF8, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x1F, 0x07, 0xE0, 0x7C, 0x03,
  0xE0, 0xFC, 0x1F, 0xC0, 0x7C, 0x1F, 0x03, 0xFC, 0x1F, 0x83, 0xE0, 0x7F,
  0x83, 0xF0, 0x7C, 0x0F, 0xF0, 0x7E, 0x1F, 0x81, 0xFC, 0x0F, 0x83, 0xF0,
  0x1F, 0x81, 0xF0, 0x7E, 0x00, 0xC0, 0x3E, 0x0F, 0x80, 0x00, 0x0F, 0xC1,
  0xF0, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x07,
  0xC1, 0xF8, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x1F, 0x83, 0xE0,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xF7, 0xE0, 0x00, 0x3F, 0xC7, 0xE0,
  0x00, 0xFF, 0x87, 0xC0, 0x01, 0xFE, 0x07, 0xC0, 0x01, 0xFC, 0x07, 0xC0,
  0x01, 0xF0, 0x0F, 0xC0, 0x01, 0xC0, 0x0F, 0xC0, 0x03, 0x80, 0x0F, 0xC0,
  0x02, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x0F, 0xC0, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x3E, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xF8, 0x3F, 0xF0, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x7C, 0x07, 0xF0, 0x00, 0x7C, 0x07,
  0xE0, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0xF8, 0x7C,
  0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x7F, 0xC0, 0x00, 0xFC, 0x7F, 0xFC, 0x00,
  0x3E, 0x7F, 0xFF, 0xC0, 0x0F, 0xBF, 0xFF, 0xF0, 0x03, 0xEF, 0xFF, 0xFE,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x00,
  0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x83, 0xE0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0x1F, 0xC0, 0x1F, 0xF8, 0x3F, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x8F, 0xF0, 0x00, 0x1F, 0xBF, 0xFE, 0x00, 0x1F, 0xBF, 0xFF, 0x80, 0x1F,
  0xBF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xF8, 0x03, 0xFE, 0x07,
  0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x0F, 0xE3,
  0xF0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0xFC,
  0xFC, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x1F,
  0xBF, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x03,
  0xE7, 0xE0, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00,
  0xF8, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x01, 0xFF, 0x83,
  0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0x80, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00,
  0x7E, 0x1F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0xC1, 0xF0, 0x00,
  0x03, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x3F,
  0x80, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x3E, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0xF8, 0x00,
  0x03, 0xE0, 0x1F, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x07, 0xE0, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x1F, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x1F,
  0xC0, 0xFF, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x1F, 0x81,
  0xF0, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x03,
  0xF8, 0x1F, 0xC0, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xC0, 0x00,
  0x1F, 0x8F, 0xC0, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x03, 0xE7, 0xE0, 0x00,
  0x01, 0xF3, 0xF0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x7C, 0xF8, 0x00,
  0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x1F, 0xBF, 0x00,
  0x00, 0x0F, 0x9F, 0x80, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x07, 0xE3, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF8, 0x7F,
  0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x7E, 0x00, 0x7F, 0xFF, 0x7E, 0x00,
  0x0F, 0xFE, 0x7E, 0x00, 0x00, 0x70, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0xFE,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x7F,
  0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x00,
  0xFF, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x04, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x01,
  0xF0, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0xFF, 0x87, 0x81, 0xF0, 0x00, 0xFF, 0xF3,
  0xC0, 0xF8, 0x00, 0xFF, 0xF9, 0xE0, 0x7C, 0x00, 0xFF, 0xFE, 0xF0, 0x3E,
  0x00, 0xFC, 0x03, 0xF8, 0x1F, 0x00, 0x7C, 0x00, 0xFC, 0x0F, 0x80, 0x7C,
  0x00, 0x7E, 0x0F, 0x80, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x1F, 0x00, 0x1F,
  0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0xF8,
  0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x01, 0xF0, 0x7C, 0x01, 0xF0,
  0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x00, 0x7C,
  0x0F, 0x80, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x3E, 0x00, 0x1F, 0x03, 0xE0,
  0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x07, 0xC0,
  0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x03, 0xF0,
  0x3E, 0x00, 0xFC, 0x03, 0xF8, 0x1F, 0x00, 0x7F, 0x03, 0xFC, 0x0F, 0x80,
  0x3F, 0xFF, 0xBE, 0x0F, 0x80, 0x0F, 0xFF, 0x9E, 0x07, 0xC0, 0x03, 0xFF,
  0x8F, 0x03, 0xE0, 0x00, 0x7F, 0x07, 0x81, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x00, 0xFB, 0xE0, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x1F, 0x3E, 0x00,
  0x00, 0x0F, 0xCF, 0x80, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0xF8, 0x7C,
  0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0xC1,
  0xF0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03,
  0xE0, 0x1F, 0x80, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x03, 0xE0, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x00, 0x3E,
  0x3F, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x00,
  0xF9, 0xF8, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x0F, 0xBF, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8,
  0x03, 0xE0, 0x00, 0xFF, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0x80,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00,
  0xFC, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0xE0,
  0x0F, 0xC0, 0x00, 0xFE, 0x01, 0xF0, 0x00, 0x0F, 0xE0, 0x3E, 0x00, 0x00,
  0xFC, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x1F,
  0x00, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00,
  0xFC, 0x0F, 0x80, 0x00, 0x3F, 0x81, 0xF0, 0x00, 0x0F, 0xE0, 0x3E, 0x00,
  0x03, 0xFC, 0x07, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x03, 0xF8, 0x07,
  0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x03, 0xE0,
  0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x07, 0xE0, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xFE, 0x0F, 0xF8,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x3F, 0xC0,
  0x1F, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00,
  0x3F, 0x03, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x01, 0xF0,
  0x3E, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x0F,
  0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x7E,
  0x01, 0xF0, 0x00, 0x7F, 0x80, 0x7C, 0x00, 0x7F, 0xC0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xE0, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x7E, 0x00,
  0x00, 0xFC, 0x1F, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x43, 0xF0, 0x1F, 0xFF, 0xE0, 0xFC, 0x07,
  0xFF, 0xF8, 0x3E, 0x01, 0xFF, 0xFE, 0x0F, 0x80, 0x7F, 0xFF, 0x83, 0xE0,
  0x1F, 0xFF, 0xE1, 0xF8, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x7E, 0x1F,
  0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x01, 0xF0,
  0x7C, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x07, 0xE0, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0x1F, 0x80, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x80,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x7E, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x3F, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x3E, 0x00,
  0x00, 0xFC, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x7C, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x7C, 0x00,
  0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x00, 0x3E, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x1F, 0x80, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x1F,
  0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7C,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x3E, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x3E,
  0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0xF8,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x7C, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x3E,
  0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00,
  0x00, 0x7E, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00,
  0x07, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x3F, 0xE0,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x01, 0xF7, 0x80, 0x7D, 0xE0,
  0x03, 0xEF, 0x00, 0xFB, 0xC0, 0x07, 0xBE, 0x01, 0xE7, 0x80, 0x1F, 0x78,
  0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x07, 0x9F, 0x00, 0xF9, 0xE0, 0x0F, 0x3E,
  0x01, 0xE7, 0xC0, 0x3E, 0x3C, 0x07, 0xCF, 0x80, 0x7C, 0x78, 0x0F, 0x1F,
  0x00, 0xF8, 0xF0, 0x3E, 0x3C, 0x01, 0xF1, 0xE0, 0x78, 0xF8, 0x03, 0xE3,
  0xE1, 0xF1, 0xF0, 0x07, 0xC3, 0xC3, 0xC3, 0xE0, 0x1F, 0x87, 0x8F, 0x87,
  0xC0, 0x3E, 0x0F, 0x1E, 0x0F, 0x80, 0x7C, 0x1E, 0x7C, 0x3F, 0x00, 0xF8,
  0x3C, 0xF0, 0x7C, 0x01, 0xF0, 0x7F, 0xE0, 0xF8, 0x03, 0xE0, 0x7F, 0x81,
  0xF0, 0x07, 0xC0, 0xFF, 0x03, 0xE0, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0x3F,
  0x03, 0xF8, 0x1F, 0x80, 0x7C, 0x07, 0xE0, 0x3E, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xF0, 0x1F, 0xE0, 0x00, 0x3F, 0x01, 0xFE, 0x00, 0x03, 0xE0, 0x1F, 0xF0,
  0x00, 0x3E, 0x01, 0xFF, 0x00, 0x03, 0xE0, 0x1F, 0xF0, 0x00, 0x3E, 0x03,
  0xFF, 0x00, 0x07, 0xE0, 0x3E, 0xF0, 0x00, 0x7E, 0x03, 0xEF, 0x80, 0x07,
  0xC0, 0x3E, 0xF8, 0x00, 0x7C, 0x03, 0xEF, 0x80, 0x07, 0xC0, 0x3E, 0xF8,
  0x00, 0x7C, 0x07, 0xE7, 0x80, 0x0F, 0xC0, 0x7E, 0x7C, 0x00, 0xFC, 0x07,
  0xC7, 0xC0, 0x0F, 0x80, 0x7C, 0x7C, 0x00, 0xF8, 0x07, 0xC3, 0xC0, 0x0F,
  0x80, 0x7C, 0x3E, 0x00, 0xF8, 0x07, 0xC3, 0xE0, 0x0F, 0x80, 0xFC, 0x3E,
  0x01, 0xF8, 0x0F, 0x83, 0xE0, 0x1F, 0x80, 0xF8, 0x1E, 0x01, 0xF0, 0x0F,
  0x81, 0xF0, 0x1F, 0x00, 0xF8, 0x1F, 0x01, 0xF0, 0x0F, 0x81, 0xF0, 0x1F,
  0x01, 0xF8, 0x1F, 0x03, 0xF0, 0x1F, 0x80, 0xF0, 0x3F, 0x01, 0xF0, 0x0F,
  0x83, 0xE0, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x0F, 0x83, 0xE0, 0x1F,
  0x00, 0xF8, 0x3E, 0x03, 0xF0, 0x07, 0xC7, 0xE0, 0x3F, 0x00, 0x7C, 0x7E,
  0x03, 0xE0, 0x07, 0xC7, 0xC0, 0x3E, 0x00, 0x7C, 0x7C, 0x03, 0xE0, 0x07,
  0xC7, 0xC0, 0x3E, 0x00, 0x3E, 0x7C, 0x07, 0xE0, 0x03, 0xE7, 0xC0, 0x7E,
  0x00, 0x3E, 0x7C, 0x07, 0xC0, 0x03, 0xEF, 0x80, 0x7C, 0x00, 0x1E, 0xF8,
  0x07, 0xC0, 0x01, 0xFF, 0x80, 0x7C, 0x00, 0x1F, 0xF8, 0x07, 0xC0, 0x01,
  0xFF, 0x80, 0xFC, 0x00, 0x1F, 0xF8, 0x0F, 0xC0, 0x00, 0xFF, 0x80, 0xF8,
  0x00, 0x0F, 0xF0, 0x0F, 0x80, 0x00, 0xFF, 0x00, 0xF8, 0x00, 0x0F, 0xF0,
  0x0F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0xF0, 0x07,
  0xE0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00,
  0x7E, 0x0F, 0x80, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x07, 0xC1, 0xF8, 0x00,
  0x01, 0xF0, 0x7E, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xC0,
  0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x0F, 0xC1, 0xF0, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x3E, 0x0F, 0xC0,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF0, 0x3F,
  0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFE, 0x0F, 0xF8,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x74, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x00,
  0x0F, 0xF0, 0x07, 0xC0, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x00, 0xFE, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x00,
  0x7C, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x1F, 0x03, 0xF0,
  0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x00, 0x7E,
  0x07, 0xC0, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x1F, 0x81, 0xF0, 0x00,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x3E, 0x00, 0x01, 0xFE, 0x01, 0xF0, 0x00, 0x3F,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x0F, 0xE0, 0x00,
  0xFE, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0x80,
  0x00, 0x1F, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0x7C, 0x0F,
  0x80, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x3E,
  0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00,
  0x3F, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0xF8, 0x1F, 0x00,
  0x00, 0x1F, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xF8,
  0x1F, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x01, 0xF8, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F,
  0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0x00, 0x03, 0xFC, 0x01, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x00,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x7E, 0x00,
  0x00, 0x7E, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0x7E, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x01, 0xF0, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFC,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x1F, 0x00, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x7E, 0x00, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0x7E,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x01, 0xFC, 0x03, 0xFC, 0x00,
  0x3F, 0x80, 0x1F, 0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x07, 0xE1, 0xF0, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x1F, 0x81, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF0, 0x1F,
  0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x3E, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x7C,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x01,
  0xF0, 0x1F, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1F, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0xF8, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x7E, 0x1F, 0x00,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x00, 0xF8, 0xF8,
  0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x0F,
  0xBE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x7F, 0x00, 0x3E, 0x7C, 0x00, 0xFE, 0x00, 0x7C, 0xF8,
  0x01, 0xFC, 0x00, 0xF9, 0xF0, 0x03, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0xF0,
  0x07, 0xC7, 0xC0, 0x1F, 0xE0, 0x0F, 0x8F, 0x80, 0x3B, 0xC0, 0x3E, 0x1F,
  0x00, 0xF7, 0x00, 0x7C, 0x3E, 0x01, 0xEE, 0x00, 0xF8, 0x7C, 0x03, 0xDC,
  0x01, 0xF0, 0xF0, 0x07, 0x38, 0x07, 0xC3, 0xE0, 0x1E, 0x70, 0x0F, 0x87,
  0xC0, 0x3C, 0xE0, 0x1F, 0x0F, 0x80, 0x71, 0xC0, 0x3E, 0x1F, 0x01, 0xE3,
  0x80, 0xF8, 0x3E, 0x03, 0xC7, 0x01, 0xF0, 0x7C, 0x07, 0x8E, 0x03, 0xE0,
  0xF8, 0x0E, 0x1C, 0x07, 0x81, 0xF0, 0x3C, 0x38, 0x1F, 0x03, 0xE0, 0x78,
  0xF0, 0x3E, 0x07, 0xC0, 0xE1, 0xE0, 0x7C, 0x0F, 0x83, 0xC3, 0xC1, 0xF0,
  0x1F, 0x07, 0x87, 0x83, 0xE0, 0x3E, 0x0F, 0x0F, 0x07, 0xC0, 0x7C, 0x1C,
  0x1E, 0x0F, 0x00, 0xF8, 0x78, 0x3C, 0x3E, 0x01, 0xF0, 0xF0, 0x78, 0x7C,
  0x03, 0xE1, 0xC0, 0xF0, 0xF8, 0x07, 0xC7, 0x81, 0xE1, 0xE0, 0x0F, 0x8F,
  0x03, 0xC7, 0xC0, 0x1E, 0x1E, 0x07, 0x8F, 0x80, 0x3C, 0x38, 0x0F, 0x1F,
  0x00, 0x78, 0xF0, 0x1E, 0x7C, 0x00, 0xF1, 0xE0, 0x38, 0xF8, 0x01, 0xE3,
  0x80, 0x71, 0xF0, 0x07, 0xCF, 0x00, 0xE3, 0xC0, 0x0F, 0x9E, 0x01, 0xCF,
  0x80, 0x1F, 0x38, 0x03, 0x9F, 0x00, 0x3E, 0x70, 0x07, 0x3E, 0x00, 0x7D,
  0xE0, 0x0E, 0x78, 0x00, 0xFB, 0xC0, 0x1D, 0xF0, 0x01, 0xF7, 0x00, 0x3B,
  0xE0, 0x03, 0xFE, 0x00, 0x77, 0x80, 0x07, 0xFC, 0x00, 0xEF, 0x00, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x01,
  0xFC, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00,
  0x00, 0x3E, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE1,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x0F, 0xC7,
  0xC0, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x03,
  0xF0, 0x3E, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0x00,
  0x00, 0xFC, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x1F, 0x80, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00, 0x1F, 0x0F, 0xC0,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x00, 0xFB,
  0xF0, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x3E, 0x78, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x01,
  0xF0, 0x78, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x7C, 0x03, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF8,
  0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x1F,
  0x00, 0x07, 0xC1, 0xF8, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0xF8, 0xF8, 0x00,
  0x07, 0xCF, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x0F, 0x81,
  0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x7C, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0xFF, 0x83, 0xF0, 0x03, 0xFF, 0xF8, 0xFC,
  0x01, 0xFF, 0xFF, 0x3E, 0x00, 0xFF, 0xFF, 0xCF, 0x80, 0x7F, 0xC0, 0xFB,
  0xE0, 0x3F, 0xC0, 0x0F, 0xF8, 0x0F, 0xC0, 0x01, 0xFE, 0x07, 0xE0, 0x00,
  0x7F, 0x81, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0xFC, 0x0F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x00, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xFC,
  0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x03, 0xFE, 0x03,
  0xFE, 0x07, 0xDF, 0x00, 0x7F, 0xFF, 0xF7, 0xC0, 0x0F, 0xFF, 0xF9, 0xF0,
  0x01, 0xFF, 0xF8, 0x7C, 0x00, 0x3F, 0xF8, 0x3F, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x01, 0xC0, 0x00, 0x3E, 0x0F, 0xFE, 0x00, 0x3F, 0x1F, 0xFF, 0xC0, 0x1F,
  0x9F, 0xFF, 0xF0, 0x0F, 0xDF, 0xFF, 0xF8, 0x07, 0xDF, 0x03, 0xFE, 0x03,
  0xEE, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x07, 0xE0,
  0xFE, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7C,
  0x1F, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF0, 0x7E, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0xFC, 0x0F, 0xF0,
  0x00, 0xFE, 0x07, 0xFC, 0x00, 0xFE, 0x07, 0xEF, 0x83, 0xFE, 0x03, 0xF7,
  0xFF, 0xFF, 0x01, 0xF9, 0xFF, 0xFE, 0x00, 0xF8, 0x7F, 0xFE, 0x00, 0x7C,
  0x1F, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x07, 0xFC, 0x03, 0xF8, 0x01, 0xFE,
  0x07, 0xE0, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3E,
  0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x3F,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x7F, 0x80, 0x1F, 0xC0,
  0x3F, 0xE0, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0x00, 0xFC, 0x00, 0x0F, 0xFE, 0x0F, 0xC0, 0x03,
  0xFF, 0xF8, 0xFC, 0x00, 0x7F, 0xFF, 0xCF, 0x80, 0x0F, 0xFF, 0xFC, 0xF8,
  0x01, 0xFF, 0x03, 0xEF, 0x80, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xF0, 0x00,
  0x7F, 0x80, 0x7E, 0x00, 0x07, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x1F, 0x80, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x7E, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x03,
  0xF8, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x0F, 0xF8, 0x03, 0xFE,
  0x07, 0xDF, 0x00, 0x1F, 0xFF, 0xFD, 0xF0, 0x00, 0xFF, 0xFF, 0x9F, 0x00,
  0x07, 0xFF, 0xE1, 0xF0, 0x00, 0x3F, 0xF8, 0x3F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFE,
  0x07, 0xFC, 0x03, 0xF0, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x7E, 0x0F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x00,
  0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x3E, 0x3F, 0x00,
  0x00, 0x7E, 0x3E, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0x7E, 0x3F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xFC, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0x7E, 0x00,
  0x07, 0xE0, 0x7F, 0x00, 0x0F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x0F, 0xC0,
  0x0F, 0xFF, 0xC7, 0xE0, 0x1F, 0xFF, 0xF3, 0xE0, 0x1F, 0xFF, 0xFD, 0xF0,
  0x1F, 0xF0, 0x3E, 0xF8, 0x1F, 0xE0, 0x07, 0xFC, 0x0F, 0xC0, 0x01, 0xFE,
  0x0F, 0xC0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00,
  0x7C, 0x1F, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF8, 0x3E, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7F, 0x07, 0xE0,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x77, 0xC0, 0x7F,
  0xE1, 0xFB, 0xE0, 0x1F, 0xFF, 0xFB, 0xF0, 0x07, 0xFF, 0xF9, 0xF8, 0x01,
  0xFF, 0xF8, 0xF8, 0x00, 0x7F, 0xF0, 0x7C, 0x00, 0x01, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00,
  0x3E, 0x0F, 0xFE, 0x00, 0x3F, 0x1F, 0xFF, 0xC0, 0x1F, 0x9F, 0xFF, 0xF0,
  0x0F, 0xDF, 0xFF, 0xF8, 0x07, 0xDF, 0x03, 0xFE, 0x03, 0xEE, 0x00, 0x7F,
  0x01, 0xFE, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00,
  0x7E, 0x0F, 0x80, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xF8, 0x3E,
  0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3F, 0x07,
  0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xC1,
  0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xF0, 0x3E, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x7C,
  0x00, 0x07, 0xF0, 0x07, 0xC0, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x1F, 0xC0,
  0x07, 0xC0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x00, 0xF8,
  0x03, 0xF8, 0x00, 0x0F, 0x80, 0x7F, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xF0,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0x7F, 0x00, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x3F,
  0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0x07, 0xF0, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x01, 0xFC, 0x0F, 0x80,
  0x00, 0x0F, 0xC0, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x1F, 0x3F,
  0xC1, 0xFE, 0x01, 0xF3, 0xFF, 0x1F, 0xF8, 0x0F, 0xBF, 0xF9, 0xFF, 0xE0,
  0x7D, 0xFF, 0xEF, 0xFF, 0x03, 0xF8, 0x3F, 0xC1, 0xF8, 0x1F, 0x80, 0xFC,
  0x07, 0xC0, 0xF8, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x7E,
  0x01, 0xF0, 0x0F, 0x83, 0xE0, 0x0F, 0x00, 0x7C, 0x1F, 0x00, 0x78, 0x03,
  0xE0, 0xF8, 0x03, 0xC0, 0x1F, 0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x3E, 0x01,
  0xF0, 0x0F, 0x83, 0xF0, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0x7C, 0x03, 0xE0,
  0xF8, 0x03, 0xC0, 0x1F, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x3E, 0x01, 0xF0,
  0x07, 0xC1, 0xF0, 0x0F, 0x80, 0x7E, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0xF8,
  0x03, 0xE0, 0x1F, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x3E, 0x00, 0xF0, 0x07,
  0xC1, 0xF0, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x7C, 0x03,
  0xE0, 0x1F, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x3E, 0x00, 0xF0, 0x07, 0xC1,
  0xF0, 0x07, 0x80, 0x3E, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x7C, 0x03, 0xE0,
  0x0F, 0x83, 0xE0, 0x1F, 0x00, 0xF8, 0x3F, 0x00, 0xF8, 0x07, 0xC1, 0xF0,
  0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x7C, 0x01, 0xE0, 0x0F,
  0x83, 0xE0, 0x1F, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0x7F, 0xF0, 0x01, 0xF8, 0xFF, 0xFE, 0x00, 0xFC, 0xFF, 0xFF, 0x80, 0x7E,
  0xFF, 0xFF, 0xC0, 0x3E, 0xF8, 0x1F, 0xF0, 0x1F, 0x70, 0x03, 0xF8, 0x0F,
  0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x03, 0xF0,
  0x7C, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00,
  0x7C, 0x1F, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF8, 0x3E, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3E, 0x0F, 0xC0,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFE, 0x07, 0xFC, 0x03,
  0xF8, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3E, 0x1F,
  0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x3F,
  0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0x7C, 0x3E,
  0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0xFC, 0x7E,
  0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0xF8, 0x7C,
  0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x1F, 0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x1D, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1F, 0x07, 0xFF, 0x00,
  0x07, 0xE3, 0xFF, 0xF8, 0x00, 0xFC, 0xFF, 0xFF, 0x80, 0x1F, 0xBF, 0xFF,
  0xF0, 0x03, 0xEF, 0x81, 0xFF, 0x00, 0x7D, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0,
  0x00, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x01, 0xF8, 0x1F,
  0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xE0, 0x3F, 0x00,
  0x00, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x07, 0xE0, 0x1F,
  0xE0, 0x01, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0x00, 0xFD, 0xF0, 0x3F, 0xC0,
  0x1F, 0xBF, 0xFF, 0xF0, 0x03, 0xE3, 0xFF, 0xFC, 0x00, 0x7C, 0x3F, 0xFF,
  0x00, 0x0F, 0x83, 0xFF, 0x80, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0xFF, 0x83, 0xF0, 0x03, 0xFF, 0xF8, 0xF8,
  0x01, 0xFF, 0xFF, 0x3E, 0x00, 0xFF, 0xFF, 0xCF, 0x80, 0x7F, 0xC1, 0xFF,
  0xE0, 0x3F, 0xC0, 0x0F, 0xF8, 0x0F, 0xC0, 0x01, 0xFE, 0x07, 0xE0, 0x00,
  0x7F, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x3E, 0x00,
  0x00, 0xFC, 0x0F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xE0, 0x7E, 0x00,
  0x00, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xFC,
  0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x07, 0xFE, 0x03,
  0xFE, 0x07, 0xDF, 0x00, 0x7F, 0xFF, 0xE7, 0xC0, 0x0F, 0xFF, 0xF1, 0xF0,
  0x01, 0xFF, 0xF8, 0xFC, 0x00, 0x3F, 0xFC, 0x3F, 0x00, 0x00, 0xF0, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x01, 0xF0, 0x7F, 0xF0, 0x00, 0xF8, 0xFF, 0xFE,
  0x00, 0x7C, 0xFF, 0xFF, 0x80, 0x7E, 0xFF, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F,
  0xF0, 0x1F, 0x70, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x7E, 0x07, 0xF0, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x00, 0xFC, 0x3E, 0x00,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x03,
  0xF8, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x1F,
  0x80, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x1F, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0x7F, 0x80, 0x1F, 0xC0,
  0x1F, 0xF0, 0x7F, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x1F, 0x9F, 0x00, 0x00,
  0x0F, 0xCF, 0x80, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x01, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x7C, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F,
  0xC0, 0x0F, 0x80, 0x03, 0xE0, 0x0F, 0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x00,
  0xF8, 0x07, 0xE0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x3F, 0x01, 0xF0, 0x00,
  0x1F, 0x81, 0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0x7E, 0x3E, 0x00,
  0x00, 0x1F, 0x3F, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x07, 0xDF, 0x80,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0x00, 0x3E, 0xF0,
  0x03, 0xF0, 0x03, 0xEF, 0x00, 0x3F, 0x00, 0x3E, 0xF0, 0x07, 0xF0, 0x03,
  0xCF, 0x00, 0x7F, 0x00, 0x7C, 0xF0, 0x07, 0x70, 0x07, 0xCF, 0x00, 0xF7,
  0x00, 0x78, 0xF0, 0x0F, 0x70, 0x0F, 0x8F, 0x00, 0xE7, 0x00, 0xF8, 0xF0,
  0x1E, 0x70, 0x0F, 0x0F, 0x01, 0xE7, 0x01, 0xF0, 0xF0, 0x1C, 0x70, 0x1F,
  0x0F, 0x03, 0xC7, 0x01, 0xE0, 0xF0, 0x3C, 0x70, 0x3E, 0x0F, 0x03, 0x87,
  0x03, 0xE0, 0xF0, 0x78, 0x70, 0x3C, 0x0F, 0x07, 0x87, 0x03, 0xC0, 0xF0,
  0x70, 0x70, 0x7C, 0x0F, 0x0F, 0x07, 0x07, 0x80, 0xF0, 0xF0, 0x70, 0x78,
  0x0F, 0x0E, 0x07, 0x0F, 0x80, 0xF0, 0xE0, 0x70, 0xF0, 0x0F, 0x1E, 0x07,
  0x0F, 0x00, 0xF1, 0xE0, 0x71, 0xF0, 0x0F, 0x1C, 0x07, 0x1E, 0x00, 0xF3,
  0xC0, 0x71, 0xE0, 0x0F, 0x3C, 0x07, 0xBE, 0x00, 0xF3, 0x80, 0x7B, 0xC0,
  0x0F, 0x78, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x7F, 0xC0, 0x0F, 0x70, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x7F, 0x00,
  0x00, 0x3F, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00,
  0x1F, 0x8F, 0xC0, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0x3F,
  0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0x0F, 0x83, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x03, 0xF0, 0x7C, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0xDF, 0x01, 0xFC, 0x01, 0xEF, 0x80, 0xFF, 0xC7,
  0xEF, 0xC0, 0x3F, 0xFF, 0xF7, 0xE0, 0x0F, 0xFF, 0xF3, 0xE0, 0x03, 0xFF,
  0xE1, 0xF0, 0x00, 0x7F, 0xC0, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x2F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x40, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0x83, 0xFF, 0x80, 0x07, 0xC7,
  0xFF, 0xE0, 0x03, 0xE7, 0xFF, 0xF0, 0x01, 0xF3, 0xFB, 0xFC, 0x00, 0xFB,
  0xF0, 0x7F, 0x00, 0xFD, 0xF0, 0x1F, 0xC0, 0x7C, 0xF8, 0x07, 0xE0, 0x3E,
  0xFC, 0x01, 0xFC, 0x7F, 0x7C, 0x00, 0xFF, 0xFF, 0x3E, 0x00, 0x3F, 0xFF,
  0x1F, 0x00, 0x0F, 0xFF, 0x0F, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x10,
  0x00,
};

const GFXglyph JetBrainsMono_LightItalic69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 16, 50, 41, 13, -50 },
  { 101, 23, 20, 41, 13, -50 },
  { 159, 40, 50, 41, 2, -50 },
  { 409, 36, 70, 41, 3, -60 },
  { 724, 47, 51, 41, -2, -51 },
  { 1024, 37, 52, 41, 2, -51 },
  { 1265, 8, 20, 41, 20, -50 },
  { 1285, 29, 67, 41, 11, -58 },
  { 1528, 27, 67, 41, 4, -58 },
  { 1755, 36, 35, 41, 4, -42 },
  { 1913, 33, 32, 41, 5, -39 },
  { 2045, 17, 21, 41, 7, -10 },
  { 2090, 23, 5, 41, 10, -25 },
  { 2105, 12, 11, 41, 12, -10 },
  { 2122, 41, 65, 41, 1, -57 },
  { 2456, 35, 52, 41, 4, -51 },
  { 2684, 32, 50, 41, 3, -50 },
  { 2884, 36, 51, 41, 3, -51 },
  { 3114, 34, 51, 41, 4, -50 },
  { 3331, 32, 50, 41, 5, -50 },
  { 3531, 34, 51, 41, 5, -50 },
  { 3748, 33, 51, 41, 4, -50 },
  { 3959, 34, 50, 41, 8, -50 },
  { 4172, 35, 52, 41, 4, -51 },
  { 4400, 33, 51, 41, 7, -51 },
  { 4611, 17, 40, 41, 12, -39 },
  { 4696, 22, 50, 41, 7, -39 },
  { 4834, 33, 36, 41, 6, -41 },
  { 4983, 33, 21, 41, 5, -33 },
  { 5070, 33, 36, 41, 4, -41 },
  { 5219, 28, 50, 41, 10, -50 },
  { 5394, 41, 63, 41, 1, -51 },
  { 5717, 34, 50, 41, 1, -50 },
  { 5930, 35, 50, 41, 4, -50 },
  { 6149, 34, 52, 41, 5, -51 },
  { 6370, 34, 50, 41, 4, -50 },
  { 6583, 37, 50, 41, 4, -50 },
  { 6815, 37, 50, 41, 4, -50 },
  { 7047, 34, 52, 41, 5, -51 },
  { 7268, 36, 50, 41, 4, -50 },
  { 7493, 35, 50, 41, 4, -50 },
  { 7712, 37, 51, 41, 2, -50 },
  { 7948, 39, 50, 41, 4, -50 },
  { 8192, 30, 50, 41, 5, -50 },
  { 8380, 39, 50, 41, 2, -50 },
  { 8624, 36, 50, 41, 4, -50 },
  { 8849, 34, 52, 41, 5, -51 },
  { 9070, 37, 50, 41, 4, -50 },
  { 9302, 35, 63, 41, 4, -51 },
  { 9578, 36, 50, 41, 4, -50 },
  { 9803, 36, 52, 41, 3, -51 },
  { 10037, 35, 50, 41, 8, -50 },
  { 10256, 35, 51, 41, 5, -50 },
  { 10480, 34, 50, 41, 9, -50 },
  { 10693, 39, 50, 41, 5, -50 },
  { 10937, 43, 50, 41, 0, -50 },
  { 11206, 36, 50, 41, 8, -50 },
  { 11431, 37, 50, 41, 3, -50 },
  { 11663, 27, 65, 41, 10, -57 },
  { 11883, 20, 65, 41, 12, -57 },
  { 12046, 27, 65, 41, 6, -57 },
  { 12266, 29, 27, 41, 7, -50 },
  { 12364, 34, 4, 41, 0, 2 },
  { 12381, 11, 10, 41, 19, -54 },
  { 12395, 34, 40, 41, 4, -39 },
  { 12565, 33, 51, 41, 4, -50 },
  { 12776, 32, 40, 41, 5, -39 },
  { 12936, 36, 51, 41, 4, -50 },
  { 13166, 32, 40, 41, 5, -39 },
  { 13326, 46, 62, 41, -3, -50 },
  { 13683, 33, 51, 41, 5, -39 },
  { 13894, 33, 50, 41, 4, -50 },
  { 14101, 32, 53, 41, 3, -53 },
  { 14313, 35, 65, 41, 1, -53 },
  { 14598, 36, 50, 41, 4, -50 },
  { 14823, 29, 50, 41, 7, -50 },
  { 15005, 37, 39, 41, 2, -39 },
  { 15186, 33, 39, 41, 4, -39 },
  { 15347, 32, 40, 41, 5, -39 },
  { 15507, 35, 51, 41, 2, -39 },
  { 15731, 34, 51, 41, 4, -39 },
  { 15948, 33, 39, 41, 5, -39 },
  { 16109, 33, 40, 41, 4, -39 },
  { 16274, 33, 48, 41, 6, -48 },
  { 16472, 33, 39, 41, 5, -38 },
  { 16633, 33, 38, 41, 7, -38 },
  { 16790, 36, 38, 41, 6, -38 },
  { 16961, 38, 38, 41, 1, -38 },
  { 17142, 33, 50, 41, 5, -38 },
  { 17349, 34, 38, 41, 3, -38 },
  { 17511, 34, 65, 41, 7, -57 },
  { 17788, 15, 65, 41, 14, -57 },
  { 17910, 35, 65, 41, 2, -57 },
  { 18195, 33, 14, 41, 5, -31 },
};

const GFXfont JetBrainsMono_LightItalic69pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_LightItalic69pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_LightItalic69pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _JETBRAINSMONO_LIGHTITALIC69PT7B_H_
