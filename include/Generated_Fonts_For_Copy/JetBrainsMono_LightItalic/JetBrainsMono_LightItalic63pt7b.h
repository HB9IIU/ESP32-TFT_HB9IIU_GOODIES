#ifndef _JETBRAINSMONO_LIGHTITALIC63PT7B_H_
#define _JETBRAINSMONO_LIGHTITALIC63PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-LightItalic.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_LightItalic63pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x7F,
  0x81, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x01, 0xF8, 0x00, 0x3F, 0x01,
  0xF9, 0xF8, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x07, 0xE3, 0xE0, 0x3F, 0x3F,
  0x01, 0xF9, 0xF8, 0x0F, 0x8F, 0xC0, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F,
  0x1F, 0x00, 0xF8, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x3C, 0x03, 0xE3, 0xE0,
  0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0x87, 0x80, 0x3C, 0x3C, 0x01, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x04, 0x1E, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x03,
  0xE0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xE0, 0x03, 0xF9, 0xE7, 0xF0, 0x03, 0xF0, 0xF1, 0xFC, 0x03,
  0xF0, 0x70, 0x7E, 0x01, 0xF0, 0x38, 0x1F, 0x01, 0xF8, 0x1C, 0x0F, 0x80,
  0xF8, 0x1E, 0x07, 0xC0, 0x7C, 0x0F, 0x03, 0xE0, 0x3E, 0x07, 0x81, 0xF0,
  0x1F, 0x03, 0x80, 0x00, 0x1F, 0x81, 0xC0, 0x00, 0x07, 0xC0, 0xE0, 0x00,
  0x03, 0xE0, 0x70, 0x00, 0x01, 0xF8, 0x78, 0x00, 0x00, 0xFE, 0x3C, 0x00,
  0x00, 0x3F, 0x9E, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x39,
  0xFE, 0x00, 0x00, 0x1C, 0x3F, 0x80, 0x00, 0x1E, 0x0F, 0xC0, 0x00, 0x0F,
  0x07, 0xE0, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x03, 0x80, 0xF8, 0x00, 0x01,
  0xC0, 0x7C, 0x00, 0x00, 0xE0, 0x3E, 0x0F, 0x80, 0xF0, 0x1F, 0x07, 0xC0,
  0x78, 0x0F, 0x83, 0xE0, 0x3C, 0x07, 0xC1, 0xF0, 0x1E, 0x07, 0xC0, 0xF8,
  0x0E, 0x07, 0xE0, 0x7E, 0x07, 0x03, 0xE0, 0x3F, 0x83, 0x87, 0xF0, 0x0F,
  0xF3, 0xCF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x78, 0x01, 0xFF, 0xF8, 0x00,
  0x1E, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xF0,
  0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x0F,
  0x00, 0xF8, 0x03, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x00, 0x7C, 0x03,
  0xC0, 0x3C, 0x00, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0x0F, 0x03,
  0xE0, 0x00, 0x3C, 0x01, 0xE0, 0xF8, 0x00, 0x07, 0x80, 0x3C, 0x1E, 0x00,
  0x00, 0xF0, 0x0F, 0x07, 0x80, 0x00, 0x1E, 0x03, 0xE1, 0xE0, 0x00, 0x03,
  0xE0, 0xF8, 0x78, 0x00, 0x00, 0x7F, 0xFF, 0x1F, 0x00, 0x00, 0x07, 0xFF,
  0xC7, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x81, 0xF0, 0x00, 0x00, 0x01, 0xE1, 0xFF, 0x80, 0x00, 0x00,
  0x78, 0x7F, 0xF8, 0x00, 0x00, 0x1E, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0x87,
  0xE1, 0xF0, 0x00, 0x01, 0xF0, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x3C, 0x01,
  0xE0, 0x00, 0x0F, 0x07, 0x80, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x07, 0x80,
  0x00, 0xF0, 0x3E, 0x01, 0xF0, 0x00, 0x3C, 0x07, 0x80, 0x3C, 0x00, 0x0F,
  0x80, 0xF0, 0x07, 0x80, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0x1E, 0x00, 0x78, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0xF0, 0x01, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x78, 0x00, 0x3F, 0xFF, 0x80,
  0x1F, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xC0, 0x00, 0x3F, 0xF8, 0x01, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x03,
  0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F,
  0xCF, 0xC0, 0x07, 0xC7, 0xE1, 0xF8, 0x03, 0xE3, 0xF0, 0x7E, 0x01, 0xF0,
  0xF8, 0x0F, 0xC0, 0x7C, 0x3E, 0x01, 0xF0, 0x3E, 0x0F, 0x80, 0x7E, 0x1F,
  0x07, 0xC0, 0x0F, 0x8F, 0xC1, 0xF0, 0x03, 0xF3, 0xE0, 0x7C, 0x00, 0x7D,
  0xF0, 0x1F, 0x00, 0x0F, 0xF8, 0x07, 0xC0, 0x03, 0xFE, 0x01, 0xF0, 0x00,
  0x7F, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x07, 0xE0, 0x0F, 0x80,
  0x01, 0xFC, 0x03, 0xE0, 0x00, 0xFF, 0x80, 0xFC, 0x00, 0x7F, 0xE0, 0x3F,
  0x00, 0x7E, 0xFC, 0x07, 0xE0, 0x3F, 0x1F, 0x01, 0xFF, 0xFF, 0x87, 0xE0,
  0x3F, 0xFF, 0xC0, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0x00, 0xFF, 0xE0, 0x07,
  0xE0, 0x03, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3F, 0x3E, 0x3E, 0x3E, 0x7E,
  0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0xF8, 0xF8, 0xF8, 0xF8, 0xF0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x0E, 0x00, 0x7C, 0x00, 0xE3, 0xF0, 0x1F, 0x01,
  0xF9, 0xFF, 0x07, 0x83, 0xFE, 0x7F, 0xF0, 0xE3, 0xFF, 0xBF, 0xFE, 0x33,
  0xFF, 0xF0, 0xFF, 0xED, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3D, 0xC0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x08, 0x00, 0x08, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03,
  0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xE0, 0x02, 0x03, 0xF8, 0xFF, 0x3F, 0xF7, 0xFE, 0xFF, 0xDF, 0xFB,
  0xFE, 0x7F, 0xC7, 0xF0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01,
  0xFE, 0x03, 0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3E, 0x1F,
  0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x1F,
  0x03, 0x80, 0x7C, 0x3E, 0x07, 0xE0, 0x7C, 0x3E, 0x0F, 0xE0, 0x7C, 0x3E,
  0x0F, 0xE0, 0x7C, 0x3E, 0x0F, 0xE0, 0xF8, 0x3E, 0x07, 0xE0, 0xF8, 0x3E,
  0x07, 0xC0, 0xF8, 0x3E, 0x01, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0xF8, 0x7C,
  0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0xFC,
  0x00, 0x07, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0x7F,
  0x00, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xCF,
  0x80, 0x03, 0xFC, 0x7C, 0x00, 0x3F, 0x83, 0xE0, 0x03, 0xF8, 0x1F, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0xF0, 0x0F, 0x80, 0x06, 0x00, 0x7C, 0x00, 0x60,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF,
  0x01, 0xFE, 0x01, 0xFC, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x3F, 0x03, 0xE0,
  0x00, 0x3F, 0x03, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0x7E, 0x00,
  0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0xF8, 0x0F, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x7C,
  0x0F, 0xC0, 0x01, 0xF0, 0x7E, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0xF8, 0x7E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x3E, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0x83, 0xFE, 0x00, 0x1F, 0x1F, 0xFF, 0x00, 0x3E, 0x7F, 0xFF,
  0x00, 0x7D, 0xFF, 0xFF, 0x00, 0xFF, 0xC1, 0xFE, 0x01, 0xFE, 0x00, 0xFE,
  0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xF8, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x80,
  0x00, 0xF8, 0x1F, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0x7E, 0x00,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x9F,
  0xF0, 0x00, 0x7D, 0xFF, 0xF0, 0x03, 0xEF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xC0, 0xFF, 0x80, 0x7F, 0x83, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xF8,
  0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x1F, 0x3E,
  0x00, 0x00, 0x7D, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07, 0xDF, 0x00,
  0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x0F, 0x9F, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07,
  0xC7, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0xC0,
  0xFF, 0x00, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF9, 0xF0, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x1F, 0x3F, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F,
  0x8F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3F,
  0x01, 0xF0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0xFC,
  0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0x7F, 0x80,
  0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xC0, 0x03, 0xF0,
  0x0F, 0x80, 0x03, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x01, 0xF8,
  0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0xF8,
  0x7C, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0,
  0x7C, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x0F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x3D, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7E, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0xF8, 0x7C, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x0F, 0xCF, 0x80, 0x00,
  0x1F, 0x7C, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07,
  0xDF, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0x1F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0,
  0x7F, 0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xF7,
  0xC0, 0x03, 0xFF, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFF, 0x01, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0xFE, 0x03, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xC0, 0xFF, 0x80, 0xFE, 0x00, 0x60, 0x00, 0x00, 0x1F, 0xC0,
  0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x80, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0x06,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x80,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0x8F, 0xFC, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x80, 0xF0, 0x7C, 0x00,
  0x7F, 0xC7, 0x83, 0xC0, 0x0F, 0xFF, 0x7C, 0x1E, 0x00, 0xFF, 0xFB, 0xE0,
  0xF0, 0x07, 0xE0, 0xFE, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x7C, 0x03, 0xE0,
  0x0F, 0x83, 0xE0, 0x3E, 0x00, 0x7C, 0x1E, 0x01, 0xF0, 0x03, 0xE0, 0xF0,
  0x0F, 0x00, 0x1F, 0x07, 0x80, 0x78, 0x00, 0xF8, 0x7C, 0x07, 0xC0, 0x07,
  0x83, 0xE0, 0x3E, 0x00, 0x3C, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0xF8, 0x0F,
  0x80, 0x1F, 0x07, 0x80, 0x78, 0x00, 0xF8, 0x3C, 0x03, 0xC0, 0x07, 0xC1,
  0xE0, 0x1E, 0x00, 0x3C, 0x1F, 0x01, 0xF0, 0x01, 0xE0, 0xF8, 0x0F, 0x80,
  0x1F, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x3C, 0x03, 0xE0, 0x0F, 0xC1, 0xE0,
  0x1F, 0x80, 0xFE, 0x0F, 0x00, 0x7E, 0x0F, 0xE0, 0xF8, 0x03, 0xFF, 0xEF,
  0x07, 0xC0, 0x0F, 0xFE, 0x78, 0x3E, 0x00, 0x3F, 0xE3, 0xC1, 0xF0, 0x00,
  0x10, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x3E, 0xF0, 0x00,
  0x00, 0x7D, 0xF0, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00,
  0xF8, 0x3C, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F,
  0x81, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF8,
  0x0F, 0x80, 0x03, 0xE0, 0x1F, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xF0, 0x01,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x0F,
  0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x01, 0xE0,
  0x7C, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x7C, 0x7C,
  0x00, 0x00, 0xF9, 0xF0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x03, 0xEF, 0xC0,
  0x00, 0x03, 0xDF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x07, 0xF0, 0x07, 0xC0, 0x01, 0xF8,
  0x07, 0xC0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01,
  0xF0, 0x1E, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00,
  0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x7C, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0xF0, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0x80,
  0x1F, 0xF0, 0x07, 0xC0, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x7E, 0x03, 0xE0,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xE0, 0x7C,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x78, 0x1F,
  0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x0F, 0xC0,
  0xF8, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x1F, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0x7E, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x0F,
  0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xF0, 0x3F,
  0xFC, 0x01, 0xF0, 0x01, 0xFC, 0x01, 0xF0, 0x00, 0xFE, 0x03, 0xE0, 0x00,
  0x7E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x3F, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00,
  0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x01,
  0xF0, 0x3F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07,
  0xE0, 0x3E, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x7F,
  0x80, 0x7C, 0x07, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x08,
  0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x01,
  0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x3E, 0x07,
  0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x01, 0xFF, 0xF8, 0x3E, 0x03, 0xFF, 0xF8, 0x3E, 0x03, 0xFF, 0xF8, 0x3E,
  0x03, 0xFF, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF8, 0x3E,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xE0, 0x7C,
  0x00, 0x07, 0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x3F,
  0x80, 0x7F, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x1F,
  0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x7C, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x3F,
  0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x1F, 0x00, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x01,
  0xF0, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x1F, 0x80, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00,
  0x7C, 0x07, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0x80,
  0xFC, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x1F,
  0x80, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xFE, 0x03,
  0xBC, 0x00, 0x7B, 0x80, 0x77, 0x80, 0x1F, 0xF0, 0x1E, 0xF0, 0x03, 0xDE,
  0x03, 0xCF, 0x00, 0xFB, 0xC0, 0x79, 0xE0, 0x1E, 0x78, 0x0F, 0x3C, 0x07,
  0xDF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x3C, 0xF0, 0x3E, 0x78, 0x0F, 0x8F,
  0x07, 0x8F, 0x01, 0xF1, 0xE1, 0xF1, 0xE0, 0x3E, 0x3C, 0x3C, 0x7C, 0x07,
  0xC7, 0x8F, 0x8F, 0x80, 0xF0, 0xF1, 0xE1, 0xF0, 0x1E, 0x1E, 0x3C, 0x3C,
  0x07, 0xC1, 0xEF, 0x0F, 0x80, 0xF8, 0x3D, 0xE1, 0xF0, 0x1F, 0x07, 0xF8,
  0x3E, 0x03, 0xE0, 0xFF, 0x07, 0xC0, 0x7C, 0x1F, 0xC0, 0xF8, 0x0F, 0x81,
  0xF8, 0x3E, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00,
  0x7C, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x1F,
  0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0x80, 0xFE, 0x00, 0x07, 0xC0, 0x7F, 0x80, 0x03, 0xE0,
  0x3F, 0xC0, 0x01, 0xF0, 0x1F, 0xE0, 0x00, 0xF8, 0x0F, 0xF0, 0x00, 0x78,
  0x0F, 0xFC, 0x00, 0x7C, 0x07, 0xFE, 0x00, 0x3E, 0x03, 0xEF, 0x00, 0x1F,
  0x01, 0xF7, 0x80, 0x0F, 0x80, 0xFB, 0xC0, 0x07, 0xC0, 0x79, 0xF0, 0x03,
  0xE0, 0x3C, 0xF8, 0x01, 0xE0, 0x3E, 0x3C, 0x01, 0xF0, 0x1F, 0x1E, 0x00,
  0xF8, 0x0F, 0x8F, 0x00, 0x7C, 0x07, 0xC7, 0xC0, 0x3E, 0x03, 0xE3, 0xE0,
  0x1F, 0x01, 0xE0, 0xF0, 0x0F, 0x01, 0xF0, 0x78, 0x0F, 0x80, 0xF8, 0x3C,
  0x07, 0xC0, 0x7C, 0x1F, 0x03, 0xE0, 0x3E, 0x0F, 0x81, 0xF0, 0x1F, 0x03,
  0xC0, 0xF8, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC0,
  0x7C, 0x3E, 0x03, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0x0F, 0x0F, 0x80, 0xF8,
  0x07, 0x87, 0xC0, 0x7C, 0x03, 0xE3, 0xE0, 0x3C, 0x01, 0xF1, 0xE0, 0x3E,
  0x00, 0x79, 0xF0, 0x1F, 0x00, 0x3C, 0xF8, 0x0F, 0x80, 0x1E, 0x7C, 0x07,
  0xC0, 0x0F, 0xBE, 0x03, 0xE0, 0x07, 0xDF, 0x01, 0xE0, 0x01, 0xEF, 0x01,
  0xF0, 0x00, 0xF7, 0x80, 0xF8, 0x00, 0x7B, 0xC0, 0x7C, 0x00, 0x3F, 0xE0,
  0x3E, 0x00, 0x1F, 0xF0, 0x1F, 0x00, 0x07, 0xF8, 0x0F, 0x00, 0x03, 0xF8,
  0x0F, 0x80, 0x01, 0xFC, 0x07, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0x7F, 0x80, 0x7E, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC,
  0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00,
  0xF8, 0x7C, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8,
  0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x80,
  0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x1F, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00,
  0x3F, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x00, 0x7C, 0x0F, 0x80, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x03, 0xF0,
  0x1F, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0xFE, 0x03, 0xE0, 0x00, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0xFE, 0x03, 0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x1F,
  0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x3E,
  0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x3E,
  0x00, 0x01, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0xFC,
  0x00, 0x03, 0xE0, 0xFC, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x1F, 0x80, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0xFF, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x00, 0x1F,
  0xC0, 0x1F, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x7E, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x0F, 0x80,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x03, 0xF8,
  0x0F, 0x80, 0x01, 0xFC, 0x03, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x03, 0xF0, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0,
  0x03, 0xF8, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x7E,
  0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x03, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00,
  0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00,
  0xF8, 0x1F, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0xFF,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x7C,
  0x3E, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x0F,
  0x80, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x3E,
  0x00, 0x1F, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80,
  0x3E, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x3C, 0x03,
  0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3C, 0x7C, 0x00,
  0x00, 0x78, 0xF8, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF9, 0xF0, 0x07, 0xE0, 0x0F, 0x8F, 0x80, 0x3F, 0x00, 0x7C, 0x7C, 0x01,
  0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0xC0, 0x1E, 0x1F, 0x00, 0xEE, 0x01, 0xF0,
  0xF8, 0x07, 0x70, 0x0F, 0x87, 0xC0, 0x3B, 0x80, 0x78, 0x3E, 0x03, 0xDC,
  0x03, 0xC1, 0xF0, 0x1C, 0xE0, 0x3E, 0x0F, 0x00, 0xE7, 0x01, 0xF0, 0x78,
  0x0F, 0x38, 0x0F, 0x03, 0xC0, 0x79, 0xC0, 0x78, 0x1E, 0x03, 0x8E, 0x07,
  0xC0, 0xF0, 0x1C, 0xF0, 0x3C, 0x07, 0x81, 0xE7, 0x81, 0xE0, 0x3C, 0x0E,
  0x3C, 0x1F, 0x01, 0xE0, 0x71, 0xE0, 0xF8, 0x0F, 0x07, 0x8F, 0x07, 0x80,
  0x78, 0x38, 0x78, 0x3C, 0x07, 0xC1, 0xC3, 0x83, 0xE0, 0x3E, 0x0E, 0x1C,
  0x1F, 0x01, 0xF0, 0xF0, 0xE0, 0xF0, 0x0F, 0x87, 0x07, 0x07, 0x80, 0x7C,
  0x38, 0x38, 0x7C, 0x03, 0xE3, 0xC1, 0xC3, 0xC0, 0x1F, 0x1C, 0x0E, 0x1E,
  0x00, 0xF8, 0xE0, 0x70, 0xF0, 0x07, 0xC7, 0x03, 0x8F, 0x80, 0x3E, 0x78,
  0x1C, 0x78, 0x01, 0xE3, 0x80, 0xE3, 0xC0, 0x0F, 0x1C, 0x07, 0x3E, 0x00,
  0x79, 0xE0, 0x39, 0xE0, 0x03, 0xCE, 0x01, 0xCF, 0x00, 0x1E, 0x70, 0x0E,
  0x78, 0x00, 0xF3, 0x80, 0x77, 0xC0, 0x07, 0xBC, 0x03, 0xBC, 0x00, 0x3D,
  0xC0, 0x1D, 0xE0, 0x01, 0xEE, 0x00, 0xEF, 0x00, 0x0F, 0xF0, 0x07, 0xF8,
  0x00, 0x7F, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xC0,
  0x1F, 0xE0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0xF8, 0x00, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x00, 0x07, 0xE1, 0xF0, 0x00,
  0x00, 0x1F, 0x83, 0xE0, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x00, 0xFC,
  0x07, 0xC0, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0x9F, 0x00,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x1F,
  0x00, 0x03, 0xE0, 0x0F, 0x80, 0x03, 0xF0, 0x07, 0xC0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x01, 0xF0, 0x7E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00,
  0x00, 0x1F, 0x3F, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x07, 0xDF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1E, 0xF8, 0x00, 0x07, 0xCF,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x3E, 0x3C, 0x00, 0x0F, 0x87, 0xC0, 0x01,
  0xE0, 0x78, 0x00, 0x7C, 0x0F, 0x00, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x1E,
  0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x07, 0xC0, 0x0F, 0x81, 0xF0,
  0x00, 0xF0, 0x3E, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0x7C,
  0x7C, 0x00, 0x07, 0x9F, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x81,
  0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x00, 0x0F, 0xF0, 0x7C, 0x01, 0xFF, 0xF1,
  0xF0, 0x0F, 0xFF, 0xE7, 0xC0, 0x7F, 0xFF, 0xDF, 0x03, 0xFC, 0x0F, 0x7C,
  0x1F, 0xC0, 0x0D, 0xF0, 0x7E, 0x00, 0x3F, 0xC3, 0xF0, 0x00, 0x7E, 0x0F,
  0x80, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF8, 0x78, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x7C,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0xFF, 0x03, 0xF8, 0x07,
  0x7C, 0x0F, 0xFF, 0xFD, 0xF0, 0x1F, 0xFF, 0xEF, 0x80, 0x3F, 0xFE, 0x3E,
  0x00, 0x7F, 0xF0, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x07, 0xFC, 0x00, 0x3E, 0x3F, 0xFE, 0x00, 0xF8,
  0xFF, 0xFE, 0x01, 0xF3, 0xFF, 0xFC, 0x03, 0xEF, 0x03, 0xFC, 0x07, 0xF8,
  0x01, 0xF8, 0x0F, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3E, 0x00,
  0x03, 0xE0, 0xFC, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C,
  0x3F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x7C, 0x0F,
  0xC0, 0x01, 0xF8, 0x3F, 0x80, 0x03, 0xE0, 0x7F, 0x80, 0x1F, 0xC0, 0xFB,
  0x80, 0x7F, 0x01, 0xF7, 0xFF, 0xFC, 0x03, 0xEF, 0xFF, 0xF0, 0x07, 0xCF,
  0xFF, 0xC0, 0x1F, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF8, 0x03, 0xFE, 0x0F, 0xF0, 0x0F, 0xC0, 0x0F, 0xE0, 0x7E, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x7E, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x7E, 0x1F, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x7E, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x0F,
  0xF0, 0x7C, 0x00, 0x7F, 0xFC, 0x7C, 0x00, 0xFF, 0xFE, 0x7C, 0x01, 0xFF,
  0xFF, 0x7C, 0x03, 0xFC, 0x0F, 0x7C, 0x07, 0xF0, 0x03, 0x7C, 0x07, 0xE0,
  0x03, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0x80, 0x01, 0xF8, 0x1F, 0x80,
  0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00,
  0x01, 0xF8, 0x1E, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0xC0, 0x3F, 0x80,
  0x77, 0xC0, 0x3F, 0xFF, 0xF7, 0xC0, 0x1F, 0xFF, 0xEF, 0x80, 0x0F, 0xFF,
  0x8F, 0x80, 0x07, 0xFF, 0x0F, 0x80, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0x3F, 0xC0, 0xFF, 0x01, 0xF8, 0x01, 0xF8, 0x1F, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x00,
  0x7C, 0xF8, 0x00, 0x03, 0xC7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x78, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0xC0, 0xFE,
  0x01, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0xF8, 0x03, 0xFF, 0xC7, 0xC0,
  0x7F, 0xFF, 0x3E, 0x07, 0xFF, 0xFD, 0xF0, 0x7F, 0x81, 0xEF, 0x87, 0xF0,
  0x03, 0x7C, 0x3F, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x7E, 0x1F, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x8F, 0x80,
  0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00,
  0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x1F, 0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xC3, 0xE0,
  0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xE0, 0xFE, 0x01, 0xFF, 0x03, 0xFF, 0xFE,
  0xF8, 0x1F, 0xFF, 0xE7, 0xC0, 0x7F, 0xFE, 0x3E, 0x00, 0xFF, 0xE1, 0xF0,
  0x01, 0xF0, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xE0,
  0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x07,
  0xFC, 0x00, 0x3E, 0x3F, 0xFE, 0x00, 0xF9, 0xFF, 0xFE, 0x01, 0xF3, 0xFF,
  0xFC, 0x03, 0xEF, 0x03, 0xFC, 0x07, 0xF8, 0x01, 0xF8, 0x0F, 0xE0, 0x01,
  0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x7C, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x03, 0xF0, 0x1F, 0x00,
  0x03, 0xF0, 0x1F, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x03, 0xF0, 0x07, 0xC0,
  0x03, 0xF0, 0x03, 0xE0, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8,
  0x01, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x3E,
  0x01, 0xF8, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x7C, 0x07, 0xE0, 0x00,
  0x3E, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x3F, 0x00,
  0x0F, 0x80, 0x1F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x7C, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x01,
  0xF8, 0x0F, 0x80, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x7F, 0xFF,
  0x80, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x07, 0x8F, 0xE0, 0xFE, 0x01, 0xE7, 0xFC, 0x7F,
  0xC0, 0x7B, 0xFF, 0x3F, 0xF0, 0x1E, 0xFF, 0xDF, 0xFE, 0x0F, 0xC1, 0xFE,
  0x1F, 0x83, 0xF0, 0x3F, 0x03, 0xE0, 0xF8, 0x0F, 0x80, 0xF8, 0x3E, 0x03,
  0xE0, 0x3E, 0x0F, 0x00, 0xF0, 0x0F, 0x83, 0xC0, 0x3C, 0x03, 0xE1, 0xF0,
  0x0F, 0x00, 0xF8, 0x7C, 0x03, 0xC0, 0x3C, 0x1F, 0x00, 0xF0, 0x0F, 0x07,
  0xC0, 0x7C, 0x07, 0xC1, 0xF0, 0x1E, 0x01, 0xF0, 0x78, 0x07, 0x80, 0x7C,
  0x3E, 0x01, 0xE0, 0x1F, 0x0F, 0x80, 0x78, 0x07, 0x83, 0xE0, 0x1E, 0x01,
  0xE0, 0xF8, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE0, 0x3E, 0x0F, 0x00, 0xF0,
  0x0F, 0x83, 0xC0, 0x3C, 0x03, 0xE1, 0xF0, 0x0F, 0x00, 0xF8, 0x7C, 0x03,
  0xC0, 0x3C, 0x1F, 0x00, 0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x07, 0xC1, 0xE0,
  0x1E, 0x01, 0xF0, 0x78, 0x07, 0x80, 0x7C, 0x3E, 0x01, 0xE0, 0x1F, 0x0F,
  0x80, 0x78, 0x07, 0x83, 0xE0, 0x1E, 0x01, 0xE0, 0xF8, 0x0F, 0x80, 0xF8,
  0x3C, 0x03, 0xC0, 0x3E, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0x03, 0xE0, 0xFF,
  0x80, 0x07, 0xC7, 0xFF, 0xC0, 0x1F, 0x3F, 0xFF, 0xC0, 0x3E, 0x7F, 0xFF,
  0x80, 0x7D, 0xE0, 0x7F, 0x80, 0xFF, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0xF8,
  0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xC0, 0xFF, 0x01, 0xF8, 0x01, 0xF8, 0x1F,
  0x80, 0x07, 0xC1, 0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0xF8, 0xFC, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F,
  0x9F, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3E, 0x3E,
  0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C, 0x7C, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F,
  0x8F, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3E, 0x1F,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xF8, 0x3F, 0x80,
  0x1F, 0xC0, 0xFE, 0x01, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0xF0, 0x7F, 0xC0, 0x01, 0xF1, 0xFF, 0xF0, 0x03, 0xE3, 0xFF, 0xF8,
  0x03, 0xE7, 0xFF, 0xF8, 0x03, 0xEF, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0xFC,
  0x03, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x3E,
  0x07, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C,
  0x1F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8,
  0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x01, 0xF0,
  0x3F, 0x80, 0x03, 0xF0, 0x3F, 0x80, 0x03, 0xE0, 0x3F, 0xC0, 0x07, 0xE0,
  0x3E, 0xE0, 0x1F, 0xC0, 0x3E, 0xFF, 0xFF, 0x80, 0x3E, 0xFF, 0xFF, 0x00,
  0x3E, 0x7F, 0xFE, 0x00, 0x7C, 0x1F, 0xF8, 0x00, 0x7C, 0x03, 0x80, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x7C, 0x01, 0xFF, 0xF1, 0xF0,
  0x0F, 0xFF, 0xE7, 0xC0, 0x7F, 0xFF, 0xDF, 0x03, 0xFC, 0x0F, 0x7C, 0x1F,
  0xC0, 0x0D, 0xF0, 0x7C, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x7E, 0x0F, 0x80,
  0x01, 0xF8, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE1, 0xF0,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x07, 0xE1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0xFF, 0x03, 0xF8, 0x0F, 0x7C,
  0x0F, 0xFF, 0xF9, 0xE0, 0x1F, 0xFF, 0xEF, 0x80, 0x3F, 0xFE, 0x3E, 0x00,
  0x7F, 0xF0, 0xF8, 0x00, 0x1C, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0xFF,
  0x80, 0x07, 0xC7, 0xFF, 0xC0, 0x0F, 0x9F, 0xFF, 0xC0, 0x3E, 0x7F, 0xFF,
  0xC0, 0x7D, 0xE0, 0x3F, 0x80, 0xFF, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0xF8,
  0x3F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0x7F, 0x83, 0xF0, 0x00, 0xFC, 0x3F,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x3E,
  0x00, 0x00, 0xF9, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7C, 0x7E, 0x00,
  0x07, 0xE1, 0xFC, 0x00, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F,
  0x03, 0xF0, 0x00, 0x7C, 0x07, 0xE0, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0xE0, 0x3F, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7D, 0xF0,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C,
  0x1F, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xF0, 0x1F,
  0x00, 0x1F, 0x00, 0xF8, 0x01, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00,
  0x7C, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x3E, 0x03, 0xE0,
  0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3C, 0x0F, 0x80, 0x01,
  0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x03, 0xDF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xFC,
  0x01, 0xF0, 0x07, 0xFE, 0x01, 0xF8, 0x03, 0xDE, 0x00, 0xFC, 0x01, 0xEF,
  0x00, 0x7E, 0x01, 0xF7, 0x80, 0x7F, 0x00, 0xF3, 0xC0, 0x3B, 0x80, 0x79,
  0xE0, 0x1D, 0xC0, 0x7C, 0xF0, 0x1E, 0xE0, 0x3C, 0x78, 0x0E, 0x70, 0x1E,
  0x3C, 0x07, 0x38, 0x0F, 0x1E, 0x07, 0x9C, 0x0F, 0x0F, 0x03, 0x8E, 0x07,
  0x87, 0x81, 0xC7, 0x03, 0xC3, 0xC1, 0xE3, 0x83, 0xC1, 0xE0, 0xE1, 0xC1,
  0xE0, 0xF0, 0x70, 0xE0, 0xF0, 0x78, 0x78, 0x70, 0xF0, 0x3C, 0x38, 0x38,
  0x78, 0x1E, 0x1C, 0x1C, 0x3C, 0x0F, 0x1E, 0x0E, 0x3C, 0x07, 0x8E, 0x07,
  0x1E, 0x03, 0xC7, 0x03, 0x8F, 0x01, 0xE7, 0x81, 0xC7, 0x00, 0xF3, 0x80,
  0xE7, 0x80, 0x79, 0xC0, 0x73, 0xC0, 0x3D, 0xE0, 0x39, 0xE0, 0x1E, 0xE0,
  0x1D, 0xE0, 0x0F, 0x70, 0x0E, 0xF0, 0x07, 0xB8, 0x07, 0x78, 0x03, 0xFC,
  0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x0F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x3F, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x7E, 0x00, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x07, 0xC7, 0xE0,
  0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFB, 0xE0, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x1F, 0x81,
  0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x1F,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0xF8, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F,
  0x8F, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x3E, 0x3E,
  0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C, 0x7C, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F,
  0x8F, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x1F,
  0x00, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C, 0x7C, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x1F,
  0xC7, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xE0, 0xFE, 0x01, 0xFF, 0x03,
  0xFF, 0xFE, 0xF8, 0x1F, 0xFF, 0xE7, 0xC0, 0x7F, 0xFE, 0x3E, 0x00, 0xFF,
  0xC3, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x3E, 0x1F, 0xFC, 0x00, 0x7C, 0x7F, 0xFC,
  0x00, 0xF9, 0xFF, 0xFC, 0x01, 0xE3, 0xE0, 0xFC, 0x03, 0xCF, 0x80, 0xF8,
  0x0F, 0x9F, 0x01, 0xF8, 0x1F, 0x3E, 0x01, 0xF8, 0x7C, 0x78, 0x01, 0xFF,
  0xF8, 0xF0, 0x03, 0xFF, 0xE3, 0xE0, 0x03, 0xFF, 0x87, 0xC0, 0x01, 0xFC,
  0x00,
};

const GFXglyph JetBrainsMono_LightItalic63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 14, 46, 38, 12, -46 },
  { 82, 21, 19, 38, 12, -46 },
  { 132, 37, 46, 38, 1, -46 },
  { 345, 33, 64, 38, 3, -55 },
  { 609, 43, 46, 38, -2, -46 },
  { 857, 34, 48, 38, 2, -47 },
  { 1061, 8, 19, 38, 18, -46 },
  { 1080, 26, 61, 38, 10, -53 },
  { 1279, 26, 61, 38, 3, -53 },
  { 1478, 34, 32, 38, 3, -38 },
  { 1614, 30, 30, 38, 4, -36 },
  { 1727, 16, 20, 38, 6, -10 },
  { 1767, 21, 4, 38, 9, -23 },
  { 1778, 11, 11, 38, 11, -10 },
  { 1794, 37, 59, 38, 1, -52 },
  { 2067, 32, 48, 38, 4, -47 },
  { 2259, 29, 46, 38, 3, -46 },
  { 2426, 32, 47, 38, 3, -47 },
  { 2614, 32, 47, 38, 3, -46 },
  { 2802, 30, 46, 38, 4, -46 },
  { 2975, 31, 47, 38, 4, -46 },
  { 3158, 30, 47, 38, 3, -46 },
  { 3335, 30, 46, 38, 8, -46 },
  { 3508, 32, 48, 38, 3, -47 },
  { 3700, 30, 47, 38, 6, -47 },
  { 3877, 15, 36, 38, 11, -35 },
  { 3945, 20, 45, 38, 7, -35 },
  { 4058, 29, 33, 38, 6, -37 },
  { 4178, 29, 19, 38, 5, -30 },
  { 4247, 30, 33, 38, 3, -37 },
  { 4371, 25, 46, 38, 9, -46 },
  { 4515, 37, 58, 38, 1, -47 },
  { 4784, 31, 46, 38, 1, -46 },
  { 4963, 33, 46, 38, 3, -46 },
  { 5153, 32, 48, 38, 4, -47 },
  { 5345, 32, 46, 38, 3, -46 },
  { 5529, 33, 46, 38, 4, -46 },
  { 5719, 34, 46, 38, 4, -46 },
  { 5915, 32, 48, 38, 4, -47 },
  { 6107, 33, 46, 38, 3, -46 },
  { 6297, 31, 46, 38, 4, -46 },
  { 6476, 33, 47, 38, 2, -46 },
  { 6670, 36, 46, 38, 3, -46 },
  { 6877, 27, 46, 38, 5, -46 },
  { 7033, 35, 46, 38, 2, -46 },
  { 7235, 33, 46, 38, 3, -46 },
  { 7425, 31, 48, 38, 4, -47 },
  { 7611, 34, 46, 38, 3, -46 },
  { 7807, 32, 58, 38, 4, -47 },
  { 8039, 34, 46, 38, 3, -46 },
  { 8235, 33, 48, 38, 3, -47 },
  { 8433, 32, 46, 38, 7, -46 },
  { 8617, 32, 47, 38, 4, -46 },
  { 8805, 31, 46, 38, 8, -46 },
  { 8984, 37, 46, 38, 4, -46 },
  { 9197, 39, 46, 38, 0, -46 },
  { 9422, 33, 46, 38, 7, -46 },
  { 9612, 33, 46, 38, 3, -46 },
  { 9802, 25, 59, 38, 9, -52 },
  { 9987, 18, 59, 38, 11, -52 },
  { 10120, 24, 59, 38, 6, -52 },
  { 10297, 27, 25, 38, 6, -46 },
  { 10382, 31, 4, 38, 0, 2 },
  { 10398, 11, 8, 38, 17, -49 },
  { 10409, 30, 36, 38, 4, -35 },
  { 10544, 31, 47, 38, 3, -46 },
  { 10727, 30, 36, 38, 4, -35 },
  { 10862, 32, 47, 38, 4, -46 },
  { 11050, 29, 36, 38, 4, -35 },
  { 11181, 43, 57, 38, -3, -46 },
  { 11488, 29, 46, 38, 5, -35 },
  { 11655, 31, 46, 38, 3, -46 },
  { 11834, 29, 49, 38, 3, -49 },
  { 12012, 32, 60, 38, 1, -49 },
  { 12252, 33, 46, 38, 4, -46 },
  { 12442, 26, 46, 38, 6, -46 },
  { 12592, 34, 35, 38, 2, -35 },
  { 12741, 31, 35, 38, 3, -35 },
  { 12877, 29, 36, 38, 4, -35 },
  { 13008, 32, 46, 38, 2, -35 },
  { 13192, 30, 46, 38, 4, -35 },
  { 13365, 31, 35, 38, 4, -35 },
  { 13501, 29, 36, 38, 4, -35 },
  { 13632, 29, 44, 38, 6, -44 },
  { 13792, 31, 36, 38, 4, -35 },
  { 13932, 29, 35, 38, 7, -35 },
  { 14059, 33, 35, 38, 5, -35 },
  { 14204, 35, 35, 38, 1, -35 },
  { 14358, 29, 46, 38, 5, -35 },
  { 14525, 31, 35, 38, 3, -35 },
  { 14661, 32, 59, 38, 6, -52 },
  { 14897, 14, 59, 38, 13, -52 },
  { 15001, 31, 59, 38, 2, -52 },
  { 15230, 31, 12, 38, 4, -28 },
};

const GFXfont JetBrainsMono_LightItalic63pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_LightItalic63pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_LightItalic63pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _JETBRAINSMONO_LIGHTITALIC63PT7B_H_
