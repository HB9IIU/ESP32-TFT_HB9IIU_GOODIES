#ifndef _JETBRAINSMONO_LIGHTITALIC49PT7B_H_
#define _JETBRAINSMONO_LIGHTITALIC49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-LightItalic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_LightItalic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x7F, 0x0F, 0xE0, 0x7E, 0x07, 0xC0, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C,
  0x0F, 0x3C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78,
  0x1E, 0x78, 0x1E, 0x78, 0x1C, 0x70, 0x1C, 0x70, 0x3C, 0xF0, 0x3C, 0xF0,
  0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x38, 0x07, 0x00, 0x03, 0xC0, 0x38,
  0x00, 0x1C, 0x03, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x0F, 0x00, 0xE0, 0x00,
  0x70, 0x0F, 0x00, 0x03, 0x80, 0x70, 0x00, 0x3C, 0x03, 0x80, 0x01, 0xC0,
  0x3C, 0x03, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0x00, 0x38, 0x07, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x1C, 0x03, 0xC0, 0x00,
  0xE0, 0x1C, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x70, 0x0F, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x3C, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x0E, 0x01, 0xC0,
  0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x03,
  0xC0, 0x78, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x01,
  0xE0, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x80, 0x70, 0x00, 0x38, 0x07, 0x80,
  0x01, 0xC0, 0x38, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0xE0, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xDB, 0xF0,
  0x07, 0x8E, 0x3E, 0x03, 0xC3, 0x87, 0x81, 0xF0, 0xE1, 0xE0, 0x78, 0x38,
  0x38, 0x1E, 0x0E, 0x1E, 0x07, 0x83, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x78,
  0x70, 0x00, 0x1E, 0x1C, 0x00, 0x07, 0xC7, 0x00, 0x01, 0xF9, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0C, 0x7C, 0x00, 0x03,
  0x0F, 0x80, 0x01, 0xC1, 0xE0, 0x00, 0x70, 0x78, 0x00, 0x1C, 0x1E, 0x00,
  0x07, 0x07, 0x87, 0x81, 0x81, 0xE1, 0xE0, 0x60, 0x78, 0x78, 0x38, 0x3C,
  0x1E, 0x0E, 0x0F, 0x07, 0xC3, 0x8F, 0x80, 0xFC, 0xEF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x03, 0x80,
  0xFF, 0xC0, 0x03, 0x80, 0xFF, 0xE0, 0x03, 0x80, 0x78, 0x78, 0x03, 0x80,
  0x78, 0x3C, 0x03, 0xC0, 0x38, 0x0E, 0x03, 0xC0, 0x1C, 0x07, 0x01, 0xC0,
  0x1E, 0x07, 0x81, 0xC0, 0x0E, 0x03, 0xC1, 0xC0, 0x07, 0x01, 0xC1, 0xC0,
  0x03, 0x80, 0xE1, 0xC0, 0x01, 0xC0, 0x71, 0xE0, 0x00, 0xF0, 0x71, 0xE0,
  0x00, 0x7F, 0xF8, 0xE0, 0x00, 0x1F, 0xF8, 0xE0, 0x00, 0x07, 0xF0, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0xFC, 0x00, 0x00, 0x71,
  0xFF, 0x80, 0x00, 0x71, 0xFF, 0xC0, 0x00, 0x79, 0xE0, 0xF0, 0x00, 0x78,
  0xE0, 0x78, 0x00, 0x78, 0x70, 0x1C, 0x00, 0x38, 0x78, 0x1E, 0x00, 0x38,
  0x3C, 0x0F, 0x00, 0x38, 0x1C, 0x07, 0x00, 0x38, 0x0E, 0x03, 0x80, 0x3C,
  0x07, 0x01, 0xC0, 0x3C, 0x03, 0x81, 0xE0, 0x1C, 0x01, 0xE1, 0xE0, 0x1C,
  0x00, 0xFF, 0xF0, 0x1C, 0x00, 0x3F, 0xF0, 0x1C, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x7E,
  0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0,
  0x1E, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7C, 0xF8, 0x07, 0x8F, 0x0F, 0x01, 0xE3, 0xC1, 0xF0, 0x78, 0x78,
  0x1E, 0x0F, 0x0F, 0x03, 0xE3, 0xC1, 0xE0, 0x3C, 0xF0, 0x78, 0x03, 0xDE,
  0x0F, 0x00, 0x7F, 0x81, 0xE0, 0x07, 0xE0, 0x3C, 0x00, 0xF8, 0x07, 0x80,
  0x0F, 0x00, 0xF0, 0x03, 0xF0, 0x1E, 0x00, 0xFE, 0x03, 0xC0, 0x3D, 0xE0,
  0x7C, 0x1F, 0x3E, 0x07, 0xFF, 0xC3, 0xC0, 0xFF, 0xF0, 0x7C, 0x07, 0xF8,
  0x07, 0xC0, 0x3C, 0xF7, 0xDF, 0x7D, 0xE7, 0x9E, 0x7B, 0xEF, 0x3C, 0xF3,
  0xCE, 0x00, 0x00, 0x00, 0x70, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x18, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x07,
  0xF8, 0x00, 0x7E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0xC0, 0x3C, 0x01, 0x78,
  0x1E, 0x07, 0xFF, 0x8E, 0x1F, 0xFF, 0xE7, 0x3F, 0xEF, 0xFD, 0x7F, 0xC0,
  0xFF, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xEF, 0x00, 0x01, 0xE3, 0xC0, 0x01, 0xF1, 0xE0, 0x01, 0xF0, 0xF8,
  0x00, 0xF0, 0x3C, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0xF8, 0x03,
  0xC0, 0x18, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00,
  0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F,
  0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3E, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x7F, 0x0F, 0xC0, 0x7C, 0x01, 0xF0, 0x3C, 0x00, 0x78, 0x3C, 0x00,
  0x3C, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80,
  0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF1, 0xE0, 0x00, 0x78, 0xF0,
  0x00, 0x3C, 0x78, 0x38, 0x1C, 0x3C, 0x3E, 0x1E, 0x1E, 0x1F, 0x0F, 0x0F,
  0x0F, 0x87, 0x87, 0x07, 0xC3, 0xC7, 0x81, 0xC1, 0xE3, 0xC0, 0x00, 0xE1,
  0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x38, 0x00, 0x1E,
  0x3C, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03,
  0xC1, 0xE0, 0x03, 0xC0, 0xF8, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x1F, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x0F, 0xDE, 0x00, 0x3E,
  0x3C, 0x01, 0xF8, 0x78, 0x03, 0xC0, 0xF0, 0x07, 0x01, 0xC0, 0x08, 0x07,
  0x80, 0x20, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x07, 0xF0, 0xFC, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x01, 0xE0,
  0x78, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00,
  0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF0, 0xF0, 0x01, 0xF0, 0xF8, 0x03,
  0xE0, 0x7E, 0x07, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x0E, 0x03,
  0xC0, 0x3C, 0x0F, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0xF8, 0x01, 0xE3, 0xE0,
  0x03, 0xCF, 0x80, 0x07, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x7F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x02, 0x00,
  0x0E, 0x3F, 0xE0, 0x1E, 0xFF, 0xF0, 0x1E, 0xFF, 0xF8, 0x1F, 0xC0, 0xFC,
  0x1F, 0x00, 0x7C, 0x1E, 0x00, 0x3C, 0x3E, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x78,
  0xF0, 0x00, 0xF8, 0x78, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0x7E, 0x07, 0xE0,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE7, 0xF0, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0x83,
  0xF0, 0xFC, 0x01, 0xF1, 0xF0, 0x01, 0xE7, 0xC0, 0x03, 0xCF, 0x00, 0x07,
  0xDE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7B,
  0xC0, 0x00, 0xF7, 0x80, 0x01, 0xEF, 0x00, 0x07, 0x9E, 0x00, 0x0F, 0x3E,
  0x00, 0x3C, 0x3E, 0x00, 0xF8, 0x7E, 0x07, 0xE0, 0x7F, 0xFF, 0x80, 0x7F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0x70,
  0x00, 0x3C, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xFE, 0x03, 0xF8, 0x7E, 0x03, 0xC0, 0x1F, 0x07, 0x80, 0x0F, 0x07,
  0x80, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F,
  0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x7C, 0x07,
  0xC0, 0xF0, 0x03, 0xF3, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFF, 0xC0, 0x07, 0xE7, 0xE0, 0x0F, 0x81, 0xF0, 0x1F, 0x00, 0xF8, 0x3C,
  0x00, 0x78, 0x3C, 0x00, 0x7C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0xF0,
  0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF8,
  0x00, 0xF8, 0x78, 0x01, 0xF0, 0x7E, 0x07, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x7F, 0x0F, 0xC1, 0xF0, 0x07, 0xC7, 0xC0, 0x07, 0x8F, 0x00,
  0x0F, 0xBE, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00, 0x0F,
  0x7C, 0x00, 0x3C, 0xF8, 0x00, 0xF8, 0xF8, 0x03, 0xE1, 0xF8, 0x1F, 0xC1,
  0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFE, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xE1, 0xFC, 0x3F, 0x8F, 0xF1, 0xFE, 0x1F, 0x81, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0xFE, 0x1F, 0xC7, 0xF8, 0xFF, 0x1F,
  0xC1, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x10, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFC, 0x00, 0x08, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0x00, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xE0, 0x1F,
  0xFF, 0x81, 0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x1F, 0x80, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x07, 0x80, 0x03, 0xE0, 0x3C,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x3C,
  0x78, 0x38, 0x03, 0xFD, 0xE0, 0xE0, 0x3F, 0xF7, 0x83, 0x80, 0xF8, 0x7C,
  0x1E, 0x07, 0x80, 0xF0, 0x78, 0x1C, 0x03, 0xC1, 0xE0, 0xF0, 0x0F, 0x07,
  0x03, 0xC0, 0x3C, 0x1C, 0x0F, 0x00, 0xF0, 0x70, 0x38, 0x03, 0x83, 0xC0,
  0xE0, 0x0E, 0x0F, 0x03, 0x80, 0x38, 0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x78,
  0x07, 0x83, 0x81, 0xE0, 0x1E, 0x0E, 0x07, 0x80, 0x70, 0x78, 0x1E, 0x03,
  0xC1, 0xE0, 0x78, 0x1F, 0x07, 0x80, 0xFF, 0xDC, 0x1E, 0x03, 0xFE, 0x70,
  0x70, 0x07, 0xF3, 0xC1, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0E,
  0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C,
  0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x38, 0x00, 0x70, 0x38, 0x00, 0xF0,
  0x38, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x3C, 0x01, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x3C, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0x00, 0x1E, 0x1E, 0x00,
  0x1E, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x78, 0x00,
  0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00,
  0x0F, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0x70, 0x03, 0xF0, 0x78, 0x00, 0xF8, 0x3C, 0x00, 0x3C, 0x1E,
  0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1,
  0xC0, 0x01, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x01, 0xF0, 0x78, 0x01, 0xF0,
  0x3C, 0x03, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x07, 0x80, 0x3F, 0x03, 0xC0, 0x07, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x00,
  0xF0, 0x70, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x00,
  0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC3, 0x80, 0x03, 0xC3, 0xC0,
  0x03, 0xE1, 0xE0, 0x03, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x7F, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x3C, 0x00,
  0x78, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07,
  0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x03, 0xC0, 0xF8, 0x03, 0xE0, 0x3E, 0x07,
  0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07,
  0x00, 0x7E, 0x0F, 0x00, 0x3E, 0x0F, 0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x0F,
  0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E,
  0x00, 0x0E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E,
  0x00, 0x1E, 0x1C, 0x00, 0x1E, 0x3C, 0x00, 0x1C, 0x3C, 0x00, 0x3C, 0x3C,
  0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x3C, 0x78,
  0x00, 0x3C, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78,
  0x00, 0xF0, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE0, 0xF0, 0x07, 0xE0, 0xF0,
  0x7F, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0xFF, 0x80, 0x7F, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x3C, 0x00, 0x78,
  0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x07, 0xFF, 0x87, 0x83, 0xFF, 0xC3, 0xC1, 0xFF, 0xE1, 0xE0,
  0xFF, 0xE0, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x3C,
  0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83,
  0xC0, 0x03, 0xC1, 0xE0, 0x03, 0xC0, 0xF8, 0x03, 0xE0, 0x3E, 0x07, 0xE0,
  0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0x80,
  0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x78,
  0x00, 0x70, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0F,
  0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xC0, 0x03, 0xC1,
  0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x3C,
  0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0x80, 0x07,
  0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00,
  0x70, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00,
  0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0x83, 0xC0, 0x03, 0xC1, 0xE0,
  0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E,
  0x00, 0x1E, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00,
  0xF0, 0x1E, 0x00, 0x1E, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x03, 0xF0, 0x07,
  0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x1F, 0x03, 0xC0, 0x03, 0xC0,
  0x70, 0x00, 0xF0, 0x1E, 0x00, 0x3E, 0x03, 0xC0, 0x07, 0x80, 0x78, 0x01,
  0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x0F,
  0x00, 0xF8, 0x01, 0xE0, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x81, 0xF0,
  0x00, 0xF0, 0x3C, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0xF8, 0x00, 0x78, 0x0F, 0x00,
  0x0F, 0x01, 0xE0, 0x01, 0xC0, 0x3E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0xF0, 0x03, 0xE0, 0x3C, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x80, 0xF0, 0x00,
  0xF8, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0x07,
  0xE0, 0x03, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x07,
  0x70, 0x7E, 0x00, 0xFC, 0x0F, 0xE0, 0x3B, 0x83, 0xDC, 0x07, 0x70, 0x73,
  0x81, 0xCE, 0x0E, 0x70, 0x3B, 0xC1, 0xCE, 0x0E, 0x78, 0x39, 0xC1, 0xCE,
  0x07, 0x3C, 0x71, 0xC1, 0xE3, 0x8E, 0x78, 0x3C, 0x73, 0x8F, 0x07, 0x8E,
  0x71, 0xE0, 0xF1, 0xDE, 0x3C, 0x1E, 0x3B, 0x87, 0x03, 0x83, 0x71, 0xE0,
  0x70, 0x7C, 0x3C, 0x1E, 0x0F, 0x87, 0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00,
  0x1E, 0x0F, 0x00, 0x03, 0x81, 0xE0, 0x00, 0xF0, 0x38, 0x00, 0x1E, 0x0F,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x01,
  0xE0, 0xF0, 0x00, 0x38, 0x1C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0xF0,
  0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0x03, 0xC0, 0xFC, 0x00, 0xF0, 0x3F, 0x00, 0x3C, 0x0F,
  0xC0, 0x0F, 0x07, 0xF0, 0x03, 0xC1, 0xFC, 0x00, 0xE0, 0x7F, 0x80, 0x78,
  0x1F, 0xE0, 0x1E, 0x07, 0x38, 0x07, 0x81, 0xCE, 0x01, 0xE0, 0x73, 0xC0,
  0x78, 0x3C, 0xF0, 0x1C, 0x0F, 0x3C, 0x07, 0x03, 0xC7, 0x03, 0xC0, 0xF1,
  0xC0, 0xF0, 0x3C, 0x78, 0x3C, 0x0E, 0x1E, 0x0F, 0x07, 0x83, 0x83, 0xC1,
  0xE0, 0xE0, 0xE0, 0x78, 0x38, 0x78, 0x1E, 0x0F, 0x1E, 0x07, 0x83, 0xC7,
  0x81, 0xC0, 0x71, 0xE0, 0xF0, 0x1C, 0x78, 0x3C, 0x07, 0x1C, 0x0F, 0x01,
  0xE7, 0x03, 0xC0, 0x7B, 0xC0, 0xF0, 0x0E, 0xF0, 0x38, 0x03, 0xBC, 0x0E,
  0x00, 0xFF, 0x07, 0x80, 0x3F, 0x81, 0xE0, 0x0F, 0xE0, 0x78, 0x01, 0xF8,
  0x1E, 0x00, 0x7E, 0x07, 0x80, 0x1F, 0x83, 0xC0, 0x07, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xF8, 0xFE, 0x03, 0xC0,
  0x1E, 0x07, 0x80, 0x1F, 0x0F, 0x80, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00,
  0x0F, 0x0E, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00,
  0x0E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x3C, 0x00,
  0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x3C, 0x00,
  0x3C, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00,
  0x3C, 0x78, 0x00, 0x38, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00,
  0x78, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x7C, 0x01, 0xE0, 0x3E, 0x07,
  0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07,
  0x00, 0x1F, 0x83, 0xC0, 0x03, 0xE0, 0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x0F,
  0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x78, 0x00,
  0x1E, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0x78,
  0x00, 0x7C, 0x1E, 0x00, 0x3E, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0x1F, 0xC0, 0x7C, 0x01, 0xF0, 0x3C,
  0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F,
  0x00, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0,
  0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1E,
  0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC3, 0x80, 0x01,
  0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00,
  0x3C, 0x3C, 0x00, 0x1E, 0x1C, 0x00, 0x0E, 0x1E, 0x00, 0x0F, 0x0F, 0x00,
  0x07, 0x83, 0xC0, 0x07, 0xC1, 0xE0, 0x03, 0xC0, 0xF8, 0x03, 0xC0, 0x7E,
  0x07, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x70, 0x01, 0xF0, 0x78, 0x00, 0x7C, 0x3C,
  0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC3,
  0xC0, 0x01, 0xE3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78,
  0x78, 0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x1E, 0x00, 0xFC, 0x0F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x01, 0xE0, 0x78,
  0x00, 0xF0, 0x1E, 0x00, 0x70, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x1E, 0x03, 0xC0,
  0x0F, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x78,
  0x00, 0x78, 0x3C, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x07, 0xF0, 0xFC, 0x01, 0xE0,
  0x0F, 0x80, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0x78, 0x1E, 0x00, 0x0E, 0x07,
  0x80, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x07, 0x80,
  0x07, 0xC1, 0xF0, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x07, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03,
  0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00,
  0x38, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80,
  0x07, 0x83, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x01, 0xE0, 0xF0,
  0x00, 0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1C, 0x00, 0x1E, 0x1E,
  0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1,
  0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x38,
  0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07,
  0x83, 0xC0, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0xF8, 0x03, 0xC0, 0x3E, 0x07,
  0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0x70, 0x00, 0x1E, 0x78,
  0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x78, 0x78,
  0x00, 0x78, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xE0, 0x78,
  0x01, 0xE0, 0x38, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x07, 0x80, 0x3C, 0x07, 0x80, 0x3C, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x3C,
  0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x1C, 0x1E, 0x00, 0x1C, 0x1C, 0x00, 0x1C,
  0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E,
  0x70, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3C,
  0x07, 0x80, 0x79, 0xC0, 0x3C, 0x03, 0x8E, 0x03, 0xE0, 0x3C, 0x70, 0x1F,
  0x01, 0xE3, 0x80, 0xD8, 0x0E, 0x1C, 0x06, 0xC0, 0x70, 0xE0, 0x76, 0x07,
  0x87, 0x03, 0xB0, 0x38, 0x38, 0x19, 0x81, 0xC1, 0xC1, 0xCC, 0x1E, 0x0E,
  0x0E, 0x60, 0xF0, 0xF0, 0x77, 0x07, 0x07, 0x83, 0x38, 0x38, 0x3C, 0x39,
  0xC3, 0xC1, 0xE1, 0xCE, 0x1E, 0x0F, 0x0C, 0x70, 0xE0, 0x78, 0xE3, 0x87,
  0x03, 0xC7, 0x1C, 0x78, 0x1E, 0x30, 0xE3, 0x80, 0xF1, 0x87, 0x1C, 0x07,
  0x9C, 0x39, 0xE0, 0x38, 0xE1, 0xCF, 0x01, 0xC6, 0x0E, 0x70, 0x0E, 0x70,
  0x73, 0x80, 0x73, 0x83, 0xBC, 0x03, 0x98, 0x19, 0xC0, 0x1C, 0xC0, 0xCE,
  0x00, 0xEE, 0x06, 0x70, 0x07, 0x70, 0x37, 0x80, 0x3B, 0x01, 0xB8, 0x01,
  0xF8, 0x0D, 0xC0, 0x0F, 0xC0, 0x6E, 0x00, 0x7C, 0x03, 0xF0, 0x03, 0xE0,
  0x1F, 0x00, 0x1F, 0x00, 0xF8, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x80, 0x3C, 0x00,
  0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x7C,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x7C, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x1E,
  0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x3E, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF8, 0xE0,
  0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x03, 0xC0,
  0x78, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x1E,
  0x00, 0x3C, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0x78,
  0x78, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xDF, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x3F, 0xFC,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x20, 0x3F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0xF0, 0x03, 0xC0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x3F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0x70, 0x00, 0x7B, 0xC0,
  0x03, 0x8E, 0x00, 0x3C, 0x70, 0x03, 0xC3, 0xC0, 0x1C, 0x1E, 0x01, 0xE0,
  0x70, 0x1E, 0x03, 0x80, 0xF0, 0x1E, 0x0F, 0x00, 0x70, 0x70, 0x03, 0x87,
  0x80, 0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x03, 0xBC, 0x00, 0x1E, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1E,
  0x0F, 0x03, 0xC0, 0xE0, 0x7C, 0x00, 0xFF, 0x8F, 0x01, 0xFF, 0xCF, 0x03,
  0xFF, 0xEE, 0x07, 0xC0, 0xFE, 0x0F, 0x80, 0x7E, 0x1F, 0x00, 0x3E, 0x1E,
  0x00, 0x3E, 0x1E, 0x00, 0x3E, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C,
  0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x3C, 0x78,
  0x00, 0x3C, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78,
  0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0xF8, 0x78, 0x00, 0xF0, 0x7C,
  0x01, 0xF0, 0x7E, 0x07, 0xF0, 0x3F, 0xFE, 0xF0, 0x1F, 0xFC, 0xF0, 0x0F,
  0xF8, 0xF0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x3F, 0xC0, 0x39, 0xFF, 0xE0, 0xF7, 0xFF,
  0xC1, 0xEE, 0x0F, 0xC3, 0xF0, 0x07, 0x87, 0xC0, 0x0F, 0x8F, 0x00, 0x0F,
  0x1E, 0x00, 0x1E, 0x38, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0, 0x01, 0xE3,
  0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x0F, 0x1C, 0x00, 0x1E, 0x78,
  0x00, 0x3C, 0xF0, 0x00, 0x71, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80,
  0x07, 0x8F, 0x00, 0x1E, 0x3E, 0x00, 0x3C, 0x7E, 0x00, 0xF0, 0xFE, 0x07,
  0xE1, 0xEF, 0xFF, 0x83, 0xDF, 0xFE, 0x07, 0x8F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0x07, 0xE0, 0xF8, 0x03,
  0xE3, 0xE0, 0x07, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x0F, 0x3C, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00,
  0x1E, 0x1F, 0x00, 0x7C, 0x1F, 0x03, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x7F, 0xC7, 0x80,
  0x7F, 0xF3, 0xC0, 0x7F, 0xFD, 0xC0, 0x7C, 0x0F, 0xE0, 0x7C, 0x03, 0xF0,
  0x7C, 0x00, 0xF8, 0x3C, 0x00, 0x7C, 0x1E, 0x00, 0x3E, 0x1E, 0x00, 0x1E,
  0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01,
  0xE0, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x78, 0x3C, 0x00,
  0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0,
  0x07, 0xC1, 0xE0, 0x03, 0xC0, 0xF8, 0x03, 0xE0, 0x7E, 0x07, 0xF0, 0x1F,
  0xFF, 0x78, 0x07, 0xFF, 0x3C, 0x01, 0xFF, 0x1E, 0x00, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3E, 0x07, 0xE0, 0xF8, 0x03, 0xC3,
  0xE0, 0x07, 0x87, 0x80, 0x07, 0x8E, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x78,
  0x00, 0x38, 0xF0, 0x00, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x9E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x07, 0x8F, 0x00, 0x1E,
  0x1F, 0x00, 0x7C, 0x1F, 0x01, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x1E,
  0x07, 0xFF, 0x3C, 0x1F, 0xFF, 0x70, 0x7C, 0x0F, 0xE1, 0xF0, 0x0F, 0xC7,
  0xC0, 0x0F, 0x8F, 0x00, 0x1F, 0x1E, 0x00, 0x1E, 0x78, 0x00, 0x38, 0xF0,
  0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8E, 0x00,
  0x0F, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x01,
  0xE3, 0xC0, 0x07, 0xC7, 0xC0, 0x0F, 0x87, 0x80, 0x3F, 0x0F, 0xC3, 0xDC,
  0x0F, 0xFF, 0x78, 0x1F, 0xFC, 0xF0, 0x0F, 0xF1, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x3F, 0xC0, 0x39, 0xFF,
  0xE0, 0xF7, 0xFF, 0xC1, 0xEC, 0x0F, 0xC3, 0xF0, 0x07, 0x87, 0xC0, 0x0F,
  0x8F, 0x00, 0x1F, 0x1E, 0x00, 0x1E, 0x38, 0x00, 0x3C, 0xF0, 0x00, 0xF1,
  0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x0F, 0x1C,
  0x00, 0x1E, 0x78, 0x00, 0x38, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0,
  0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x0F, 0x3C, 0x00, 0x1C, 0x78, 0x00,
  0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x01, 0xF0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x3E,
  0x07, 0x80, 0x1F, 0x01, 0xE0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x1E, 0x01,
  0xE0, 0x07, 0x80, 0xF0, 0x01, 0xC0, 0x78, 0x00, 0xF0, 0x3E, 0x00, 0x3F,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x38, 0x1F, 0x00, 0x1E, 0x03, 0xC0, 0x07, 0x80, 0xF8, 0x01, 0xE0, 0x1E,
  0x00, 0x78, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x03, 0xC0,
  0x07, 0x80, 0xF0, 0x01, 0xF0, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x83,
  0xC0, 0x01, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x0F, 0x3E, 0x1F,
  0x81, 0xEF, 0xE7, 0xF8, 0x3F, 0xFD, 0xFF, 0x07, 0x83, 0xE1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1C, 0x0F, 0x03, 0x87, 0x81, 0xC0, 0xF0, 0xF0, 0x38, 0x1E,
  0x1E, 0x07, 0x03, 0xC3, 0xC0, 0xE0, 0x78, 0x78, 0x3C, 0x0E, 0x0E, 0x07,
  0x81, 0xC3, 0xC0, 0xE0, 0x78, 0x78, 0x1C, 0x0F, 0x0F, 0x03, 0x81, 0xE1,
  0xE0, 0x70, 0x3C, 0x3C, 0x0E, 0x07, 0x87, 0x03, 0xC0, 0xE0, 0xE0, 0x78,
  0x1C, 0x3C, 0x0E, 0x07, 0x87, 0x81, 0xC0, 0xF0, 0xF0, 0x38, 0x1E, 0x1E,
  0x07, 0x03, 0xC3, 0x81, 0xE0, 0x70, 0x70, 0x3C, 0x0E, 0x1E, 0x07, 0x03,
  0xC3, 0xC0, 0xE0, 0x78, 0x00, 0x0F, 0x1F, 0xE0, 0x1E, 0xFF, 0xF0, 0x7B,
  0xFF, 0xE0, 0xF6, 0x07, 0xE1, 0xF8, 0x03, 0xC3, 0xE0, 0x07, 0xC7, 0x80,
  0x0F, 0x8F, 0x00, 0x0F, 0x1C, 0x00, 0x1E, 0x78, 0x00, 0x78, 0xF0, 0x00,
  0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8E, 0x00, 0x0F,
  0x3C, 0x00, 0x1C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xE3,
  0xC0, 0x03, 0xC7, 0x80, 0x07, 0x9E, 0x00, 0x0E, 0x3C, 0x00, 0x3C, 0x78,
  0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC0, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3E, 0x07, 0xE0, 0xF8,
  0x03, 0xC3, 0xE0, 0x07, 0x87, 0x80, 0x07, 0x8F, 0x00, 0x0F, 0x3C, 0x00,
  0x1E, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x03,
  0xCF, 0x00, 0x07, 0x9E, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x38,
  0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x0F, 0x0F,
  0x00, 0x1E, 0x1F, 0x00, 0x78, 0x1F, 0x03, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xC7, 0xF8, 0x01, 0xEF, 0xFF, 0x01,
  0xEF, 0xFF, 0x80, 0xF7, 0x07, 0xE0, 0x7E, 0x00, 0xF0, 0x3E, 0x00, 0x7C,
  0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03,
  0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00,
  0x78, 0x38, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0E, 0x0F, 0x00,
  0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x03, 0xC1, 0xF0,
  0x01, 0xE0, 0xFC, 0x01, 0xE0, 0x7F, 0x03, 0xF0, 0x3D, 0xFF, 0xF0, 0x1E,
  0x7F, 0xF0, 0x0F, 0x1F, 0xE0, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x8F, 0x01, 0xFF, 0xCF, 0x07, 0xFF, 0xFE, 0x07, 0xC0, 0xFE, 0x0F, 0x80,
  0x7E, 0x1F, 0x00, 0x3E, 0x1E, 0x00, 0x3E, 0x1E, 0x00, 0x3E, 0x3C, 0x00,
  0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00,
  0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x38, 0x78, 0x00, 0x78, 0x78, 0x00,
  0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00,
  0xF8, 0x78, 0x01, 0xF0, 0x7C, 0x03, 0xF0, 0x7E, 0x07, 0xF0, 0x3F, 0xFE,
  0xF0, 0x1F, 0xFC, 0xF0, 0x0F, 0xF0, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x07, 0x8F,
  0xF0, 0x0F, 0x3F, 0xFC, 0x0F, 0x7F, 0xFC, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0,
  0x1E, 0x0F, 0x80, 0x1F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x1E, 0x00,
  0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x7E, 0x03, 0xE0, 0xF0, 0x03, 0xE3, 0xC0, 0x03,
  0xC7, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xCF, 0x00, 0x07, 0x9E, 0x00, 0x0F, 0x3E, 0x00,
  0x3C, 0x3E, 0x01, 0xF8, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x7F, 0xFC,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x3F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x0F, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x1E, 0x00, 0x0E,
  0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E,
  0x1C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C,
  0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x3C,
  0x78, 0x00, 0x38, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78,
  0x78, 0x00, 0x78, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x7C, 0x01, 0xE0,
  0x3E, 0x07, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xE7,
  0x80, 0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x3C, 0x1C, 0x00, 0x78, 0x3C,
  0x01, 0xE0, 0x78, 0x03, 0xC0, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0,
  0x78, 0x03, 0x80, 0xF0, 0x07, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x1E,
  0x00, 0x3C, 0x3C, 0x00, 0x78, 0x70, 0x00, 0x71, 0xE0, 0x00, 0xE3, 0x80,
  0x01, 0xEF, 0x00, 0x03, 0xDC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xE0, 0x1E, 0x03, 0xF8, 0x0F, 0x80,
  0xEE, 0x03, 0xE0, 0x7B, 0x80, 0xF8, 0x1C, 0xE0, 0x7E, 0x07, 0x38, 0x1F,
  0x81, 0xCE, 0x06, 0xE0, 0xF3, 0x83, 0xB8, 0x38, 0xE0, 0xEE, 0x0E, 0x38,
  0x33, 0x87, 0x8E, 0x1C, 0xE1, 0xC3, 0x87, 0x38, 0x70, 0xE1, 0x8E, 0x3C,
  0x38, 0xE3, 0x8E, 0x0E, 0x38, 0xE3, 0x83, 0x8C, 0x39, 0xE0, 0xE7, 0x0E,
  0x70, 0x39, 0xC3, 0x9C, 0x0E, 0x60, 0xE7, 0x03, 0xB8, 0x3B, 0x80, 0xEE,
  0x0E, 0xE0, 0x3B, 0x03, 0xB8, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00,
  0xF8, 0x0F, 0xC0, 0x3E, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x0F, 0x00, 0x3E, 0x01, 0xF0, 0x07, 0x80,
  0x1E, 0x01, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x3C, 0x1F, 0x00, 0x03, 0xC7,
  0xC0, 0x00, 0x78, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x07,
  0x87, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x7C, 0x0F, 0x00, 0x1F, 0x01, 0xE0,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x3C, 0x00, 0x3C, 0x0F, 0x80,
  0x07, 0xC3, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x1E, 0x78, 0x00, 0x3C,
  0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8F,
  0x00, 0x0F, 0x1C, 0x00, 0x1E, 0x78, 0x00, 0x38, 0xF0, 0x00, 0xF1, 0xE0,
  0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x0F, 0x3C, 0x00,
  0x1C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x07,
  0xC7, 0xC0, 0x1F, 0x8F, 0xC0, 0x6E, 0x0F, 0xE3, 0xFC, 0x0F, 0xFF, 0x78,
  0x0F, 0xFC, 0xF0, 0x0F, 0xE1, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0x80, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x07,
  0x1F, 0xF0, 0x0F, 0x3F, 0xF8, 0x0F, 0x3C, 0x7C, 0x0F, 0x78, 0x3C, 0x0E,
  0x78, 0x1E, 0x1E, 0x70, 0x1F, 0xFE, 0x70, 0x0F, 0xFC, 0xF0, 0x07, 0xF8,
  0x00, 0x00, 0x80,
};

const GFXglyph JetBrainsMono_LightItalic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 12, 36, 29, 9, -36 },
  { 55, 16, 15, 29, 9, -36 },
  { 85, 29, 36, 29, 1, -36 },
  { 216, 26, 50, 29, 2, -43 },
  { 379, 33, 36, 29, -1, -36 },
  { 528, 27, 36, 29, 1, -36 },
  { 650, 6, 15, 29, 14, -36 },
  { 662, 20, 47, 29, 8, -41 },
  { 780, 20, 47, 29, 2, -41 },
  { 898, 25, 25, 29, 3, -30 },
  { 977, 24, 23, 29, 3, -28 },
  { 1046, 12, 15, 29, 5, -7 },
  { 1069, 16, 4, 29, 7, -18 },
  { 1077, 8, 7, 29, 9, -7 },
  { 1084, 29, 46, 29, 1, -41 },
  { 1251, 25, 36, 29, 3, -36 },
  { 1364, 23, 36, 29, 2, -36 },
  { 1468, 26, 36, 29, 2, -36 },
  { 1585, 24, 36, 29, 3, -36 },
  { 1693, 23, 36, 29, 3, -36 },
  { 1797, 24, 36, 29, 3, -36 },
  { 1905, 23, 36, 29, 3, -36 },
  { 2009, 24, 36, 29, 6, -36 },
  { 2117, 24, 36, 29, 3, -36 },
  { 2225, 23, 36, 29, 5, -36 },
  { 2329, 11, 27, 29, 9, -27 },
  { 2367, 16, 35, 29, 5, -27 },
  { 2437, 24, 26, 29, 4, -29 },
  { 2515, 23, 15, 29, 4, -24 },
  { 2559, 23, 26, 29, 3, -29 },
  { 2634, 20, 36, 29, 7, -36 },
  { 2724, 30, 45, 29, 0, -36 },
  { 2893, 24, 36, 29, 1, -36 },
  { 3001, 25, 36, 29, 3, -36 },
  { 3114, 25, 36, 29, 3, -36 },
  { 3227, 24, 36, 29, 3, -36 },
  { 3335, 26, 36, 29, 3, -36 },
  { 3452, 26, 36, 29, 3, -36 },
  { 3569, 25, 36, 29, 3, -36 },
  { 3682, 25, 36, 29, 3, -36 },
  { 3795, 25, 36, 29, 3, -36 },
  { 3908, 27, 36, 29, 1, -36 },
  { 4030, 27, 36, 29, 3, -36 },
  { 4152, 21, 36, 29, 4, -36 },
  { 4247, 27, 36, 29, 2, -36 },
  { 4369, 26, 36, 29, 2, -36 },
  { 4486, 24, 36, 29, 3, -36 },
  { 4594, 26, 36, 29, 3, -36 },
  { 4711, 25, 45, 29, 3, -36 },
  { 4852, 25, 36, 29, 3, -36 },
  { 4965, 26, 36, 29, 2, -36 },
  { 5082, 24, 36, 29, 6, -36 },
  { 5190, 25, 36, 29, 3, -36 },
  { 5303, 24, 36, 29, 6, -36 },
  { 5411, 29, 36, 29, 3, -36 },
  { 5542, 30, 36, 29, 0, -36 },
  { 5677, 26, 36, 29, 5, -36 },
  { 5794, 26, 36, 29, 2, -36 },
  { 5911, 19, 46, 29, 7, -41 },
  { 6021, 14, 46, 29, 8, -41 },
  { 6102, 19, 46, 29, 4, -41 },
  { 6212, 21, 19, 29, 5, -36 },
  { 6262, 24, 4, 29, 0, 1 },
  { 6274, 9, 6, 29, 13, -38 },
  { 6281, 24, 27, 29, 3, -27 },
  { 6362, 23, 36, 29, 3, -36 },
  { 6466, 23, 27, 29, 3, -27 },
  { 6544, 25, 36, 29, 3, -36 },
  { 6657, 23, 27, 29, 3, -27 },
  { 6735, 33, 45, 29, -2, -36 },
  { 6921, 23, 36, 29, 4, -27 },
  { 7025, 23, 36, 29, 3, -36 },
  { 7129, 23, 38, 29, 2, -38 },
  { 7239, 25, 47, 29, 1, -38 },
  { 7386, 26, 36, 29, 3, -36 },
  { 7503, 20, 36, 29, 5, -36 },
  { 7593, 27, 27, 29, 1, -27 },
  { 7685, 23, 27, 29, 3, -27 },
  { 7763, 23, 27, 29, 3, -27 },
  { 7841, 25, 36, 29, 1, -27 },
  { 7954, 24, 36, 29, 3, -27 },
  { 8062, 24, 27, 29, 3, -27 },
  { 8143, 23, 27, 29, 3, -27 },
  { 8221, 23, 34, 29, 4, -34 },
  { 8319, 24, 27, 29, 3, -27 },
  { 8400, 23, 27, 29, 5, -27 },
  { 8478, 26, 27, 29, 4, -27 },
  { 8566, 27, 27, 29, 1, -27 },
  { 8658, 23, 36, 29, 4, -27 },
  { 8762, 24, 27, 29, 2, -27 },
  { 8843, 24, 46, 29, 5, -41 },
  { 8981, 11, 46, 29, 10, -41 },
  { 9045, 25, 46, 29, 1, -41 },
  { 9189, 24, 10, 29, 3, -22 },
};

const GFXfont JetBrainsMono_LightItalic49pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_LightItalic49pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_LightItalic49pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _JETBRAINSMONO_LIGHTITALIC49PT7B_H_
