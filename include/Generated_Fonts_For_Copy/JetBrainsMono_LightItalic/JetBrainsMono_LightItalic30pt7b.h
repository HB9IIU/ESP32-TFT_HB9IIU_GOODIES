#ifndef _JETBRAINSMONO_LIGHTITALIC30PT7B_H_
#define _JETBRAINSMONO_LIGHTITALIC30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-LightItalic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_LightItalic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x18, 0x70, 0xE1, 0xC3, 0x86, 0x0C, 0x18, 0x30, 0xE1, 0x83,
  0x06, 0x0C, 0x18, 0x00, 0x00, 0x07, 0x8F, 0x1E, 0x00, 0x61, 0xD8, 0x6E,
  0x3B, 0x8E, 0xE3, 0xB0, 0xEC, 0x33, 0x0C, 0xC3, 0x00, 0x00, 0xC3, 0x80,
  0xC1, 0x80, 0x60, 0xC0, 0x30, 0xE0, 0x30, 0x60, 0x18, 0x30, 0xFF, 0xFE,
  0x7F, 0xFF, 0x06, 0x0C, 0x07, 0x0C, 0x03, 0x06, 0x01, 0x83, 0x01, 0x83,
  0x00, 0xC1, 0x83, 0xFF, 0xF9, 0xFF, 0xFC, 0x30, 0x60, 0x18, 0x30, 0x18,
  0x30, 0x0C, 0x18, 0x06, 0x0C, 0x06, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x20, 0x01, 0xFC, 0x07, 0xFE, 0x0F, 0x6E, 0x0C, 0x67,
  0x1C, 0x47, 0x1C, 0x47, 0x1C, 0xC0, 0x1C, 0xC0, 0x1E, 0xC0, 0x0F, 0xC0,
  0x07, 0xE0, 0x01, 0xF8, 0x01, 0xBC, 0x01, 0x9C, 0x01, 0x8C, 0x01, 0x8C,
  0x61, 0x8C, 0x61, 0x0C, 0x71, 0x1C, 0x73, 0x38, 0x3F, 0xF0, 0x1F, 0xC0,
  0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x07, 0xC0, 0x38, 0x7F,
  0x03, 0x83, 0x18, 0x18, 0x30, 0xC1, 0x81, 0x86, 0x18, 0x0C, 0x31, 0x80,
  0x61, 0x98, 0x03, 0x1D, 0x80, 0x1F, 0xCC, 0x00, 0x7C, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x70, 0x00, 0xCF, 0xE0, 0x0E, 0xE3, 0x00,
  0x66, 0x18, 0x06, 0x30, 0xC0, 0x61, 0x86, 0x06, 0x18, 0x30, 0x60, 0xE3,
  0x06, 0x03, 0xF8, 0x70, 0x0F, 0x00, 0x03, 0xF0, 0x07, 0xFC, 0x0E, 0x1C,
  0x0C, 0x0C, 0x1C, 0x0C, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x3F, 0x00, 0x33, 0x87, 0x61, 0x86, 0x61, 0xCC, 0x60, 0xDC,
  0xE0, 0xF8, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0xF8, 0xE1, 0xD8, 0x7F, 0x9C,
  0x7F, 0x0E, 0x7F, 0xFF, 0xB6, 0xC0, 0x00, 0x30, 0x0F, 0x03, 0xC0, 0x70,
  0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x06, 0x00, 0x60, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1F, 0x00, 0x70,
  0x01, 0x00, 0x0C, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00,
  0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03,
  0x00, 0x70, 0x0E, 0x03, 0xC0, 0xF8, 0x0E, 0x00, 0x80, 0x00, 0x01, 0xC0,
  0x03, 0x80, 0x06, 0x00, 0x0C, 0x04, 0x18, 0x3F, 0x33, 0xFF, 0x5F, 0x8F,
  0xF8, 0x03, 0x00, 0x0F, 0x00, 0x33, 0x00, 0xC7, 0x03, 0x8E, 0x0E, 0x0E,
  0x08, 0x18, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80,
  0x0E, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0,
  0x07, 0x00, 0x18, 0x00, 0x0F, 0x1E, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0x70,
  0x60, 0xC0, 0x7F, 0xFF, 0xF0, 0x11, 0xE7, 0x9E, 0x78, 0x00, 0x03, 0x80,
  0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xF0, 0x1F,
  0xF8, 0x78, 0x70, 0xC0, 0x73, 0x80, 0xE6, 0x01, 0xCC, 0x03, 0xB8, 0x06,
  0x70, 0x0C, 0xE6, 0x19, 0x8E, 0x33, 0x1C, 0xE6, 0x11, 0xDC, 0x03, 0xB8,
  0x06, 0x70, 0x0C, 0xC0, 0x19, 0x80, 0x73, 0x80, 0xC7, 0x83, 0x87, 0xFE,
  0x07, 0xF0, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x7B, 0x03, 0xDC, 0x1C, 0x70,
  0x61, 0x82, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0x60, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x07, 0xFE, 0x0E, 0x0E,
  0x1C, 0x07, 0x18, 0x07, 0x18, 0x07, 0x20, 0x07, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x7F, 0xFC,
  0xFF, 0xFC, 0x1F, 0xFE, 0x3F, 0xF8, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0xC0, 0x0F, 0xE0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0xC0, 0x39, 0x80, 0x63,
  0x01, 0xC7, 0x07, 0x07, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x30, 0x71, 0xC1, 0x8E, 0x06, 0x70, 0x19, 0x80, 0x6E, 0x03, 0xBF, 0xFE,
  0xFF, 0xF0, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x1F,
  0xFE, 0x3F, 0xFC, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x37, 0xF0, 0x7F, 0xF0, 0xE0, 0xE3, 0x80, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x39, 0xC0, 0x73, 0x80, 0xC7, 0x03,
  0x87, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x70,
  0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x80, 0xFF, 0xC3, 0xEF,
  0x9C, 0x0E, 0x60, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1B, 0x00,
  0xEE, 0x03, 0x3C, 0x3C, 0x7F, 0xE0, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0x01, 0xF0, 0x06, 0xC0, 0x3B, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xC0,
  0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80,
  0x1C, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x00, 0x03,
  0xF0, 0x1F, 0xF8, 0x70, 0x70, 0xC0, 0x63, 0x80, 0xE7, 0x01, 0x8E, 0x03,
  0x1C, 0x0E, 0x1C, 0x38, 0x1D, 0xE0, 0x1F, 0x00, 0x7F, 0x03, 0x87, 0x0E,
  0x07, 0x18, 0x06, 0x70, 0x0C, 0xC0, 0x19, 0x80, 0x73, 0x80, 0xC7, 0x03,
  0x87, 0xFE, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x7F, 0xE3, 0xC3, 0x9C, 0x07,
  0x60, 0x1D, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xEE, 0x03,
  0x9F, 0x7C, 0x3F, 0xE0, 0x33, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x18, 0x01, 0xE0, 0x00, 0x0E, 0x1E, 0x1E, 0x1E,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x78, 0x78,
  0x78, 0x03, 0x81, 0xE0, 0xFC, 0x1E, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x0E, 0x03,
  0x01, 0xC0, 0x60, 0x30, 0x00, 0x00, 0x04, 0x00, 0x70, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0x80, 0x38, 0x00, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x04, 0x3F, 0xFD, 0xFF,
  0xF7, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFB, 0xFF, 0xE0, 0x20, 0x00, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x1C, 0x01, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x0E, 0x00, 0x20, 0x00, 0x3F, 0x83, 0xFC, 0x01, 0xE0,
  0x07, 0x00, 0x70, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x07, 0xC1,
  0xF8, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x78, 0x07, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x70, 0x38, 0x38,
  0x07, 0x0C, 0x01, 0xC6, 0x00, 0x31, 0x80, 0x0C, 0xE0, 0x27, 0x30, 0x7F,
  0xCC, 0x38, 0xE3, 0x0C, 0x18, 0xC3, 0x06, 0x31, 0xC1, 0x8C, 0x60, 0x67,
  0x18, 0x39, 0x86, 0x0C, 0x61, 0x83, 0x18, 0x61, 0xC6, 0x1E, 0xF1, 0x83,
  0xEC, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x06,
  0xC0, 0x0D, 0x80, 0x3B, 0x00, 0x66, 0x01, 0xCE, 0x03, 0x1C, 0x06, 0x38,
  0x1C, 0x30, 0x30, 0x60, 0xE0, 0xC1, 0x81, 0x87, 0xFF, 0x0F, 0xFE, 0x18,
  0x0C, 0x70, 0x1C, 0xC0, 0x3B, 0x80, 0x76, 0x00, 0x7C, 0x00, 0xC0, 0x1F,
  0xF0, 0x3F, 0xF0, 0x60, 0xF0, 0xC0, 0x73, 0x80, 0xE7, 0x01, 0xCC, 0x03,
  0x18, 0x06, 0x30, 0x18, 0x61, 0xE1, 0xFF, 0x03, 0xFF, 0x86, 0x03, 0x8C,
  0x03, 0x18, 0x07, 0x30, 0x0C, 0xE0, 0x19, 0xC0, 0x33, 0x80, 0xE6, 0x07,
  0x8F, 0xFE, 0x1F, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0xF8, 0x78, 0x70, 0xC0,
  0x73, 0x80, 0xE6, 0x01, 0xCC, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0,
  0x19, 0xC0, 0x73, 0x80, 0xC3, 0x83, 0x87, 0xFE, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0x3F, 0xF0, 0x60, 0xF0, 0xC0, 0xE3, 0x80, 0xC7, 0x01, 0x8C, 0x03,
  0x18, 0x06, 0x30, 0x0C, 0x60, 0x39, 0xC0, 0x73, 0x80, 0xE6, 0x01, 0x8C,
  0x03, 0x18, 0x06, 0x30, 0x0C, 0xE0, 0x39, 0xC0, 0x63, 0x81, 0xC6, 0x0F,
  0x0F, 0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xFF, 0x1F, 0xFE, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x3F,
  0xF8, 0x3F, 0xF8, 0x7F, 0xF8, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x08, 0xFF, 0xF0, 0xFF,
  0xF0, 0x1F, 0xFF, 0x1F, 0xFF, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x7F, 0xF8, 0x7F,
  0xF8, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x03, 0xF0, 0x1F,
  0xF8, 0x78, 0x70, 0xC0, 0x73, 0x80, 0xE6, 0x01, 0xCC, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x8F, 0xE6, 0x1F, 0xCC, 0x03, 0x98,
  0x06, 0x70, 0x0C, 0xE0, 0x19, 0xC0, 0x73, 0x80, 0xC3, 0x83, 0x87, 0xFE,
  0x07, 0xF0, 0x00, 0x18, 0x06, 0x30, 0x0C, 0x60, 0x38, 0xC0, 0x73, 0x80,
  0xE7, 0x01, 0x8C, 0x03, 0x18, 0x06, 0x30, 0x0C, 0x60, 0x39, 0xFF, 0xF3,
  0xFF, 0xC7, 0x01, 0x8C, 0x03, 0x18, 0x06, 0x30, 0x1C, 0xE0, 0x39, 0xC0,
  0x63, 0x80, 0xC6, 0x01, 0x8C, 0x03, 0x18, 0x0E, 0x00, 0x1F, 0xFE, 0x3F,
  0xFC, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x0F, 0xFF,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0xE0,
  0x18, 0xE0, 0x38, 0xE0, 0x38, 0x70, 0x70, 0x7F, 0xE0, 0x3F, 0x80, 0x18,
  0x03, 0x8C, 0x03, 0x86, 0x03, 0x83, 0x01, 0x83, 0x81, 0xC1, 0xC1, 0xC0,
  0xC0, 0xC0, 0x60, 0xE0, 0x30, 0xE0, 0x18, 0x60, 0x1F, 0xF0, 0x0F, 0xF8,
  0x06, 0x1C, 0x03, 0x06, 0x01, 0x83, 0x80, 0xC1, 0xC0, 0xE0, 0x60, 0x70,
  0x38, 0x38, 0x1C, 0x18, 0x06, 0x0C, 0x03, 0x86, 0x01, 0xC0, 0x0C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x1E, 0x07,
  0x8F, 0x03, 0xC7, 0x83, 0x43, 0xC1, 0xE1, 0xA1, 0xB0, 0xD8, 0xD8, 0x6C,
  0xCC, 0x76, 0x6E, 0x33, 0x66, 0x19, 0xB3, 0x0C, 0x51, 0x86, 0x38, 0xC3,
  0x00, 0xE3, 0x80, 0x71, 0xC0, 0x30, 0xC0, 0x18, 0x60, 0x0C, 0x30, 0x06,
  0x18, 0x07, 0x1C, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0xC0, 0x1C, 0x06, 0x38,
  0x0C, 0x78, 0x19, 0xF0, 0x73, 0xE0, 0xE6, 0xC1, 0x8D, 0xC3, 0x19, 0x86,
  0x33, 0x0C, 0x66, 0x19, 0xCC, 0x73, 0x9C, 0xE6, 0x19, 0x8C, 0x33, 0x18,
  0x66, 0x30, 0xCC, 0xE0, 0xF9, 0xC1, 0xF3, 0x03, 0xC6, 0x07, 0x8C, 0x0F,
  0x18, 0x0E, 0x00, 0x03, 0xF0, 0x1F, 0xF8, 0x78, 0x70, 0xC0, 0x63, 0x80,
  0xE6, 0x01, 0xCC, 0x03, 0x18, 0x06, 0x30, 0x0C, 0xE0, 0x19, 0xC0, 0x73,
  0x80, 0xE6, 0x01, 0x8C, 0x03, 0x18, 0x06, 0x70, 0x0C, 0xE0, 0x39, 0xC0,
  0x63, 0x80, 0xC3, 0x87, 0x07, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x1F,
  0xFC, 0x18, 0x1E, 0x18, 0x0E, 0x38, 0x07, 0x38, 0x07, 0x30, 0x07, 0x30,
  0x06, 0x30, 0x0E, 0x30, 0x1C, 0x70, 0x7C, 0x7F, 0xF0, 0x7F, 0xC0, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x03, 0xF0, 0x1F, 0xF8, 0x78, 0x70, 0xC0,
  0x73, 0x80, 0xE6, 0x01, 0xCC, 0x03, 0x98, 0x06, 0x70, 0x0C, 0xE0, 0x19,
  0x80, 0x73, 0x00, 0xE6, 0x01, 0xCC, 0x03, 0x38, 0x06, 0x70, 0x0C, 0xE0,
  0x39, 0xC0, 0x73, 0x80, 0xC3, 0x87, 0x87, 0xFE, 0x07, 0xF0, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x1F, 0xF0, 0x3F, 0xF8,
  0x60, 0x78, 0xC0, 0x73, 0x80, 0x67, 0x00, 0xCC, 0x01, 0x98, 0x07, 0x30,
  0x0C, 0x60, 0x39, 0xFF, 0xE3, 0xFF, 0x87, 0xFC, 0x0C, 0x18, 0x18, 0x30,
  0x30, 0x70, 0xE0, 0xE1, 0xC0, 0xC3, 0x81, 0xC6, 0x03, 0x8C, 0x03, 0x18,
  0x07, 0x00, 0x01, 0xFC, 0x07, 0xFE, 0x0F, 0x0E, 0x0C, 0x07, 0x1C, 0x07,
  0x1C, 0x07, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x60, 0x0C,
  0x60, 0x0C, 0x70, 0x1C, 0x70, 0x38, 0x3F, 0xF0, 0x1F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xF0, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x18, 0x06, 0x30, 0x0C, 0x60, 0x19, 0xC0, 0x73, 0x80, 0xE7, 0x01,
  0x8C, 0x03, 0x18, 0x06, 0x30, 0x0C, 0xE0, 0x39, 0xC0, 0x73, 0x80, 0xE6,
  0x01, 0x8C, 0x03, 0x18, 0x06, 0x30, 0x1C, 0xE0, 0x39, 0xC0, 0x63, 0x81,
  0xC3, 0x87, 0x07, 0xFE, 0x07, 0xF0, 0x00, 0xC0, 0x0F, 0x80, 0x3B, 0x00,
  0x77, 0x00, 0xCE, 0x03, 0x9C, 0x06, 0x38, 0x1C, 0x30, 0x30, 0x60, 0x60,
  0xC1, 0xC1, 0x83, 0x03, 0x0E, 0x06, 0x18, 0x0E, 0x70, 0x1C, 0xC0, 0x39,
  0x80, 0x37, 0x00, 0x6C, 0x00, 0xD8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00,
  0x00, 0x60, 0xE1, 0xB0, 0xE0, 0xD8, 0x70, 0xEC, 0x28, 0x66, 0x14, 0x33,
  0x1A, 0x19, 0x8D, 0x1C, 0xC4, 0x8C, 0x66, 0x46, 0x33, 0x23, 0x19, 0x13,
  0x0C, 0x89, 0x8E, 0xCC, 0xC7, 0x66, 0xE3, 0xA3, 0x61, 0xB1, 0xB0, 0xD8,
  0xD8, 0x68, 0x78, 0x34, 0x3C, 0x1E, 0x1E, 0x0F, 0x0F, 0x07, 0x07, 0x00,
  0x0E, 0x01, 0xC3, 0x80, 0x60, 0x60, 0x38, 0x1C, 0x1C, 0x03, 0x06, 0x00,
  0xC3, 0x80, 0x39, 0xC0, 0x06, 0x60, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x73, 0x00, 0x18, 0xE0,
  0x0E, 0x18, 0x07, 0x07, 0x03, 0x81, 0xC0, 0xC0, 0x30, 0x70, 0x0E, 0x38,
  0x01, 0x80, 0xE0, 0x07, 0x60, 0x06, 0x70, 0x0C, 0x70, 0x1C, 0x30, 0x18,
  0x38, 0x38, 0x38, 0x70, 0x18, 0x60, 0x18, 0xE0, 0x1D, 0xC0, 0x0D, 0x80,
  0x0F, 0x80, 0x0F, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x0F, 0xFF,
  0x0F, 0xFF, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x60, 0x00, 0x7F, 0xF8, 0xFF, 0xF8, 0x07, 0xF0, 0x7F, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00,
  0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x7F, 0x0F, 0xF0,
  0xE0, 0x70, 0x18, 0x0C, 0x06, 0x03, 0x81, 0xC0, 0x60, 0x30, 0x1C, 0x0E,
  0x03, 0x01, 0x80, 0xC0, 0x70, 0x38, 0x0C, 0x06, 0x03, 0x81, 0xC0, 0x60,
  0x30, 0x18, 0x0E, 0x03, 0x01, 0x80, 0xC0, 0x70, 0x0F, 0xE1, 0xFC, 0x01,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC3, 0xF8, 0x7F, 0x00, 0x01,
  0x80, 0x1E, 0x00, 0xF0, 0x0D, 0x80, 0xE6, 0x06, 0x30, 0x61, 0x87, 0x0C,
  0x30, 0x33, 0x81, 0x98, 0x0D, 0x80, 0x30, 0xFF, 0xFF, 0xFF, 0xF8, 0xE3,
  0x1C, 0x71, 0x80, 0x03, 0x8C, 0x3F, 0xB1, 0xE6, 0xCE, 0x07, 0x30, 0x1D,
  0xC0, 0x77, 0x01, 0x98, 0x06, 0x60, 0x19, 0x80, 0x66, 0x03, 0xB8, 0x0E,
  0xE0, 0x3B, 0x81, 0xC7, 0x0F, 0x1F, 0xEC, 0x3F, 0x70, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE7, 0x83, 0x7F, 0x8D, 0x9E, 0x38,
  0x1C, 0xC0, 0x77, 0x01, 0xDC, 0x07, 0x60, 0x19, 0x80, 0x66, 0x01, 0x98,
  0x06, 0xE0, 0x3B, 0x80, 0xEE, 0x03, 0x3C, 0x1C, 0xDF, 0xE3, 0x3E, 0x00,
  0x03, 0xC0, 0x3F, 0xC1, 0xE7, 0x8E, 0x07, 0x30, 0x1D, 0xC0, 0x77, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x3B, 0x80,
  0xC7, 0x07, 0x1F, 0xF8, 0x3F, 0x80, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x71, 0x83, 0xFB, 0x0F, 0x36, 0x38, 0x1C, 0x60,
  0x39, 0xC0, 0x73, 0x80, 0xC6, 0x01, 0x8C, 0x03, 0x18, 0x06, 0x30, 0x1C,
  0xE0, 0x39, 0xC0, 0x73, 0x81, 0xC3, 0x87, 0x87, 0xFB, 0x07, 0xEE, 0x00,
  0x03, 0xC0, 0x3F, 0xC1, 0xC3, 0x8E, 0x06, 0x30, 0x1D, 0xC0, 0x76, 0x01,
  0xDF, 0xFE, 0x7F, 0xF9, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0xC7, 0x07, 0x1F, 0xF8, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x0F, 0xF0, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xCC, 0x3F, 0xB1, 0xE6, 0xCE, 0x07, 0x30, 0x1D, 0xC0,
  0x77, 0x01, 0x98, 0x06, 0x60, 0x19, 0x80, 0x66, 0x03, 0xB8, 0x0E, 0x60,
  0x79, 0xC3, 0xC3, 0xFB, 0x07, 0x8C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00,
  0x38, 0x7F, 0xC1, 0xFE, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x38, 0x00, 0xE7, 0x83, 0x7F, 0x8D, 0x0E, 0x38, 0x1C, 0xC0, 0x77, 0x01,
  0xDC, 0x07, 0x60, 0x19, 0x80, 0x66, 0x01, 0x98, 0x0E, 0xE0, 0x3B, 0x80,
  0xEE, 0x03, 0x30, 0x0C, 0xC0, 0x33, 0x01, 0xC0, 0x00, 0x70, 0x03, 0xE0,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x83, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x60, 0x00, 0xE0, 0x01, 0xE0, 0x7F, 0xC0, 0xFF, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0xCE, 0x03, 0x98, 0x0E,
  0x30, 0x38, 0x60, 0xE1, 0xC3, 0x83, 0x8E, 0x07, 0xFC, 0x0F, 0xF0, 0x1F,
  0xE0, 0x30, 0xE0, 0x61, 0xC1, 0xC1, 0xC3, 0x83, 0x86, 0x03, 0x8C, 0x07,
  0x18, 0x07, 0x00, 0xFF, 0x0F, 0xF0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x1F, 0xF0, 0xFF,
  0x33, 0x8C, 0x37, 0xFE, 0x39, 0xE7, 0x30, 0xC7, 0x30, 0xC7, 0x31, 0xC6,
  0x71, 0x86, 0x71, 0x86, 0x61, 0x86, 0x61, 0x86, 0x61, 0x8E, 0x61, 0x8C,
  0xE3, 0x0C, 0xE3, 0x0C, 0xC3, 0x0C, 0xC3, 0x0C, 0xC3, 0x1C, 0x39, 0xE0,
  0xDF, 0xE3, 0x43, 0x8E, 0x07, 0x30, 0x1D, 0xC0, 0x77, 0x01, 0xD8, 0x06,
  0x60, 0x19, 0x80, 0x66, 0x03, 0xB8, 0x0E, 0xE0, 0x3B, 0x80, 0xCC, 0x03,
  0x30, 0x0C, 0xC0, 0x70, 0x03, 0xE0, 0x3F, 0xC1, 0xE7, 0x8E, 0x06, 0x30,
  0x1D, 0xC0, 0x76, 0x01, 0xD8, 0x06, 0x60, 0x19, 0x80, 0x6E, 0x01, 0xB8,
  0x0E, 0xE0, 0x33, 0x80, 0xC7, 0x0E, 0x1F, 0xF8, 0x3F, 0x80, 0x1C, 0xF0,
  0x37, 0xF8, 0x6C, 0xF0, 0xE0, 0x71, 0x80, 0xE7, 0x01, 0xCE, 0x03, 0x98,
  0x06, 0x30, 0x0C, 0x60, 0x18, 0xC0, 0x33, 0x80, 0xE7, 0x01, 0xCE, 0x03,
  0x1E, 0x0E, 0x37, 0xF8, 0x67, 0xE1, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x8C, 0x3F, 0xB1, 0xE6, 0xCE, 0x07, 0x30,
  0x1D, 0xC0, 0x76, 0x01, 0x98, 0x06, 0x60, 0x19, 0x80, 0x6E, 0x03, 0xB8,
  0x0E, 0xE0, 0x33, 0x81, 0xC7, 0x0F, 0x1F, 0xEC, 0x3F, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x18, 0xE0, 0x37, 0xF0, 0xF8,
  0xF1, 0xE0, 0xE3, 0x80, 0xC6, 0x01, 0x8C, 0x03, 0x18, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0x03, 0xE0, 0x7F, 0xE1, 0xC3, 0xCE, 0x07, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0F, 0xC0, 0x1F, 0xE0, 0x0F, 0xC0, 0x03, 0x80, 0x0E,
  0x00, 0x3B, 0x00, 0xEE, 0x07, 0x1F, 0xF8, 0x3F, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x60, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0x80, 0x0E,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x07, 0xF8, 0x0F, 0xE0, 0x38, 0x0C,
  0xC0, 0x33, 0x00, 0xCC, 0x03, 0x30, 0x1D, 0xC0, 0x77, 0x01, 0xD8, 0x06,
  0x60, 0x19, 0x80, 0x66, 0x01, 0xB8, 0x0E, 0xE0, 0x33, 0x81, 0xC7, 0x0E,
  0x1F, 0xF0, 0x3F, 0x80, 0xE0, 0x0F, 0x80, 0x76, 0x01, 0x98, 0x0E, 0x60,
  0x31, 0x81, 0xC7, 0x06, 0x1C, 0x18, 0x30, 0xC0, 0xC3, 0x03, 0x18, 0x0C,
  0x60, 0x3B, 0x00, 0xEC, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xE1, 0x83,
  0xE1, 0x83, 0xE3, 0x86, 0xE3, 0x86, 0xC2, 0x86, 0xC6, 0x8E, 0xC6, 0x8C,
  0xC4, 0x8C, 0xCC, 0x8C, 0xCC, 0x98, 0xC8, 0xD8, 0xD8, 0xD8, 0x58, 0xF0,
  0x50, 0xF0, 0x70, 0xF0, 0x70, 0xE0, 0x60, 0xE0, 0x1C, 0x03, 0x87, 0x01,
  0x83, 0x81, 0xC0, 0xE1, 0xC0, 0x31, 0xC0, 0x1D, 0xC0, 0x06, 0xC0, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xDC, 0x00, 0xEE, 0x00, 0xE3, 0x80,
  0xE1, 0xC0, 0x60, 0x70, 0x70, 0x38, 0xF0, 0x0E, 0x00, 0x38, 0x0C, 0xC0,
  0x33, 0x00, 0xCC, 0x03, 0x70, 0x1D, 0xC0, 0x77, 0x01, 0x98, 0x06, 0x60,
  0x19, 0x80, 0x66, 0x03, 0xB8, 0x0E, 0x60, 0x71, 0xE3, 0xC3, 0xFB, 0x07,
  0x8C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x7F, 0xC1, 0xFE, 0x00,
  0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x3F, 0xFC, 0xFF, 0xF8, 0x00, 0x1E, 0x00, 0xFC,
  0x03, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x1F, 0xE0, 0x3F, 0x80,
  0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1F, 0x80, 0x1F,
  0x00, 0x0E, 0x1C, 0x30, 0x60, 0xC1, 0x87, 0x0E, 0x1C, 0x30, 0x60, 0xC3,
  0x87, 0x0E, 0x18, 0x30, 0x61, 0xC3, 0x87, 0x0C, 0x18, 0x30, 0x61, 0xC3,
  0x87, 0x00, 0x0F, 0x00, 0x1F, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0xE0, 0x03, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x1C, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x08, 0x00, 0x7C, 0x1D, 0xDC,
  0x37, 0x1C, 0x6E, 0x1F, 0xD8, 0x1F, 0x00,
};

const GFXglyph JetBrainsMono_LightItalic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 7, 22, 18, 6, -22 },
  { 21, 10, 9, 18, 6, -22 },
  { 33, 17, 22, 18, 1, -22 },
  { 80, 16, 30, 18, 1, -26 },
  { 140, 21, 22, 18, -1, -22 },
  { 198, 16, 22, 18, 1, -22 },
  { 242, 3, 9, 18, 9, -22 },
  { 246, 12, 29, 18, 5, -25 },
  { 290, 12, 29, 18, 2, -25 },
  { 334, 15, 15, 18, 2, -18 },
  { 363, 14, 14, 18, 2, -17 },
  { 388, 8, 10, 18, 3, -5 },
  { 398, 10, 2, 18, 4, -11 },
  { 401, 6, 5, 18, 5, -5 },
  { 405, 17, 28, 18, 1, -25 },
  { 465, 15, 22, 18, 2, -22 },
  { 507, 14, 22, 18, 1, -22 },
  { 546, 16, 22, 18, 1, -22 },
  { 590, 15, 22, 18, 2, -22 },
  { 632, 14, 22, 18, 2, -22 },
  { 671, 15, 22, 18, 2, -22 },
  { 713, 14, 22, 18, 2, -22 },
  { 752, 14, 22, 18, 4, -22 },
  { 791, 15, 22, 18, 2, -22 },
  { 833, 14, 22, 18, 3, -22 },
  { 872, 8, 17, 18, 5, -17 },
  { 889, 10, 22, 18, 3, -17 },
  { 917, 14, 16, 18, 3, -18 },
  { 945, 14, 10, 18, 2, -15 },
  { 963, 14, 16, 18, 2, -18 },
  { 991, 12, 22, 18, 4, -22 },
  { 1024, 18, 27, 18, 0, -22 },
  { 1085, 15, 22, 18, 0, -22 },
  { 1127, 15, 22, 18, 2, -22 },
  { 1169, 15, 22, 18, 2, -22 },
  { 1211, 15, 22, 18, 2, -22 },
  { 1253, 16, 22, 18, 2, -22 },
  { 1297, 16, 22, 18, 2, -22 },
  { 1341, 15, 22, 18, 2, -22 },
  { 1383, 15, 22, 18, 2, -22 },
  { 1425, 15, 22, 18, 2, -22 },
  { 1467, 16, 22, 18, 1, -22 },
  { 1511, 17, 22, 18, 2, -22 },
  { 1558, 13, 22, 18, 2, -22 },
  { 1594, 17, 22, 18, 1, -22 },
  { 1641, 15, 22, 18, 2, -22 },
  { 1683, 15, 22, 18, 2, -22 },
  { 1725, 16, 22, 18, 2, -22 },
  { 1769, 15, 27, 18, 2, -22 },
  { 1820, 15, 22, 18, 2, -22 },
  { 1862, 16, 22, 18, 1, -22 },
  { 1906, 14, 22, 18, 4, -22 },
  { 1945, 15, 22, 18, 2, -22 },
  { 1987, 15, 22, 18, 4, -22 },
  { 2029, 17, 22, 18, 2, -22 },
  { 2076, 18, 22, 18, 0, -22 },
  { 2126, 16, 22, 18, 3, -22 },
  { 2170, 16, 22, 18, 1, -22 },
  { 2214, 12, 28, 18, 4, -25 },
  { 2256, 9, 28, 18, 5, -25 },
  { 2288, 11, 28, 18, 3, -25 },
  { 2327, 13, 12, 18, 3, -22 },
  { 2347, 15, 2, 18, 0, 1 },
  { 2351, 5, 5, 18, 8, -24 },
  { 2355, 14, 17, 18, 2, -17 },
  { 2385, 14, 22, 18, 2, -22 },
  { 2424, 14, 17, 18, 2, -17 },
  { 2454, 15, 22, 18, 2, -22 },
  { 2496, 14, 17, 18, 2, -17 },
  { 2526, 20, 27, 18, -1, -22 },
  { 2594, 14, 22, 18, 2, -17 },
  { 2633, 14, 22, 18, 2, -22 },
  { 2672, 14, 23, 18, 1, -23 },
  { 2713, 16, 28, 18, 0, -23 },
  { 2769, 15, 22, 18, 2, -22 },
  { 2811, 12, 22, 18, 3, -22 },
  { 2844, 16, 17, 18, 1, -17 },
  { 2878, 14, 17, 18, 2, -17 },
  { 2908, 14, 17, 18, 2, -17 },
  { 2938, 15, 22, 18, 1, -17 },
  { 2980, 14, 22, 18, 2, -17 },
  { 3019, 15, 17, 18, 2, -17 },
  { 3051, 14, 17, 18, 2, -17 },
  { 3081, 14, 21, 18, 3, -21 },
  { 3118, 14, 17, 18, 2, -17 },
  { 3148, 14, 17, 18, 3, -17 },
  { 3178, 16, 17, 18, 2, -17 },
  { 3212, 17, 17, 18, 0, -17 },
  { 3249, 14, 22, 18, 2, -17 },
  { 3288, 15, 17, 18, 1, -17 },
  { 3320, 15, 28, 18, 3, -25 },
  { 3373, 7, 28, 18, 6, -25 },
  { 3398, 15, 28, 18, 1, -25 },
  { 3451, 15, 6, 18, 2, -14 },
};

const GFXfont JetBrainsMono_LightItalic30pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_LightItalic30pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_LightItalic30pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _JETBRAINSMONO_LIGHTITALIC30PT7B_H_
