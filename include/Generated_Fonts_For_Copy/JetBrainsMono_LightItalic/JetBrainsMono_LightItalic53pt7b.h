#ifndef _JETBRAINSMONO_LIGHTITALIC53PT7B_H_
#define _JETBRAINSMONO_LIGHTITALIC53PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-LightItalic.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_LightItalic53pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0x7C, 0x00,
  0x3E, 0x07, 0x9F, 0x03, 0xCF, 0x03, 0xEF, 0x81, 0xF7, 0xC0, 0xFB, 0xE0,
  0x7D, 0xF0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x0F, 0x9E, 0x07, 0xCF,
  0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x38, 0x00, 0x03,
  0xC0, 0x1C, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x70, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0xE0, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x70, 0x07, 0x80, 0x01, 0xE0, 0x0E, 0x00, 0x03, 0xC0, 0x3C, 0x00,
  0x07, 0x00, 0x78, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x70, 0x07, 0x80, 0x01, 0xE0, 0x0E, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x00, 0x70,
  0x07, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x70, 0x07,
  0x00, 0x01, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xF8, 0xE7, 0xE0, 0x3E,
  0x1C, 0x7C, 0x0F, 0x87, 0x07, 0xC1, 0xE0, 0xE0, 0xF8, 0x3C, 0x1C, 0x1F,
  0x0F, 0x83, 0x83, 0xE1, 0xF0, 0x70, 0x00, 0x3E, 0x0E, 0x00, 0x07, 0xC1,
  0x80, 0x00, 0xF8, 0x70, 0x00, 0x0F, 0x8E, 0x00, 0x01, 0xF9, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1C, 0xFC, 0x00,
  0x03, 0x8F, 0xC0, 0x00, 0x70, 0xF8, 0x00, 0x1C, 0x1F, 0x00, 0x03, 0x81,
  0xE0, 0x00, 0x70, 0x3C, 0x00, 0x0E, 0x07, 0x8F, 0x01, 0xC0, 0xF1, 0xE0,
  0x38, 0x1E, 0x3C, 0x06, 0x07, 0x87, 0xC1, 0xC0, 0xF0, 0xF8, 0x38, 0x3C,
  0x0F, 0x87, 0x1F, 0x81, 0xFE, 0xEF, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x0F, 0xFC,
  0x00, 0x1E, 0x01, 0xFF, 0xC0, 0x03, 0xC0, 0x3E, 0x3E, 0x00, 0x78, 0x03,
  0x81, 0xE0, 0x07, 0x00, 0x78, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x1E,
  0x00, 0x70, 0x0E, 0x03, 0xC0, 0x07, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x1E,
  0x0F, 0x00, 0x0F, 0x01, 0xE0, 0xE0, 0x00, 0xF0, 0x1C, 0x1C, 0x00, 0x0F,
  0x01, 0xC3, 0xC0, 0x00, 0xF0, 0x3C, 0x78, 0x00, 0x07, 0xDF, 0x8F, 0x00,
  0x00, 0x7F, 0xF1, 0xE0, 0x00, 0x03, 0xFE, 0x3C, 0x00, 0x00, 0x0F, 0x83,
  0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x87, 0xF8,
  0x00, 0x00, 0x71, 0xFF, 0xC0, 0x00, 0x0E, 0x3F, 0xFE, 0x00, 0x01, 0xE3,
  0xC1, 0xE0, 0x00, 0x3C, 0x78, 0x1E, 0x00, 0x07, 0x87, 0x00, 0xE0, 0x00,
  0xF0, 0x70, 0x1E, 0x00, 0x0E, 0x0F, 0x01, 0xE0, 0x01, 0xC0, 0xF0, 0x1E,
  0x00, 0x38, 0x0F, 0x01, 0xE0, 0x07, 0x80, 0xF0, 0x1C, 0x00, 0xF0, 0x0F,
  0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0x0F, 0x87, 0x80, 0x38,
  0x00, 0x7F, 0xF8, 0x07, 0x00, 0x07, 0xFE, 0x00, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0xFE, 0x7F, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x78, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xF1, 0xF0, 0x07, 0x8F, 0x07, 0xC0, 0x78, 0xF8, 0x3E, 0x07,
  0x87, 0x80, 0xF8, 0x7C, 0x3C, 0x03, 0xC3, 0xC1, 0xE0, 0x1F, 0x3C, 0x0F,
  0x00, 0x7B, 0xE0, 0x78, 0x03, 0xFE, 0x07, 0xC0, 0x0F, 0xE0, 0x3C, 0x00,
  0x3E, 0x01, 0xE0, 0x01, 0xF0, 0x0F, 0x00, 0x0F, 0x80, 0x78, 0x00, 0xFE,
  0x03, 0xC0, 0x0F, 0xF0, 0x1F, 0x01, 0xFF, 0xC0, 0xFE, 0x3F, 0x9F, 0x03,
  0xFF, 0xF0, 0x78, 0x0F, 0xFF, 0x03, 0xE0, 0x3F, 0xE0, 0x0F, 0x80, 0x38,
  0x00, 0x00, 0x3E, 0x7C, 0xF9, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF1, 0xE3,
  0xC7, 0x9E, 0x3C, 0x78, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00,
  0x1F, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x38, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x02, 0x00, 0xF0, 0x02, 0x78, 0x0F, 0x01, 0xE7, 0xF0, 0x70,
  0x7E, 0xFF, 0xC6, 0x3F, 0xF7, 0xFE, 0x67, 0xFE, 0x1F, 0xF7, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0x38, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3E, 0x3E, 0x00,
  0x07, 0xC1, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x81, 0xF8, 0x01, 0xF0,
  0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xC0, 0x07, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x07, 0xE0,
  0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x0F, 0x80,
  0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1E, 0x3F, 0xBF, 0xDF, 0xEF,
  0xF7, 0xFB, 0xFC, 0xFC, 0x10, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0x00,
  0xFC, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x00, 0xF0, 0x7C, 0x00, 0x1F, 0x0F,
  0x00, 0x03, 0xE1, 0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x0F, 0x8F, 0x80, 0x01,
  0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0xF0,
  0x00, 0x1E, 0x1E, 0x04, 0x07, 0xC7, 0xC3, 0xE0, 0xF0, 0xF8, 0x7E, 0x1E,
  0x1E, 0x0F, 0xC3, 0xC3, 0xC1, 0xF8, 0x78, 0x78, 0x3E, 0x0F, 0x0F, 0x01,
  0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x01, 0xF0, 0xF0, 0x00,
  0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x3C, 0x0F,
  0x80, 0x0F, 0x81, 0xF8, 0x03, 0xE0, 0x1F, 0xC3, 0xF8, 0x01, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0xFE, 0xF0, 0x01, 0xF9, 0xF0, 0x07, 0xF1, 0xF0, 0x07, 0xC1, 0xE0, 0x0F,
  0x81, 0xE0, 0x0E, 0x01, 0xE0, 0x0C, 0x01, 0xE0, 0x08, 0x01, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0x00,
  0xFC, 0x0F, 0x80, 0x0F, 0x81, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0F,
  0x00, 0x03, 0xC3, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x80, 0x01, 0xE1, 0xE0, 0x00,
  0x3C, 0x3C, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xE0, 0xF8, 0x00, 0x7C, 0x0F,
  0x00, 0x1F, 0x01, 0xF0, 0x07, 0xE0, 0x3F, 0xC7, 0xF8, 0x03, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x01, 0x03, 0xC0, 0x1E, 0x07, 0xC0, 0x1E, 0x0F, 0x80, 0x1E, 0x1F,
  0x00, 0x1E, 0x3E, 0x00, 0x1E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3C, 0xF8,
  0x00, 0x3C, 0xF8, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE3, 0xFE, 0x00, 0x79, 0xFF, 0xE0,
  0x1E, 0xFF, 0xFC, 0x07, 0xF8, 0xFF, 0x03, 0xF8, 0x07, 0xE0, 0xFC, 0x00,
  0xF8, 0x3E, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x03,
  0xC3, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x78, 0x3E, 0x00, 0x3E, 0x0F, 0xC0,
  0x1F, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xCF, 0xC0, 0x07, 0xDF, 0xF8, 0x07,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83, 0xF8, 0x0F, 0xE1, 0xF0, 0x01, 0xF1,
  0xF0, 0x00, 0xF8, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x0F,
  0xBC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x7B, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x3C, 0xF8, 0x00,
  0x3E, 0x3E, 0x00, 0x3E, 0x1F, 0x80, 0x3E, 0x07, 0xF0, 0xFE, 0x01, 0xFF,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x7F,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0xF7, 0xC0, 0x00, 0xFB, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x7C,
  0xF0, 0x00, 0x3C, 0x78, 0x00, 0x3E, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0x00, 0xFC, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x00,
  0xF0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x3E,
  0x00, 0x0F, 0x07, 0xC0, 0x03, 0xE0, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x1E,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x01, 0xF8, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xE3, 0xF0, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x1E, 0x00,
  0x1E, 0x07, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x07, 0x87,
  0x80, 0x00, 0xF0, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0x87, 0xC0, 0x00,
  0xF0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x81, 0xF8, 0x03, 0xF0, 0x3F,
  0xC3, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFC, 0x03, 0xF0, 0xFC, 0x00, 0xF8, 0x7C,
  0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3C, 0x00, 0x07, 0xBE, 0x00, 0x03, 0xDE,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x7D,
  0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x1F, 0x3E, 0x00, 0x1F,
  0x1F, 0x00, 0x1F, 0x8F, 0xC0, 0x1F, 0x83, 0xFC, 0x7F, 0xC0, 0xFF, 0xFB,
  0xC0, 0x3F, 0xFB, 0xC0, 0x0F, 0xF3, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0x80, 0x7E, 0x0F, 0xF0, 0xFF,
  0x1F, 0xF1, 0xFF, 0x0F, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x07, 0xE0, 0x10, 0x00, 0x00, 0x1C, 0x00, 0x7E, 0x00, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x06, 0x00, 0x3F, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xC0,
  0x07, 0xF8, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0,
  0x03, 0xF8, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0xE0, 0xF0,
  0x00, 0x03, 0xC3, 0xC0, 0x03, 0x87, 0x87, 0x80, 0x3F, 0xEF, 0x0F, 0x00,
  0xFF, 0xDE, 0x1E, 0x03, 0xFB, 0xFC, 0x3C, 0x0F, 0x81, 0xF8, 0x70, 0x1E,
  0x01, 0xE1, 0xE0, 0x3C, 0x03, 0xC3, 0xC0, 0xF0, 0x07, 0x87, 0x81, 0xE0,
  0x0F, 0x0F, 0x03, 0xC0, 0x1E, 0x1E, 0x07, 0x80, 0x3C, 0x38, 0x0F, 0x00,
  0x70, 0xF0, 0x1C, 0x01, 0xE1, 0xE0, 0x78, 0x03, 0xC3, 0xC0, 0xF0, 0x07,
  0x87, 0x81, 0xE0, 0x0F, 0x0F, 0x03, 0xC0, 0x1E, 0x1E, 0x07, 0x80, 0x78,
  0x38, 0x0F, 0x01, 0xF0, 0xF0, 0x1F, 0x06, 0xE1, 0xE0, 0x1F, 0xFD, 0xC3,
  0xC0, 0x3F, 0xF7, 0x87, 0x80, 0x1F, 0x8F, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1E, 0xF0,
  0x00, 0x0F, 0x9C, 0x00, 0x03, 0xC7, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x78,
  0x78, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00,
  0xF0, 0x78, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x01, 0xE0,
  0x03, 0xC0, 0x3C, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x0F, 0x01, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xC0, 0x01, 0xE1,
  0xF0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x3E, 0x00, 0x07, 0x8F, 0x00, 0x01,
  0xE7, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0xBE, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x7C, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x78, 0x03, 0xF8, 0x0F, 0x00,
  0x1F, 0x81, 0xE0, 0x01, 0xF0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0,
  0xF0, 0x00, 0x78, 0x3E, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00,
  0x7C, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xE0, 0x78, 0x00, 0xF8, 0x1F,
  0x00, 0x7E, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xC0, 0x3C, 0x00, 0xFC, 0x0F, 0x80, 0x07, 0xC1, 0xE0,
  0x00, 0xF8, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C,
  0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x1E, 0x1E, 0x00,
  0x07, 0xC3, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x3E, 0x0F, 0x00, 0x0F, 0x81,
  0xE0, 0x07, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xE0, 0x1F, 0x81, 0xF0, 0x03,
  0xE0, 0xF8, 0x00, 0x78, 0x3C, 0x00, 0x1F, 0x0F, 0x00, 0x07, 0xC7, 0x80,
  0x01, 0xF1, 0xE0, 0x00, 0x7C, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x3E, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0xF0, 0xF8, 0x00, 0x78, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x1F, 0x01, 0xFE,
  0x3F, 0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0x80, 0x3F, 0x81, 0xE0, 0x03, 0xE0, 0x78,
  0x00, 0x7C, 0x1E, 0x00, 0x1F, 0x07, 0x80, 0x03, 0xC3, 0xE0, 0x00, 0xF0,
  0xF8, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x01,
  0xF0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x1F, 0x00, 0x07, 0x87, 0x80,
  0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x07,
  0x80, 0x03, 0xC3, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F,
  0x0F, 0x00, 0x07, 0xC3, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x78, 0x7C, 0x00,
  0x1E, 0x1F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xE1, 0xE0, 0x00, 0xF0, 0x78,
  0x00, 0x7C, 0x1E, 0x00, 0x3E, 0x07, 0x80, 0x3F, 0x03, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x78,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFC, 0x03, 0xE0, 0x1F, 0x81, 0xF0, 0x03, 0xE0, 0xF8, 0x00, 0x78,
  0x3C, 0x00, 0x1F, 0x0F, 0x00, 0x07, 0xC7, 0x80, 0x01, 0xF1, 0xE0, 0x00,
  0x7C, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x3F, 0xFC, 0x7C, 0x0F, 0xFF, 0x1F, 0x07, 0xFF,
  0xC7, 0x81, 0xFF, 0xF1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x1E, 0x00,
  0x07, 0x87, 0x80, 0x01, 0xE3, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x3E, 0x3C,
  0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x78,
  0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x1F, 0x01, 0xFE, 0x3F, 0x80, 0x3F, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x03,
  0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x83, 0xE0, 0x00,
  0xF0, 0x7C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0xF0, 0x3C,
  0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x3E, 0x00, 0x0F,
  0x07, 0x80, 0x03, 0xE0, 0xF0, 0x00, 0x7C, 0x1E, 0x00, 0x0F, 0x03, 0xC0,
  0x01, 0xE0, 0x78, 0x00, 0x3C, 0x1F, 0x00, 0x07, 0x83, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3C, 0x00,
  0x1E, 0x0F, 0x80, 0x03, 0xC1, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1F, 0x07,
  0x80, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x01,
  0xE0, 0xF8, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x83, 0xC0, 0x01, 0xE0, 0x78,
  0x00, 0x3C, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x7C, 0x00, 0x1E,
  0x0F, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0xF8, 0x3C, 0x00, 0x1E, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x03, 0xE0,
  0x01, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x0F, 0x01,
  0xF0, 0x00, 0x7C, 0x07, 0x80, 0x03, 0xE0, 0x1E, 0x00, 0x1F, 0x00, 0x78,
  0x00, 0x7C, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x03, 0xC0, 0x1F, 0x00, 0x0F, 0x00, 0x7C,
  0x00, 0x3C, 0x03, 0xE0, 0x00, 0xF0, 0x1F, 0x00, 0x03, 0xC0, 0x7C, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x78, 0x1F, 0x00, 0x03, 0xE0,
  0x3C, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0xF0, 0x07,
  0x80, 0x03, 0xC0, 0x1F, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF0,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x07, 0x80, 0x1E, 0x00, 0x1F, 0x00,
  0x78, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0x03, 0xE0, 0x3E,
  0x00, 0x0F, 0x80, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x7C, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x01, 0xF8,
  0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xF0, 0x7F,
  0x00, 0x3B, 0x83, 0xBC, 0x03, 0xFC, 0x1D, 0xE0, 0x1D, 0xC0, 0xEF, 0x01,
  0xEE, 0x07, 0x38, 0x0E, 0x70, 0x39, 0xC0, 0xF7, 0x83, 0xCE, 0x07, 0x3C,
  0x1E, 0x78, 0x79, 0xE0, 0xF3, 0xC3, 0x8E, 0x07, 0x8E, 0x3C, 0xF0, 0x3C,
  0x71, 0xC7, 0x81, 0xE3, 0x9E, 0x3C, 0x1E, 0x1C, 0xE1, 0xE0, 0xF0, 0xFF,
  0x0F, 0x07, 0x87, 0xF0, 0xF8, 0x3C, 0x1F, 0x87, 0x81, 0xE0, 0xF8, 0x3C,
  0x0F, 0x07, 0xC1, 0xE0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x3C,
  0x00, 0x07, 0xC1, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x78, 0x3E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3E,
  0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x1E,
  0x00, 0x03, 0xC1, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xF0, 0x78, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x3F, 0x00,
  0x1E, 0x07, 0xF0, 0x01, 0xE0, 0x7F, 0x00, 0x1E, 0x07, 0xF0, 0x01, 0xE0,
  0x7F, 0x80, 0x1E, 0x07, 0xF8, 0x01, 0xE0, 0x7F, 0x80, 0x3C, 0x07, 0x78,
  0x03, 0xC0, 0xF3, 0x80, 0x3C, 0x0F, 0x3C, 0x03, 0xC0, 0xF3, 0xC0, 0x3C,
  0x0F, 0x3C, 0x03, 0xC0, 0xF3, 0xC0, 0x78, 0x0F, 0x1C, 0x07, 0x81, 0xF1,
  0xE0, 0x78, 0x1E, 0x1E, 0x07, 0x81, 0xE1, 0xE0, 0x78, 0x1E, 0x0E, 0x07,
  0x81, 0xE0, 0xE0, 0xF8, 0x1E, 0x0F, 0x0F, 0x03, 0xE0, 0xF0, 0xF0, 0x3C,
  0x0F, 0x0F, 0x03, 0xC0, 0x70, 0xF0, 0x3C, 0x07, 0x8F, 0x03, 0xC0, 0x79,
  0xF0, 0x3C, 0x07, 0x9E, 0x03, 0xC0, 0x79, 0xE0, 0x78, 0x03, 0x9E, 0x07,
  0x80, 0x3D, 0xE0, 0x78, 0x03, 0xDE, 0x07, 0x80, 0x3D, 0xE0, 0x78, 0x03,
  0xDC, 0x07, 0x80, 0x1D, 0xC0, 0xF8, 0x01, 0xFC, 0x0F, 0x00, 0x1F, 0xC0,
  0xF0, 0x01, 0xFC, 0x0F, 0x00, 0x1F, 0xC0, 0xF0, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0xF8, 0x00, 0x78, 0x3C, 0x00,
  0x1E, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78,
  0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF0,
  0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0xF0, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0x87, 0x80,
  0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87,
  0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F,
  0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x01, 0xE0, 0xF8, 0x00, 0x78, 0x3E, 0x00,
  0x3E, 0x07, 0xC0, 0x1F, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x07,
  0x80, 0x0F, 0xE0, 0x78, 0x00, 0x3E, 0x07, 0x80, 0x01, 0xF0, 0x78, 0x00,
  0x1F, 0x07, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF0,
  0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x1F, 0x0F, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0xFC,
  0x1E, 0x00, 0x3F, 0x81, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xC0, 0x0F, 0x81, 0xF0,
  0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xE1, 0xE0, 0x00, 0x78,
  0x3C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE1, 0xF0, 0x00, 0x3C, 0x3E, 0x00,
  0x07, 0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x1E, 0x1F, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x78, 0x78, 0x00, 0x1F, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x3C,
  0x00, 0x0F, 0x0F, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x0F,
  0x87, 0x80, 0x01, 0xF0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC0,
  0x01, 0xF0, 0x78, 0x00, 0x3C, 0x0F, 0x80, 0x0F, 0x81, 0xF8, 0x03, 0xE0,
  0x1F, 0xC3, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0x01, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFC, 0x07, 0x80, 0x1F, 0xC0, 0x78, 0x00, 0x7E, 0x07, 0x80, 0x03,
  0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x1E, 0x0F,
  0x80, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x3E, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x81,
  0xE0, 0x01, 0xF8, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xC0, 0x3C, 0x00,
  0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x3E, 0x00, 0x3C, 0x01, 0xE0, 0x03, 0xC0,
  0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x78, 0x00, 0xF0,
  0x07, 0x80, 0x0F, 0x80, 0x78, 0x00, 0x78, 0x07, 0x80, 0x07, 0x80, 0x78,
  0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x03,
  0xE0, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0x00, 0xFC, 0x07, 0xC0,
  0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x1F, 0x07, 0x80, 0x03, 0xE1,
  0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x3C, 0x00,
  0x07, 0xC7, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x1E, 0x1F, 0x00, 0x07, 0x81,
  0xF0, 0x03, 0xF0, 0x3F, 0xC3, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0xF0, 0x00, 0x78, 0x3E, 0x00, 0x0F, 0x07, 0xC0, 0x01, 0xE0, 0xF0, 0x00,
  0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x3C, 0x0F,
  0x00, 0x07, 0x83, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0xF8, 0x3C, 0x00, 0x1F, 0x07, 0x80, 0x03, 0xC1, 0xF0,
  0x00, 0x78, 0x3E, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x7C,
  0x1E, 0x00, 0x0F, 0x83, 0xC0, 0x01, 0xE0, 0xF8, 0x00, 0x3C, 0x1F, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0xC1,
  0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xC1, 0xE0, 0x00,
  0x78, 0x3C, 0x00, 0x1F, 0x07, 0x80, 0x03, 0xC0, 0xF8, 0x00, 0xF8, 0x1F,
  0x00, 0x1E, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0xC7, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x3C,
  0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xE3, 0xE0, 0x00,
  0xF8, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x81, 0xE0,
  0x01, 0xE0, 0x78, 0x00, 0xF8, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x1F, 0x01,
  0xE0, 0x07, 0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x3C,
  0x00, 0xF0, 0x1F, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x01, 0xE0, 0x03, 0xC0,
  0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x07, 0x80, 0x03,
  0xC1, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x9E, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xBC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x3D, 0xE0, 0x1F,
  0x00, 0xF7, 0x80, 0x7C, 0x03, 0x9E, 0x01, 0xF0, 0x1E, 0x78, 0x0F, 0xC0,
  0x79, 0xE0, 0x3F, 0x01, 0xE7, 0x80, 0xDC, 0x07, 0x1E, 0x07, 0x70, 0x3C,
  0x78, 0x1D, 0xC0, 0xF1, 0xE0, 0x77, 0x03, 0xC7, 0x81, 0x9C, 0x1E, 0x1E,
  0x0E, 0x70, 0x78, 0x78, 0x39, 0xC1, 0xE1, 0xE0, 0xC7, 0x07, 0x07, 0x87,
  0x1C, 0x3C, 0x1C, 0x1C, 0x70, 0xF0, 0x70, 0x71, 0x83, 0xC1, 0xC1, 0x86,
  0x0E, 0x07, 0x0E, 0x18, 0x78, 0x1C, 0x38, 0x61, 0xE0, 0x70, 0xC1, 0x87,
  0x03, 0xC7, 0x06, 0x1C, 0x0F, 0x1C, 0x18, 0xF0, 0x3C, 0x70, 0xE3, 0xC0,
  0xF3, 0x83, 0x8E, 0x03, 0xCE, 0x0E, 0x78, 0x0F, 0x38, 0x39, 0xE0, 0x3C,
  0xC0, 0xE7, 0x80, 0xF7, 0x03, 0x9C, 0x03, 0xDC, 0x0E, 0xF0, 0x0F, 0x70,
  0x3B, 0xC0, 0x3F, 0x80, 0xEE, 0x00, 0xFE, 0x03, 0xB8, 0x03, 0xB8, 0x0F,
  0xE0, 0x0E, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xF0,
  0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x0F, 0x80, 0x1F, 0x00,
  0x07, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x01, 0xF0,
  0x03, 0xC0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00,
  0xF1, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3E, 0xF0, 0x00,
  0x00, 0x3E, 0x78, 0x00, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x1F, 0x0F, 0x00,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0xF0,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x07, 0x80, 0x0F,
  0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x01, 0xE0, 0x07, 0xC0, 0x00,
  0xF8, 0x03, 0xE0, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3E, 0x78, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x78, 0x7C, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0xF0, 0x3C,
  0x00, 0x1F, 0x03, 0xC0, 0x03, 0xE0, 0x1E, 0x00, 0x3C, 0x01, 0xE0, 0x07,
  0xC0, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x01, 0xF0, 0x00,
  0xF0, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x7C, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x3D, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80,
  0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0xFF, 0xF8,
  0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xDC, 0x00, 0x07,
  0x38, 0x00, 0x1E, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF0, 0xE0, 0x03, 0xC1,
  0xC0, 0x0F, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0F,
  0x03, 0xC0, 0x1E, 0x0F, 0x00, 0x1C, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0x78,
  0xF0, 0x00, 0xF3, 0xC0, 0x00, 0xEF, 0x00, 0x01, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3C,
  0x0F, 0x07, 0xC1, 0xE0, 0x78, 0x3E, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0xF0, 0xF0, 0x1F, 0xFF, 0x3C, 0x0F, 0xFF, 0xDF, 0x07, 0xF0, 0x7F, 0x81,
  0xF0, 0x07, 0xE0, 0xF8, 0x00, 0xF8, 0x3C, 0x00, 0x3E, 0x1F, 0x00, 0x0F,
  0x87, 0x80, 0x03, 0xE1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x3E, 0x00,
  0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x7C, 0x3C,
  0x00, 0x1F, 0x0F, 0x00, 0x07, 0x87, 0xC0, 0x01, 0xE1, 0xF0, 0x00, 0x78,
  0x78, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x87, 0x80, 0x03, 0xE1, 0xF0, 0x01,
  0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x80, 0x3F, 0x03, 0xF8, 0x7B, 0xC0, 0xFF,
  0xFC, 0xF0, 0x1F, 0xFE, 0x7C, 0x01, 0xFF, 0x1E, 0x00, 0x04, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0xF0, 0x03, 0xC3, 0xFE, 0x01, 0xE7,
  0xFF, 0xC0, 0xF7, 0xFF, 0xE0, 0x7B, 0x81, 0xF8, 0x3F, 0x00, 0x7C, 0x1F,
  0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC7, 0x80, 0x03, 0xE3,
  0xC0, 0x01, 0xF1, 0xE0, 0x00, 0xF8, 0xF0, 0x00, 0x78, 0xF8, 0x00, 0x3C,
  0x78, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x8F, 0x00, 0x07,
  0xC7, 0x80, 0x03, 0xC7, 0xC0, 0x01, 0xE3, 0xE0, 0x00, 0xF1, 0xF0, 0x00,
  0x78, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3C, 0x3E, 0x00, 0x3E, 0x1F, 0x80,
  0x3E, 0x1F, 0xF0, 0xFE, 0x0F, 0x3F, 0xFE, 0x07, 0x9F, 0xFE, 0x03, 0xC7,
  0xFE, 0x00, 0x00, 0x20, 0x00, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7E, 0x07, 0xE0, 0x7C, 0x01, 0xF8,
  0x7C, 0x00, 0x7C, 0x3C, 0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x1E, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xC7, 0x80,
  0x01, 0xE3, 0xC0, 0x00, 0xF1, 0xF0, 0x00, 0xF0, 0xF8, 0x00, 0xF8, 0x3E,
  0x00, 0xF8, 0x1F, 0xE3, 0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x7F, 0xC3, 0xC0, 0x1F, 0xFF, 0x3C,
  0x03, 0xFF, 0xF7, 0xC0, 0x7F, 0x07, 0xF8, 0x07, 0xC0, 0x1F, 0x80, 0xF8,
  0x00, 0xF8, 0x0F, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x1E, 0x00, 0x0F,
  0x81, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0xF0, 0x3C,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x1F, 0x03, 0xC0, 0x01,
  0xF0, 0x3C, 0x00, 0x1E, 0x07, 0xC0, 0x01, 0xE0, 0x7C, 0x00, 0x1E, 0x07,
  0x80, 0x01, 0xE0, 0x78, 0x00, 0x3E, 0x07, 0x80, 0x03, 0xE0, 0x7C, 0x00,
  0x7C, 0x07, 0xC0, 0x07, 0xC0, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x7B, 0xC0,
  0x3F, 0xFF, 0x3C, 0x01, 0xFF, 0xE7, 0xC0, 0x07, 0xFC, 0x78, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x07, 0xC0, 0x7E, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x1E, 0x1E,
  0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x3C, 0x00, 0x0F, 0x3C, 0x00, 0x1F, 0x7C,
  0x00, 0x1E, 0x78, 0x00, 0x1E, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFE, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x04, 0xF8,
  0x00, 0x78, 0xF8, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0x7E, 0x07, 0xE0, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x7F, 0xE3, 0xC0, 0xFF, 0xF9, 0xE0, 0xFF, 0xFD, 0xF0, 0xFE,
  0x0F, 0xF0, 0x7C, 0x01, 0xF8, 0x7C, 0x00, 0x7C, 0x3C, 0x00, 0x3E, 0x3E,
  0x00, 0x1F, 0x1E, 0x00, 0x0F, 0x8F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC7,
  0xC0, 0x01, 0xE3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x7C,
  0x78, 0x00, 0x3E, 0x3C, 0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x1F, 0x00, 0x07,
  0x8F, 0x80, 0x07, 0xC3, 0xC0, 0x03, 0xE1, 0xF0, 0x03, 0xF0, 0xFC, 0x07,
  0xF0, 0x3F, 0xFF, 0x78, 0x1F, 0xFF, 0x3C, 0x07, 0xFF, 0x1E, 0x00, 0xFE,
  0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC1, 0xF0, 0x03, 0xC3,
  0xFE, 0x01, 0xE7, 0xFF, 0xC0, 0xF7, 0xFF, 0xE0, 0x7B, 0x81, 0xF8, 0x3F,
  0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC7,
  0x80, 0x03, 0xE3, 0xC0, 0x01, 0xF1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78,
  0xF8, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x1E, 0x00, 0x0F,
  0x8F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC7, 0xC0, 0x01, 0xE3, 0xE0, 0x00,
  0xF1, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x7C, 0x78, 0x00, 0x3C, 0x3C, 0x00,
  0x1E, 0x1E, 0x00, 0x0F, 0x1F, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xC7, 0x80,
  0x03, 0xE3, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0xF8, 0x00,
  0x7C, 0x0F, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0xF8, 0x0F, 0x00, 0x1F, 0x00,
  0xF0, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x1E, 0x01,
  0xF0, 0x01, 0xE0, 0x1F, 0x00, 0x1E, 0x03, 0xE0, 0x01, 0xE0, 0x7C, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x3C, 0x0F, 0x80, 0x03, 0xC0, 0x7C, 0x00, 0x3C, 0x07, 0xC0,
  0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x78,
  0x01, 0xF0, 0x07, 0x80, 0x0F, 0x80, 0x78, 0x00, 0xF8, 0x07, 0x80, 0x07,
  0xC0, 0xF8, 0x00, 0x7C, 0x0F, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x3E, 0x00,
  0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x00, 0x06, 0x01, 0x80, 0x3D, 0xFC, 0x7F, 0x01, 0xDF, 0xF7, 0xFC, 0x0E,
  0xFF, 0xBF, 0xE0, 0xF8, 0x3E, 0x0F, 0x07, 0xC1, 0xF0, 0x78, 0x3C, 0x0F,
  0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x07,
  0x87, 0x80, 0xE0, 0x3C, 0x3C, 0x07, 0x01, 0xE1, 0xE0, 0x38, 0x0F, 0x0F,
  0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x3C, 0x3C, 0x07,
  0x01, 0xE1, 0xE0, 0x38, 0x0F, 0x0F, 0x01, 0xC0, 0x78, 0x78, 0x1E, 0x03,
  0x83, 0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xE1, 0xE0, 0x3C, 0x0F, 0x0F,
  0x01, 0xC0, 0x78, 0x78, 0x0E, 0x03, 0xC3, 0xC0, 0x70, 0x1E, 0x1E, 0x07,
  0x81, 0xE0, 0xF0, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0x78, 0x78, 0x0E, 0x03,
  0xC0, 0x00, 0x03, 0xE0, 0x07, 0xC7, 0xFC, 0x03, 0xCF, 0xFF, 0x81, 0xEF,
  0xFF, 0xC0, 0xF7, 0x03, 0xF0, 0x7E, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x3E,
  0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x00, 0x07, 0xC7, 0x80, 0x03, 0xE3,
  0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF1, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x3C,
  0x78, 0x00, 0x1E, 0x3C, 0x00, 0x1F, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07,
  0x8F, 0x80, 0x03, 0xC7, 0xC0, 0x01, 0xE3, 0xC0, 0x00, 0xF1, 0xE0, 0x00,
  0xF8, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x3E, 0x00,
  0x0F, 0x1E, 0x00, 0x07, 0x8F, 0x00, 0x07, 0xC7, 0x80, 0x03, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07,
  0xE0, 0xFE, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x1E, 0x1E, 0x00, 0x1F, 0x3E,
  0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C,
  0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78,
  0x00, 0x1E, 0x78, 0x00, 0x3E, 0xF8, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0,
  0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x78, 0xF8, 0x00, 0x78, 0xF8,
  0x00, 0xF8, 0x7C, 0x01, 0xF0, 0x7F, 0x0F, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x7C, 0x7F, 0xC0, 0x0F, 0x3F, 0xFE, 0x01, 0xEF, 0xFF, 0xC0, 0x3D, 0xC0,
  0xFC, 0x07, 0xE0, 0x0F, 0x81, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07,
  0xC0, 0x03, 0xE0, 0xF0, 0x00, 0x7C, 0x1E, 0x00, 0x0F, 0x83, 0xC0, 0x01,
  0xF0, 0x78, 0x00, 0x3C, 0x1F, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x78,
  0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0xF8, 0x3C, 0x00, 0x1E,
  0x0F, 0x80, 0x03, 0xC1, 0xF0, 0x00, 0x78, 0x3E, 0x00, 0x0F, 0x07, 0xC0,
  0x03, 0xE0, 0xF8, 0x00, 0x78, 0x1F, 0x00, 0x1F, 0x07, 0xF0, 0x07, 0xC0,
  0xFF, 0x83, 0xF0, 0x1E, 0x7F, 0xFC, 0x03, 0xCF, 0xFF, 0x00, 0x78, 0x7F,
  0xC0, 0x0F, 0x01, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x1F, 0xF0, 0xF0, 0x1F, 0xFF, 0x7C, 0x0F, 0xFF, 0xDF,
  0x07, 0xF0, 0x7F, 0x81, 0xF0, 0x07, 0xE0, 0xF8, 0x00, 0xF8, 0x3C, 0x00,
  0x3E, 0x1F, 0x00, 0x0F, 0x87, 0x80, 0x03, 0xE1, 0xE0, 0x00, 0xF0, 0xF8,
  0x00, 0x3C, 0x3E, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0,
  0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x87, 0xC0, 0x01,
  0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x87, 0x80,
  0x03, 0xE1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x80, 0x7F, 0x03,
  0xF8, 0x7B, 0xC0, 0xFF, 0xFC, 0xF0, 0x1F, 0xFE, 0x7C, 0x01, 0xFF, 0x1E,
  0x00, 0x04, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x83, 0xE0,
  0x03, 0xC7, 0xFE, 0x00, 0xF3, 0xFF, 0xE0, 0x3D, 0xFF, 0xF8, 0x0F, 0xF0,
  0x3F, 0x03, 0xF0, 0x07, 0xC1, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F,
  0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x3E,
  0x1E, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x7E, 0x03, 0xF0, 0x7C, 0x00, 0x7C, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x79, 0xF0,
  0x00, 0x7C, 0xF8, 0x00, 0x3C, 0x3E, 0x00, 0x3E, 0x1F, 0xC0, 0x7E, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0x00, 0x07, 0x8F,
  0x00, 0x03, 0xC7, 0x80, 0x03, 0xE3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF1,
  0xF0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x1F,
  0x1E, 0x00, 0x0F, 0x8F, 0x00, 0x07, 0x8F, 0x80, 0x03, 0xC7, 0xC0, 0x01,
  0xE3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x7C, 0x78, 0x00,
  0x3C, 0x3C, 0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x8F, 0x00,
  0x07, 0xC7, 0xC0, 0x03, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xE0, 0x7C,
  0x03, 0xF0, 0x3F, 0x87, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xBC, 0x00, 0x07, 0x9E, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xC3, 0xC0, 0x01,
  0xE1, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x3C, 0x00,
  0x78, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xE0,
  0x1E, 0x00, 0xF0, 0x1F, 0x00, 0x78, 0x0F, 0x00, 0x1E, 0x0F, 0x80, 0x0F,
  0x07, 0x80, 0x07, 0x87, 0xC0, 0x03, 0xC3, 0xC0, 0x01, 0xE3, 0xE0, 0x00,
  0xF1, 0xE0, 0x00, 0x3D, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x78, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0xFF, 0x00, 0xF0, 0x0E, 0xF0, 0x1F, 0x00, 0xEF,
  0x01, 0xF0, 0x1E, 0xF0, 0x1B, 0x01, 0xEF, 0x03, 0xB0, 0x1C, 0xF0, 0x3B,
  0x03, 0xCF, 0x03, 0x30, 0x3C, 0xF0, 0x73, 0x03, 0x8F, 0x07, 0x30, 0x78,
  0xF0, 0x63, 0x07, 0x8F, 0x0E, 0x30, 0x70, 0xF0, 0xE3, 0x0F, 0x0F, 0x0C,
  0x30, 0xF0, 0xF1, 0xC3, 0x0E, 0x0F, 0x1C, 0x30, 0xE0, 0xF1, 0x83, 0x1E,
  0x0F, 0x38, 0x31, 0xC0, 0xF3, 0x83, 0x1C, 0x0F, 0x30, 0x33, 0xC0, 0xF7,
  0x03, 0x38, 0x0F, 0x70, 0x33, 0x80, 0xF6, 0x03, 0x78, 0x0F, 0xE0, 0x37,
  0x00, 0xFE, 0x03, 0x70, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F,
  0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x1F,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x0F, 0x00,
  0x78, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xE0, 0x7C, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x3C, 0x7C, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x07, 0xBE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xEF, 0x00,
  0x00, 0x1E, 0x7C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x01,
  0xF0, 0x3C, 0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x07, 0x80, 0x0F, 0x00,
  0x3E, 0x00, 0xF8, 0x00, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x1E,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0x8F, 0x00, 0x07, 0xC7,
  0x80, 0x03, 0xE3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF1, 0xF0, 0x00, 0x78,
  0xF0, 0x00, 0x3C, 0x78, 0x00, 0x3E, 0x3C, 0x00, 0x1F, 0x1E, 0x00, 0x0F,
  0x0F, 0x00, 0x07, 0x8F, 0x80, 0x03, 0xC7, 0xC0, 0x01, 0xE3, 0xC0, 0x00,
  0xF1, 0xE0, 0x00, 0xF8, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x7C, 0x00,
  0x1E, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x87, 0x80, 0x0F, 0xC3, 0xE0,
  0x0F, 0xC1, 0xF8, 0x0F, 0xE0, 0x7F, 0xFE, 0xF0, 0x3F, 0xFE, 0x78, 0x0F,
  0xFE, 0x3C, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80,
  0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07,
  0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x07, 0x8F, 0xF8, 0x03, 0xCF, 0xFE, 0x01, 0xEF, 0xFF, 0x80, 0xF7,
  0x87, 0xC0, 0x7F, 0x81, 0xF0, 0x7F, 0xC0, 0x7C, 0x3D, 0xE0, 0x1F, 0xFE,
  0xF0, 0x0F, 0xFE, 0x78, 0x01, 0xFE, 0x00, 0x00, 0x30, 0x00,
};

const GFXglyph JetBrainsMono_LightItalic53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 12, 39, 32, 10, -39 },
  { 60, 17, 16, 32, 10, -39 },
  { 94, 31, 39, 32, 1, -39 },
  { 246, 27, 53, 32, 3, -46 },
  { 425, 36, 39, 32, -1, -39 },
  { 601, 29, 40, 32, 1, -39 },
  { 746, 7, 16, 32, 15, -39 },
  { 760, 21, 52, 32, 9, -45 },
  { 897, 21, 52, 32, 3, -45 },
  { 1034, 28, 27, 32, 3, -32 },
  { 1129, 25, 25, 32, 4, -30 },
  { 1208, 14, 16, 32, 5, -8 },
  { 1236, 17, 3, 32, 8, -19 },
  { 1243, 9, 9, 32, 10, -8 },
  { 1254, 31, 50, 32, 1, -44 },
  { 1448, 27, 40, 32, 3, -39 },
  { 1583, 24, 39, 32, 3, -39 },
  { 1700, 27, 39, 32, 3, -39 },
  { 1832, 27, 40, 32, 3, -39 },
  { 1967, 24, 39, 32, 4, -39 },
  { 2084, 26, 40, 32, 4, -39 },
  { 2214, 25, 40, 32, 3, -39 },
  { 2339, 25, 39, 32, 7, -39 },
  { 2461, 27, 40, 32, 3, -39 },
  { 2596, 25, 39, 32, 5, -39 },
  { 2718, 12, 31, 32, 10, -30 },
  { 2765, 16, 38, 32, 6, -30 },
  { 2841, 25, 27, 32, 5, -31 },
  { 2926, 25, 17, 32, 4, -26 },
  { 2980, 25, 27, 32, 3, -31 },
  { 3065, 21, 39, 32, 8, -39 },
  { 3168, 31, 49, 32, 1, -39 },
  { 3358, 26, 39, 32, 1, -39 },
  { 3485, 27, 39, 32, 3, -39 },
  { 3617, 26, 40, 32, 4, -39 },
  { 3747, 26, 39, 32, 3, -39 },
  { 3874, 28, 39, 32, 3, -39 },
  { 4011, 29, 39, 32, 3, -39 },
  { 4153, 26, 40, 32, 4, -39 },
  { 4283, 27, 39, 32, 3, -39 },
  { 4415, 27, 39, 32, 3, -39 },
  { 4547, 29, 40, 32, 1, -39 },
  { 4692, 30, 39, 32, 3, -39 },
  { 4839, 23, 39, 32, 4, -39 },
  { 4952, 29, 39, 32, 2, -39 },
  { 5094, 28, 39, 32, 3, -39 },
  { 5231, 26, 40, 32, 4, -39 },
  { 5361, 28, 39, 32, 3, -39 },
  { 5498, 27, 49, 32, 3, -39 },
  { 5664, 28, 39, 32, 3, -39 },
  { 5801, 27, 40, 32, 3, -39 },
  { 5936, 27, 39, 32, 6, -39 },
  { 6068, 27, 40, 32, 4, -39 },
  { 6203, 26, 39, 32, 7, -39 },
  { 6330, 30, 39, 32, 4, -39 },
  { 6477, 33, 39, 32, 0, -39 },
  { 6638, 28, 39, 32, 6, -39 },
  { 6775, 28, 39, 32, 2, -39 },
  { 6912, 20, 50, 32, 8, -44 },
  { 7037, 15, 50, 32, 9, -44 },
  { 7131, 20, 50, 32, 5, -44 },
  { 7256, 23, 21, 32, 5, -39 },
  { 7317, 26, 4, 32, 0, 1 },
  { 7330, 9, 8, 32, 14, -42 },
  { 7339, 26, 31, 32, 3, -30 },
  { 7440, 25, 40, 32, 3, -39 },
  { 7565, 25, 31, 32, 4, -30 },
  { 7662, 28, 40, 32, 3, -39 },
  { 7802, 24, 31, 32, 4, -30 },
  { 7895, 35, 49, 32, -2, -39 },
  { 8110, 25, 40, 32, 4, -30 },
  { 8235, 25, 39, 32, 3, -39 },
  { 8357, 25, 41, 32, 2, -41 },
  { 8486, 27, 51, 32, 1, -41 },
  { 8659, 28, 39, 32, 3, -39 },
  { 8796, 22, 39, 32, 5, -39 },
  { 8904, 29, 30, 32, 1, -30 },
  { 9013, 25, 30, 32, 3, -30 },
  { 9107, 24, 31, 32, 4, -30 },
  { 9200, 27, 40, 32, 1, -30 },
  { 9335, 26, 40, 32, 3, -30 },
  { 9465, 26, 30, 32, 4, -30 },
  { 9563, 25, 31, 32, 3, -30 },
  { 9660, 25, 37, 32, 5, -37 },
  { 9776, 25, 30, 32, 4, -29 },
  { 9870, 25, 29, 32, 6, -29 },
  { 9961, 28, 29, 32, 4, -29 },
  { 10063, 29, 29, 32, 1, -29 },
  { 10169, 25, 39, 32, 4, -29 },
  { 10291, 26, 29, 32, 3, -29 },
  { 10386, 27, 50, 32, 5, -44 },
  { 10555, 12, 50, 32, 11, -44 },
  { 10630, 27, 50, 32, 1, -44 },
  { 10799, 25, 11, 32, 4, -24 },
};

const GFXfont JetBrainsMono_LightItalic53pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_LightItalic53pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_LightItalic53pt7bGlyphs,
  0x20, 0x7E, 70
};

#endif // _JETBRAINSMONO_LIGHTITALIC53PT7B_H_
