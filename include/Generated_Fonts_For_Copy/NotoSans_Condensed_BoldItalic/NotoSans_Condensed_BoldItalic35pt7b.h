#ifndef _NOTOSANS_CONDENSED_BOLDITALIC35PT7B_H_
#define _NOTOSANS_CONDENSED_BOLDITALIC35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BoldItalic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BoldItalic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xF0, 0x7C, 0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x07, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0xF0, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x1F, 0x0F, 0xC3, 0xE0, 0xF8, 0x00, 0x3C, 0xFB, 0xE7,
  0x9F, 0x3C, 0xF1, 0xE7, 0x8F, 0x3C, 0xF1, 0xC7, 0x8E, 0x3C, 0xF1, 0xC0,
  0x00, 0x71, 0xC0, 0x1E, 0x78, 0x03, 0x8F, 0x00, 0x71, 0xC0, 0x1E, 0x38,
  0x03, 0x8F, 0x00, 0x71, 0xC0, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC,
  0x8E, 0x38, 0x03, 0xCF, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x03, 0xC7, 0x03,
  0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF0, 0x71, 0xE0, 0x0E, 0x38, 0x01,
  0xC7, 0x00, 0x79, 0xE0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x79, 0xE0, 0x00,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x1F, 0xC0, 0x3F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xFC, 0x1F, 0x4C, 0x1F, 0x62, 0x0F, 0xB0, 0x07, 0xD8, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0xDF, 0x00, 0x6F, 0x90, 0x37, 0xC6, 0x1B, 0xE3, 0xEF, 0xE3, 0xFF,
  0xF1, 0xFF, 0xF0, 0x7F, 0xF0, 0x03, 0xC0, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x0F, 0x80, 0x78, 0x3F, 0x81, 0xE0, 0xFF, 0x03, 0x83, 0xCE,
  0x0F, 0x07, 0x9E, 0x1C, 0x0E, 0x38, 0x70, 0x3C, 0x71, 0xE0, 0x78, 0xE3,
  0x80, 0xF3, 0xCF, 0x01, 0xC7, 0x9C, 0x03, 0x8E, 0x71, 0xF7, 0xBD, 0xEF,
  0xFF, 0xF3, 0x9F, 0xFF, 0xEF, 0x79, 0xDF, 0xBC, 0xE3, 0x80, 0x73, 0xC7,
  0x01, 0xE7, 0x8E, 0x03, 0x8E, 0x3C, 0x0F, 0x1C, 0x78, 0x3C, 0x38, 0xE0,
  0x70, 0x73, 0xC1, 0xE0, 0xE7, 0x83, 0x81, 0xFE, 0x0F, 0x03, 0xF8, 0x3C,
  0x03, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x3C, 0xF0,
  0x07, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0x79, 0xF0, 0x07, 0xBE,
  0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xF1, 0xF1, 0xFF,
  0x1E, 0x3E, 0xFB, 0xE7, 0xCF, 0xBC, 0x7C, 0xFF, 0xC7, 0x87, 0xF8, 0xF8,
  0x7F, 0x8F, 0x83, 0xF0, 0xF8, 0x7F, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x87,
  0xFE, 0xF8, 0x1F, 0xCF, 0xC0, 0x3D, 0xF7, 0xDE, 0x79, 0xE7, 0x9C, 0xF0,
  0x01, 0xF0, 0x3E, 0x03, 0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xE0,
  0x3E, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x78, 0x00, 0x01,
  0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01,
  0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F,
  0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x00, 0x03, 0x80,
  0x0F, 0x00, 0x3C, 0x10, 0xE0, 0x73, 0x83, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF,
  0x0F, 0xFC, 0x7E, 0x03, 0xFC, 0x3F, 0x78, 0x79, 0xE0, 0xC7, 0xC1, 0x0C,
  0x00, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x1F, 0x3E,
  0x3E, 0x3C, 0x7C, 0x78, 0x78, 0xF0, 0x7F, 0xDF, 0xF7, 0xF9, 0xFE, 0xFF,
  0x80, 0x7B, 0xFF, 0xFE, 0xF8, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x0F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF1, 0xF3, 0xE3,
  0xC3, 0xCF, 0x87, 0x9E, 0x0F, 0x7C, 0x1E, 0xF8, 0x7D, 0xF0, 0xFB, 0xC1,
  0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x1F, 0x7C, 0x3E, 0xF0, 0x7D, 0xE0, 0xF3,
  0xC3, 0xE7, 0x87, 0xCF, 0x9F, 0x1F, 0xFC, 0x3F, 0xF8, 0x3F, 0xE0, 0x3F,
  0x00, 0x00, 0xF0, 0x3F, 0x07, 0xF0, 0xFF, 0x1F, 0xE3, 0xFE, 0xFF, 0xE7,
  0xBE, 0x33, 0xE2, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xE0, 0x3E, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xF0,
  0x70, 0xF8, 0x30, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F,
  0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF8, 0xFF, 0xFC, 0x00, 0x03, 0xFC, 0x07,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x61, 0xF8, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x7F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x0F, 0x88, 0x0F, 0xC7, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xC0,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xBC, 0x03, 0xBE, 0x03, 0xDE,
  0x03, 0xCF, 0x01, 0xC7, 0x81, 0xE7, 0xC1, 0xE3, 0xE0, 0xE1, 0xE0, 0xF0,
  0xF0, 0xFF, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xC0, 0x0F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x03, 0xFF, 0x83,
  0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x0F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x83, 0xFF,
  0xC0, 0x43, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x0F, 0x8C, 0x0F, 0xC7, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xC0,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x0F,
  0xC0, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3D, 0xF0, 0x7F,
  0xF8, 0x7F, 0xFC, 0x7F, 0xFC, 0xFC, 0x7C, 0xF8, 0x3C, 0xF8, 0x3C, 0xF8,
  0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0xF8, 0xF8, 0xF8, 0xFF, 0xF8, 0x7F,
  0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE7,
  0xFF, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x01, 0xFF, 0x81, 0xFF, 0xC1, 0xFB, 0xF0, 0xF0, 0xF8, 0xF8, 0x7C,
  0x7C, 0x3E, 0x3E, 0x1E, 0x0F, 0x1F, 0x07, 0xDF, 0x01, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0xC0, 0xFD, 0xF0, 0xF8, 0xF8, 0x7C, 0x3E, 0x7C,
  0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xC7, 0xF7, 0xE1, 0xFF, 0xE0,
  0x7F, 0xE0, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x07, 0xFE, 0x0F, 0xFE, 0x0F,
  0xFF, 0x1F, 0x1F, 0x1F, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E,
  0x1F, 0x3E, 0x1F, 0x3E, 0x3F, 0x3F, 0xFF, 0x3F, 0xFE, 0x1F, 0xFE, 0x0F,
  0xBE, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0xFF,
  0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0x0F, 0x0F, 0xC7, 0xE3, 0xE1,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE1,
  0xF8, 0xFC, 0x7C, 0x3E, 0x00, 0x03, 0xC0, 0x7C, 0x1F, 0x83, 0xE0, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x1E, 0x07, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x1C,
  0x07, 0x80, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01,
  0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7E, 0x03, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0xF8, 0x1F, 0xC0,
  0x3E, 0x00, 0x70, 0x00, 0x80, 0x00, 0x0F, 0xE1, 0xFF, 0xCF, 0xFE, 0x7F,
  0xF1, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x81, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x78, 0x03, 0x80, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0x78, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xE0, 0x3C, 0x07,
  0x80, 0x1E, 0x0F, 0x00, 0x0E, 0x1E, 0x04, 0x0E, 0x1C, 0x3F, 0xCF, 0x3C,
  0x7F, 0xCF, 0x38, 0xF3, 0xCF, 0x78, 0xE3, 0x8F, 0x71, 0xC3, 0x8E, 0x71,
  0xC3, 0x8E, 0x73, 0xC7, 0x8E, 0xF3, 0x87, 0x0E, 0xE3, 0x87, 0x1C, 0xE3,
  0x8F, 0x1C, 0xE3, 0x8F, 0x38, 0xE3, 0xFF, 0xF8, 0xE3, 0xFF, 0xF0, 0xF1,
  0xF3, 0xE0, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E,
  0x03, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x0F, 0x78, 0x03, 0xDE, 0x01, 0xF7, 0x80, 0x79, 0xE0, 0x3E, 0x78,
  0x0F, 0x1E, 0x03, 0xC7, 0x81, 0xF1, 0xF0, 0x78, 0x7C, 0x3F, 0xFF, 0x0F,
  0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0xF8, 0x1F, 0x3E, 0x07, 0xDF, 0x01,
  0xF7, 0xC0, 0x7D, 0xE0, 0x1F, 0xF8, 0x07, 0xC0, 0x07, 0xFE, 0x01, 0xFF,
  0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x07, 0xC7, 0xC3, 0xE1, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F,
  0xFC, 0x07, 0xFF, 0x83, 0xE1, 0xF0, 0xF8, 0x3C, 0x3E, 0x0F, 0x0F, 0x03,
  0xC3, 0xC1, 0xF1, 0xF0, 0x7C, 0x7C, 0x3F, 0x1F, 0xFF, 0x87, 0xFF, 0xC1,
  0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFC,
  0x1F, 0xFE, 0x0F, 0xC1, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7E, 0x08, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0,
  0x78, 0xFE, 0x1F, 0x0F, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE3,
  0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xCF,
  0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x0F, 0xC7, 0xC1, 0xF0, 0xF0, 0x7E, 0x3E,
  0x1F, 0x87, 0xC7, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xE0, 0x78,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07,
  0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xFF,
  0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x83, 0xFF,
  0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0xE0, 0xFF, 0xE0, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFE,
  0x0F, 0xE0, 0xC1, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC3, 0xFC, 0x7C, 0x3F, 0xC7, 0xC3,
  0xFC, 0x7C, 0x7F, 0x87, 0xC0, 0xF8, 0xFC, 0x0F, 0x87, 0xC0, 0xF8, 0x7C,
  0x0F, 0x87, 0xC0, 0xF0, 0x7E, 0x1F, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x01,
  0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0,
  0x3E, 0x0F, 0x81, 0xF0, 0x78, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1,
  0xF0, 0x3E, 0x0F, 0x81, 0xE0, 0xF8, 0x1F, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3E,
  0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8,
  0x3E, 0x07, 0xC1, 0xF0, 0x3C, 0x0F, 0x03, 0xE0, 0xF8, 0x1F, 0x00, 0x07,
  0xFE, 0x0F, 0xFC, 0x3F, 0xF8, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78,
  0x01, 0xF0, 0x03, 0xE0, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00,
  0xFC, 0x00, 0x07, 0xC1, 0xF8, 0x3E, 0x0F, 0x81, 0xF0, 0xF8, 0x0F, 0x0F,
  0x80, 0x78, 0xFC, 0x07, 0xC7, 0xC0, 0x3E, 0x7C, 0x01, 0xF7, 0xE0, 0x0F,
  0x3E, 0x00, 0xFB, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xEF, 0x00, 0x3E, 0x7C, 0x01, 0xE3,
  0xE0, 0x0F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x01,
  0xE0, 0xF8, 0x0F, 0x07, 0xC0, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0xFD, 0xFF, 0xCF, 0xFE, 0xFF,
  0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x83,
  0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F,
  0xF0, 0x7F, 0x83, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFE, 0x1E, 0xF0, 0x7F,
  0xC3, 0xFE, 0x0F, 0x78, 0xF7, 0xC1, 0xEF, 0x1E, 0xF0, 0x3D, 0xE7, 0x9E,
  0x0F, 0xBC, 0xF3, 0xC1, 0xF7, 0xBC, 0xF8, 0x3C, 0x77, 0x9F, 0x07, 0x8E,
  0xE3, 0xC0, 0xF1, 0xFC, 0x78, 0x3E, 0x3F, 0x8F, 0x07, 0x87, 0xE3, 0xE0,
  0xF0, 0xFC, 0x7C, 0x1E, 0x1F, 0x0F, 0x03, 0xC3, 0xE1, 0xE0, 0xF8, 0x78,
  0x7C, 0x00, 0x07, 0xE0, 0x3E, 0x0F, 0xC0, 0x78, 0x1F, 0x80, 0xF0, 0x3F,
  0x83, 0xE0, 0x7F, 0x07, 0xC1, 0xFE, 0x0F, 0x03, 0xFC, 0x1E, 0x07, 0xF8,
  0x3C, 0x0F, 0xF8, 0xF8, 0x3E, 0xF1, 0xF0, 0x7D, 0xE3, 0xC0, 0xF3, 0xC7,
  0x81, 0xE7, 0xCF, 0x03, 0xCF, 0xBE, 0x0F, 0x8F, 0x78, 0x1F, 0x1E, 0xF0,
  0x3C, 0x3D, 0xE0, 0x78, 0x7F, 0xC0, 0xF0, 0x7F, 0x83, 0xE0, 0xFE, 0x07,
  0x81, 0xFC, 0x0F, 0x03, 0xF8, 0x1E, 0x07, 0xF0, 0x3C, 0x07, 0xE0, 0xF8,
  0x0F, 0x80, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE,
  0x0F, 0xC7, 0xE1, 0xF8, 0x3E, 0x1F, 0x03, 0xE3, 0xF0, 0x3E, 0x3E, 0x03,
  0xF3, 0xE0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0,
  0x3E, 0x7C, 0x03, 0xEF, 0xC0, 0x7C, 0xFC, 0x07, 0xCF, 0xC0, 0xFC, 0x7C,
  0x0F, 0x87, 0xC1, 0xF8, 0x7E, 0x3F, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x01,
  0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF,
  0x03, 0xFF, 0xE0, 0x78, 0x7C, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F,
  0x0F, 0x03, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x8F, 0xC1, 0xFF, 0xF8,
  0x3F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0xC0, 0x7F, 0xFE, 0x0F, 0xC7, 0xE1, 0xF8, 0x3E, 0x1F, 0x03, 0xE3, 0xF0,
  0x3E, 0x3E, 0x03, 0xF3, 0xE0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C,
  0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x07, 0xEF, 0xC0, 0x7C, 0xFC, 0x07, 0xCF,
  0xC0, 0xFC, 0x7C, 0x0F, 0x87, 0xC1, 0xF8, 0x7E, 0x3F, 0x07, 0xFF, 0xE0,
  0x3F, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFE, 0x07, 0x8F, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x07, 0xC7, 0xC3, 0xE1, 0xF1, 0xF8,
  0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0xF9, 0xE0, 0x3E,
  0x78, 0x0F, 0x1F, 0x03, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0x83, 0xE1, 0xE0, 0xF8, 0xF8, 0x1F, 0x00, 0x01, 0xFE, 0x01, 0xFF,
  0xC1, 0xFF, 0xC1, 0xFF, 0xE0, 0xF8, 0x60, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x10, 0x0F, 0x8E, 0x1F, 0x87, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F,
  0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xE0, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x0F, 0x03, 0xE3, 0xE0,
  0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x7C, 0x3C, 0x0F, 0x8F, 0x81,
  0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0x87, 0xC1, 0xF1, 0xF0, 0x3E, 0x3E, 0x07,
  0xC7, 0xC0, 0xF8, 0xF8, 0x1E, 0x1F, 0x07, 0xC3, 0xC0, 0xF8, 0x7C, 0x3F,
  0x0F, 0x87, 0xC1, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xC0,
  0x00, 0xF8, 0x07, 0xFE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x7C, 0xF8, 0x1F,
  0x3E, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xF0, 0xF8, 0x7C, 0x3E, 0x1E, 0x07,
  0x8F, 0x81, 0xE3, 0xC0, 0x79, 0xF0, 0x1E, 0x7C, 0x07, 0x9E, 0x01, 0xEF,
  0x80, 0x7B, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x1E,
  0x03, 0xFF, 0x03, 0xC0, 0xFB, 0xE0, 0xF8, 0x1F, 0x7C, 0x1F, 0x03, 0xCF,
  0x03, 0xE0, 0xF9, 0xE0, 0xFC, 0x1E, 0x3C, 0x1F, 0x87, 0xC7, 0x87, 0xF0,
  0xF8, 0xF0, 0xFE, 0x1E, 0x1E, 0x3D, 0xC7, 0xC3, 0xC7, 0xF8, 0xF0, 0x78,
  0xFF, 0x3E, 0x0F, 0x3D, 0xE7, 0xC1, 0xE7, 0xBC, 0xF0, 0x3D, 0xE7, 0xBE,
  0x07, 0xBC, 0xF7, 0x80, 0xF7, 0x9E, 0xF0, 0x1F, 0xE3, 0xFE, 0x03, 0xFC,
  0x7F, 0x80, 0x7F, 0x0F, 0xF0, 0x0F, 0xE1, 0xFC, 0x01, 0xF8, 0x3F, 0x80,
  0x3F, 0x07, 0xF0, 0x07, 0xE0, 0xFC, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x03,
  0xE0, 0xFC, 0x0F, 0x83, 0xE0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x01, 0xE3,
  0xE0, 0x07, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0x78,
  0x00, 0xF9, 0xE0, 0x03, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0xF8, 0x7C, 0x03,
  0xE1, 0xF0, 0x1F, 0x03, 0xE0, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0xFC, 0x0F,
  0x9E, 0x0F, 0x8F, 0x07, 0x87, 0x87, 0xC3, 0xE7, 0xC1, 0xF3, 0xE0, 0xFB,
  0xE0, 0x3D, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFF, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x1F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC3, 0xC7, 0x8F, 0x1E, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x80, 0x1E, 0x00,
  0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xFC, 0x03,
  0xFC, 0x07, 0xBC, 0x0F, 0x1C, 0x0F, 0x1E, 0x1E, 0x1E, 0x3C, 0x1E, 0x3C,
  0x0E, 0x78, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0xF9, 0xF1, 0xE1,
  0xC3, 0xC0, 0x07, 0xCF, 0x87, 0xF7, 0x87, 0xFF, 0xC7, 0xFF, 0xE3, 0xE3,
  0xF3, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x3E,
  0x0F, 0x1F, 0x0F, 0x8F, 0x87, 0xC7, 0xC3, 0xE3, 0xE3, 0xE1, 0xFF, 0xF0,
  0xFF, 0xF8, 0x3F, 0xBC, 0x0F, 0x9E, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x3E, 0x07, 0xBF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xF0, 0xF8, 0xF8,
  0x7C, 0x78, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0x1E, 0x0F, 0x8F, 0x07, 0xC7,
  0x83, 0xE7, 0xC1, 0xE3, 0xE1, 0xF1, 0xF1, 0xF8, 0xFF, 0xF8, 0x7F, 0xF8,
  0x7B, 0xF8, 0x3C, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0xF1, 0xFF, 0x8F, 0xFE,
  0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x82, 0x3F, 0xF8, 0x7F, 0xE1, 0xFF,
  0x83, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x07, 0xEF, 0x03,
  0xFB, 0xC1, 0xFF, 0xF0, 0xFD, 0xFC, 0x3E, 0x3F, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x78, 0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xC3, 0xE0, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x8F, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F,
  0xDE, 0x03, 0xE7, 0x80, 0x03, 0xF8, 0x1F, 0xF8, 0x7F, 0xF0, 0xF9, 0xF3,
  0xE3, 0xEF, 0x87, 0xDF, 0x0F, 0x3C, 0x7E, 0xFF, 0xF9, 0xFF, 0xE3, 0xFE,
  0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x04, 0x7E, 0x38, 0x7F, 0xF0,
  0xFF, 0xE0, 0x7F, 0x80, 0x00, 0x03, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x07, 0xE4, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF7, 0xC1, 0xFD, 0xE0, 0xFF, 0xF8, 0x7F,
  0xFE, 0x1F, 0x1F, 0x8F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x7C, 0x1F,
  0x1F, 0x07, 0xC7, 0xC1, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x1F, 0x87,
  0xC7, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x01, 0xF7, 0xC0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x3E, 0x08, 0x1F, 0x83, 0xDF, 0xC0, 0xFF, 0xE0,
  0x3F, 0xF8, 0x0F, 0xF8, 0x00, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x3E, 0x0F,
  0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x1F, 0x8F, 0x1F, 0x0F, 0x1F, 0x0F, 0x3E,
  0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3C, 0x1E, 0x3C, 0x1E, 0x7C, 0x3E, 0x7C,
  0x3E, 0x7C, 0x3E, 0x78, 0x3C, 0x78, 0x3C, 0xF8, 0x7C, 0xF8, 0x7C, 0x01,
  0x01, 0xF0, 0x7C, 0x1F, 0x07, 0x80, 0x40, 0x00, 0x00, 0x0F, 0x83, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x3E, 0x0F, 0x80, 0x00, 0x10, 0x00,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00,
  0x7C, 0x01, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x07, 0xC3, 0xC3, 0xE0, 0xF1, 0xF0,
  0x7C, 0xF8, 0x1F, 0x7C, 0x07, 0x9E, 0x01, 0xEF, 0x80, 0xFF, 0xC0, 0x3F,
  0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x7C, 0xF8, 0x1F, 0x3E,
  0x07, 0x8F, 0x81, 0xE1, 0xE0, 0x78, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC0,
  0x03, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x3E, 0x0F, 0x80, 0x0F, 0x7E,
  0x3F, 0x07, 0x7F, 0xBF, 0x83, 0xBF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xF1,
  0xF8, 0xF8, 0xF8, 0x7C, 0x7C, 0x78, 0x7C, 0x3E, 0x7C, 0x3E, 0x1E, 0x3E,
  0x1F, 0x0F, 0x1F, 0x0F, 0x0F, 0x8F, 0x07, 0x87, 0xC7, 0x87, 0xC3, 0xE7,
  0xC3, 0xE1, 0xE3, 0xE1, 0xE0, 0xF1, 0xE0, 0xF0, 0xF8, 0xF0, 0x78, 0x7C,
  0x78, 0x7C, 0x3E, 0x7C, 0x3E, 0x1E, 0x3E, 0x1E, 0x1F, 0x00, 0x0F, 0x3E,
  0x0E, 0xFF, 0x0E, 0xFF, 0x1F, 0xFF, 0x1F, 0x8F, 0x1F, 0x0F, 0x1F, 0x0F,
  0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3C, 0x1E, 0x3C, 0x1E, 0x7C, 0x3E,
  0x7C, 0x3E, 0x7C, 0x3E, 0x78, 0x3C, 0x78, 0x3C, 0xF8, 0x7C, 0xF8, 0x7C,
  0x00, 0x40, 0x0F, 0xF0, 0x3F, 0xF0, 0xFF, 0xE3, 0xFF, 0xE7, 0xC7, 0xDF,
  0x0F, 0xBE, 0x0F, 0x78, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83,
  0xDF, 0x0F, 0xBE, 0x1F, 0x7C, 0x7C, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0x80,
  0xFE, 0x00, 0x03, 0xCF, 0x80, 0x7F, 0xF8, 0x0E, 0xFF, 0x03, 0xFB, 0xE0,
  0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xC1,
  0xE0, 0xF8, 0x3C, 0x1F, 0x07, 0x83, 0xE1, 0xF0, 0x78, 0x3E, 0x1F, 0x07,
  0xC7, 0xE0, 0xFF, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0xFB, 0xE0, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE7, 0x87, 0xF7, 0x87,
  0xFF, 0xC7, 0xEF, 0xE3, 0xE3, 0xF3, 0xE1, 0xF1, 0xF0, 0xF8, 0xF0, 0x7C,
  0x78, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0x1F, 0x07, 0x8F, 0x87, 0xC7, 0xC3,
  0xE3, 0xE3, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xBE, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x0F, 0x3C, 0x3D, 0xE1, 0xFF, 0x87, 0xFE,
  0x1F, 0xE8, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0x80, 0x00, 0x07, 0xF8, 0x7F, 0xF1, 0xFF, 0x8F, 0xCE, 0x3E, 0x08,
  0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC,
  0x01, 0xF0, 0x07, 0xC8, 0x1F, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x0F, 0xF8,
  0x00, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x81, 0xFE, 0xFF, 0xDF, 0xFB, 0xFF,
  0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78,
  0x0F, 0x03, 0xE0, 0x7F, 0x8F, 0xF0, 0xFE, 0x0F, 0xC0, 0x1E, 0x0F, 0x1E,
  0x0F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x3E, 0x7C,
  0x3E, 0x7C, 0x3E, 0x78, 0x3C, 0x78, 0x3C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8,
  0x7C, 0xF8, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0x78, 0x7E, 0x70, 0xF0,
  0x3F, 0xE0, 0x7B, 0xC1, 0xF7, 0xC3, 0xCF, 0x8F, 0x9F, 0x1E, 0x3E, 0x7C,
  0x7C, 0xF0, 0xF9, 0xE0, 0xF7, 0x81, 0xEF, 0x03, 0xFE, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0xF8,
  0x7C, 0x3F, 0xE1, 0xF8, 0x7B, 0xC3, 0xF0, 0xF7, 0x87, 0xE3, 0xEF, 0x1F,
  0xC7, 0x9E, 0x3F, 0x9F, 0x3C, 0xFF, 0x3C, 0x79, 0xFE, 0x78, 0xF3, 0xBD,
  0xE1, 0xEF, 0x7B, 0xC3, 0xDC, 0xFF, 0x87, 0xB9, 0xFE, 0x0F, 0xF3, 0xFC,
  0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0x7E, 0x1F, 0xC0, 0xFC, 0x3F, 0x01,
  0xF8, 0x7E, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0xF8, 0xF8, 0x1F,
  0x3E, 0x01, 0xE7, 0xC0, 0x3D, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x1F, 0xF8, 0x07, 0xDF, 0x00, 0xF1, 0xE0, 0x3E, 0x3E, 0x0F, 0x87,
  0xC3, 0xF0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0xC3, 0xE0,
  0x7C, 0x3C, 0x07, 0xC7, 0xC0, 0x3C, 0x7C, 0x03, 0xCF, 0x80, 0x3C, 0xF8,
  0x03, 0xCF, 0x00, 0x3D, 0xF0, 0x03, 0xDE, 0x00, 0x3F, 0xE0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0xFF, 0xE0, 0x07, 0x80, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x0F, 0x80, 0x3F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0x80,
  0x00, 0x3C, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xE0, 0x0F, 0x80, 0x3C,
  0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x81, 0xFC,
  0x07, 0xE0, 0x1E, 0x00, 0xFE, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x0F,
  0xE0, 0x1F, 0x80, 0x3E, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0x80, 0x0F, 0x80, 0x7F, 0x01, 0xFC, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x07, 0xF0, 0x0F, 0xC0, 0x1E, 0x03, 0xF8, 0x1F, 0xC0, 0x7C, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x07, 0xE0,
  0x3F, 0x80, 0xFC, 0x03, 0xE0, 0x0C, 0x00, 0x00, 0x3F, 0x01, 0x7F, 0xC7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x80, 0x10,
};

const GFXglyph NotoSans_Condensed_BoldItalic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 10, 25, 9, 0, -25 },
  { 33, 13, 9, 14, 3, -25 },
  { 48, 19, 25, 18, 0, -25 },
  { 108, 17, 29, 16, 0, -27 },
  { 170, 23, 25, 26, 2, -25 },
  { 242, 20, 25, 20, 0, -25 },
  { 305, 6, 9, 9, 3, -25 },
  { 312, 12, 31, 10, 1, -25 },
  { 359, 12, 31, 10, -3, -25 },
  { 406, 14, 15, 16, 3, -27 },
  { 433, 15, 17, 17, 2, -21 },
  { 465, 8, 9, 9, -2, -4 },
  { 474, 10, 5, 10, 0, -12 },
  { 481, 6, 5, 9, 0, -5 },
  { 485, 18, 25, 14, -2, -25 },
  { 542, 15, 25, 16, 1, -25 },
  { 589, 12, 25, 16, 3, -25 },
  { 627, 17, 25, 16, -1, -25 },
  { 681, 17, 25, 16, 0, -25 },
  { 735, 17, 25, 16, 0, -25 },
  { 789, 17, 25, 16, 0, -25 },
  { 843, 16, 25, 16, 1, -25 },
  { 893, 17, 25, 16, 1, -25 },
  { 947, 17, 25, 16, 0, -25 },
  { 1001, 16, 25, 16, 0, -25 },
  { 1051, 9, 19, 9, 0, -19 },
  { 1073, 11, 24, 9, -2, -19 },
  { 1106, 16, 17, 17, 1, -21 },
  { 1140, 16, 11, 17, 1, -18 },
  { 1162, 15, 17, 17, 2, -21 },
  { 1194, 13, 25, 13, 1, -25 },
  { 1235, 24, 28, 25, 1, -25 },
  { 1319, 18, 25, 18, -2, -25 },
  { 1376, 18, 25, 18, 0, -25 },
  { 1433, 18, 25, 17, 1, -25 },
  { 1490, 19, 25, 20, 0, -25 },
  { 1550, 17, 25, 15, 0, -25 },
  { 1604, 17, 25, 15, 0, -25 },
  { 1658, 20, 25, 20, 1, -25 },
  { 1721, 21, 25, 20, 0, -25 },
  { 1787, 15, 25, 12, -1, -25 },
  { 1834, 16, 32, 10, -5, -25 },
  { 1898, 21, 25, 18, 0, -25 },
  { 1964, 13, 25, 15, 0, -25 },
  { 2005, 27, 25, 26, 0, -25 },
  { 2090, 23, 25, 22, 0, -25 },
  { 2162, 20, 25, 21, 1, -25 },
  { 2225, 19, 25, 18, 0, -25 },
  { 2285, 20, 31, 21, 1, -25 },
  { 2363, 18, 25, 18, 0, -25 },
  { 2420, 17, 25, 16, 0, -25 },
  { 2474, 15, 25, 15, 3, -25 },
  { 2521, 19, 25, 20, 2, -25 },
  { 2581, 18, 25, 18, 3, -25 },
  { 2638, 27, 25, 27, 3, -25 },
  { 2723, 22, 25, 17, -2, -25 },
  { 2792, 17, 25, 16, 3, -25 },
  { 2846, 18, 25, 15, -1, -25 },
  { 2903, 14, 31, 10, -1, -25 },
  { 2958, 7, 25, 14, 4, -25 },
  { 2980, 14, 31, 10, -2, -25 },
  { 3035, 16, 15, 16, 0, -25 },
  { 3065, 12, 2, 12, -3, 3 },
  { 3068, 7, 6, 11, 5, -27 },
  { 3074, 17, 19, 18, 1, -19 },
  { 3115, 17, 27, 18, 0, -27 },
  { 3173, 14, 19, 14, 1, -19 },
  { 3207, 18, 27, 18, 1, -27 },
  { 3268, 15, 19, 16, 1, -19 },
  { 3304, 19, 35, 11, -4, -27 },
  { 3388, 18, 27, 18, 0, -19 },
  { 3449, 16, 27, 18, 0, -27 },
  { 3503, 10, 27, 9, 0, -27 },
  { 3537, 14, 35, 9, -4, -27 },
  { 3599, 18, 27, 16, 0, -27 },
  { 3660, 10, 27, 9, 0, -27 },
  { 3694, 25, 19, 26, 0, -19 },
  { 3754, 16, 19, 18, 0, -19 },
  { 3792, 15, 20, 17, 1, -20 },
  { 3830, 19, 27, 18, -2, -19 },
  { 3895, 17, 27, 18, 1, -19 },
  { 3953, 14, 19, 12, 0, -19 },
  { 3987, 14, 19, 14, 0, -19 },
  { 4021, 11, 23, 11, 1, -23 },
  { 4053, 16, 19, 17, 1, -19 },
  { 4091, 15, 19, 15, 2, -19 },
  { 4127, 23, 19, 23, 2, -19 },
  { 4182, 19, 19, 16, -2, -19 },
  { 4228, 20, 27, 15, -3, -19 },
  { 4296, 15, 19, 13, -1, -19 },
  { 4332, 14, 31, 12, 0, -25 },
  { 4387, 4, 35, 15, 5, -27 },
  { 4405, 14, 31, 12, -2, -25 },
  { 4460, 16, 6, 17, 1, -15 },
};

const GFXfont NotoSans_Condensed_BoldItalic35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BoldItalic35pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BoldItalic35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_CONDENSED_BOLDITALIC35PT7B_H_
