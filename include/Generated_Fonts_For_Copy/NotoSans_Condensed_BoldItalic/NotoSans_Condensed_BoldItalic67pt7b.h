#ifndef _NOTOSANS_CONDENSED_BOLDITALIC67PT7B_H_
#define _NOTOSANS_CONDENSED_BOLDITALIC67PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BoldItalic.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BoldItalic67pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF0,
  0x00, 0x1C, 0x00, 0x00, 0x1F, 0xF1, 0xFF, 0x1F, 0xE1, 0xFF, 0x1F, 0xE1,
  0xFF, 0x3F, 0xE1, 0xFE, 0x3F, 0xE1, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0xC3,
  0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0x83, 0xFC, 0x3F, 0x83, 0xFC, 0x7F, 0x83,
  0xF8, 0x7F, 0x83, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x07, 0xF8, 0x7F, 0x07,
  0xF0, 0x7E, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x3F,
  0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x20, 0xFE, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF8,
  0x3F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0xFE, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xEE, 0x3E, 0x00, 0xFF, 0x9C, 0x1C, 0x03,
  0xFE, 0x38, 0x10, 0x07, 0xFC, 0x70, 0x00, 0x0F, 0xF9, 0xE0, 0x00, 0x1F,
  0xF3, 0x80, 0x00, 0x3F, 0xE7, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0E, 0x7F,
  0xC0, 0x00, 0x1C, 0xFF, 0x80, 0x00, 0x39, 0xFF, 0x08, 0x00, 0xF3, 0xFE,
  0x08, 0x01, 0xC7, 0xFC, 0x1C, 0x03, 0x8F, 0xF8, 0x7E, 0x07, 0x3F, 0xF0,
  0xFF, 0xCF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x01, 0xFF,
  0xC0, 0x00, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xE0,
  0x01, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0xF0, 0x03,
  0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x0F, 0xE0,
  0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x1F, 0xC0, 0x07,
  0xF0, 0x7F, 0x01, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x3F, 0x80, 0x07, 0xE0,
  0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x1F,
  0xC0, 0x00, 0xFC, 0x0F, 0xE3, 0xF8, 0x00, 0x0F, 0xC1, 0xFC, 0x3F, 0x80,
  0x00, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x8F, 0xC1, 0xFC, 0x7E, 0x1F, 0xFC,
  0xFC, 0x3F, 0x8F, 0xE3, 0xFF, 0xEF, 0xE7, 0xF9, 0xFC, 0x7F, 0xFE, 0xFF,
  0xFF, 0x1F, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xF8, 0xFF, 0xFF, 0xFF, 0xFE,
  0x3F, 0x1F, 0xC7, 0xF7, 0xFF, 0xC7, 0xF1, 0xFC, 0x7F, 0x3F, 0xF8, 0xFE,
  0x3F, 0x83, 0xF1, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x01, 0x01, 0xFC, 0x7F,
  0x07, 0xF0, 0x00, 0x1F, 0x87, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x07,
  0xF0, 0x00, 0x7F, 0x07, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x07, 0xF0,
  0x00, 0xFE, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x01,
  0xFC, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x03, 0xF8,
  0x0F, 0xE0, 0xFC, 0x00, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F,
  0xE1, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xFF,
  0xF8, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xE0,
  0x07, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0x80, 0x0F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00,
  0x7F, 0xC3, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF,
  0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x7F,
  0xC1, 0xFE, 0x00, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0xFF, 0x00,
  0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x0F, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0x81, 0xFF,
  0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xE1, 0xFF, 0xFF, 0xE1, 0xFE,
  0x0F, 0xF9, 0xFF, 0x1F, 0xF0, 0xFF, 0x8F, 0xFC, 0xFF, 0x0F, 0xF8, 0x3F,
  0xEF, 0xF8, 0x7F, 0xC1, 0xFF, 0xFF, 0x87, 0xFC, 0x07, 0xFF, 0xFC, 0x3F,
  0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xF8, 0x07, 0xFF,
  0xE0, 0x7F, 0xC0, 0x1F, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xF0,
  0x07, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFE, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xCF, 0xFC, 0x03,
  0xFF, 0xFC, 0x7F, 0xF0, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xE7, 0xFC, 0xFF, 0x1F, 0xE7, 0xFC, 0xFF, 0x9F, 0xE3,
  0xFC, 0x7F, 0x8F, 0xE1, 0xFC, 0x7F, 0x8F, 0xF1, 0xFC, 0x3F, 0x87, 0xF0,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x20, 0x1F, 0xC0,
  0x07, 0x03, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0x3F, 0x8F, 0xC0, 0x07, 0xFD,
  0xF8, 0x3D, 0xFF, 0xFE, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xC7, 0xE0, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x01,
  0xFF, 0xBF, 0x80, 0x7F, 0xE7, 0xF0, 0x0F, 0xF8, 0xFF, 0x00, 0xFE, 0x0F,
  0xE0, 0x0F, 0xC1, 0xFE, 0x00, 0xF0, 0x3F, 0xC0, 0x0C, 0x07, 0xE0, 0x00,
  0x80, 0x70, 0x00, 0x00, 0x08, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x81,
  0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x81, 0xFE,
  0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x00,
  0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0xBF,
  0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0x0F, 0x87, 0xF9, 0xFF, 0xBF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xCF, 0xE0, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x7F, 0xC1, 0xFF,
  0x83, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0xC0, 0xFF, 0x87, 0xFC, 0x07,
  0xFC, 0x3F, 0xE0, 0x3F, 0xE3, 0xFE, 0x01, 0xFF, 0x1F, 0xF0, 0x0F, 0xF8,
  0xFF, 0x80, 0x7F, 0xCF, 0xF8, 0x03, 0xFE, 0x7F, 0xC0, 0x1F, 0xF3, 0xFE,
  0x00, 0xFF, 0xBF, 0xE0, 0x07, 0xFD, 0xFF, 0x00, 0x7F, 0xEF, 0xF8, 0x03,
  0xFE, 0x7F, 0xC0, 0x1F, 0xF3, 0xFE, 0x00, 0xFF, 0xBF, 0xE0, 0x07, 0xFD,
  0xFF, 0x00, 0x7F, 0xEF, 0xF8, 0x03, 0xFE, 0x7F, 0xC0, 0x1F, 0xF3, 0xFE,
  0x00, 0xFF, 0x9F, 0xF0, 0x0F, 0xFC, 0xFF, 0x80, 0x7F, 0xC7, 0xF8, 0x03,
  0xFE, 0x3F, 0xC0, 0x3F, 0xF1, 0xFE, 0x01, 0xFF, 0x0F, 0xF0, 0x0F, 0xF8,
  0x7F, 0x80, 0xFF, 0x83, 0xFC, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0xE0, 0xFF,
  0x87, 0xFE, 0x07, 0xFE, 0x7F, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xCF, 0xFE,
  0xFF, 0x8F, 0xF9, 0xFF, 0x0F, 0xE3, 0xFC, 0x1F, 0x8F, 0xF8, 0x1E, 0x1F,
  0xF0, 0x10, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xE7, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0xC0,
  0x0F, 0x80, 0x3F, 0xE0, 0x07, 0x80, 0x1F, 0xF0, 0x01, 0x80, 0x0F, 0xF8,
  0x00, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0x8F, 0xFF, 0x80, 0x1E, 0x01, 0xFF, 0xC0, 0x04,
  0x00, 0x7F, 0xE0, 0x02, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC1, 0x80, 0x00,
  0xFF, 0xE0, 0xE0, 0x00, 0xFF, 0xE0, 0x7F, 0x01, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F,
  0xBF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xDF, 0xF0, 0x00, 0x0F,
  0xEF, 0xF0, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x0F, 0xE7, 0xFC, 0x00, 0x07,
  0xE3, 0xFE, 0x00, 0x07, 0xF1, 0xFF, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x03,
  0xF0, 0x7F, 0x80, 0x03, 0xF8, 0x7F, 0xC0, 0x03, 0xF8, 0x3F, 0xE0, 0x03,
  0xF8, 0x1F, 0xE0, 0x01, 0xFC, 0x0F, 0xF0, 0x01, 0xFC, 0x0F, 0xF8, 0x01,
  0xFC, 0x07, 0xFC, 0x00, 0xFE, 0x03, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xF3, 0xFF, 0xF0, 0x01, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0xC0, 0x00,
  0xFF, 0xC0, 0xF0, 0x01, 0xFF, 0xC0, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x7F, 0xF8, 0x08, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC3, 0xF0, 0x00, 0xFF, 0x1F, 0xF8, 0x01,
  0xFE, 0x7F, 0xF8, 0x07, 0xFD, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFD, 0xFF, 0xC1, 0xFF,
  0xC0, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0x07, 0xFE, 0x03, 0xFE, 0x1F, 0xF8,
  0x07, 0xFC, 0x3F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF0, 0xFF, 0x80,
  0x3F, 0xE1, 0xFF, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0xFF, 0x87, 0xFC, 0x03,
  0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F,
  0xF0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xCF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0x83, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE,
  0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x03, 0xFE,
  0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x01, 0xFF,
  0x07, 0xFC, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xC0, 0x1F, 0xFC,
  0x7F, 0xE0, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xC0,
  0x0F, 0xF0, 0xFF, 0x80, 0x0F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0xC0,
  0x1F, 0xF0, 0xFF, 0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0xE0,
  0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x9F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xC0, 0x7F, 0xC3, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x3F,
  0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0xC7, 0xFC, 0x01, 0xFF, 0x1F, 0xF0,
  0x07, 0xFC, 0x7F, 0xC0, 0x1F, 0xF1, 0xFF, 0x00, 0xFF, 0xC7, 0xFC, 0x03,
  0xFF, 0x1F, 0xF0, 0x0F, 0xFC, 0x7F, 0xC0, 0x7F, 0xE1, 0xFF, 0x01, 0xFF,
  0x87, 0xFC, 0x0F, 0xFE, 0x1F, 0xFC, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0x7F, 0x80, 0x3F, 0xF1, 0xFE, 0x00, 0x3F, 0x8F, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x03, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0x80, 0x7F,
  0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFE, 0x00, 0xFE, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x03, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x81,
  0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x07, 0xF0,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xC1, 0xFF, 0x87, 0x00, 0x7F,
  0xC2, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x3F, 0x80, 0x06, 0x00, 0x3F, 0x81, 0xFC, 0x03, 0xFF, 0xC0,
  0xFC, 0x1F, 0xC0, 0x7F, 0xFF, 0x87, 0xE0, 0xFC, 0x07, 0xFF, 0xF8, 0x3F,
  0x0F, 0xE0, 0x7F, 0xFF, 0xC1, 0xF8, 0x7E, 0x07, 0xFF, 0xFE, 0x0F, 0xC7,
  0xF0, 0x7F, 0x87, 0xF0, 0x7E, 0x3F, 0x03, 0xF8, 0x3F, 0x03, 0xF3, 0xF8,
  0x3F, 0x81, 0xF8, 0x1F, 0x9F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0xFC, 0x1F,
  0xC0, 0xFE, 0x07, 0xE7, 0xE0, 0xFC, 0x07, 0xF0, 0x3F, 0x7E, 0x07, 0xE0,
  0x3F, 0x03, 0xF3, 0xF0, 0x7F, 0x01, 0xF8, 0x1F, 0x9F, 0x83, 0xF0, 0x1F,
  0xC0, 0xFC, 0xFC, 0x1F, 0x80, 0xFE, 0x07, 0xEF, 0xE0, 0xFC, 0x07, 0xE0,
  0x7E, 0x7E, 0x0F, 0xE0, 0x7F, 0x03, 0xF3, 0xF0, 0x7F, 0x03, 0xF8, 0x1F,
  0x9F, 0x83, 0xF8, 0x1F, 0xC1, 0xF8, 0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0xC7,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x3F, 0x07, 0xF0, 0xFF, 0x8F, 0xC1, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7E, 0x07,
  0xFF, 0x9F, 0xFE, 0x03, 0xF0, 0x1F, 0xF8, 0xFF, 0xE0, 0x1F, 0xC0, 0x7F,
  0x83, 0xFC, 0x00, 0x7E, 0x00, 0x60, 0x03, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x38, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xC0, 0x00,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xBF, 0x80, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xBF, 0xC0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x01, 0xFE, 0xFF, 0x00,
  0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x03, 0xFC, 0x7F,
  0x80, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x03, 0xFC,
  0x3F, 0xE0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x07,
  0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0xC0,
  0x07, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x3F,
  0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xC0, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x1F,
  0xF0, 0x7F, 0xC0, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x7F, 0xC3, 0xFE, 0x00,
  0x0F, 0xF8, 0xFF, 0xC0, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x3F, 0xE7, 0xFE,
  0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x1F, 0xF7,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0xE0, 0x0F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x07,
  0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x1F,
  0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x0F,
  0xF8, 0x0F, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xE0,
  0x0F, 0xFC, 0x0F, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xF8, 0x07, 0x80, 0x3F, 0xFC, 0x00, 0x40, 0x1F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x02, 0x00,
  0x7F, 0xF0, 0x07, 0x00, 0x1F, 0xFF, 0xBF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xC3, 0xFF,
  0xE0, 0x03, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xFC,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0x00,
  0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x07, 0xFE, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x0F,
  0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x07, 0xFE, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x0F, 0xFC,
  0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x07, 0xFE, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x3F, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x0F,
  0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0xFF,
  0xE0, 0x3F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xFC, 0x1F, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3E, 0x00,
  0xFF, 0xF0, 0x00, 0x60, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0x0F,
  0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xC0, 0x3F, 0xFF, 0x87, 0xFE, 0x01, 0xFF,
  0xFC, 0x3F, 0xF0, 0x1F, 0xFF, 0xE1, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFC,
  0x07, 0xFF, 0xF0, 0x7F, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0x00, 0x07, 0xFC,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x03, 0xFE, 0x07, 0xFE, 0x00,
  0x1F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x07, 0xFC, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x03, 0xFE, 0x03, 0xFF, 0x80, 0x1F,
  0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFC, 0x03, 0xFF,
  0xFB, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xFC,
  0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x00, 0x7F,
  0xC0, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF,
  0xC0, 0x00, 0x7F, 0x81, 0xFF, 0x80, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x00,
  0xFF, 0x83, 0xFF, 0x00, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x00, 0xFF, 0x87,
  0xFC, 0x00, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x7F, 0xE0, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x00, 0x1F,
  0xF0, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x3F,
  0xF0, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x00, 0x3F, 0xC0,
  0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x01,
  0xFE, 0xFE, 0x00, 0x7F, 0x7F, 0x80, 0x1F, 0xEF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x01, 0xFE, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xEF, 0xE0, 0x1F, 0xEF,
  0xF0, 0x01, 0xFE, 0xFE, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xEF, 0xE0, 0x1F,
  0xDF, 0xF0, 0x03, 0xFC, 0xFE, 0x03, 0xFD, 0xFF, 0x00, 0x3F, 0xCF, 0xE0,
  0x3F, 0x9F, 0xE0, 0x03, 0xFC, 0xFE, 0x07, 0xF9, 0xFE, 0x00, 0x3F, 0xCF,
  0xE0, 0x7F, 0x3F, 0xE0, 0x07, 0xFC, 0xFE, 0x0F, 0xF3, 0xFE, 0x00, 0x7F,
  0x8F, 0xE0, 0xFE, 0x3F, 0xE0, 0x07, 0xF8, 0xFE, 0x1F, 0xE3, 0xFC, 0x00,
  0x7F, 0x8F, 0xE1, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0xFE, 0x3F, 0xC7, 0xFC,
  0x00, 0xFF, 0x8F, 0xE3, 0xF8, 0x7F, 0xC0, 0x0F, 0xF0, 0xFF, 0x3F, 0x87,
  0xF8, 0x00, 0xFF, 0x0F, 0xF7, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x7F,
  0x07, 0xF8, 0x01, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0xFF,
  0xFE, 0x0F, 0xF8, 0x01, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0x00, 0x1F, 0xE0,
  0xFF, 0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0x00, 0x3F,
  0xE0, 0x7F, 0xF8, 0x1F, 0xF0, 0x03, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0x00,
  0x3F, 0xC0, 0x7F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xFF, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x07, 0xFC, 0x07, 0xFE, 0x03,
  0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x07, 0xF8, 0x07, 0xFC,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x0F, 0xF8, 0x07,
  0xF8, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xE0, 0x07, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0x1F, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xE0, 0x03, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xF0, 0x03, 0xFF,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xE0,
  0x0F, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0xBF, 0xC0, 0x3F,
  0xC0, 0x0F, 0xF7, 0xF8, 0x07, 0xF8, 0x01, 0xFE, 0xFF, 0x01, 0xFF, 0x00,
  0x3F, 0xDF, 0xE0, 0x3F, 0xC0, 0x07, 0xF9, 0xFE, 0x07, 0xF8, 0x01, 0xFF,
  0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0xC7, 0xF8, 0x3F, 0xE0, 0x07, 0xF8, 0xFF,
  0x07, 0xFC, 0x00, 0xFF, 0x1F, 0xF0, 0xFF, 0x00, 0x1F, 0xE1, 0xFE, 0x1F,
  0xE0, 0x07, 0xFC, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0xFF, 0x80,
  0x1F, 0xE0, 0xFF, 0x1F, 0xF0, 0x03, 0xFC, 0x0F, 0xF3, 0xFC, 0x00, 0x7F,
  0x81, 0xFE, 0x7F, 0x80, 0x1F, 0xF0, 0x3F, 0xCF, 0xF0, 0x03, 0xFC, 0x07,
  0xF9, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xFF, 0xC0,
  0x0F, 0xF0, 0x07, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F,
  0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xE0,
  0x07, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x1F,
  0xE0, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFB, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x7F, 0xF0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x03,
  0xFF, 0x0F, 0xFC, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x01, 0xFF, 0x1F, 0xF8,
  0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x1F, 0xF3,
  0xFF, 0x00, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x03,
  0xFF, 0x7F, 0xE0, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x03, 0xFF, 0x7F, 0xE0,
  0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xEF,
  0xFC, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x07,
  0xFE, 0xFF, 0xC0, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x0F, 0xFC, 0xFF, 0x80,
  0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x01, 0xFF, 0x8F,
  0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x3F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0xE0,
  0x07, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03,
  0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x1F, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x1F, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x07,
  0xFC, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xFC, 0x03, 0xFE,
  0x07, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x7F, 0xF0, 0x03,
  0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x03, 0xFF, 0x0F, 0xFC,
  0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x1F, 0xF1,
  0xFF, 0x80, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x01,
  0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x03, 0xFF, 0x7F, 0xE0,
  0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x3F, 0xF7,
  0xFC, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x07,
  0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x07, 0xFC, 0xFF, 0xC0,
  0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x00, 0xFF, 0xCF,
  0xF8, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x3F,
  0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xC0,
  0x0F, 0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xC1, 0xFF, 0xC0, 0x1F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x07, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x00,
  0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8,
  0x07, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x83, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0x8F, 0xF8,
  0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x07, 0xFC, 0x1F,
  0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xF0,
  0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFC, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF8,
  0x1F, 0xF0, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0x1F, 0x00, 0x3F, 0xF0, 0x03, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x80, 0x01, 0xFF, 0x80, 0xF0, 0x00, 0xFF, 0xC0, 0x7E, 0x01,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x07, 0xFE,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x07, 0xFC, 0x07,
  0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x07, 0xFC, 0x07, 0xFE,
  0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF8,
  0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x07, 0xFC, 0x07, 0xFE, 0x00,
  0x3F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x3F,
  0xE0, 0x3F, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xE0,
  0x3F, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x3F,
  0xE0, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xFC,
  0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x1F, 0xF3, 0xFE, 0x00,
  0x07, 0xFC, 0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0x8F, 0xF8,
  0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x07, 0xFC, 0x3F,
  0xE0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xC0,
  0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFE,
  0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x1F,
  0xF0, 0x07, 0xF8, 0x0F, 0xF8, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0x81,
  0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFE,
  0x0F, 0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x07,
  0xF8, 0x7F, 0xC0, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x7F, 0x8F, 0xF8, 0x00,
  0x1F, 0xE7, 0xFC, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x01, 0xFE, 0x7F, 0x80,
  0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x07, 0xFB, 0xFC,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x03,
  0xFC, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x7F,
  0x80, 0x07, 0xFC, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC,
  0x7F, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0x87, 0xF8, 0x01, 0xFF, 0xC0, 0x0F,
  0xF8, 0x7F, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0x07, 0xF8, 0x01, 0xFF, 0xC0,
  0x1F, 0xF0, 0x7F, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0x07, 0xF8, 0x03, 0xFF,
  0xC0, 0x3F, 0xE0, 0x7F, 0x80, 0x7F, 0xFC, 0x03, 0xFE, 0x07, 0xF8, 0x07,
  0xFF, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0xFC, 0x07, 0xFC, 0x07, 0xF8,
  0x0F, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0xFC, 0x0F, 0xF8, 0x07,
  0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0x81, 0xFD, 0xFC, 0x0F, 0xF0,
  0x07, 0xF8, 0x1F, 0xDF, 0xC1, 0xFF, 0x00, 0x7F, 0x83, 0xF9, 0xFC, 0x1F,
  0xF0, 0x07, 0xF8, 0x3F, 0x9F, 0xC3, 0xFE, 0x00, 0x7F, 0x87, 0xF9, 0xFC,
  0x3F, 0xE0, 0x07, 0xF8, 0x7F, 0x1F, 0xC3, 0xFC, 0x00, 0x7F, 0x8F, 0xF1,
  0xFC, 0x7F, 0xC0, 0x07, 0xF8, 0xFF, 0x1F, 0xC7, 0xFC, 0x00, 0x7F, 0x8F,
  0xE1, 0xFC, 0xFF, 0x80, 0x07, 0xF9, 0xFE, 0x1F, 0xCF, 0xF8, 0x00, 0x7F,
  0x9F, 0xC1, 0xFC, 0xFF, 0x00, 0x07, 0xFB, 0xFC, 0x1F, 0xDF, 0xF0, 0x00,
  0x7F, 0xBF, 0xC1, 0xFD, 0xFE, 0x00, 0x07, 0xFB, 0xF8, 0x3F, 0xDF, 0xE0,
  0x00, 0x7F, 0xFF, 0x83, 0xFB, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x3F, 0xBF,
  0xC0, 0x00, 0x7F, 0x7F, 0x03, 0xFB, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x07, 0xFE, 0x00,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x00, 0x1F,
  0xF0, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x00, 0x0F, 0xF1, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x00,
  0x3F, 0xEF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xEF,
  0xF8, 0x00, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x7F, 0x80,
  0x00, 0x03, 0xFF, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x00,
  0x7F, 0xC1, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE,
  0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x7F,
  0xC7, 0xFC, 0x01, 0xFF, 0x8F, 0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x0F, 0xFC,
  0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x80,
  0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x07,
  0xFC, 0x7F, 0xC0, 0x0F, 0xF8, 0xFF, 0x80, 0x0F, 0xF3, 0xFE, 0x00, 0x1F,
  0xE7, 0xFC, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8,
  0x1F, 0xE0, 0x3F, 0x80, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F,
  0xE0, 0x7F, 0x81, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x01, 0xFD, 0xFE, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x07,
  0xF8, 0x1F, 0xC0, 0x1F, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0xFF,
  0x00, 0x7F, 0x03, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xE0,
  0x03, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0xFF, 0x00, 0x07, 0xF3, 0xFC, 0x00,
  0x0F, 0xE7, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xC7,
  0xFE, 0x1F, 0xF0, 0xFF, 0xC3, 0xFE, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x07,
  0xF0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x7F, 0xF0, 0xFE, 0x00,
  0xFF, 0xF9, 0xFE, 0x01, 0xFF, 0xF9, 0xFE, 0x03, 0xFF, 0xFD, 0xFE, 0x03,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x7F, 0xFC, 0x0F,
  0xFC, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xF8, 0x0F, 0xFC, 0x3F,
  0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F,
  0xE0, 0x0F, 0xF8, 0x7F, 0xE0, 0x0F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F,
  0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0xFF, 0xC0, 0x1F, 0xF0, 0xFF,
  0x80, 0x1F, 0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF,
  0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0x80, 0x7F, 0xC0, 0xFF,
  0x80, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0xC0, 0xFF,
  0xC3, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0x7F, 0x80, 0x7F, 0xFF, 0x7F, 0x80, 0x3F, 0xFE, 0x7F, 0x00, 0x1F,
  0xFC, 0x7F, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x00,
  0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0x7F, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x01,
  0xFE, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xC7, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x03,
  0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x07,
  0xFC, 0x01, 0xFF, 0x07, 0xF8, 0x01, 0xFF, 0x07, 0xF8, 0x01, 0xFF, 0x0F,
  0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xF0, 0x03, 0xFE, 0x0F,
  0xF0, 0x03, 0xFE, 0x1F, 0xF0, 0x03, 0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x1F,
  0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F,
  0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF0, 0x3F,
  0xF0, 0x3F, 0xF0, 0x3F, 0xF8, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0x7F, 0xFF, 0x00, 0x7F,
  0x3F, 0xFE, 0x00, 0xFF, 0x1F, 0xFC, 0x00, 0xFE, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFC, 0xF8, 0x0F, 0xFE, 0x03, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x04, 0x0F, 0xFC, 0x03, 0x01, 0xFF, 0xC1, 0xE0, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x8F, 0xF0, 0x00, 0xFF,
  0xFB, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0x7F, 0xF8,
  0x03, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF0,
  0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xE0, 0x1F,
  0xF0, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x0F,
  0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0,
  0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F,
  0xF0, 0x1F, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xE1, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFB, 0xFC, 0x00, 0x3F, 0xFE, 0x7F, 0x00, 0x03, 0xFF,
  0x8F, 0xE0, 0x00, 0x3F, 0xE1, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xF0, 0x7F, 0xC1, 0xFF, 0x0F, 0xF8, 0x0F, 0xF1, 0xFF, 0x00, 0xFF, 0x1F,
  0xF0, 0x0F, 0xF1, 0xFE, 0x00, 0xFF, 0x3F, 0xE0, 0x1F, 0xF3, 0xFC, 0x03,
  0xFE, 0x7F, 0xC0, 0x7F, 0xE7, 0xFC, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x02, 0x0F, 0xFC, 0x00, 0xE0, 0x7F, 0xF0, 0x7E,
  0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x8C, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0xC3, 0xF8,
  0x00, 0x7F, 0xFC, 0xFF, 0x00, 0x1F, 0xFF, 0xDF, 0xE0, 0x07, 0xFF, 0xFB,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0x7F, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x0F,
  0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xE0,
  0x0F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F,
  0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x7F,
  0xE0, 0x0F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xF0,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFB, 0xFE, 0x00, 0x1F, 0xFF, 0x7F, 0x80,
  0x03, 0xFF, 0xDF, 0xF0, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x00, 0x60, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x40,
  0x00, 0xFF, 0xC0, 0x0F, 0x00, 0x3F, 0xF8, 0x01, 0xFE, 0x3F, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0xFF, 0x3F, 0xF8, 0x01,
  0xFF, 0x7F, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x07,
  0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x07,
  0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFC, 0x0F,
  0xF8, 0x07, 0xFC, 0x0F, 0xF8, 0x07, 0xFC, 0x0F, 0xF8, 0x07, 0xFC, 0x0F,
  0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F,
  0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x3F, 0xE0, 0x1F, 0xF0, 0x3F, 0xE0, 0x1F, 0xF0, 0x3F,
  0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F,
  0xC0, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0x80, 0x3F, 0xE0, 0xFF,
  0x80, 0x3F, 0xC0, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x07, 0xC0, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x07, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xE0, 0x07,
  0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0xC0,
  0x07, 0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xE1, 0xFF,
  0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x1F, 0xF7,
  0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xF3,
  0xFE, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x3F,
  0xE1, 0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x03, 0xFE, 0x00,
  0x1F, 0xE0, 0x7F, 0xC0, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0x1F, 0xF0, 0x1F, 0xF0, 0x03, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07,
  0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x0F, 0xE0,
  0x07, 0xF0, 0x00, 0xFE, 0x3F, 0xF8, 0x1F, 0xF8, 0x01, 0xFC, 0x7F, 0xF8,
  0x7F, 0xFC, 0x01, 0xFC, 0xFF, 0xFC, 0xFF, 0xFE, 0x01, 0xFD, 0xFF, 0xFD,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xE7, 0xFF, 0xE7, 0xFF, 0x03, 0xFF, 0x83, 0xFF,
  0x83, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFC,
  0x03, 0xFE, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFC, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x0F, 0xF8, 0x07, 0xF8,
  0x07, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0,
  0x1F, 0xF0, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x7F, 0xC0, 0x3F, 0xC0,
  0x3F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x7F, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0xFF, 0x80, 0x7F, 0xC0,
  0x7F, 0xC0, 0x00, 0xFC, 0x0F, 0xE0, 0x01, 0xF8, 0x3F, 0xF0, 0x07, 0xF1,
  0xFF, 0xF0, 0x0F, 0xE7, 0xFF, 0xE0, 0x1F, 0xDF, 0xFF, 0xE0, 0x3F, 0xBF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x83,
  0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x1F,
  0xF0, 0x7F, 0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x00, 0xFF,
  0x83, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x03, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8,
  0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0x00, 0x7F, 0xC3,
  0xFE, 0x00, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x1F,
  0xE0, 0x0F, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x80, 0x3F, 0xC1, 0xFF,
  0x00, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x07, 0xF8, 0x03, 0xFE, 0x1F, 0xF0,
  0x07, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0x80,
  0x7F, 0xC1, 0xFE, 0x00, 0xFF, 0x87, 0xFC, 0x01, 0xFE, 0x0F, 0xF8, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xEF, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0xFF,
  0xC0, 0x7F, 0xC7, 0xFC, 0x03, 0xFE, 0x7F, 0xE0, 0x1F, 0xF3, 0xFE, 0x00,
  0xFF, 0x9F, 0xF0, 0x07, 0xFD, 0xFF, 0x00, 0x3F, 0xEF, 0xF8, 0x01, 0xFF,
  0x7F, 0xC0, 0x0F, 0xFB, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFD, 0xFF,
  0x00, 0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0x7F, 0xC0, 0x0F, 0xFB, 0xFE, 0x00,
  0x7F, 0xDF, 0xF0, 0x07, 0xFC, 0xFF, 0x80, 0x3F, 0xE7, 0xFC, 0x03, 0xFF,
  0x3F, 0xE0, 0x1F, 0xF1, 0xFF, 0x01, 0xFF, 0x8F, 0xF8, 0x1F, 0xF8, 0x7F,
  0xE1, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x03, 0xF0, 0xFF, 0xE0, 0x00, 0xFE, 0x3F, 0xFE, 0x00, 0x1F, 0xCF,
  0xFF, 0xC0, 0x03, 0xFB, 0xFF, 0xFC, 0x00, 0x7F, 0x7F, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xC7, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xE0,
  0x0F, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xC0,
  0x0F, 0xF8, 0x07, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F,
  0xE0, 0x0F, 0xF8, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xE0,
  0x1F, 0xE0, 0x07, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x7F,
  0xE0, 0x7F, 0xE0, 0x0F, 0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFE, 0xFF, 0xFE,
  0x00, 0x3F, 0xCF, 0xFF, 0x80, 0x0F, 0xF9, 0xFF, 0xE0, 0x01, 0xFF, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x70, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x3F, 0xF0, 0xFE, 0x00, 0x7F, 0xF8, 0xFE,
  0x00, 0xFF, 0xFD, 0xFE, 0x01, 0xFF, 0xFD, 0xFE, 0x03, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFE, 0x3F, 0xFC, 0x0F, 0xFC, 0x1F, 0xFC,
  0x0F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8,
  0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8,
  0x7F, 0xC0, 0x0F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0,
  0x7F, 0xC0, 0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0xE0,
  0xFF, 0x80, 0x1F, 0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xE0,
  0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0xC0,
  0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFE, 0xFF, 0x00, 0x1F, 0xFC, 0xFF, 0x00,
  0x0F, 0xF1, 0xFF, 0x00, 0x03, 0xC1, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x0F, 0xE0,
  0x1F, 0xC7, 0xF8, 0x07, 0xF9, 0xFF, 0x00, 0xFF, 0x7F, 0xE0, 0x1F, 0xEF,
  0xFC, 0x03, 0xFB, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x10, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xE0, 0x7F, 0xE0, 0x78, 0x0F, 0xF8, 0x03, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x40, 0x03, 0xFF, 0x0C,
  0x00, 0x7F, 0xC1, 0xE0, 0x1F, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0x0F, 0xFF, 0xF9, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8, 0x3F,
  0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x20, 0x7F,
  0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x38, 0x00, 0x00, 0x03, 0xFC, 0x01,
  0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F,
  0xF0, 0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x83, 0xFE, 0x01, 0xFF,
  0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF0, 0x07, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0,
  0x7F, 0xC0, 0x1F, 0xE0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x00, 0xFF, 0x83,
  0xFC, 0x01, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F,
  0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0x00, 0x7F, 0x81, 0xFE,
  0x00, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0,
  0x0F, 0xF8, 0x3F, 0xC0, 0x3F, 0xE0, 0x7F, 0x80, 0x7F, 0xC1, 0xFF, 0x00,
  0xFF, 0x83, 0xFE, 0x03, 0xFF, 0x07, 0xFC, 0x07, 0xFE, 0x0F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0xFE, 0x01, 0xFF, 0xF9, 0xFC,
  0x01, 0xFF, 0xE3, 0xF8, 0x01, 0xFF, 0x07, 0xF0, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xBF, 0xC0, 0x07, 0xFD,
  0xFE, 0x00, 0x7F, 0xCF, 0xF0, 0x03, 0xFE, 0x7F, 0x80, 0x3F, 0xE3, 0xFC,
  0x01, 0xFF, 0x1F, 0xE0, 0x1F, 0xF0, 0xFF, 0x00, 0xFF, 0x87, 0xF8, 0x07,
  0xF8, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0,
  0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x1F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F,
  0x8F, 0xF8, 0x03, 0xFC, 0x7F, 0xC0, 0x1F, 0xE3, 0xFC, 0x00, 0xFF, 0x3F,
  0xE0, 0x07, 0xF9, 0xFE, 0x00, 0x3F, 0xDF, 0xF0, 0x01, 0xFE, 0xFF, 0x00,
  0x0F, 0xF7, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0xF0, 0x07,
  0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xEF, 0xF0, 0x0F, 0xFE,
  0x03, 0xFE, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xCF, 0xF0, 0x1F, 0xFE, 0x07,
  0xFC, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xCF, 0xF0, 0x3F, 0xFE, 0x07, 0xF8,
  0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0x8F, 0xF0, 0x3F, 0xFC, 0x0F, 0xF0, 0xFF,
  0x07, 0xFF, 0xC1, 0xFF, 0x0F, 0xF0, 0x7E, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F,
  0xEF, 0xC1, 0xFE, 0x0F, 0xF0, 0xFE, 0xFC, 0x3F, 0xE0, 0xFF, 0x0F, 0xCF,
  0xC3, 0xFC, 0x0F, 0xF1, 0xFC, 0xFC, 0x7F, 0xC0, 0xFF, 0x1F, 0xCF, 0xC7,
  0xF8, 0x0F, 0xF3, 0xF9, 0xFC, 0x7F, 0x80, 0xFF, 0x3F, 0x9F, 0xCF, 0xF0,
  0x0F, 0xF3, 0xF1, 0xFC, 0xFF, 0x00, 0xFF, 0x7F, 0x1F, 0xCF, 0xF0, 0x0F,
  0xF7, 0xF1, 0xFD, 0xFE, 0x00, 0xFF, 0x7E, 0x1F, 0xDF, 0xE0, 0x0F, 0xFF,
  0xE1, 0xFD, 0xFC, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x81, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x81, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x7F,
  0xC0, 0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0xC3, 0xFF, 0x00,
  0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x03, 0xFE, 0xFF,
  0xC0, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xF7, 0xF8,
  0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x03, 0xFE,
  0x7F, 0xC0, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00,
  0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x03, 0xFF, 0x03, 0xFE,
  0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x03, 0xFE,
  0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x00, 0xFF,
  0x01, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0xE0,
  0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x03, 0xFC,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x0F, 0xF3,
  0xFE, 0x00, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00,
  0x01, 0xFD, 0xFE, 0x00, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x00, 0x1F, 0xDF,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0x9F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x09,
  0xFF, 0xE0, 0x00, 0xDF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xF4, 0x00, 0x0F, 0xFE, 0x20, 0x00, 0x0F, 0xC0,
};

const GFXglyph NotoSans_Condensed_BoldItalic67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 20, 49, 17, 0, -48 },
  { 124, 24, 17, 28, 6, -48 },
  { 175, 37, 48, 35, 0, -48 },
  { 397, 31, 55, 31, 1, -51 },
  { 611, 44, 50, 50, 4, -49 },
  { 886, 37, 50, 38, 1, -49 },
  { 1118, 11, 17, 17, 7, -48 },
  { 1142, 24, 59, 20, 1, -48 },
  { 1319, 23, 60, 20, -5, -49 },
  { 1492, 27, 29, 30, 5, -51 },
  { 1590, 29, 32, 33, 3, -40 },
  { 1706, 15, 18, 17, -3, -9 },
  { 1740, 18, 8, 20, 1, -22 },
  { 1758, 11, 11, 17, 0, -10 },
  { 1774, 34, 48, 26, -3, -48 },
  { 1978, 29, 50, 31, 2, -49 },
  { 2160, 23, 48, 31, 6, -48 },
  { 2298, 33, 49, 31, -2, -49 },
  { 2501, 33, 50, 31, -1, -49 },
  { 2708, 33, 48, 31, -1, -48 },
  { 2906, 32, 49, 31, 0, -48 },
  { 3102, 31, 50, 31, 2, -49 },
  { 3296, 33, 48, 31, 2, -48 },
  { 3494, 32, 50, 31, 0, -49 },
  { 3694, 30, 50, 31, 1, -49 },
  { 3882, 17, 38, 17, 0, -37 },
  { 3963, 21, 46, 17, -4, -37 },
  { 4084, 29, 33, 33, 3, -41 },
  { 4204, 29, 20, 33, 3, -34 },
  { 4277, 29, 33, 33, 3, -41 },
  { 4397, 25, 50, 25, 3, -49 },
  { 4554, 45, 54, 48, 2, -48 },
  { 4858, 35, 48, 35, -4, -48 },
  { 5068, 35, 48, 35, 0, -48 },
  { 5278, 34, 50, 33, 3, -49 },
  { 5491, 37, 48, 38, 0, -48 },
  { 5713, 33, 48, 30, 0, -48 },
  { 5911, 33, 48, 29, 0, -48 },
  { 6109, 37, 50, 39, 3, -49 },
  { 6341, 41, 48, 39, 0, -48 },
  { 6587, 30, 48, 23, -3, -48 },
  { 6767, 30, 62, 18, -10, -48 },
  { 7000, 40, 48, 34, 0, -48 },
  { 7240, 24, 48, 28, 0, -48 },
  { 7384, 52, 48, 50, 0, -48 },
  { 7696, 43, 48, 42, 0, -48 },
  { 7954, 36, 50, 40, 3, -49 },
  { 8179, 36, 48, 34, 0, -48 },
  { 8395, 36, 60, 40, 3, -49 },
  { 8665, 34, 48, 34, 0, -48 },
  { 8869, 33, 50, 30, -1, -49 },
  { 9076, 29, 48, 29, 5, -48 },
  { 9250, 37, 49, 38, 3, -48 },
  { 9477, 34, 48, 34, 6, -48 },
  { 9681, 52, 48, 51, 5, -48 },
  { 9993, 42, 48, 33, -4, -48 },
  { 10245, 31, 48, 31, 6, -48 },
  { 10431, 35, 48, 29, -2, -48 },
  { 10641, 27, 59, 20, -2, -48 },
  { 10841, 14, 48, 26, 7, -48 },
  { 10925, 27, 59, 20, -5, -48 },
  { 11125, 31, 30, 31, 0, -48 },
  { 11242, 24, 4, 23, -6, 6 },
  { 11254, 13, 10, 21, 10, -51 },
  { 11271, 32, 38, 34, 2, -37 },
  { 11423, 32, 52, 34, 0, -51 },
  { 11631, 27, 38, 27, 2, -37 },
  { 11760, 35, 52, 34, 2, -51 },
  { 11988, 28, 38, 31, 2, -37 },
  { 12121, 36, 67, 21, -8, -51 },
  { 12423, 35, 53, 34, -1, -37 },
  { 12655, 32, 51, 34, 0, -51 },
  { 12859, 19, 51, 17, 0, -51 },
  { 12981, 28, 67, 17, -9, -51 },
  { 13216, 35, 51, 31, 0, -51 },
  { 13440, 20, 51, 17, 0, -51 },
  { 13568, 48, 37, 50, 0, -37 },
  { 13790, 31, 37, 34, 0, -37 },
  { 13934, 29, 38, 33, 2, -37 },
  { 14072, 35, 53, 34, -3, -37 },
  { 14304, 32, 53, 34, 2, -37 },
  { 14516, 27, 37, 24, 0, -37 },
  { 14641, 27, 38, 26, 0, -37 },
  { 14770, 21, 45, 22, 3, -44 },
  { 14889, 31, 38, 33, 2, -37 },
  { 15037, 29, 37, 29, 4, -37 },
  { 15172, 44, 37, 45, 4, -37 },
  { 15376, 36, 37, 30, -3, -37 },
  { 15543, 38, 53, 29, -5, -37 },
  { 15795, 29, 37, 25, -2, -37 },
  { 15930, 27, 59, 23, 1, -48 },
  { 16130, 8, 66, 29, 10, -51 },
  { 16196, 26, 59, 23, -4, -48 },
  { 16388, 29, 11, 33, 3, -29 },
};

const GFXfont NotoSans_Condensed_BoldItalic67pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BoldItalic67pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BoldItalic67pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _NOTOSANS_CONDENSED_BOLDITALIC67PT7B_H_
