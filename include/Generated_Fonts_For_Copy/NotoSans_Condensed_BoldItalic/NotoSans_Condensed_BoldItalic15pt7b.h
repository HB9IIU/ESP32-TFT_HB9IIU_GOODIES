#ifndef _NOTOSANS_CONDENSED_BOLDITALIC15PT7B_H_
#define _NOTOSANS_CONDENSED_BOLDITALIC15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BoldItalic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BoldItalic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x33, 0x66, 0x66, 0x0C, 0xC0, 0x6D, 0xA5, 0xB6, 0x0B, 0x1A,
  0x1A, 0x7F, 0x7F, 0x34, 0x24, 0xFE, 0x68, 0x48, 0xD8, 0x08, 0x7C, 0xFB,
  0x47, 0x07, 0x87, 0x0E, 0xDD, 0xF8, 0x81, 0x00, 0x71, 0x9C, 0x4D, 0x22,
  0x58, 0xB4, 0xBF, 0xFE, 0xAC, 0x5B, 0x36, 0xC9, 0xA6, 0x30, 0x0C, 0x0F,
  0x0D, 0x86, 0xC3, 0xC1, 0xCD, 0xED, 0x9E, 0xCE, 0x7F, 0x1F, 0xC0, 0x6D,
  0x60, 0x08, 0xCC, 0x66, 0x31, 0x98, 0xC6, 0x31, 0x86, 0x00, 0x18, 0xC6,
  0x31, 0x8C, 0x63, 0x31, 0x8C, 0xCC, 0x00, 0x28, 0x45, 0x3F, 0x33, 0xE4,
  0x80, 0x30, 0xC3, 0x3F, 0xFC, 0xC3, 0x00, 0x76, 0x6C, 0xFF, 0xF0, 0x03,
  0x06, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x60, 0xC0, 0x1C, 0x7C,
  0xDB, 0x36, 0x6C, 0xF1, 0xE6, 0xCD, 0xF1, 0xC0, 0x0C, 0xE7, 0xB6, 0x18,
  0xC3, 0x0C, 0x30, 0xC6, 0x00, 0x0E, 0x3F, 0x13, 0x03, 0x06, 0x06, 0x0C,
  0x18, 0x30, 0x7E, 0xFC, 0x1C, 0x7C, 0x98, 0x30, 0xC7, 0x03, 0x06, 0x0D,
  0xFB, 0xE0, 0x06, 0x1C, 0x38, 0xA3, 0xCD, 0x93, 0x7F, 0xFC, 0x30, 0x60,
  0x3E, 0x7C, 0xC1, 0x07, 0x8F, 0x83, 0x06, 0x0D, 0xFB, 0xE0, 0x0E, 0x3C,
  0xC3, 0x07, 0xCF, 0x99, 0xE6, 0xCC, 0xF9, 0xE0, 0x3F, 0x7F, 0x06, 0x06,
  0x0C, 0x18, 0x18, 0x30, 0x30, 0x60, 0xE0, 0x1C, 0x7C, 0x9B, 0x33, 0xC7,
  0x1B, 0x66, 0xCD, 0xF9, 0xE0, 0x1C, 0x7D, 0x9B, 0x36, 0x6D, 0xDF, 0x06,
  0x0D, 0xF3, 0xC0, 0x77, 0x00, 0x00, 0xCC, 0x19, 0xC0, 0x00, 0x01, 0xCC,
  0x66, 0x00, 0x04, 0x77, 0x30, 0xF0, 0xF0, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x83, 0x87, 0x83, 0x3F, 0x88, 0x00, 0x77, 0xE6, 0x33, 0x31, 0x18, 0x06,
  0x30, 0x07, 0x03, 0xB8, 0xC1, 0x13, 0xB6, 0x96, 0xB6, 0x94, 0x96, 0x96,
  0xDF, 0x88, 0x01, 0x84, 0x1F, 0x00, 0x06, 0x0E, 0x0F, 0x1B, 0x1B, 0x1B,
  0x33, 0x3F, 0x63, 0x63, 0xC3, 0x3C, 0x3F, 0x33, 0x33, 0x66, 0x7C, 0x66,
  0x66, 0x66, 0xFC, 0xF8, 0x1E, 0x7D, 0x8F, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0xF1, 0xE0, 0x3C, 0x3F, 0x33, 0x33, 0x73, 0x63, 0x63, 0x67, 0x66, 0xFC,
  0xF8, 0x3E, 0x7C, 0xC1, 0x87, 0x0F, 0x98, 0x30, 0x61, 0xF3, 0xE0, 0x3E,
  0x7C, 0xC1, 0x87, 0x0F, 0x9F, 0x30, 0x61, 0x83, 0x00, 0x1E, 0x3F, 0x72,
  0xE0, 0xC0, 0xCE, 0xDE, 0xC6, 0xCC, 0xFC, 0x7C, 0x31, 0x98, 0xCC, 0x66,
  0x67, 0x33, 0xF9, 0x8C, 0xCE, 0x66, 0x63, 0x31, 0x80, 0x1E, 0x78, 0x60,
  0xC1, 0x83, 0x06, 0x18, 0x30, 0x63, 0xE0, 0x0E, 0x18, 0x30, 0x60, 0xC3,
  0x06, 0x0C, 0x18, 0x70, 0xC1, 0x8F, 0x1C, 0x00, 0x31, 0x99, 0x8D, 0x87,
  0xC6, 0xC3, 0xC1, 0xF0, 0xD8, 0x6C, 0x66, 0x33, 0x80, 0x31, 0x8C, 0x67,
  0x31, 0x8C, 0x67, 0xFE, 0x38, 0x73, 0x8E, 0x38, 0xE2, 0x9E, 0x69, 0xE6,
  0xB6, 0x6B, 0xC6, 0xAC, 0x4E, 0xCC, 0xCC, 0xCD, 0x80, 0x38, 0xCE, 0x23,
  0x98, 0xA6, 0x6D, 0x9B, 0x66, 0xD1, 0xBC, 0x47, 0x31, 0xCC, 0x60, 0x1C,
  0x3E, 0x67, 0xE3, 0xC3, 0xC7, 0xC6, 0xC6, 0xCE, 0xFC, 0x78, 0x3C, 0x3F,
  0x33, 0x33, 0x73, 0x7E, 0x7C, 0x60, 0x60, 0xC0, 0xC0, 0x1C, 0x3E, 0x67,
  0xE3, 0xC3, 0xC7, 0xC6, 0xC6, 0xCE, 0xFC, 0x78, 0x18, 0x18, 0x1C, 0x3C,
  0x3E, 0x37, 0x33, 0x66, 0x7E, 0x7C, 0x6C, 0x6C, 0xCC, 0xCE, 0x1E, 0x7D,
  0xCB, 0x87, 0x07, 0x07, 0x06, 0x8D, 0xF3, 0xE0, 0x7F, 0xF8, 0xC1, 0x83,
  0x0E, 0x18, 0x30, 0x60, 0xC3, 0x80, 0x63, 0x63, 0x66, 0x66, 0xC6, 0xC6,
  0xC6, 0xCC, 0xCC, 0xFC, 0xF8, 0xC3, 0xC6, 0xC6, 0xCC, 0xCC, 0x48, 0x58,
  0x58, 0x70, 0x70, 0x60, 0xC6, 0x3C, 0x66, 0xCE, 0x6C, 0xEC, 0xDE, 0xCD,
  0xEC, 0xD7, 0x8F, 0x78, 0xE7, 0x0E, 0x70, 0xE7, 0x00, 0x19, 0x8C, 0xC6,
  0xC3, 0xC0, 0xE0, 0x60, 0x70, 0x6C, 0x36, 0x33, 0x39, 0x80, 0xC6, 0xCD,
  0xB3, 0xC7, 0x8E, 0x1C, 0x30, 0x60, 0xC1, 0x80, 0x1F, 0x3F, 0x07, 0x06,
  0x0C, 0x1C, 0x18, 0x30, 0x70, 0x7E, 0xFC, 0x1E, 0x38, 0x60, 0x83, 0x06,
  0x0C, 0x18, 0x20, 0xC1, 0x83, 0x0F, 0x00, 0x93, 0x6D, 0xB2, 0x4D, 0x80,
  0x1C, 0xF0, 0xC2, 0x18, 0x61, 0x84, 0x30, 0xC3, 0x0C, 0xE0, 0x08, 0x38,
  0x71, 0xE2, 0x4C, 0xF1, 0x80, 0xF8, 0xEC, 0x3B, 0x76, 0x66, 0x66, 0xE6,
  0xCC, 0xFC, 0x7C, 0x30, 0x60, 0xC1, 0xF7, 0x6C, 0xD9, 0xB3, 0x6D, 0xFB,
  0xE0, 0x3D, 0xD6, 0x18, 0xE3, 0x07, 0x9E, 0x03, 0x03, 0x03, 0x3E, 0x76,
  0x66, 0x66, 0xC6, 0xCC, 0xFC, 0x7C, 0x3C, 0xED, 0x9B, 0xEF, 0x18, 0x1B,
  0x3E, 0x07, 0x0C, 0x0C, 0x1E, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x30,
  0x30, 0x30, 0xE0, 0xC0, 0x3B, 0x76, 0x66, 0x66, 0xE6, 0xCC, 0xFC, 0x7C,
  0x0C, 0x98, 0xF8, 0x60, 0x30, 0x60, 0xC1, 0x77, 0x6C, 0xD9, 0xB3, 0x6D,
  0x9B, 0x30, 0x33, 0x03, 0x66, 0x66, 0x6C, 0xC0, 0x0C, 0x30, 0x03, 0x18,
  0x61, 0x86, 0x18, 0xC3, 0x0C, 0x33, 0x8C, 0x00, 0x30, 0x30, 0x31, 0x36,
  0x6C, 0x7C, 0x78, 0x78, 0x58, 0xCC, 0xCC, 0x33, 0x33, 0x66, 0x66, 0x6C,
  0xC0, 0x2F, 0xCE, 0xED, 0x99, 0xB3, 0x66, 0x4C, 0x99, 0xB3, 0x36, 0x6E,
  0x2E, 0xED, 0x9B, 0x36, 0x6D, 0xB3, 0x66, 0x3C, 0xED, 0x9B, 0x3C, 0x79,
  0x9F, 0x3C, 0x17, 0x3B, 0x33, 0x33, 0x33, 0x36, 0x7E, 0x7C, 0x60, 0x60,
  0xC0, 0xC0, 0x3B, 0x76, 0x66, 0x66, 0xC6, 0xCC, 0xFC, 0x7C, 0x0C, 0x18,
  0x18, 0x18, 0x2D, 0xF6, 0x18, 0x61, 0x8C, 0x30, 0x7D, 0x96, 0x1C, 0x38,
  0x6F, 0xBC, 0x26, 0xF4, 0xCC, 0xCC, 0xEE, 0x36, 0xCD, 0x9B, 0x36, 0x49,
  0xBF, 0x3E, 0xCF, 0x3D, 0xB6, 0xF3, 0xCE, 0x38, 0xDC, 0xF7, 0x6D, 0xDB,
  0xFC, 0xEF, 0x3B, 0x8E, 0xE3, 0x38, 0x33, 0x1E, 0x1C, 0x1C, 0x1C, 0x3C,
  0x6C, 0xEE, 0x33, 0x33, 0x36, 0x36, 0x3C, 0x3C, 0x38, 0x38, 0x30, 0x30,
  0xE0, 0xC0, 0x7C, 0x71, 0x8C, 0x61, 0x8F, 0xBE, 0x0C, 0x71, 0x8C, 0x30,
  0xCE, 0x38, 0x61, 0x86, 0x18, 0x70, 0xFF, 0xFF, 0xFF, 0xF0, 0x10, 0xE1,
  0x86, 0x18, 0x61, 0xC7, 0x30, 0xC3, 0x18, 0xE0, 0x47, 0xF9, 0xC0,
};

const GFXglyph NotoSans_Condensed_BoldItalic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 11, 4, 0, -11 },
  { 7, 6, 4, 6, 1, -11 },
  { 10, 8, 11, 8, 0, -11 },
  { 21, 7, 12, 7, 0, -11 },
  { 32, 10, 11, 11, 1, -11 },
  { 46, 9, 11, 9, 0, -11 },
  { 59, 3, 4, 4, 1, -11 },
  { 61, 5, 13, 4, 0, -11 },
  { 70, 5, 13, 4, -1, -11 },
  { 79, 6, 7, 7, 1, -12 },
  { 85, 6, 7, 7, 1, -9 },
  { 91, 4, 4, 4, -1, -2 },
  { 93, 4, 2, 4, 0, -5 },
  { 94, 2, 2, 4, 0, -2 },
  { 95, 8, 11, 6, -1, -11 },
  { 106, 7, 11, 7, 0, -11 },
  { 116, 6, 11, 7, 1, -11 },
  { 125, 8, 11, 7, -1, -11 },
  { 136, 7, 11, 7, 0, -11 },
  { 146, 7, 11, 7, 0, -11 },
  { 156, 7, 11, 7, 0, -11 },
  { 166, 7, 11, 7, 0, -11 },
  { 176, 8, 11, 7, 0, -11 },
  { 187, 7, 11, 7, 0, -11 },
  { 197, 7, 11, 7, 0, -11 },
  { 207, 4, 8, 4, 0, -8 },
  { 211, 5, 10, 4, -1, -8 },
  { 218, 6, 7, 7, 1, -9 },
  { 224, 6, 5, 7, 1, -8 },
  { 228, 6, 7, 7, 1, -9 },
  { 234, 5, 11, 6, 1, -11 },
  { 241, 11, 12, 11, 0, -11 },
  { 258, 8, 11, 8, -1, -11 },
  { 269, 8, 11, 8, 0, -11 },
  { 280, 7, 11, 7, 1, -11 },
  { 290, 8, 11, 8, 0, -11 },
  { 301, 7, 11, 7, 0, -11 },
  { 311, 7, 11, 6, 0, -11 },
  { 321, 8, 11, 9, 1, -11 },
  { 332, 9, 11, 9, 0, -11 },
  { 345, 7, 11, 5, -1, -11 },
  { 355, 7, 14, 4, -2, -11 },
  { 368, 9, 11, 8, 0, -11 },
  { 381, 5, 11, 6, 0, -11 },
  { 388, 12, 11, 11, 0, -11 },
  { 405, 10, 11, 9, 0, -11 },
  { 419, 8, 11, 9, 1, -11 },
  { 430, 8, 11, 8, 0, -11 },
  { 441, 8, 14, 9, 1, -11 },
  { 455, 8, 11, 8, 0, -11 },
  { 466, 7, 11, 7, 0, -11 },
  { 476, 7, 11, 7, 1, -11 },
  { 486, 8, 11, 9, 1, -11 },
  { 497, 8, 11, 8, 1, -11 },
  { 508, 12, 11, 11, 1, -11 },
  { 525, 9, 11, 7, -1, -11 },
  { 538, 7, 11, 7, 1, -11 },
  { 548, 8, 11, 7, -1, -11 },
  { 559, 7, 13, 4, -1, -11 },
  { 571, 3, 11, 6, 2, -11 },
  { 576, 6, 13, 4, -1, -11 },
  { 586, 7, 7, 7, 0, -11 },
  { 593, 5, 1, 5, -1, 1 },
  { 594, 3, 2, 5, 2, -11 },
  { 595, 8, 8, 8, 0, -8 },
  { 603, 7, 11, 8, 0, -11 },
  { 613, 6, 8, 6, 0, -8 },
  { 619, 8, 11, 8, 0, -11 },
  { 630, 7, 8, 7, 0, -8 },
  { 637, 8, 15, 5, -2, -11 },
  { 652, 8, 12, 8, 0, -8 },
  { 664, 7, 11, 8, 0, -11 },
  { 674, 4, 11, 4, 0, -11 },
  { 680, 6, 15, 4, -2, -11 },
  { 692, 8, 11, 7, 0, -11 },
  { 703, 4, 11, 4, 0, -11 },
  { 709, 11, 8, 11, 0, -8 },
  { 720, 7, 8, 8, 0, -8 },
  { 727, 7, 8, 7, 0, -8 },
  { 734, 8, 12, 8, -1, -8 },
  { 746, 8, 12, 8, 0, -8 },
  { 758, 6, 8, 5, 0, -8 },
  { 764, 6, 8, 6, 0, -8 },
  { 770, 4, 10, 5, 1, -10 },
  { 775, 7, 8, 7, 0, -8 },
  { 782, 6, 8, 7, 1, -8 },
  { 788, 10, 8, 10, 1, -8 },
  { 798, 8, 8, 7, -1, -8 },
  { 806, 8, 12, 7, -1, -8 },
  { 818, 6, 8, 6, 0, -8 },
  { 824, 6, 13, 5, 0, -11 },
  { 834, 2, 14, 6, 2, -11 },
  { 838, 6, 13, 5, -1, -11 },
  { 848, 6, 3, 7, 1, -7 },
};

const GFXfont NotoSans_Condensed_BoldItalic15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BoldItalic15pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BoldItalic15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_CONDENSED_BOLDITALIC15PT7B_H_
