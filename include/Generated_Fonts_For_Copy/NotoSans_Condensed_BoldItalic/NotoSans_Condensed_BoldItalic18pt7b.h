#ifndef _NOTOSANS_CONDENSED_BOLDITALIC18PT7B_H_
#define _NOTOSANS_CONDENSED_BOLDITALIC18PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BoldItalic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BoldItalic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x19, 0xCE, 0x63, 0x19, 0xCC, 0x60, 0x19, 0xCE, 0x00, 0xEF, 0x3D,
  0xB6, 0xD8, 0x0C, 0x83, 0x60, 0x98, 0x64, 0x7F, 0xC6, 0xC1, 0x20, 0xD8,
  0xFF, 0x89, 0x86, 0x41, 0xB0, 0x4C, 0x00, 0x02, 0x02, 0x07, 0xE7, 0xE3,
  0x51, 0xA0, 0xF0, 0x3C, 0x0F, 0x07, 0xA5, 0xDF, 0xCF, 0xC0, 0x80, 0x40,
  0x38, 0x67, 0x8C, 0x49, 0x8C, 0x98, 0xDB, 0x0D, 0xA6, 0xF6, 0xF7, 0xDB,
  0x0D, 0xB1, 0x93, 0x13, 0x23, 0x1E, 0x61, 0xC0, 0x0F, 0x07, 0xC1, 0xB0,
  0x6C, 0x1F, 0x07, 0x83, 0xCD, 0xF7, 0x6F, 0xB9, 0xEE, 0x73, 0xFC, 0x7B,
  0x80, 0xFB, 0x6C, 0x0E, 0x38, 0x61, 0x83, 0x0E, 0x18, 0x30, 0x61, 0xC3,
  0x87, 0x0E, 0x0C, 0x18, 0x30, 0x18, 0x70, 0xC3, 0x0C, 0x30, 0xC7, 0x18,
  0x61, 0x8C, 0x31, 0x86, 0x30, 0x0C, 0x08, 0x78, 0xFF, 0x1F, 0x3C, 0x6C,
  0x26, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x76, 0x6E,
  0x7F, 0xC0, 0x7F, 0x80, 0x01, 0x81, 0xC0, 0xC0, 0xE0, 0x60, 0x60, 0x30,
  0x30, 0x18, 0x18, 0x0C, 0x0C, 0x0E, 0x00, 0x0E, 0x1F, 0x3B, 0x33, 0x73,
  0x63, 0x63, 0x67, 0xE7, 0xE6, 0xEE, 0x7C, 0x78, 0x1C, 0xF7, 0xBE, 0x98,
  0xE3, 0x8C, 0x30, 0xC7, 0x18, 0x60, 0x0F, 0x0F, 0xC6, 0x60, 0x30, 0x18,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x0F, 0xEF, 0xF0, 0x1F, 0x1F, 0x88,
  0xE0, 0x60, 0x30, 0xF0, 0xF0, 0x1C, 0x06, 0x03, 0x23, 0x9F, 0xCF, 0x80,
  0x03, 0x83, 0x83, 0xC1, 0x61, 0xF1, 0xB0, 0x98, 0xCC, 0xFF, 0x7F, 0x83,
  0x01, 0x81, 0xC0, 0x1F, 0x8F, 0x8E, 0x06, 0x03, 0x01, 0xF1, 0xF8, 0x0E,
  0x07, 0x03, 0x23, 0x9F, 0x8F, 0x80, 0x0F, 0x3F, 0x30, 0x60, 0x60, 0xDC,
  0xFE, 0xCE, 0xCE, 0xCE, 0xCC, 0xFC, 0x78, 0x7F, 0x7F, 0x07, 0x06, 0x0E,
  0x0C, 0x1C, 0x18, 0x30, 0x70, 0x60, 0xE0, 0xC0, 0x1F, 0x1F, 0x8C, 0xE6,
  0x73, 0x31, 0xF0, 0xF0, 0xFC, 0xE7, 0x73, 0xB9, 0x9F, 0xC7, 0xC0, 0x1E,
  0x3F, 0x33, 0x73, 0x63, 0x67, 0x7F, 0x7F, 0x06, 0x06, 0x0C, 0xFC, 0xF8,
  0x31, 0xCC, 0x00, 0x00, 0x0C, 0xE7, 0x00, 0x18, 0x71, 0x80, 0x00, 0x00,
  0x00, 0x71, 0x86, 0x30, 0x01, 0x07, 0x1E, 0x78, 0xE0, 0xF8, 0x3E, 0x07,
  0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xE0, 0xF8, 0x1E, 0x07, 0x1E,
  0x78, 0xE0, 0x80, 0x7D, 0xF4, 0xC3, 0x1C, 0xE7, 0x18, 0x60, 0x04, 0x30,
  0xC0, 0x07, 0x81, 0xFE, 0x30, 0x66, 0x33, 0x4F, 0xBD, 0x93, 0xD9, 0x39,
  0x32, 0x93, 0x69, 0xFC, 0x9D, 0x8C, 0x00, 0xC1, 0x07, 0xF0, 0x08, 0x00,
  0x03, 0x83, 0xC1, 0xE1, 0xB0, 0xD8, 0xEC, 0x66, 0x73, 0x3F, 0xBF, 0xDC,
  0x6C, 0x3E, 0x18, 0x1F, 0x0F, 0xCE, 0x66, 0x33, 0x19, 0xF9, 0xF8, 0xE6,
  0x63, 0x31, 0x99, 0xDF, 0xCF, 0xC0, 0x0F, 0x1F, 0xCE, 0x4E, 0x06, 0x07,
  0x03, 0x81, 0x80, 0xC0, 0x60, 0x38, 0x9F, 0x87, 0xC0, 0x1F, 0x07, 0xE3,
  0xBC, 0xE7, 0x31, 0xCC, 0x77, 0x1D, 0xC6, 0x73, 0x98, 0xE6, 0x73, 0xF8,
  0xFC, 0x00, 0x1F, 0x8F, 0x8E, 0x07, 0x03, 0x01, 0xF1, 0xF8, 0xE0, 0x70,
  0x30, 0x18, 0x1F, 0x8F, 0xC0, 0x1F, 0x8F, 0x8E, 0x07, 0x03, 0x01, 0x81,
  0xF8, 0xFC, 0x70, 0x30, 0x18, 0x1C, 0x0E, 0x00, 0x0F, 0xCF, 0xE3, 0x89,
  0xC0, 0x60, 0x38, 0x0E, 0x7B, 0x3C, 0xC3, 0x30, 0xCE, 0x73, 0xFC, 0x7E,
  0x00, 0x18, 0xE3, 0x1C, 0xE3, 0x1C, 0x63, 0x0C, 0x7F, 0x9F, 0xF3, 0x8C,
  0x71, 0x8C, 0x71, 0x8E, 0x71, 0xCE, 0x30, 0x1F, 0x1F, 0x0C, 0x0C, 0x0C,
  0x1C, 0x18, 0x18, 0x18, 0x38, 0x38, 0x78, 0xFC, 0x03, 0x03, 0x07, 0x07,
  0x06, 0x06, 0x06, 0x0E, 0x0E, 0x0C, 0x0C, 0x0C, 0x1C, 0x1C, 0xB8, 0xF8,
  0xE0, 0x18, 0xE3, 0x38, 0xEE, 0x19, 0x83, 0x70, 0x7C, 0x1F, 0x03, 0xF0,
  0x6E, 0x0C, 0xC1, 0x98, 0x73, 0x8E, 0x70, 0x18, 0x30, 0xE1, 0xC3, 0x06,
  0x1C, 0x38, 0x70, 0xC1, 0x8F, 0xEF, 0xC0, 0x1C, 0x3C, 0x70, 0xF3, 0xC3,
  0x8F, 0x1E, 0x3C, 0x78, 0xF3, 0x67, 0xCF, 0x9B, 0x6C, 0x6D, 0xB1, 0xBC,
  0xC6, 0xF7, 0x3B, 0x9C, 0xC6, 0x60, 0x1C, 0x71, 0xC6, 0x3C, 0x63, 0xC6,
  0x3E, 0xE3, 0x6C, 0x76, 0xC6, 0x6C, 0x66, 0xC6, 0x7C, 0x63, 0x8E, 0x38,
  0xC3, 0x80, 0x0F, 0x0F, 0xE3, 0x99, 0xC7, 0x61, 0xF8, 0x6E, 0x1B, 0x06,
  0xC3, 0xB0, 0xCE, 0x73, 0xF8, 0x7C, 0x00, 0x1F, 0x07, 0xE3, 0x9C, 0xE7,
  0x31, 0x8C, 0x67, 0xF9, 0xFC, 0x70, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x00,
  0x0F, 0x0F, 0xE3, 0xB9, 0xC7, 0x61, 0xF8, 0x6E, 0x1B, 0x0E, 0xC3, 0xB0,
  0xCE, 0x73, 0xF8, 0x7C, 0x07, 0x00, 0xE0, 0x38, 0x1F, 0x0F, 0xCE, 0xE7,
  0x33, 0x19, 0x9D, 0xFC, 0xFC, 0x6E, 0x33, 0x19, 0x9C, 0xEE, 0x70, 0x1F,
  0x9F, 0x8E, 0x46, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x23, 0x9F,
  0x8F, 0x80, 0x7F, 0x7F, 0x98, 0x18, 0x38, 0x38, 0x30, 0x30, 0x30, 0x70,
  0x70, 0x60, 0x60, 0x31, 0xDC, 0x67, 0x19, 0xC6, 0x63, 0x98, 0xEE, 0x33,
  0x8C, 0xC7, 0x31, 0xCE, 0x63, 0xF8, 0x7C, 0x00, 0xC3, 0xE1, 0xB1, 0xD8,
  0xCC, 0xE6, 0x63, 0x71, 0xB0, 0xD8, 0x78, 0x3C, 0x1C, 0x0E, 0x00, 0x63,
  0x0D, 0x8C, 0x76, 0x71, 0x99, 0xC6, 0x67, 0x31, 0xBC, 0xC6, 0xF7, 0x1E,
  0xD8, 0x7B, 0x63, 0xEF, 0x0F, 0x3C, 0x3C, 0xF0, 0xE3, 0x80, 0x18, 0xE3,
  0x98, 0x77, 0x06, 0xC0, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x1F, 0x07, 0xE0,
  0xCC, 0x31, 0x8E, 0x38, 0xC7, 0xC6, 0xCE, 0xCC, 0xF8, 0x78, 0x70, 0x70,
  0x60, 0x60, 0xE0, 0xE0, 0xC0, 0x1F, 0xC7, 0xF0, 0x38, 0x0C, 0x07, 0x03,
  0x80, 0xC0, 0x70, 0x18, 0x0E, 0x07, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0x1E,
  0x18, 0x18, 0x18, 0x18, 0x38, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60, 0x60,
  0x78, 0xF0, 0xCC, 0xCC, 0xE6, 0x66, 0x66, 0x66, 0x30, 0x1E, 0x3C, 0x30,
  0x60, 0xC1, 0x87, 0x0C, 0x18, 0x30, 0x61, 0xC3, 0x06, 0x3C, 0x78, 0x04,
  0x0E, 0x0E, 0x1E, 0x36, 0x33, 0x63, 0xC3, 0xFE, 0xDD, 0x80, 0x1D, 0x9F,
  0xDC, 0xEE, 0x66, 0x33, 0x1B, 0x9D, 0xCC, 0x7E, 0x3B, 0x00, 0x18, 0x0C,
  0x0E, 0x07, 0x03, 0x71, 0xF8, 0xCE, 0xE7, 0x63, 0x31, 0x99, 0xCC, 0xEF,
  0xE6, 0xE0, 0x1F, 0x3E, 0x32, 0x70, 0x60, 0x60, 0xE0, 0x64, 0x7C, 0x7C,
  0x01, 0xC0, 0x70, 0x18, 0x06, 0x1D, 0x8F, 0xE3, 0x39, 0xCC, 0x63, 0x18,
  0xCE, 0x73, 0x98, 0x7E, 0x1F, 0x80, 0x1E, 0x3F, 0x33, 0x63, 0x7E, 0x7C,
  0xE0, 0x60, 0x7E, 0x3E, 0x03, 0xC1, 0xE0, 0x60, 0x18, 0x0F, 0x07, 0xC0,
  0xC0, 0x30, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xC0,
  0xF0, 0x38, 0x00, 0x1D, 0x9F, 0xCC, 0xEE, 0x66, 0x33, 0x1B, 0x9D, 0xCC,
  0x7E, 0x3B, 0x03, 0x81, 0xCF, 0xC7, 0xC0, 0x18, 0x18, 0x38, 0x38, 0x37,
  0x3F, 0x33, 0x73, 0x73, 0x63, 0x67, 0x67, 0xE6, 0xC6, 0x19, 0xC6, 0x03,
  0x98, 0xCE, 0x73, 0x18, 0xCE, 0x70, 0x06, 0x1C, 0x18, 0x00, 0xE1, 0x83,
  0x0E, 0x1C, 0x30, 0x60, 0xC3, 0x87, 0x0C, 0x18, 0xF1, 0xC0, 0x18, 0x0C,
  0x0E, 0x07, 0x03, 0x19, 0x98, 0xD8, 0xFC, 0x7C, 0x3E, 0x1B, 0x0D, 0xCE,
  0x66, 0x30, 0x18, 0xCE, 0x73, 0x18, 0xCE, 0x73, 0x18, 0xCE, 0x70, 0x37,
  0x71, 0xFF, 0xCC, 0xEE, 0xE6, 0x76, 0x33, 0x33, 0x99, 0x9C, 0xCC, 0xC6,
  0xE6, 0x76, 0x33, 0x00, 0x37, 0x3F, 0x33, 0x73, 0x73, 0x63, 0x67, 0x67,
  0xE6, 0xC6, 0x1E, 0x3F, 0x73, 0x63, 0x63, 0x63, 0xE7, 0x66, 0x7E, 0x3C,
  0x1B, 0x87, 0xE1, 0x9C, 0xE7, 0x31, 0x8C, 0x63, 0x18, 0xCE, 0x7F, 0x1B,
  0x86, 0x01, 0x80, 0xE0, 0x38, 0x00, 0x1D, 0x9F, 0xCC, 0xEE, 0x66, 0x33,
  0x1B, 0x9D, 0xCC, 0x7E, 0x3B, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x36, 0x7C,
  0xEB, 0x87, 0x0C, 0x18, 0x30, 0xE1, 0xC0, 0x3E, 0xFD, 0xCB, 0x87, 0x87,
  0x87, 0x46, 0xFD, 0xF0, 0x31, 0x9F, 0xF6, 0x33, 0x98, 0xC6, 0x3D, 0xE0,
  0x63, 0x67, 0x66, 0xE6, 0xC6, 0xCE, 0xCE, 0xCC, 0xFC, 0xEC, 0xC7, 0xC6,
  0xCE, 0xCC, 0xDC, 0xD8, 0xD8, 0xF0, 0xF0, 0x60, 0xC6, 0x7C, 0xE6, 0xCE,
  0x6D, 0xEE, 0xDE, 0xCD, 0x6C, 0xF7, 0x8F, 0x78, 0xE7, 0x0E, 0x70, 0x39,
  0xC6, 0xE1, 0xB0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0xD8, 0x76, 0x39, 0xC0,
  0x31, 0xCC, 0x63, 0x38, 0xEC, 0x3F, 0x0F, 0x81, 0xE0, 0x70, 0x1C, 0x06,
  0x01, 0x80, 0xC0, 0xF0, 0x38, 0x00, 0x1F, 0x3F, 0x06, 0x0E, 0x0C, 0x18,
  0x38, 0x70, 0x7E, 0xFC, 0x06, 0x1C, 0x70, 0xC1, 0x83, 0x0E, 0x78, 0xE0,
  0xE0, 0xC3, 0x86, 0x0C, 0x1C, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x18,
  0x38, 0x30, 0x60, 0xC3, 0x87, 0x07, 0x1E, 0x30, 0xE1, 0x83, 0x0E, 0x38,
  0x60, 0x61, 0xFF, 0x9E,
};

const GFXglyph NotoSans_Condensed_BoldItalic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 13, 5, 0, -13 },
  { 10, 6, 5, 7, 2, -13 },
  { 14, 10, 13, 10, 0, -13 },
  { 31, 9, 15, 8, 0, -14 },
  { 48, 12, 13, 14, 1, -13 },
  { 68, 10, 13, 10, 0, -13 },
  { 85, 3, 5, 4, 2, -13 },
  { 87, 7, 16, 5, 0, -13 },
  { 101, 6, 16, 5, -1, -13 },
  { 113, 8, 8, 8, 1, -14 },
  { 121, 8, 9, 9, 1, -11 },
  { 130, 4, 4, 5, -1, -2 },
  { 132, 5, 2, 5, 0, -6 },
  { 134, 3, 3, 5, 0, -3 },
  { 136, 9, 13, 7, -1, -13 },
  { 151, 8, 13, 8, 0, -13 },
  { 164, 6, 13, 8, 2, -13 },
  { 174, 9, 13, 8, -1, -13 },
  { 189, 9, 13, 8, 0, -13 },
  { 204, 9, 13, 8, 0, -13 },
  { 219, 9, 13, 8, 0, -13 },
  { 234, 8, 13, 8, 1, -13 },
  { 247, 8, 13, 8, 1, -13 },
  { 260, 9, 13, 8, 0, -13 },
  { 275, 8, 13, 8, 0, -13 },
  { 288, 5, 10, 5, 0, -10 },
  { 295, 6, 12, 5, -1, -10 },
  { 304, 8, 9, 9, 1, -11 },
  { 313, 8, 5, 9, 1, -9 },
  { 318, 8, 9, 9, 1, -11 },
  { 327, 6, 13, 7, 1, -13 },
  { 337, 12, 15, 13, 1, -13 },
  { 360, 9, 13, 9, -1, -13 },
  { 375, 9, 13, 9, 0, -13 },
  { 390, 9, 13, 9, 1, -13 },
  { 405, 10, 13, 10, 0, -13 },
  { 422, 9, 13, 8, 0, -13 },
  { 437, 9, 13, 8, 0, -13 },
  { 452, 10, 13, 10, 1, -13 },
  { 469, 11, 13, 10, 0, -13 },
  { 487, 8, 13, 6, -1, -13 },
  { 500, 8, 17, 5, -3, -13 },
  { 517, 11, 13, 9, 0, -13 },
  { 535, 7, 13, 8, 0, -13 },
  { 547, 14, 13, 14, 0, -13 },
  { 570, 12, 13, 11, 0, -13 },
  { 590, 10, 13, 11, 1, -13 },
  { 607, 10, 13, 9, 0, -13 },
  { 624, 10, 16, 11, 1, -13 },
  { 644, 9, 13, 9, 0, -13 },
  { 659, 9, 13, 8, 0, -13 },
  { 674, 8, 13, 8, 1, -13 },
  { 687, 10, 13, 10, 1, -13 },
  { 704, 9, 13, 9, 2, -13 },
  { 719, 14, 13, 14, 1, -13 },
  { 742, 11, 13, 9, -1, -13 },
  { 760, 8, 13, 8, 2, -13 },
  { 773, 10, 13, 8, -1, -13 },
  { 790, 8, 16, 5, -1, -13 },
  { 806, 4, 13, 7, 2, -13 },
  { 813, 7, 16, 5, -1, -13 },
  { 827, 8, 8, 8, 0, -13 },
  { 835, 7, 1, 6, -2, 2 },
  { 836, 3, 3, 6, 3, -14 },
  { 838, 9, 10, 9, 0, -10 },
  { 850, 9, 14, 9, 0, -14 },
  { 866, 8, 10, 7, 0, -10 },
  { 876, 10, 14, 9, 0, -14 },
  { 894, 8, 10, 8, 0, -10 },
  { 904, 10, 18, 6, -2, -14 },
  { 927, 9, 14, 9, 0, -10 },
  { 943, 8, 14, 9, 0, -14 },
  { 957, 5, 14, 5, 0, -14 },
  { 966, 7, 18, 5, -2, -14 },
  { 982, 9, 14, 8, 0, -14 },
  { 998, 5, 14, 4, 0, -14 },
  { 1007, 13, 10, 13, 0, -10 },
  { 1024, 8, 10, 9, 0, -10 },
  { 1034, 8, 10, 9, 0, -10 },
  { 1044, 10, 14, 9, -1, -10 },
  { 1062, 9, 14, 9, 0, -10 },
  { 1078, 7, 10, 6, 0, -10 },
  { 1087, 7, 10, 7, 0, -10 },
  { 1096, 5, 12, 6, 1, -12 },
  { 1104, 8, 10, 9, 1, -10 },
  { 1114, 8, 10, 8, 1, -10 },
  { 1124, 12, 10, 12, 1, -10 },
  { 1139, 10, 10, 8, -1, -10 },
  { 1152, 10, 14, 8, -1, -10 },
  { 1170, 8, 10, 7, -1, -10 },
  { 1180, 7, 16, 6, 0, -13 },
  { 1194, 2, 18, 8, 3, -14 },
  { 1199, 7, 16, 6, -1, -13 },
  { 1213, 8, 3, 9, 1, -8 },
};

const GFXfont NotoSans_Condensed_BoldItalic18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BoldItalic18pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BoldItalic18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_CONDENSED_BOLDITALIC18PT7B_H_
