#ifndef _NOTOSANS_CONDENSED_BOLDITALIC11PT7B_H_
#define _NOTOSANS_CONDENSED_BOLDITALIC11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BoldItalic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BoldItalic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x2D, 0xA4, 0x36, 0xFF, 0xA0, 0x14, 0xA7, 0xCA, 0x53, 0xE5, 0x38,
  0x13, 0xD4, 0xE3, 0x9F, 0xCC, 0x40, 0x65, 0x52, 0xA7, 0xBF, 0xA5, 0x53,
  0xE6, 0x38, 0xA2, 0x8C, 0x77, 0x7D, 0xBF, 0xF8, 0x32, 0x64, 0x4C, 0xCC,
  0xC4, 0x31, 0x11, 0x13, 0x22, 0x4C, 0xAF, 0x6F, 0x21, 0x09, 0xF2, 0x10,
  0x78, 0xFC, 0x70, 0x04, 0x21, 0x84, 0x30, 0x86, 0x30, 0x3B, 0x52, 0x9D,
  0xEF, 0x4C, 0x37, 0xA2, 0x66, 0x44, 0x3A, 0xC2, 0x33, 0x33, 0x1E, 0x3A,
  0xC2, 0x67, 0x0E, 0x5E, 0x18, 0xCE, 0xA5, 0x7C, 0xC6, 0x3B, 0x18, 0xE1,
  0x8E, 0x5E, 0x19, 0x18, 0xFD, 0xEF, 0x4E, 0x7C, 0x21, 0x84, 0x30, 0x86,
  0x30, 0x3B, 0x5A, 0x67, 0x6F, 0x7E, 0x3B, 0xD2, 0xB7, 0x88, 0xDC, 0x68,
  0x0D, 0x80, 0x32, 0x00, 0x06, 0xC0, 0x08, 0xD9, 0xC1, 0x84, 0xFF, 0xC1,
  0xF0, 0x87, 0x0E, 0x3E, 0x40, 0x72, 0xC4, 0x66, 0x01, 0x18, 0x1E, 0x22,
  0x4D, 0x55, 0xAD, 0xAA, 0x94, 0x40, 0x38, 0x0C, 0x51, 0x4D, 0x25, 0xF6,
  0x71, 0x39, 0xB6, 0xDE, 0x79, 0x2D, 0xBC, 0x1C, 0xD6, 0x10, 0x43, 0x04,
  0x9C, 0x39, 0xB6, 0xDB, 0x4D, 0x3D, 0xBC, 0x3B, 0x18, 0xF7, 0x23, 0x1E,
  0x3B, 0x18, 0xC7, 0x23, 0x18, 0x1E, 0x69, 0x82, 0x05, 0xD9, 0x92, 0x3C,
  0x26, 0xC9, 0x93, 0xE7, 0xC9, 0xB2, 0x6C, 0x72, 0x26, 0x64, 0x4E, 0x08,
  0xC6, 0x31, 0x08, 0xC6, 0x37, 0x00, 0x26, 0xD9, 0xE2, 0x87, 0x0A, 0x36,
  0x6C, 0x26, 0x66, 0x44, 0xCF, 0x33, 0xB9, 0x9D, 0xCA, 0xE5, 0xF2, 0xD3,
  0x69, 0xAC, 0x22, 0xED, 0xDA, 0xA5, 0x4B, 0xB7, 0x66, 0x1C, 0x96, 0x51,
  0x47, 0x34, 0x9E, 0x39, 0xB6, 0xDB, 0x79, 0x0C, 0x30, 0x1C, 0xF6, 0x51,
  0x47, 0x34, 0x9E, 0x10, 0x60, 0x39, 0xB6, 0xD2, 0x71, 0x4D, 0xB6, 0x3B,
  0x58, 0xC3, 0x0A, 0xDC, 0xFB, 0x18, 0x84, 0x63, 0x18, 0x26, 0xC9, 0x92,
  0x64, 0xC9, 0x36, 0x38, 0x8C, 0xE5, 0x2B, 0x53, 0x98, 0x99, 0x9B, 0x9A,
  0xAA, 0xAE, 0xEC, 0xDC, 0xD8, 0x36, 0x68, 0x70, 0xC1, 0x85, 0x1A, 0x66,
  0xDE, 0xBC, 0xC6, 0x23, 0x18, 0x78, 0xC4, 0x66, 0x23, 0x1E, 0x36, 0x44,
  0x44, 0xC8, 0x8C, 0x9B, 0x24, 0x93, 0x38, 0x84, 0x23, 0x18, 0x84, 0x27,
  0x00, 0x11, 0x8C, 0x9C, 0x80, 0xF0, 0xC0, 0x7D, 0xA4, 0xB6, 0xD9, 0xC0,
  0x23, 0x1E, 0xD4, 0xAF, 0x76, 0x3B, 0x11, 0x8D, 0x38, 0x0C, 0x33, 0x92,
  0x4B, 0x6D, 0x9C, 0x3A, 0x5F, 0x8C, 0x38, 0x1C, 0x43, 0x9C, 0x20, 0x86,
  0x18, 0x63, 0x08, 0x00, 0x3D, 0xA4, 0xB6, 0xD9, 0xC1, 0x3C, 0xC0, 0x23,
  0x1E, 0xD4, 0xAF, 0x7A, 0x21, 0xA4, 0xB6, 0x10, 0x32, 0x22, 0x66, 0x4C,
  0x80, 0x21, 0x86, 0xD4, 0x71, 0xCD, 0x36, 0x2D, 0xA4, 0xB6, 0x5F, 0x6B,
  0x4B, 0x5A, 0xD2, 0xD6, 0x5B, 0x52, 0xBD, 0xE8, 0x3A, 0x73, 0xBD, 0xB8,
  0x2C, 0xD2, 0x4B, 0x6D, 0xE4, 0x10, 0xC0, 0x3D, 0x24, 0xB6, 0xD9, 0xC1,
  0x0C, 0x30, 0x57, 0x44, 0xCC, 0x74, 0x63, 0xBE, 0x27, 0x44, 0x4C, 0x60,
  0x6A, 0x52, 0xBD, 0xB8, 0x9B, 0xAE, 0xCC, 0xB7, 0x6B, 0xF6, 0xCD, 0x93,
  0x00, 0x2C, 0xE3, 0x8C, 0x3B, 0x20, 0x24, 0xB2, 0x8E, 0x30, 0xC2, 0x38,
  0xC0, 0x73, 0x24, 0xDE, 0x19, 0x88, 0x4C, 0x61, 0x08, 0x43, 0x00, 0xFF,
  0xE0, 0x30, 0x84, 0x61, 0x98, 0x84, 0x66, 0x00, 0x6D, 0xC0,
};

const GFXglyph NotoSans_Condensed_BoldItalic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 8, 3, 0, -8 },
  { 4, 4, 3, 5, 1, -8 },
  { 6, 6, 8, 6, 0, -8 },
  { 12, 5, 9, 5, 0, -8 },
  { 18, 7, 8, 8, 1, -8 },
  { 25, 6, 8, 6, 0, -8 },
  { 31, 2, 3, 3, 1, -8 },
  { 32, 4, 10, 3, 0, -8 },
  { 37, 4, 10, 3, -1, -8 },
  { 42, 4, 4, 5, 1, -8 },
  { 44, 5, 6, 5, 0, -7 },
  { 48, 3, 2, 3, -1, -1 },
  { 49, 3, 2, 3, 0, -4 },
  { 50, 2, 2, 3, 0, -2 },
  { 51, 6, 8, 4, -1, -8 },
  { 57, 5, 8, 5, 0, -8 },
  { 62, 4, 8, 5, 1, -8 },
  { 66, 5, 8, 5, 0, -8 },
  { 71, 5, 8, 5, 0, -8 },
  { 76, 5, 8, 5, 0, -8 },
  { 81, 5, 8, 5, 0, -8 },
  { 86, 5, 8, 5, 0, -8 },
  { 91, 6, 8, 5, 0, -8 },
  { 97, 5, 8, 5, 0, -8 },
  { 102, 5, 8, 5, 0, -8 },
  { 107, 3, 6, 3, 0, -6 },
  { 110, 4, 7, 3, -1, -6 },
  { 114, 5, 6, 5, 0, -7 },
  { 118, 5, 4, 5, 0, -6 },
  { 121, 5, 6, 5, 0, -7 },
  { 125, 5, 8, 4, 0, -8 },
  { 130, 8, 9, 8, 0, -8 },
  { 139, 6, 8, 6, -1, -8 },
  { 145, 6, 8, 6, 0, -8 },
  { 151, 6, 8, 5, 0, -8 },
  { 157, 6, 8, 6, 0, -8 },
  { 163, 5, 8, 5, 0, -8 },
  { 168, 5, 8, 5, 0, -8 },
  { 173, 7, 8, 6, 0, -8 },
  { 180, 7, 8, 6, 0, -8 },
  { 187, 4, 8, 4, 0, -8 },
  { 191, 5, 10, 3, -2, -8 },
  { 198, 7, 8, 6, 0, -8 },
  { 205, 4, 8, 5, 0, -8 },
  { 209, 9, 8, 8, 0, -8 },
  { 218, 7, 8, 7, 0, -8 },
  { 225, 6, 8, 7, 0, -8 },
  { 231, 6, 8, 6, 0, -8 },
  { 237, 6, 10, 7, 0, -8 },
  { 245, 6, 8, 6, 0, -8 },
  { 251, 5, 8, 5, 0, -8 },
  { 256, 5, 8, 5, 1, -8 },
  { 261, 7, 8, 6, 0, -8 },
  { 268, 5, 8, 6, 1, -8 },
  { 273, 8, 8, 8, 1, -8 },
  { 281, 7, 8, 5, -1, -8 },
  { 288, 5, 8, 5, 1, -8 },
  { 293, 5, 8, 5, 0, -8 },
  { 298, 4, 10, 3, 0, -8 },
  { 303, 3, 8, 4, 1, -8 },
  { 306, 5, 10, 3, -1, -8 },
  { 313, 5, 5, 5, 0, -8 },
  { 317, 4, 1, 4, -1, 1 },
  { 318, 2, 1, 3, 2, -8 },
  { 319, 6, 6, 6, 0, -6 },
  { 324, 5, 8, 6, 0, -8 },
  { 329, 5, 6, 4, 0, -6 },
  { 333, 6, 8, 6, 0, -8 },
  { 339, 5, 6, 5, 0, -6 },
  { 343, 6, 11, 3, -1, -8 },
  { 352, 6, 9, 6, 0, -6 },
  { 359, 5, 8, 6, 0, -8 },
  { 364, 3, 8, 3, 0, -8 },
  { 367, 4, 11, 3, -1, -8 },
  { 373, 6, 8, 5, 0, -8 },
  { 379, 3, 8, 3, 0, -8 },
  { 382, 8, 6, 8, 0, -6 },
  { 388, 5, 6, 6, 0, -6 },
  { 392, 5, 6, 5, 0, -6 },
  { 396, 6, 9, 6, -1, -6 },
  { 403, 6, 9, 6, 0, -6 },
  { 410, 4, 6, 4, 0, -6 },
  { 413, 4, 6, 4, 0, -6 },
  { 416, 4, 7, 4, 0, -7 },
  { 420, 5, 6, 5, 0, -6 },
  { 424, 4, 6, 5, 1, -6 },
  { 427, 7, 6, 7, 1, -6 },
  { 433, 6, 6, 5, -1, -6 },
  { 438, 6, 9, 5, -1, -6 },
  { 445, 4, 6, 4, 0, -6 },
  { 448, 5, 10, 4, 0, -8 },
  { 455, 1, 11, 5, 2, -8 },
  { 457, 5, 10, 4, -1, -8 },
  { 464, 5, 2, 5, 0, -5 },
};

const GFXfont NotoSans_Condensed_BoldItalic11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BoldItalic11pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BoldItalic11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_CONDENSED_BOLDITALIC11PT7B_H_
