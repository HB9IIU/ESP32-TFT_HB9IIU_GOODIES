#ifndef _NOTOSANS_CONDENSED_BOLDITALIC21PT7B_H_
#define _NOTOSANS_CONDENSED_BOLDITALIC21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BoldItalic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BoldItalic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x71, 0xCE, 0x38, 0xE3, 0x8C, 0x31, 0xC0, 0x00, 0x63, 0x8E,
  0x00, 0x76, 0xDF, 0xBF, 0x6C, 0xC0, 0x06, 0x60, 0x66, 0x0C, 0xC0, 0xCC,
  0x3F, 0xF7, 0xFE, 0x19, 0x81, 0x98, 0x1B, 0x0F, 0xFC, 0xFF, 0xC3, 0x60,
  0x66, 0x06, 0x60, 0x6E, 0x00, 0x01, 0x00, 0x80, 0xFC, 0x7F, 0x3A, 0x8F,
  0x03, 0xC0, 0xF8, 0x1F, 0x01, 0xE0, 0xBA, 0x2E, 0xCB, 0xBF, 0xC7, 0xE0,
  0x40, 0x10, 0x00, 0x3C, 0x39, 0xF0, 0xC6, 0xE6, 0x1B, 0x38, 0xCC, 0xC3,
  0x36, 0x0C, 0xDB, 0xBE, 0xDF, 0x77, 0x6C, 0x1B, 0x30, 0xCC, 0xC3, 0x33,
  0x18, 0xD8, 0xE3, 0xE7, 0x0F, 0x00, 0x07, 0x80, 0xFC, 0x1D, 0xC1, 0xDC,
  0x1D, 0x81, 0xF8, 0x1F, 0x03, 0xE7, 0x7E, 0x67, 0x7E, 0xE7, 0xCE, 0x3C,
  0xE7, 0xCF, 0xFC, 0x7D, 0xE0, 0x76, 0xEE, 0xC0, 0x07, 0x0E, 0x1C, 0x18,
  0x38, 0x38, 0x30, 0x70, 0x70, 0x60, 0x60, 0x60, 0xE0, 0xE0, 0x60, 0x60,
  0x60, 0x70, 0x0E, 0x06, 0x06, 0x07, 0x07, 0x07, 0x07, 0x07, 0x06, 0x06,
  0x0E, 0x0E, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0xF0, 0x1C, 0x1C, 0xD8, 0xFF,
  0x3F, 0x38, 0xEC, 0x6E, 0x4C, 0x1C, 0x0E, 0x07, 0x1F, 0xFF, 0xFF, 0xFC,
  0x70, 0x38, 0x1C, 0x0E, 0x00, 0x3B, 0x9C, 0xCE, 0x60, 0x7D, 0xFF, 0x80,
  0x7F, 0x80, 0x00, 0xE0, 0x38, 0x06, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80,
  0x70, 0x0C, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xC0, 0x38, 0x00, 0x0F,
  0x87, 0xE1, 0xDC, 0xE7, 0x31, 0xDC, 0x77, 0x1D, 0xC6, 0x63, 0x98, 0xEE,
  0x3B, 0x9C, 0x67, 0x1F, 0x83, 0xC0, 0x0E, 0x3C, 0xFF, 0xEE, 0xCB, 0x87,
  0x0E, 0x18, 0x70, 0xE1, 0xC3, 0x86, 0x1C, 0x00, 0x07, 0xC3, 0xF8, 0x77,
  0x84, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0xF8, 0xFF, 0x3F, 0xE0, 0x1F, 0x8F, 0xF1, 0x1C, 0x07, 0x01, 0xC0,
  0xE1, 0xF0, 0x78, 0x0F, 0x00, 0xE0, 0x38, 0x0E, 0x8F, 0x3F, 0x8F, 0xC0,
  0x01, 0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x86, 0xE1, 0xB8, 0xCC, 0x67, 0x39,
  0xCF, 0xFB, 0xFE, 0x06, 0x03, 0x80, 0xE0, 0x1F, 0xC7, 0xF1, 0xF8, 0x60,
  0x38, 0x0E, 0x03, 0xF1, 0xFE, 0x03, 0x80, 0xE0, 0x38, 0x1C, 0xCF, 0x3F,
  0x8F, 0xC0, 0x07, 0x8F, 0xCF, 0x06, 0x07, 0x03, 0x73, 0xFD, 0xFE, 0xE7,
  0x73, 0xB1, 0xD8, 0xEE, 0xE7, 0xF1, 0xF0, 0x7F, 0xDF, 0xF7, 0xF8, 0x0E,
  0x07, 0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x03, 0x80, 0xC0, 0x70, 0x38,
  0x0E, 0x00, 0x0F, 0x87, 0xF3, 0x9C, 0xE7, 0x39, 0xCE, 0xE1, 0xF0, 0x78,
  0x7F, 0x1C, 0xEE, 0x3B, 0x8E, 0xE3, 0x1F, 0xC7, 0xE0, 0x0F, 0x87, 0xE3,
  0x9C, 0xC7, 0x71, 0xDC, 0x77, 0x3D, 0xFE, 0x3F, 0x86, 0xE0, 0x30, 0x1C,
  0x8E, 0x3F, 0x0F, 0x80, 0x19, 0xCE, 0x60, 0x00, 0x00, 0x03, 0x39, 0xC0,
  0x0C, 0x71, 0xC6, 0x00, 0x00, 0x00, 0x00, 0xE7, 0x1C, 0x63, 0x8C, 0x00,
  0x00, 0x80, 0xC1, 0xE3, 0xC7, 0x87, 0x03, 0xE0, 0x7E, 0x07, 0x80, 0xC0,
  0x20, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x80, 0x60, 0x3C,
  0x07, 0x80, 0xF0, 0x1C, 0x3E, 0xF8, 0xF0, 0x60, 0x20, 0x00, 0x3E, 0x7E,
  0x47, 0x07, 0x06, 0x0E, 0x1C, 0x38, 0x70, 0x60, 0x00, 0x00, 0xE0, 0xE0,
  0xE0, 0x03, 0xE0, 0x3F, 0xC1, 0x81, 0x8C, 0x03, 0x63, 0xED, 0x9F, 0x3C,
  0xCC, 0xF3, 0x33, 0xD8, 0xDB, 0x66, 0x6D, 0x99, 0x37, 0xBC, 0xCC, 0xC3,
  0x00, 0x06, 0x08, 0x1F, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x78, 0x1F, 0x03,
  0x60, 0xEC, 0x1D, 0x83, 0x30, 0xE6, 0x18, 0xC7, 0xF8, 0xFF, 0x38, 0x67,
  0x0D, 0xC1, 0xF8, 0x38, 0x1F, 0x83, 0xFC, 0x77, 0x8C, 0x73, 0x8E, 0x73,
  0x8F, 0xE1, 0xFC, 0x73, 0xCE, 0x39, 0xC7, 0x38, 0xE6, 0x79, 0xFF, 0x3F,
  0x80, 0x0F, 0xE3, 0xF8, 0xF3, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0x30, 0xFE, 0x0F, 0xC0, 0x1F, 0x81,
  0xFC, 0x1F, 0xE1, 0x8E, 0x38, 0xF3, 0x8F, 0x38, 0xE3, 0x8E, 0x70, 0xE7,
  0x0E, 0x71, 0xC7, 0x3C, 0x7F, 0x8F, 0xF0, 0xFC, 0x00, 0x1F, 0xC7, 0xF1,
  0xFC, 0x60, 0x38, 0x0E, 0x03, 0xF8, 0xFC, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x7F, 0x3F, 0x8F, 0xE0, 0x1F, 0xC7, 0xF1, 0xFC, 0x60, 0x38, 0x0E, 0x03,
  0x88, 0xFC, 0x7F, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x00, 0x07,
  0xE3, 0xFC, 0xF1, 0x9C, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x1E, 0xE7, 0xDC,
  0x3B, 0x87, 0x70, 0xCF, 0x38, 0xFF, 0x0F, 0xE0, 0x1C, 0x38, 0xE1, 0x87,
  0x1C, 0x30, 0xE3, 0x87, 0x1C, 0x38, 0xFF, 0x87, 0xFC, 0x70, 0xE3, 0x87,
  0x1C, 0x38, 0xE3, 0x87, 0x1C, 0x70, 0xE3, 0x87, 0x00, 0x1F, 0xC7, 0xE0,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x60,
  0x38, 0x3F, 0x8F, 0xC0, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x1C,
  0x0E, 0x06, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x3C, 0x7C,
  0x3C, 0x00, 0x1C, 0x78, 0xE7, 0x07, 0x38, 0x33, 0x83, 0xB8, 0x1D, 0xC0,
  0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xB8, 0x1D, 0xC0, 0xE7, 0x06, 0x38, 0x71,
  0xC3, 0x8E, 0x00, 0x1C, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x38, 0x38, 0x70,
  0x70, 0x70, 0x70, 0x7F, 0xFE, 0xFE, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x1F,
  0x1E, 0x1F, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x7E, 0x36, 0x6E, 0x76, 0xEC,
  0x76, 0xCC, 0x76, 0xDC, 0x67, 0x9C, 0x67, 0x9C, 0xE7, 0x18, 0xE7, 0x38,
  0x1E, 0x1C, 0x78, 0x61, 0xE3, 0x87, 0x8E, 0x3E, 0x38, 0xFC, 0xC3, 0x73,
  0x0C, 0xDC, 0x73, 0x71, 0xCF, 0xC7, 0x3E, 0x18, 0xF8, 0x61, 0xE3, 0x87,
  0x8E, 0x1C, 0x00, 0x0F, 0xC3, 0xFC, 0xF7, 0xBC, 0x77, 0x0E, 0xE1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x87, 0x71, 0xEF, 0x78, 0xFE, 0x0F, 0x80,
  0x1F, 0xC3, 0xFC, 0x77, 0x8C, 0x73, 0x8E, 0x71, 0xCE, 0x79, 0xFE, 0x7F,
  0x8F, 0xC1, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x00, 0x0F, 0xC3, 0xFC,
  0xF7, 0xBC, 0x77, 0x0E, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x87,
  0x71, 0xEF, 0x78, 0xFE, 0x0F, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x1E, 0x00,
  0x1F, 0x83, 0xF8, 0x77, 0x8C, 0x73, 0x8E, 0x73, 0x8E, 0x71, 0xFC, 0x7F,
  0x0E, 0xE1, 0xDC, 0x39, 0xC6, 0x39, 0xC7, 0x38, 0xE0, 0x0F, 0xC7, 0xF3,
  0xD8, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x72, 0x1C,
  0xCF, 0x3F, 0x8F, 0xC0, 0xFF, 0xFF, 0xBF, 0xC7, 0x03, 0x81, 0xC0, 0xE0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x0E, 0x07, 0x03, 0x80, 0x38, 0x73, 0x8E,
  0x38, 0xE7, 0x0E, 0x70, 0xE7, 0x1C, 0x71, 0xC7, 0x1C, 0xE1, 0xCE, 0x1C,
  0xE3, 0x8E, 0x38, 0xF7, 0x8F, 0xF0, 0x7E, 0x00, 0xE1, 0xF8, 0x7E, 0x3B,
  0x8E, 0xE3, 0x39, 0xCE, 0x63, 0xB8, 0xEE, 0x3F, 0x0F, 0xC3, 0xE0, 0xF8,
  0x3C, 0x0F, 0x00, 0xE3, 0x87, 0xE3, 0x8E, 0xE3, 0x8E, 0xC7, 0x8C, 0xC7,
  0x9C, 0xCF, 0x9C, 0xCD, 0xB8, 0xCD, 0xB8, 0xD9, 0xB0, 0xD9, 0xF0, 0xF9,
  0xF0, 0xF1, 0xE0, 0xF1, 0xE0, 0xE1, 0xC0, 0xE1, 0xC0, 0x1C, 0x78, 0x63,
  0x83, 0xB8, 0x1D, 0xC0, 0xFC, 0x07, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00,
  0xFC, 0x07, 0xE0, 0x77, 0x07, 0x18, 0x38, 0xE3, 0x87, 0x00, 0xE3, 0xF8,
  0xEE, 0x73, 0x9C, 0x6E, 0x1B, 0x07, 0xC1, 0xE0, 0x78, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x18, 0x0E, 0x00, 0x1F, 0xE3, 0xFC, 0x03, 0x80, 0xE0, 0x38,
  0x07, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xFF,
  0x3F, 0xC0, 0x0F, 0x87, 0x83, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x38,
  0x1C, 0x0C, 0x06, 0x03, 0x03, 0x81, 0xC0, 0xC0, 0x78, 0x7C, 0x00, 0xE7,
  0x38, 0xC6, 0x31, 0x8E, 0x73, 0x8C, 0x63, 0x18, 0xE0, 0x1F, 0x1F, 0x06,
  0x06, 0x06, 0x0E, 0x0E, 0x0C, 0x0C, 0x1C, 0x1C, 0x1C, 0x18, 0x18, 0x38,
  0x38, 0xF0, 0xF0, 0x02, 0x01, 0xC0, 0xF0, 0x3C, 0x1B, 0x0E, 0xE3, 0x19,
  0x86, 0xE1, 0xC0, 0xFF, 0xE7, 0x30, 0x18, 0x4F, 0x67, 0xF9, 0xCE, 0xE3,
  0xB8, 0xCE, 0x33, 0x1C, 0xC7, 0x3B, 0xCF, 0xE3, 0xD8, 0x1C, 0x07, 0x01,
  0xC0, 0x60, 0x3B, 0x0F, 0xE3, 0xFC, 0xE7, 0x31, 0xDC, 0x77, 0x1D, 0xC6,
  0x73, 0x9C, 0xEF, 0xF3, 0x78, 0x0E, 0x3F, 0x7E, 0x70, 0xE0, 0xE0, 0xE0,
  0xC0, 0xC0, 0xE4, 0xFC, 0x7C, 0x00, 0xC0, 0x70, 0x1C, 0x07, 0x19, 0xCF,
  0x67, 0xF9, 0xCE, 0xE3, 0xB8, 0xCE, 0x33, 0x1C, 0xC7, 0x3B, 0xCF, 0xE3,
  0xD8, 0x0C, 0x3F, 0x7F, 0x63, 0xE7, 0xFF, 0xFC, 0xC0, 0xC0, 0xE2, 0xFE,
  0x7C, 0x01, 0xE0, 0x78, 0x1D, 0x03, 0x80, 0x70, 0x3F, 0x07, 0xE0, 0x70,
  0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38,
  0x07, 0x03, 0xE0, 0x78, 0x0E, 0x00, 0x0C, 0x23, 0xD8, 0xFF, 0x1C, 0xE7,
  0x1C, 0xE3, 0x1C, 0x63, 0x1C, 0x63, 0x8E, 0xF1, 0xFC, 0x3F, 0x80, 0x70,
  0x0E, 0x23, 0x87, 0xF0, 0xF8, 0x00, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x3B,
  0x0F, 0xF3, 0xFC, 0xE7, 0x39, 0xDC, 0x77, 0x19, 0xCE, 0x73, 0x98, 0xEE,
  0x33, 0x9C, 0x1C, 0x71, 0xC0, 0x00, 0xE3, 0x8E, 0x31, 0xC7, 0x1C, 0x71,
  0x8E, 0x38, 0x03, 0x81, 0xC0, 0xE0, 0x00, 0x00, 0x38, 0x1C, 0x0E, 0x06,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x1C, 0x0E, 0x2E, 0x1F,
  0x0F, 0x00, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x82, 0x73, 0x8E, 0xE1,
  0x98, 0x37, 0x0F, 0xC1, 0xF8, 0x3F, 0x06, 0x70, 0xCE, 0x39, 0xC7, 0x1C,
  0x1C, 0x71, 0xC6, 0x38, 0xE3, 0x8E, 0x31, 0xC7, 0x1C, 0x71, 0x8E, 0x38,
  0x0B, 0x0C, 0x6F, 0x7C, 0xFF, 0xF9, 0xCE, 0x73, 0x1C, 0xEE, 0x31, 0xDC,
  0xE3, 0x39, 0xCE, 0x63, 0x9C, 0xC6, 0x3B, 0x8C, 0x77, 0x39, 0xC0, 0x0B,
  0x0D, 0xF3, 0xFC, 0xE7, 0x31, 0xDC, 0x77, 0x19, 0xCE, 0x73, 0x98, 0xEE,
  0x33, 0x9C, 0x0C, 0x1F, 0x9F, 0xCE, 0x7E, 0x3F, 0x1F, 0x0D, 0x8E, 0xC7,
  0x77, 0xBF, 0x8F, 0x80, 0x01, 0x83, 0xF8, 0x7F, 0x8E, 0x71, 0x8E, 0x71,
  0xCE, 0x39, 0xC6, 0x39, 0xC7, 0x79, 0xFE, 0x3B, 0x87, 0x00, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x00, 0x18, 0x4F, 0x67, 0xF9, 0xCE, 0xE3, 0xB8, 0xCE,
  0x33, 0x1C, 0xC7, 0x3B, 0xCF, 0xE3, 0xD8, 0x0E, 0x03, 0x80, 0xE0, 0x30,
  0x1C, 0x00, 0x03, 0x3F, 0x3F, 0x3C, 0x38, 0x70, 0x70, 0x70, 0x70, 0x60,
  0xE0, 0xE0, 0x0E, 0x3F, 0x7F, 0x70, 0x78, 0x3C, 0x3E, 0x0E, 0x0E, 0x8E,
  0xFE, 0xFC, 0x18, 0xE3, 0x3F, 0xFD, 0xC7, 0x18, 0xE3, 0x8E, 0x38, 0xFB,
  0xE0, 0x71, 0xB9, 0xD8, 0xEC, 0x7E, 0x37, 0x3B, 0x9D, 0x8E, 0xEF, 0x7F,
  0x3D, 0x80, 0xE3, 0xF1, 0xB9, 0xDC, 0xCE, 0xE3, 0x61, 0xF0, 0xF0, 0x78,
  0x38, 0x1C, 0x00, 0xE7, 0x9F, 0x9E, 0x6E, 0xFB, 0xBB, 0xEC, 0xEF, 0x73,
  0xED, 0xCF, 0xB6, 0x3E, 0xF8, 0xF3, 0xC3, 0xCF, 0x0E, 0x38, 0x00, 0x1C,
  0xE3, 0xB8, 0x7E, 0x07, 0xC0, 0xF0, 0x1C, 0x07, 0xC1, 0xF8, 0x3B, 0x0E,
  0x73, 0x8E, 0x00, 0x1C, 0x71, 0xC6, 0x1C, 0xE0, 0xCC, 0x0D, 0xC0, 0xD8,
  0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1C, 0x03, 0xC0,
  0x78, 0x0F, 0x00, 0x1F, 0x9F, 0xC1, 0xC0, 0xE0, 0xE0, 0xE0, 0x70, 0x70,
  0x70, 0x3F, 0xBF, 0x80, 0x07, 0x87, 0x83, 0x81, 0x81, 0xC0, 0xE0, 0x70,
  0x70, 0x78, 0x78, 0x1C, 0x07, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x78, 0x1C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1C, 0x1E, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0C, 0x0C, 0x0F, 0x0F, 0x1E, 0x18, 0x38, 0x38, 0x38,
  0x70, 0xF0, 0xE0, 0xF8, 0xFF, 0xE3, 0xE0,
};

const GFXglyph NotoSans_Condensed_BoldItalic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 6, 15, 5, 0, -15 },
  { 13, 7, 5, 9, 2, -15 },
  { 18, 12, 15, 11, 0, -15 },
  { 41, 10, 17, 10, 0, -16 },
  { 63, 14, 15, 16, 1, -15 },
  { 90, 12, 15, 12, 0, -15 },
  { 113, 4, 5, 5, 2, -15 },
  { 116, 8, 18, 6, 0, -15 },
  { 134, 8, 18, 6, -2, -15 },
  { 152, 8, 9, 9, 2, -16 },
  { 161, 9, 10, 10, 1, -12 },
  { 173, 5, 6, 5, -1, -3 },
  { 177, 6, 3, 6, 0, -7 },
  { 180, 3, 3, 5, 0, -3 },
  { 182, 11, 15, 8, -1, -15 },
  { 203, 10, 15, 10, 0, -15 },
  { 222, 7, 15, 10, 2, -15 },
  { 236, 11, 15, 10, -1, -15 },
  { 257, 10, 15, 10, 0, -15 },
  { 276, 10, 15, 10, 0, -15 },
  { 295, 10, 15, 10, 0, -15 },
  { 314, 9, 15, 10, 1, -15 },
  { 331, 10, 15, 10, 1, -15 },
  { 350, 10, 15, 10, 0, -15 },
  { 369, 10, 15, 10, 0, -15 },
  { 388, 5, 12, 5, 0, -12 },
  { 396, 6, 15, 5, -1, -12 },
  { 408, 9, 11, 10, 1, -13 },
  { 421, 9, 7, 10, 1, -11 },
  { 429, 9, 11, 10, 1, -13 },
  { 442, 8, 15, 8, 1, -15 },
  { 457, 14, 17, 15, 1, -15 },
  { 487, 11, 15, 11, -1, -15 },
  { 508, 11, 15, 11, 0, -15 },
  { 529, 11, 15, 10, 1, -15 },
  { 550, 12, 15, 12, 0, -15 },
  { 573, 10, 15, 9, 0, -15 },
  { 592, 10, 15, 9, 0, -15 },
  { 611, 11, 15, 12, 1, -15 },
  { 632, 13, 15, 12, 0, -15 },
  { 657, 10, 15, 7, -1, -15 },
  { 676, 9, 19, 6, -3, -15 },
  { 698, 13, 15, 11, 0, -15 },
  { 723, 8, 15, 9, 0, -15 },
  { 738, 16, 15, 16, 0, -15 },
  { 768, 14, 15, 13, 0, -15 },
  { 795, 11, 15, 13, 1, -15 },
  { 816, 11, 15, 11, 0, -15 },
  { 837, 11, 19, 13, 1, -15 },
  { 864, 11, 15, 11, 0, -15 },
  { 885, 10, 15, 9, 0, -15 },
  { 904, 9, 15, 9, 2, -15 },
  { 921, 12, 15, 12, 1, -15 },
  { 944, 10, 15, 11, 2, -15 },
  { 963, 16, 15, 16, 2, -15 },
  { 993, 13, 15, 10, -1, -15 },
  { 1018, 10, 15, 10, 2, -15 },
  { 1037, 11, 15, 9, -1, -15 },
  { 1058, 9, 18, 6, -1, -15 },
  { 1079, 5, 15, 8, 2, -15 },
  { 1089, 8, 18, 6, -1, -15 },
  { 1107, 10, 9, 10, 0, -15 },
  { 1119, 8, 1, 7, -2, 2 },
  { 1120, 4, 3, 6, 3, -16 },
  { 1122, 10, 12, 11, 1, -12 },
  { 1137, 10, 16, 11, 0, -16 },
  { 1157, 8, 12, 8, 1, -12 },
  { 1169, 10, 16, 11, 1, -16 },
  { 1189, 8, 12, 10, 1, -12 },
  { 1201, 11, 21, 6, -2, -16 },
  { 1230, 11, 17, 11, 0, -12 },
  { 1254, 10, 16, 11, 0, -16 },
  { 1274, 6, 16, 5, 0, -16 },
  { 1286, 9, 21, 5, -3, -16 },
  { 1310, 11, 16, 10, 0, -16 },
  { 1332, 6, 16, 5, 0, -16 },
  { 1344, 15, 12, 16, 0, -12 },
  { 1367, 10, 12, 11, 0, -12 },
  { 1382, 9, 12, 10, 1, -12 },
  { 1396, 11, 17, 11, -1, -12 },
  { 1420, 10, 17, 11, 1, -12 },
  { 1442, 8, 12, 7, 0, -12 },
  { 1454, 8, 12, 8, 0, -12 },
  { 1466, 6, 14, 7, 1, -14 },
  { 1477, 9, 11, 10, 1, -11 },
  { 1490, 9, 11, 9, 1, -11 },
  { 1503, 14, 11, 14, 1, -11 },
  { 1523, 11, 11, 9, -1, -11 },
  { 1539, 12, 16, 9, -2, -11 },
  { 1563, 9, 11, 8, -1, -11 },
  { 1576, 9, 18, 7, 0, -15 },
  { 1597, 3, 21, 9, 3, -16 },
  { 1605, 8, 18, 7, -1, -15 },
  { 1623, 9, 3, 10, 1, -9 },
};

const GFXfont NotoSans_Condensed_BoldItalic21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BoldItalic21pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BoldItalic21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_CONDENSED_BOLDITALIC21PT7B_H_
