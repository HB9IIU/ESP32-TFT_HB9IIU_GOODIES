#ifndef _NOTOSANS_CONDENSED_BOLDITALIC65PT7B_H_
#define _NOTOSANS_CONDENSED_BOLDITALIC65PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BoldItalic.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BoldItalic65pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xF8, 0x00,
  0xFE, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xE1, 0xFE, 0x7F, 0xC7, 0xFC, 0xFF,
  0x0F, 0xF9, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0x8F, 0xE0,
  0xFE, 0x1F, 0xC1, 0xFC, 0x7F, 0x87, 0xF8, 0xFE, 0x0F, 0xF1, 0xFC, 0x1F,
  0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xC0, 0xFC, 0x3F, 0x81, 0xF8,
  0x7F, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0xFE, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0xFC, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFE,
  0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x73, 0xE0, 0x0F, 0xF1, 0xC3, 0x80, 0x7F,
  0xCE, 0x02, 0x01, 0xFE, 0x38, 0x00, 0x07, 0xF8, 0xE0, 0x00, 0x1F, 0xE3,
  0x80, 0x00, 0x7F, 0xCE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xDF, 0xF8, 0x00, 0x07, 0x3F, 0xE0, 0x00, 0x38,
  0xFF, 0x80, 0x00, 0xE3, 0xFE, 0x10, 0x03, 0x8F, 0xF0, 0x60, 0x0E, 0x7F,
  0xC3, 0xE0, 0x79, 0xFF, 0x0F, 0xF1, 0xDF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xE0,
  0x01, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xC0, 0x07,
  0xFF, 0xF0, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0xE7,
  0xF0, 0x07, 0xF0, 0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x00, 0x1F, 0x83, 0xF0,
  0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x01, 0xFC, 0x00, 0x3F, 0x83, 0xF0, 0x1F,
  0x80, 0x03, 0xF0, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x3F, 0x00,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0xFE, 0x00, 0x07,
  0xE0, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xE1, 0xFC, 0x00, 0x07, 0xE0,
  0xFE, 0x1F, 0x80, 0x00, 0xFE, 0x0F, 0xE3, 0xF8, 0x08, 0x0F, 0xE0, 0xFC,
  0x7F, 0x0F, 0xF0, 0xFE, 0x1F, 0xC7, 0xE1, 0xFF, 0xCF, 0xE1, 0xF8, 0xFE,
  0x3F, 0xFC, 0x7E, 0x3F, 0x8F, 0xC7, 0xFF, 0xE7, 0xFF, 0xF1, 0xFC, 0xFF,
  0xFE, 0x7F, 0xFF, 0x3F, 0x8F, 0xEF, 0xF7, 0xFF, 0xE3, 0xF1, 0xFC, 0x7F,
  0x3F, 0xFC, 0x7F, 0x1F, 0x87, 0xF1, 0xFF, 0x8F, 0xE3, 0xF8, 0x7F, 0x07,
  0xE0, 0xFE, 0x3F, 0x07, 0xF0, 0x00, 0x1F, 0xC7, 0xF0, 0x7F, 0x00, 0x01,
  0xF8, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x87, 0xF0, 0x7E, 0x00, 0x07, 0xF0,
  0x7E, 0x07, 0xE0, 0x00, 0x7F, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0x00, 0xFC, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x0F,
  0xC0, 0x03, 0xF8, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x00, 0xFE, 0x1F, 0xC0,
  0x07, 0xF0, 0x0F, 0xE1, 0xF8, 0x00, 0x7E, 0x00, 0xFE, 0x3F, 0x80, 0x0F,
  0xE0, 0x0F, 0xF7, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0x80,
  0x07, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x00, 0x03,
  0xFF, 0x80, 0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x07, 0xF8, 0x7F,
  0xC0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF1, 0xFF,
  0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x01,
  0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xE0, 0x7F, 0xFF, 0x83, 0xFE, 0x0F, 0xFF,
  0xFC, 0x3F, 0xC1, 0xFF, 0x7F, 0xC3, 0xFC, 0x3F, 0xE3, 0xFE, 0x7F, 0x83,
  0xFC, 0x3F, 0xE7, 0xF8, 0x7F, 0xC3, 0xFF, 0xFF, 0x07, 0xF8, 0x1F, 0xFF,
  0xF0, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0x00,
  0xFF, 0xFC, 0x0F, 0xF0, 0x07, 0xFF, 0x80, 0xFF, 0x00, 0x7F, 0xF8, 0x0F,
  0xF0, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x1F, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF7, 0xFE, 0x01,
  0xFF, 0xFC, 0x3F, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1F, 0xE7, 0xFC, 0xFF, 0x9F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFC,
  0x7F, 0x8F, 0xF1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0x87, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x01, 0x81, 0xFC, 0x00, 0xF0,
  0x7F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0xF7, 0xE0, 0x37, 0xFF, 0xFB, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xCF, 0xC0, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xF7, 0xF0, 0x1F, 0xF9, 0xFC, 0x03,
  0xFE, 0x3F, 0x80, 0x7F, 0x0F, 0xF0, 0x0F, 0x83, 0xFC, 0x01, 0xE0, 0x7F,
  0x80, 0x30, 0x1F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xFC, 0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0x3F, 0xC1, 0xFF, 0x07,
  0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xFC, 0x0F,
  0xF0, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF,
  0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0x0F, 0x87,
  0xF8, 0xFF, 0x3F, 0xF7, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0x7F, 0x8F, 0xE0,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x81, 0xFE, 0x0F, 0xF8, 0x0F, 0xF0, 0x7F, 0xC0, 0x7F, 0x87, 0xFC, 0x03,
  0xFC, 0x3F, 0xE0, 0x1F, 0xE1, 0xFF, 0x00, 0xFF, 0x1F, 0xF0, 0x07, 0xF8,
  0xFF, 0x80, 0x7F, 0xC7, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x1F, 0xF3, 0xFE,
  0x00, 0xFF, 0x9F, 0xF0, 0x07, 0xFC, 0xFF, 0x80, 0x3F, 0xC7, 0xF8, 0x03,
  0xFE, 0x7F, 0xC0, 0x1F, 0xF3, 0xFE, 0x00, 0xFF, 0x9F, 0xF0, 0x07, 0xFC,
  0xFF, 0x80, 0x3F, 0xC7, 0xFC, 0x03, 0xFE, 0x3F, 0xC0, 0x1F, 0xF1, 0xFE,
  0x00, 0xFF, 0x8F, 0xF0, 0x0F, 0xF8, 0x7F, 0x80, 0x7F, 0xC7, 0xFC, 0x03,
  0xFE, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0x01, 0xFF, 0x07, 0xF8, 0x1F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x81, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x81,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x3F, 0xFB,
  0xFC, 0x7F, 0xDF, 0xF1, 0xFE, 0x7F, 0xC3, 0xE1, 0xFE, 0x07, 0x07, 0xF8,
  0x18, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x83, 0xFF, 0x00,
  0x7E, 0x01, 0xFF, 0x00, 0x3C, 0x01, 0xFF, 0x00, 0x38, 0x01, 0xFF, 0x00,
  0x10, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x3C, 0x07, 0xFF, 0x00, 0x30, 0x03, 0xFF, 0x00,
  0x20, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x80,
  0x00, 0x7F, 0xE0, 0xE0, 0x00, 0xFF, 0xE0, 0xFC, 0x03, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x01, 0xF4, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x03, 0xF7, 0xF8, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x0F, 0xEF, 0xF0, 0x00,
  0x0F, 0xCF, 0xF0, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x3F, 0x8F, 0xF0, 0x00,
  0x3F, 0x1F, 0xF0, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0xFE, 0x1F, 0xE0, 0x01,
  0xFC, 0x1F, 0xE0, 0x01, 0xF8, 0x1F, 0xE0, 0x03, 0xF8, 0x3F, 0xE0, 0x07,
  0xF0, 0x3F, 0xC0, 0x07, 0xE0, 0x3F, 0xC0, 0x0F, 0xE0, 0x3F, 0xC0, 0x1F,
  0xC0, 0x7F, 0xC0, 0x3F, 0x80, 0x7F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0,
  0x03, 0x80, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x08, 0x00,
  0x0F, 0xFC, 0x1C, 0x00, 0x7F, 0xF0, 0x3F, 0x01, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x1E,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x87,
  0xF0, 0x01, 0xFE, 0x7F, 0xE0, 0x0F, 0xFB, 0xFF, 0xC0, 0x3F, 0xDF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xF8, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0x07, 0xFE, 0x03, 0xFC, 0x3F,
  0xF0, 0x0F, 0xF0, 0xFF, 0xC0, 0x3F, 0xC3, 0xFE, 0x00, 0xFF, 0x0F, 0xF8,
  0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0xC3, 0xFC, 0x01,
  0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF,
  0x83, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF1, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x07,
  0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x3F, 0xE0, 0x3F,
  0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x03, 0xFE,
  0x01, 0xFF, 0x0F, 0xF8, 0x03, 0xFE, 0x3F, 0xE0, 0x03, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xE7, 0xFE, 0x01, 0xFF,
  0x87, 0xFC, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0,
  0x0F, 0xF0, 0x7F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xE1, 0xFE, 0x00,
  0x7F, 0x87, 0xFC, 0x00, 0xFF, 0x0F, 0xF8, 0x01, 0xFE, 0x1F, 0xF0, 0x07,
  0xFC, 0x3F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xF1, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFE, 0x1F,
  0xF8, 0x3F, 0xE0, 0x7F, 0xC3, 0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x1F, 0xF0,
  0xFF, 0x00, 0xFF, 0x8F, 0xF8, 0x07, 0xFC, 0x7F, 0xC0, 0x3F, 0xE3, 0xFE,
  0x01, 0xFF, 0x1F, 0xE0, 0x0F, 0xF8, 0xFF, 0x00, 0x7F, 0xC7, 0xF8, 0x07,
  0xFE, 0x3F, 0xC0, 0x3F, 0xF1, 0xFE, 0x03, 0xFF, 0x0F, 0xF8, 0x1F, 0xF8,
  0x7F, 0xC1, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFB,
  0xFE, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0xE1, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x10, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFC, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0xFF, 0xE0,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x01,
  0xFC, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80,
  0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x1F, 0xC3, 0xFF, 0x0E,
  0x01, 0xFF, 0x08, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x40, 0x07, 0xE0, 0x3F,
  0x00, 0x7F, 0xF0, 0x7F, 0x07, 0xF0, 0x1F, 0xFF, 0xC3, 0xF0, 0xFE, 0x03,
  0xFF, 0xF8, 0x3F, 0x0F, 0xC0, 0xFF, 0xFF, 0x83, 0xF1, 0xFC, 0x0F, 0xFF,
  0xF8, 0x3F, 0x1F, 0x81, 0xFC, 0x3F, 0x83, 0xF1, 0xF8, 0x3F, 0x83, 0xF0,
  0x3F, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF3, 0xF0, 0x7F, 0x03, 0xF0, 0x3F,
  0x3F, 0x07, 0xE0, 0x7F, 0x07, 0xE7, 0xE0, 0xFE, 0x07, 0xE0, 0x7E, 0x7E,
  0x0F, 0xC0, 0x7E, 0x07, 0xE7, 0xE0, 0xFC, 0x07, 0xE0, 0x7E, 0x7E, 0x1F,
  0xC0, 0xFE, 0x07, 0xCF, 0xC1, 0xF8, 0x0F, 0xC0, 0xFC, 0xFC, 0x1F, 0x80,
  0xFC, 0x0F, 0xCF, 0xC1, 0xF8, 0x0F, 0xC0, 0xF8, 0xFC, 0x1F, 0x81, 0xFC,
  0x1F, 0x8F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0xFC, 0x1F, 0x83, 0xF8, 0x3F,
  0x0F, 0xC1, 0xF8, 0x7F, 0x87, 0xE0, 0xFC, 0x1F, 0xCF, 0xFC, 0xFE, 0x0F,
  0xC1, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x0F, 0xFE, 0x7F, 0xF8, 0x0F, 0xC0,
  0xFF, 0xE7, 0xFF, 0x00, 0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xE0, 0x0F,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x03, 0xFD, 0xFC,
  0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x1F, 0xE7,
  0xF0, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x01, 0xFE,
  0x1F, 0xE0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x7F, 0x81, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xE0,
  0x07, 0xFC, 0x07, 0xF8, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xF0, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0x83, 0xFE,
  0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x07, 0xF8, 0x7F, 0xC0, 0x01, 0xFE, 0x1F,
  0xF0, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x07, 0xF8,
  0xFF, 0x80, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x01,
  0xFE, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x7F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03,
  0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xF8, 0x01, 0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x0F, 0xF0, 0x1F, 0xF0, 0x07,
  0xFC, 0x07, 0xFC, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0x80,
  0x3F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFE, 0x03, 0xFE,
  0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x3C, 0x01, 0xFF,
  0xC0, 0x04, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x18, 0x00, 0xFF, 0xF0, 0x7C, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFC, 0x7F, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xF8, 0x07, 0xFE,
  0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0x3F, 0xF0, 0x1F, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x1F,
  0xF0, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x03, 0xFF,
  0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x03, 0xFE, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x3F, 0xE0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x7F,
  0xC0, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x07, 0xFC,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xF8, 0x00,
  0xFF, 0xC0, 0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xF8, 0x01, 0xFF, 0x81, 0xFF,
  0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xE0, 0x3F,
  0xFC, 0x03, 0xFE, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0x80, 0x7F, 0xF8, 0x00, 0x60, 0x1F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x7F, 0xFE, 0x1F, 0xF0, 0x1F, 0xFF, 0xC3, 0xFE, 0x03, 0xFF, 0xF8, 0xFF,
  0xC0, 0x7F, 0xFF, 0x1F, 0xF8, 0x0F, 0xFF, 0xE3, 0xFE, 0x01, 0xFF, 0xF8,
  0x7F, 0xC0, 0x7F, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x07,
  0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x80,
  0x07, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xF0, 0x7F,
  0xE0, 0x03, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xF0,
  0x1F, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x01, 0xFF,
  0x80, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x10, 0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x00,
  0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xF0, 0x00,
  0x3F, 0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x01, 0xFF, 0x07,
  0xFE, 0x00, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0xFF, 0xC0, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x00, 0x7F, 0xCF,
  0xFC, 0x00, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x7F, 0xE0, 0x00,
  0x07, 0xFD, 0xFF, 0x80, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xF7, 0xFC, 0x00, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x01, 0xFE,
  0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x7F,
  0x81, 0xFF, 0x00, 0x00, 0xFF, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x1F,
  0xE0, 0x1F, 0xF8, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x07,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x07, 0xF7, 0xF8, 0x01, 0xFD, 0xFC, 0x03,
  0xFD, 0xFE, 0x00, 0xFF, 0x7F, 0x00, 0xFE, 0xFF, 0x80, 0x3F, 0xDF, 0xC0,
  0x3F, 0xBF, 0xC0, 0x0F, 0xF7, 0xF0, 0x1F, 0xCF, 0xF0, 0x03, 0xFD, 0xFC,
  0x07, 0xF3, 0xFC, 0x00, 0xFF, 0x7F, 0x03, 0xFD, 0xFF, 0x00, 0x7F, 0x8F,
  0xE0, 0xFE, 0x7F, 0xC0, 0x1F, 0xE3, 0xF8, 0x7F, 0x9F, 0xE0, 0x07, 0xF8,
  0xFE, 0x1F, 0xC7, 0xF8, 0x01, 0xFE, 0x3F, 0x8F, 0xF1, 0xFE, 0x00, 0x7F,
  0x8F, 0xE3, 0xF8, 0xFF, 0x80, 0x3F, 0xC3, 0xF9, 0xFE, 0x3F, 0xC0, 0x0F,
  0xF0, 0xFE, 0x7F, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0x9F, 0xC3, 0xFC, 0x00,
  0xFF, 0x0F, 0xEF, 0xE0, 0xFF, 0x00, 0x7F, 0x83, 0xFB, 0xF8, 0x7F, 0xC0,
  0x1F, 0xE0, 0xFF, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xFF, 0x07, 0xF8,
  0x01, 0xFE, 0x0F, 0xFF, 0x81, 0xFE, 0x00, 0x7F, 0x83, 0xFF, 0xE0, 0x7F,
  0x80, 0x3F, 0xC0, 0xFF, 0xF0, 0x3F, 0xE0, 0x0F, 0xF0, 0x3F, 0xFC, 0x0F,
  0xF0, 0x03, 0xFC, 0x0F, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFF, 0x80,
  0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0xE0, 0x7F, 0xC0, 0x1F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xFC, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xFE,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xE0, 0x3F,
  0xC0, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xC0, 0x0F, 0xFC,
  0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xF8, 0x01, 0xFF, 0xE0, 0x01,
  0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xFE, 0x00, 0x1F, 0xE0,
  0x07, 0xFF, 0xC0, 0x0F, 0xF0, 0x01, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xC0,
  0x1F, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x7F, 0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0xE0, 0x07,
  0xFB, 0xFC, 0x0F, 0xF8, 0x01, 0xFC, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x3F,
  0xC0, 0xFF, 0x00, 0x3F, 0xCF, 0xF0, 0x3F, 0xC0, 0x0F, 0xF3, 0xFC, 0x1F,
  0xF0, 0x03, 0xFC, 0x7F, 0x87, 0xF8, 0x00, 0xFF, 0x1F, 0xE1, 0xFE, 0x00,
  0x7F, 0x87, 0xF8, 0x7F, 0x80, 0x1F, 0xE1, 0xFE, 0x1F, 0xE0, 0x07, 0xF8,
  0x3F, 0xC7, 0xF8, 0x01, 0xFE, 0x0F, 0xF3, 0xFC, 0x00, 0x7F, 0x83, 0xFC,
  0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0, 0x0F, 0xF0, 0x3F, 0xCF, 0xF0,
  0x03, 0xFC, 0x07, 0xFB, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0xFE, 0x00, 0x7F,
  0x80, 0x7F, 0xFF, 0x80, 0x1F, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xF8, 0x03,
  0xFF, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xF0, 0x03, 0xFF, 0xF0, 0x03,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xFF, 0x80, 0x1F, 0xE0, 0x01, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x3F,
  0xF8, 0x01, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xE0,
  0x1F, 0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xF0, 0xFF,
  0xC0, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x0F, 0xF8,
  0xFF, 0xC0, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x07,
  0xFC, 0xFF, 0x80, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x1F, 0xF7, 0xFE, 0x00,
  0x07, 0xFE, 0xFF, 0xC0, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0x1F, 0xFB, 0xFE,
  0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x0F, 0xFB,
  0xFF, 0x00, 0x03, 0xFF, 0x7F, 0xC0, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x0F,
  0xF9, 0xFF, 0x00, 0x03, 0xFF, 0x3F, 0xE0, 0x00, 0x7F, 0xE7, 0xFC, 0x00,
  0x0F, 0xF8, 0xFF, 0x80, 0x03, 0xFF, 0x1F, 0xF0, 0x00, 0x7F, 0xE3, 0xFE,
  0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x07, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xC1,
  0xFF, 0x80, 0x3F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0xC7, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x1F, 0xFE, 0x00,
  0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF0, 0x03, 0xFE, 0x03, 0xFE, 0x00,
  0xFF, 0xC0, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x1F, 0xF8, 0x0F, 0xF8, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x07, 0xF8, 0x1F, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xC1,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0x83, 0xFF,
  0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xC7,
  0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x3F,
  0xE7, 0xFE, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0xFF, 0xBF, 0xF0, 0x00,
  0x1F, 0xF7, 0xFE, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0xFF, 0xDF, 0xF0,
  0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xDF,
  0xF8, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x03, 0xFF, 0x7F, 0xC0, 0x00, 0x7F,
  0xEF, 0xF8, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x03, 0xFF, 0x3F, 0xE0, 0x00,
  0x7F, 0xE7, 0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x03, 0xFF, 0x1F, 0xF0,
  0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x07, 0xFF, 0x0F,
  0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFE,
  0x03, 0xFF, 0xCF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0x81,
  0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFC,
  0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0x3F,
  0xC1, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x8F, 0xF0, 0x00,
  0x7F, 0xC7, 0xFC, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x00,
  0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xF8, 0x1F, 0xF0,
  0x03, 0xFC, 0x0F, 0xF8, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xE0, 0x3F, 0xC0, 0x1F,
  0xF0, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x0F, 0xF8, 0x03,
  0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0xFC, 0x01, 0xFF,
  0xC0, 0x18, 0x01, 0xFF, 0x80, 0x08, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x40, 0x00,
  0x7F, 0xC0, 0x70, 0x00, 0xFF, 0xC0, 0x7C, 0x01, 0xFF, 0xC0, 0x7F, 0xCF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x03, 0xFE,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x03, 0xFE, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x3F, 0xE0, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x7F,
  0xC0, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x07, 0xFC,
  0x07, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0x1F, 0xF0, 0x1F, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x1F, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x03,
  0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x03, 0xFE, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x7F, 0xC0, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x07,
  0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xF1, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF,
  0x80, 0x03, 0xFE, 0xFF, 0x80, 0x07, 0xFC, 0xFF, 0x80, 0x07, 0xFC, 0xFF,
  0x80, 0x0F, 0xF8, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xF0, 0xFF,
  0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF,
  0x80, 0x3F, 0xC0, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0xC0, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0x7F,
  0x81, 0xFF, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x7F,
  0x87, 0xF8, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x7F,
  0x9F, 0xF0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x7F,
  0xBF, 0xC0, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F,
  0x7F, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xDF, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF9, 0xFE, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x7F, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x1F, 0xE0,
  0x07, 0xFE, 0x00, 0x7F, 0xC7, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xE1, 0xFE,
  0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x7F, 0x80, 0x3F, 0xF8, 0x03, 0xFC, 0x1F,
  0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0x07, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xC1,
  0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0xF8, 0x0F, 0xF8,
  0x1F, 0xE0, 0x3F, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xFF, 0x80, 0xFF,
  0x01, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xC0, 0x7F, 0x81, 0xFF, 0xF8, 0x1F,
  0xE0, 0x1F, 0xE0, 0xFE, 0xFE, 0x0F, 0xF8, 0x07, 0xF8, 0x3F, 0xBF, 0x83,
  0xFC, 0x01, 0xFE, 0x1F, 0xEF, 0xE0, 0xFF, 0x00, 0x7F, 0x87, 0xF3, 0xF8,
  0x7F, 0xC0, 0x1F, 0xE1, 0xFC, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0xFE, 0x3F,
  0x8F, 0xF8, 0x01, 0xFE, 0x3F, 0x8F, 0xE3, 0xFC, 0x00, 0x7F, 0x1F, 0xE3,
  0xF8, 0xFF, 0x00, 0x3F, 0xC7, 0xF0, 0xFE, 0x7F, 0xC0, 0x0F, 0xF1, 0xFC,
  0x3F, 0x9F, 0xE0, 0x03, 0xFC, 0xFE, 0x0F, 0xEF, 0xF8, 0x00, 0xFF, 0x3F,
  0x83, 0xFB, 0xFC, 0x00, 0x3F, 0xDF, 0xE0, 0xFE, 0xFF, 0x00, 0x0F, 0xF7,
  0xF0, 0x3F, 0x7F, 0xC0, 0x03, 0xFD, 0xFC, 0x0F, 0xDF, 0xE0, 0x00, 0xFF,
  0xFE, 0x03, 0xF7, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x00, 0x1F,
  0xEF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x00,
  0x7F, 0xCF, 0xF8, 0x00, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x00, 0x3F, 0xE3,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x1F,
  0xF8, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0xBF, 0xE0,
  0x07, 0xFC, 0x7F, 0x80, 0x3F, 0xE1, 0xFE, 0x00, 0xFF, 0x87, 0xFC, 0x07,
  0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x07, 0xFC,
  0x03, 0xFC, 0x1F, 0xF0, 0x0F, 0xF0, 0xFF, 0x80, 0x3F, 0xC3, 0xFE, 0x00,
  0xFF, 0x1F, 0xF0, 0x03, 0xFE, 0x7F, 0x80, 0x07, 0xFB, 0xFE, 0x00, 0x1F,
  0xEF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x7F,
  0x81, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x81,
  0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFE,
  0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x3F, 0x9F, 0xC0, 0x01, 0xFE, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x3F,
  0x83, 0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x80,
  0x7F, 0x01, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0xC0, 0x1F,
  0xC0, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x3F, 0xC0, 0x03, 0xF8,
  0xFE, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xC3, 0xFE, 0x1F, 0xF8, 0x7F, 0xC3, 0xFE, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE,
  0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x00, 0x1F, 0xC0, 0x02, 0x00, 0xFF, 0xC3,
  0xF8, 0x03, 0xFF, 0xC7, 0xF0, 0x0F, 0xFF, 0xDF, 0xE0, 0x3F, 0xFF, 0xBF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x3F, 0xFC,
  0x0F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xC0, 0x7F, 0xE1,
  0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x1F,
  0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xF0, 0x7F, 0xC0, 0x1F, 0xE0, 0xFF,
  0x80, 0x7F, 0xC3, 0xFE, 0x00, 0xFF, 0x87, 0xFC, 0x01, 0xFF, 0x0F, 0xF8,
  0x03, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0,
  0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x07,
  0xFE, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0xFF,
  0x00, 0x7F, 0xF9, 0xFE, 0x00, 0xFF, 0xE3, 0xF8, 0x00, 0x7F, 0x87, 0xF0,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE1, 0xF8, 0x00,
  0x7F, 0xCF, 0xF8, 0x00, 0xFF, 0x3F, 0xF8, 0x01, 0xFE, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xF8, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x83, 0xFE,
  0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF0, 0x07, 0xFC, 0x1F, 0xE0,
  0x0F, 0xF8, 0x3F, 0xC0, 0x1F, 0xF0, 0xFF, 0x00, 0x3F, 0xE1, 0xFE, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x07,
  0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0x00, 0x7F,
  0xC1, 0xFE, 0x00, 0xFF, 0x87, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFC,
  0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F,
  0xEF, 0xFF, 0xE0, 0x1F, 0xDF, 0xFF, 0x80, 0x7F, 0x1F, 0xFE, 0x00, 0xFE,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFC, 0x78, 0x0F, 0xFC, 0x02,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0xC0, 0xFF, 0xC0, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0x8F, 0xF0, 0x01, 0xFF,
  0xE7, 0xF8, 0x01, 0xFF, 0xFB, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xE7, 0xFF, 0x80, 0x7F,
  0xC1, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x0F,
  0xF8, 0x03, 0xFE, 0x07, 0xFC, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x3F, 0xE0,
  0x7F, 0xC0, 0x1F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0, 0x07, 0xF8,
  0x0F, 0xF0, 0x07, 0xFC, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xC1, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFB, 0xF8, 0x00, 0xFF, 0xF9, 0xFC, 0x00, 0x3F, 0xF8,
  0xFC, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xDF, 0xF8, 0x7F,
  0xE0, 0xFF, 0x0F, 0xF8, 0x1F, 0xE3, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0x7F,
  0x9F, 0xF0, 0x0F, 0xF3, 0xFC, 0x03, 0xFE, 0x7F, 0x80, 0xFF, 0x9F, 0xF0,
  0x7F, 0xF3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0xC0, 0xFF, 0xC0, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x40, 0x03, 0xFF, 0x0F, 0xE0, 0x01, 0xFF, 0xE3, 0xF8, 0x00, 0xFF,
  0xFD, 0xFE, 0x00, 0x7F, 0xFF, 0x7F, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x3F, 0xFC, 0x01, 0xFF, 0x87, 0xFF, 0x00,
  0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x3F,
  0xE0, 0x3F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x01,
  0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xEF, 0xF8, 0x00, 0x7F, 0xF3,
  0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x00, 0x20, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x0C, 0x00, 0x1F, 0xF0, 0x03,
  0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE1, 0xF8, 0x00, 0x7F, 0xCF, 0xFC,
  0x00, 0xFF, 0x3F, 0xFC, 0x01, 0xFE, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFE, 0xFF, 0xE0,
  0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x83, 0xFF, 0x01, 0xFE, 0x07,
  0xFC, 0x03, 0xFC, 0x0F, 0xF8, 0x07, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F,
  0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x00, 0xFF, 0x03, 0xFE,
  0x01, 0xFE, 0x07, 0xF8, 0x07, 0xFC, 0x0F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0,
  0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x81, 0xFE, 0x01,
  0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x0F,
  0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0xC1, 0xFF, 0x00, 0xFF,
  0x83, 0xFE, 0x01, 0xFE, 0x07, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF8,
  0x1F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0x80,
  0x00, 0x1F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x10, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x03,
  0xFE, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x0F, 0xF8,
  0x3F, 0xE0, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x3F,
  0xC7, 0xFC, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x01,
  0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xF3,
  0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0xFF,
  0x07, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x07,
  0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xC0,
  0x1F, 0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xF0, 0xFF,
  0xC0, 0xFF, 0xC0, 0x1F, 0xCF, 0xFF, 0x8F, 0xFF, 0x80, 0x7F, 0x7F, 0xFE,
  0x7F, 0xFE, 0x01, 0xFD, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF3, 0xFF, 0xF3,
  0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF8, 0x0F,
  0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xC1, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x83, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x0F,
  0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x83, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x1F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xC1, 0xFE, 0x01,
  0xFF, 0x01, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xE0, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0x83, 0xFC, 0x03, 0xFE,
  0x03, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x3F, 0xC0, 0x3F, 0xC0,
  0x3F, 0xC1, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x03,
  0xFC, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0x80, 0x7F, 0x80, 0x7F,
  0xC1, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xF8,
  0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xF8,
  0x7F, 0xE0, 0x07, 0xF1, 0xFF, 0xE0, 0x0F, 0xE7, 0xFF, 0xC0, 0x1F, 0xDF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xE7,
  0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x1F, 0xF8, 0x0F,
  0xF0, 0x3F, 0xE0, 0x1F, 0xE0, 0x7F, 0xC0, 0x3F, 0xC0, 0xFF, 0x80, 0x7F,
  0x81, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xF8,
  0x1F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xE0, 0x7F, 0x80, 0x7F, 0xC1,
  0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x0F,
  0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xC0, 0xFF,
  0x80, 0x7F, 0x81, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xFE, 0x0F, 0xF8,
  0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF0, 0x3F, 0xE0, 0x1F, 0xE0, 0x7F, 0x80,
  0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xE0, 0xFF, 0xE7, 0xFE, 0x1F, 0xF8, 0x3F, 0xE1, 0xFF, 0x01,
  0xFF, 0x3F, 0xF0, 0x1F, 0xF3, 0xFE, 0x01, 0xFF, 0x3F, 0xE0, 0x1F, 0xF7,
  0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0x7F, 0x80,
  0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xEF, 0xF8, 0x01, 0xFE,
  0xFF, 0x80, 0x3F, 0xEF, 0xF0, 0x03, 0xFE, 0xFF, 0x00, 0x3F, 0xEF, 0xF0,
  0x07, 0xFC, 0xFF, 0x00, 0x7F, 0xCF, 0xF0, 0x0F, 0xFC, 0xFF, 0x80, 0xFF,
  0x8F, 0xF8, 0x1F, 0xF8, 0xFF, 0xC3, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE1, 0xFF, 0x80, 0x03, 0xF8, 0xFF,
  0xF0, 0x00, 0xFE, 0x7F, 0xFC, 0x00, 0x3F, 0xBF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x7F,
  0xE0, 0x7F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xF0,
  0x0F, 0xF0, 0x07, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xF8, 0x03,
  0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0,
  0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x1F, 0xF0, 0x07,
  0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xF7, 0xFF, 0xE0, 0x03, 0xFD, 0xFF, 0xF0,
  0x01, 0xFF, 0x3F, 0xF8, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x1F, 0xE0, 0x70,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x02, 0x00, 0x7F, 0xE3, 0xF8, 0x03, 0xFF, 0xE7,
  0xF0, 0x0F, 0xFF, 0xDF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x3F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF8,
  0x3F, 0xE0, 0x3F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x00, 0xFF, 0x83,
  0xFE, 0x01, 0xFF, 0x07, 0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x3F,
  0xE0, 0x0F, 0xF0, 0x7F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC3, 0xFE,
  0x00, 0x7F, 0x87, 0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x03, 0xFC, 0x1F, 0xF0,
  0x07, 0xF8, 0x3F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xE0, 0xFF, 0x00,
  0x7F, 0x81, 0xFE, 0x00, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xFC, 0x0F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0xFF, 0x00, 0x7F, 0xFB, 0xFE,
  0x00, 0xFF, 0xE7, 0xF8, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x38, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x7F, 0x0F, 0xF0, 0x1F, 0xC7, 0xF8, 0x07, 0xF3, 0xFE,
  0x01, 0xFD, 0xFF, 0x80, 0xFF, 0x7F, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xF0, 0x3C, 0x0F, 0xF8,
  0x02, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC2,
  0x00, 0x3F, 0xF0, 0xF0, 0x0F, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07,
  0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x30, 0x00, 0x07,
  0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0xC1, 0xFE,
  0x01, 0xFE, 0x0F, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00,
  0xFF, 0x83, 0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x0F, 0xF0, 0x7F, 0xC0, 0x3F,
  0xC1, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xFC, 0x1F, 0xE0, 0x1F, 0xF0,
  0xFF, 0x80, 0x7F, 0x83, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x3F,
  0xC0, 0x3F, 0xE0, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x03, 0xFC, 0x1F, 0xF0,
  0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0xC1, 0xFE, 0x01, 0xFF, 0x07, 0xF8, 0x07,
  0xF8, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x07, 0xFE,
  0x0F, 0xF8, 0x1F, 0xF8, 0x3F, 0xE0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xF7, 0xF0, 0x1F, 0xFF, 0xBF, 0xC0, 0x7F,
  0xFC, 0xFE, 0x00, 0xFF, 0xE3, 0xF8, 0x01, 0xFF, 0x0F, 0xE0, 0x00, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFE, 0xFF, 0x00, 0x3F,
  0xCF, 0xF0, 0x07, 0xFC, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x0F, 0xF8, 0xFF,
  0x00, 0xFF, 0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x3F,
  0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x0F,
  0xF0, 0x7F, 0x80, 0x7F, 0x0F, 0xF8, 0x07, 0xF0, 0xFF, 0x00, 0x7F, 0x1F,
  0xF0, 0x07, 0xF1, 0xFE, 0x00, 0x7F, 0x1F, 0xE0, 0x07, 0xF3, 0xFC, 0x00,
  0x7F, 0x3F, 0xC0, 0x07, 0xF7, 0xF8, 0x00, 0x7F, 0x7F, 0x80, 0x07, 0xF7,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x1F, 0xF8, 0x0F, 0xFB, 0xFC, 0x07, 0xFF, 0x01, 0xFE, 0x7F, 0x80, 0xFF,
  0xE0, 0x3F, 0xCF, 0xF0, 0x1F, 0xFC, 0x0F, 0xF9, 0xFE, 0x07, 0xFF, 0x81,
  0xFE, 0x3F, 0xC0, 0xFF, 0xF0, 0x7F, 0xC7, 0xF8, 0x3F, 0xFE, 0x0F, 0xF0,
  0xFF, 0x07, 0xFF, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0xF8, 0x7F, 0x83, 0xFC,
  0x3F, 0xFE, 0x0F, 0xF0, 0x7F, 0x87, 0xEF, 0xC3, 0xFE, 0x0F, 0xF1, 0xFD,
  0xF8, 0x7F, 0x81, 0xFE, 0x3F, 0xBF, 0x0F, 0xF0, 0x3F, 0xC7, 0xE7, 0xE3,
  0xFC, 0x07, 0xF9, 0xFC, 0xFC, 0x7F, 0x80, 0xFF, 0x3F, 0x1F, 0x9F, 0xE0,
  0x1F, 0xEF, 0xE3, 0xF3, 0xFC, 0x03, 0xFD, 0xFC, 0x7E, 0x7F, 0x80, 0x7F,
  0x3F, 0x0F, 0xDF, 0xE0, 0x0F, 0xEF, 0xE1, 0xFB, 0xFC, 0x01, 0xFD, 0xF8,
  0x3F, 0x7F, 0x00, 0x3F, 0xBF, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x3F, 0xF8,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x3F,
  0xF8, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x03,
  0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xE0,
  0x00, 0xFF, 0x87, 0xFC, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x01, 0xFE, 0x7F,
  0xC0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x0F, 0xF1, 0xFE, 0x00,
  0x03, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xF0, 0xFF,
  0x80, 0x07, 0xFC, 0x0F, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x03, 0xFE, 0x00,
  0x3F, 0xC0, 0x3F, 0xE0, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xE0,
  0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x07, 0xF8,
  0xFF, 0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00,
  0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x03, 0xFD, 0xFE,
  0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x13, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xC8, 0x00, 0x0F, 0xF8, 0x80,
  0x00, 0x00, 0x00,
};

const GFXglyph NotoSans_Condensed_BoldItalic65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 19, 47, 17, 0, -46 },
  { 113, 23, 16, 27, 6, -46 },
  { 159, 36, 46, 34, 0, -46 },
  { 366, 30, 53, 30, 1, -49 },
  { 565, 44, 48, 49, 3, -47 },
  { 829, 36, 48, 37, 1, -47 },
  { 1045, 11, 16, 16, 6, -46 },
  { 1067, 23, 56, 19, 1, -46 },
  { 1228, 23, 57, 19, -5, -47 },
  { 1392, 26, 28, 29, 5, -50 },
  { 1483, 28, 32, 32, 3, -39 },
  { 1595, 14, 17, 16, -3, -8 },
  { 1625, 17, 8, 19, 1, -21 },
  { 1642, 11, 11, 16, 0, -10 },
  { 1658, 34, 47, 25, -3, -47 },
  { 1858, 29, 48, 30, 1, -47 },
  { 2032, 22, 46, 30, 6, -46 },
  { 2159, 32, 47, 30, -2, -47 },
  { 2347, 32, 48, 30, -1, -47 },
  { 2539, 32, 47, 30, -1, -47 },
  { 2727, 31, 47, 30, 0, -46 },
  { 2910, 30, 48, 30, 2, -47 },
  { 3090, 32, 46, 30, 2, -46 },
  { 3274, 31, 48, 30, 0, -47 },
  { 3460, 29, 48, 30, 1, -47 },
  { 3634, 16, 37, 17, 0, -36 },
  { 3708, 20, 45, 17, -4, -36 },
  { 3821, 28, 32, 32, 3, -39 },
  { 3933, 28, 20, 32, 3, -33 },
  { 4003, 28, 32, 32, 3, -39 },
  { 4115, 24, 48, 24, 3, -47 },
  { 4259, 44, 52, 46, 2, -47 },
  { 4545, 34, 47, 34, -4, -47 },
  { 4745, 34, 46, 34, 0, -46 },
  { 4941, 33, 48, 32, 3, -47 },
  { 5139, 36, 46, 37, 0, -46 },
  { 5346, 32, 46, 29, 0, -46 },
  { 5530, 32, 46, 28, 0, -46 },
  { 5714, 35, 48, 37, 3, -47 },
  { 5924, 39, 46, 38, 0, -46 },
  { 6149, 29, 46, 22, -3, -46 },
  { 6316, 30, 60, 18, -10, -46 },
  { 6541, 39, 46, 33, 0, -46 },
  { 6766, 24, 46, 28, 0, -46 },
  { 6904, 50, 46, 49, 0, -46 },
  { 7192, 42, 46, 40, 0, -46 },
  { 7434, 35, 48, 39, 3, -47 },
  { 7644, 35, 46, 33, 0, -46 },
  { 7846, 35, 58, 39, 3, -47 },
  { 8100, 33, 46, 33, 0, -46 },
  { 8290, 32, 48, 29, -1, -47 },
  { 8482, 28, 46, 28, 5, -46 },
  { 8643, 36, 47, 37, 3, -46 },
  { 8855, 32, 46, 33, 6, -46 },
  { 9039, 50, 46, 49, 5, -46 },
  { 9327, 41, 46, 32, -4, -46 },
  { 9563, 30, 46, 30, 6, -46 },
  { 9736, 34, 46, 28, -2, -46 },
  { 9932, 26, 57, 19, -2, -47 },
  { 10118, 14, 47, 25, 7, -47 },
  { 10201, 27, 57, 19, -5, -47 },
  { 10394, 30, 28, 30, 0, -46 },
  { 10499, 23, 4, 23, -6, 6 },
  { 10511, 13, 11, 20, 9, -50 },
  { 10529, 31, 37, 33, 2, -36 },
  { 10673, 31, 50, 33, 0, -49 },
  { 10867, 26, 37, 26, 2, -36 },
  { 10988, 33, 50, 33, 2, -49 },
  { 11195, 27, 37, 30, 2, -36 },
  { 11320, 34, 66, 20, -7, -50 },
  { 11601, 34, 52, 33, -1, -36 },
  { 11822, 31, 49, 33, 0, -49 },
  { 12012, 19, 49, 16, 0, -49 },
  { 12129, 27, 65, 16, -8, -49 },
  { 12349, 34, 49, 30, 0, -49 },
  { 12558, 19, 49, 16, 0, -49 },
  { 12675, 46, 36, 48, 0, -36 },
  { 12882, 31, 36, 33, 0, -36 },
  { 13022, 28, 37, 32, 2, -36 },
  { 13152, 34, 51, 33, -3, -36 },
  { 13369, 31, 52, 33, 2, -36 },
  { 13571, 26, 36, 23, 0, -36 },
  { 13688, 26, 37, 26, 0, -36 },
  { 13809, 20, 44, 21, 3, -43 },
  { 13919, 30, 36, 32, 2, -35 },
  { 14054, 28, 35, 28, 4, -35 },
  { 14177, 43, 35, 43, 4, -35 },
  { 14366, 35, 35, 29, -3, -35 },
  { 14520, 37, 51, 28, -5, -35 },
  { 14756, 28, 35, 25, -2, -35 },
  { 14879, 26, 56, 22, 1, -46 },
  { 15061, 7, 65, 28, 10, -50 },
  { 15118, 26, 56, 22, -4, -46 },
  { 15300, 28, 11, 32, 3, -28 },
};

const GFXfont NotoSans_Condensed_BoldItalic65pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BoldItalic65pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BoldItalic65pt7bGlyphs,
  0x20, 0x7E, 89
};

#endif // _NOTOSANS_CONDENSED_BOLDITALIC65PT7B_H_
