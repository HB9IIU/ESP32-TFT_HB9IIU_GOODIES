#ifndef _NOTOSANS_CONDENSED_BOLDITALIC28PT7B_H_
#define _NOTOSANS_CONDENSED_BOLDITALIC28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BoldItalic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BoldItalic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0F, 0x0F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C, 0x3C, 0x3C,
  0x38, 0x38, 0x38, 0x00, 0x00, 0x70, 0xF8, 0xF0, 0xF0, 0x73, 0xDC, 0xEF,
  0x3B, 0x9E, 0xE7, 0x39, 0xCE, 0x70, 0x01, 0xCE, 0x03, 0x38, 0x0E, 0x70,
  0x1C, 0xE0, 0x31, 0x87, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x0E, 0x70, 0x1C,
  0xE0, 0x39, 0x80, 0xE7, 0x0F, 0xFF, 0xDF, 0xFF, 0x06, 0x30, 0x1C, 0xE0,
  0x39, 0xC0, 0x63, 0x01, 0xCE, 0x03, 0x9C, 0x00, 0x00, 0x40, 0x06, 0x00,
  0xFE, 0x1F, 0xF1, 0xFF, 0x8F, 0x58, 0x76, 0x03, 0xB0, 0x1F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0x78, 0x0B, 0xC8, 0xDE, 0x77, 0xE7,
  0xFF, 0x3F, 0xF0, 0x7E, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x00, 0x0F, 0x03,
  0x83, 0xF0, 0xE0, 0xEE, 0x1C, 0x39, 0xC7, 0x07, 0x38, 0xE0, 0xE7, 0x38,
  0x18, 0xEE, 0x03, 0x39, 0xC0, 0xE7, 0x73, 0xCF, 0xEE, 0xFD, 0xFB, 0xBB,
  0x9E, 0xE6, 0x70, 0x1D, 0xCE, 0x07, 0x39, 0xC0, 0xE7, 0x38, 0x38, 0xE7,
  0x0E, 0x19, 0xC1, 0xC3, 0xF8, 0x70, 0x7E, 0x1C, 0x07, 0x80, 0x03, 0xF0,
  0x07, 0xF8, 0x07, 0xF8, 0x0F, 0x38, 0x0E, 0x38, 0x0E, 0x78, 0x0F, 0x70,
  0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0x8F, 0x1F, 0x8F, 0x3F, 0xDE, 0x7B, 0xDE,
  0x71, 0xFC, 0xF1, 0xF8, 0xF0, 0xF8, 0xF1, 0xF8, 0xFF, 0xF8, 0x7F, 0xFC,
  0x3F, 0x3C, 0x7B, 0xBD, 0xEE, 0x73, 0x80, 0x03, 0x83, 0x83, 0xC3, 0xC1,
  0xC1, 0xE0, 0xE0, 0x70, 0x78, 0x38, 0x1C, 0x1E, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0xE0, 0x07, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x38,
  0x0E, 0x03, 0x81, 0xE0, 0x70, 0x1C, 0x0F, 0x03, 0x81, 0xE0, 0x70, 0x3C,
  0x0E, 0x07, 0x83, 0xC0, 0x07, 0x80, 0x70, 0x67, 0x07, 0x71, 0xFF, 0xE3,
  0xFE, 0x1F, 0xF3, 0xF0, 0x7B, 0x87, 0x38, 0x13, 0xC0, 0x10, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x3C, 0xF7, 0x9E, 0x73, 0xCE,
  0x38, 0x7F, 0x7F, 0xFE, 0x77, 0xFD, 0xE0, 0x00, 0x3C, 0x00, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1E,
  0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38,
  0x01, 0xE0, 0x0F, 0x00, 0x38, 0x00, 0x07, 0xC0, 0xFE, 0x1F, 0xF3, 0xCF,
  0x3C, 0xF7, 0x8F, 0x78, 0xF7, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1E,
  0xE1, 0xEE, 0x1E, 0xE3, 0xCE, 0x3C, 0xF7, 0x8F, 0xF8, 0xFF, 0x07, 0xE0,
  0x07, 0x87, 0xC7, 0xE7, 0xF7, 0xF7, 0xBB, 0xBC, 0x9E, 0x0E, 0x07, 0x07,
  0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x78, 0x3C, 0x1E, 0x0E, 0x0F, 0x00, 0x03,
  0xF0, 0x1F, 0xE1, 0xFF, 0xC3, 0x8F, 0x04, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x01, 0xFF, 0xCF, 0xFE, 0x3F, 0xF8, 0x07, 0xF0,
  0xFF, 0xC3, 0xFE, 0x18, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x0F,
  0xE0, 0x7C, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C,
  0x83, 0xE7, 0xFE, 0x3F, 0xE1, 0xFE, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x3E,
  0x03, 0xE0, 0x3F, 0x01, 0xB8, 0x1F, 0xC1, 0xDE, 0x1C, 0xE0, 0xE7, 0x0E,
  0x78, 0xE3, 0xC7, 0x1E, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0x03, 0xC0, 0x1E,
  0x00, 0xE0, 0x0F, 0x00, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1C, 0x01, 0xE0,
  0x0F, 0x00, 0x70, 0x03, 0xB0, 0x3F, 0xE1, 0xFF, 0x07, 0xFC, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0xC3, 0xE7, 0xFE, 0x3F, 0xE1, 0xFE,
  0x00, 0x01, 0xF8, 0x3F, 0x83, 0xFC, 0x3E, 0x01, 0xC0, 0x1E, 0x00, 0xE0,
  0x0F, 0x78, 0x77, 0xE7, 0xFF, 0x3E, 0x79, 0xE3, 0xCF, 0x1E, 0x78, 0xF3,
  0xC7, 0x9E, 0x3C, 0xF3, 0xC7, 0xFE, 0x1F, 0xE0, 0x7E, 0x00, 0x3F, 0xFC,
  0xFF, 0xE3, 0xFF, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70,
  0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0x07, 0xF0, 0x7F,
  0xC7, 0xFE, 0x3C, 0x71, 0xC3, 0x8E, 0x1C, 0x79, 0xE3, 0xDE, 0x0F, 0xE0,
  0x7E, 0x07, 0xF0, 0x7B, 0xC7, 0x8F, 0x78, 0x7B, 0xC3, 0xDE, 0x1E, 0xF0,
  0xE7, 0xFF, 0x1F, 0xF0, 0x7F, 0x00, 0x07, 0xE0, 0x7F, 0x87, 0xFE, 0x3C,
  0xF3, 0xC7, 0x9E, 0x3C, 0xE1, 0xE7, 0x0F, 0x38, 0xF9, 0xE7, 0xCF, 0xFC,
  0x7F, 0xE1, 0xEF, 0x00, 0x70, 0x07, 0x80, 0x78, 0x07, 0xC7, 0xFC, 0x3F,
  0xC1, 0xFC, 0x00, 0x04, 0x3C, 0x79, 0xF1, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x1F, 0x3C, 0x78, 0x01, 0x03, 0xC1, 0xE0, 0xF0, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0xF0, 0xF0, 0x78, 0x38,
  0x3C, 0x1C, 0x1E, 0x00, 0x00, 0x10, 0x07, 0x01, 0xF0, 0x7F, 0x1F, 0xC7,
  0xF0, 0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x00, 0x30,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x0E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0,
  0x1F, 0x07, 0xE1, 0xF8, 0xFE, 0x0F, 0x80, 0xE0, 0x08, 0x00, 0x1F, 0x8F,
  0xF8, 0xFF, 0x10, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0x70, 0x1C, 0x03, 0x80, 0x70, 0x00, 0x00, 0x00, 0x70, 0x1E, 0x03, 0xC0,
  0x78, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x1E, 0x1E, 0x07, 0x00, 0xE1,
  0xC0, 0x0C, 0x70, 0xF1, 0xCE, 0x7F, 0x3B, 0x9E, 0xE7, 0x73, 0x9C, 0xEC,
  0xE3, 0x9F, 0x9C, 0x63, 0x73, 0x1C, 0x6E, 0x63, 0x9D, 0xCC, 0x73, 0x31,
  0xDE, 0xE6, 0x3E, 0xF8, 0xE3, 0x9E, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x0C, 0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3B, 0x80, 0xF7, 0x01, 0xCE, 0x03, 0x9C,
  0x0F, 0x38, 0x1C, 0x70, 0x78, 0xE0, 0xFF, 0xC3, 0xFF, 0xC7, 0xFF, 0x9E,
  0x0F, 0x3C, 0x1E, 0xF0, 0x3D, 0xE0, 0x7F, 0x80, 0xF0, 0x0F, 0xF0, 0x1F,
  0xF8, 0x3F, 0xF0, 0x71, 0xF1, 0xE1, 0xE3, 0xC3, 0xC7, 0x8F, 0x0F, 0x1E,
  0x1F, 0xF8, 0x7F, 0xC0, 0xFF, 0xC1, 0xE3, 0xC3, 0x87, 0x87, 0x0F, 0x1E,
  0x1E, 0x3C, 0x3C, 0x79, 0xF0, 0xFF, 0xE3, 0xFF, 0x87, 0xFC, 0x00, 0x03,
  0xF8, 0x1F, 0xF0, 0xFF, 0xC7, 0xC6, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3E, 0x00, 0x78, 0x41, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xF0,
  0x1F, 0xF0, 0x3F, 0xF0, 0x7B, 0xF1, 0xE1, 0xE3, 0xC3, 0xC7, 0x87, 0x8F,
  0x0F, 0x1C, 0x1E, 0x78, 0x3C, 0xF0, 0x79, 0xE0, 0xF3, 0xC3, 0xC7, 0x07,
  0x9E, 0x1F, 0x3C, 0x7C, 0x7B, 0xF0, 0xFF, 0xC3, 0xFF, 0x07, 0xF8, 0x00,
  0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0x83, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x0F, 0x00, 0x3C, 0x00, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xFF, 0x0F, 0xFC, 0x3F, 0xE0, 0x0F,
  0xFC, 0x3F, 0xE0, 0xFF, 0x83, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3C, 0x00, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0x01, 0xFE,
  0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0x8C, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0xFC, 0xF0, 0xFC, 0xF1, 0xFC, 0xF0, 0x3C,
  0xF0, 0x78, 0xF0, 0x78, 0xF8, 0x78, 0x7C, 0x78, 0x7F, 0xF0, 0x3F, 0xF0,
  0x1F, 0xE0, 0x0F, 0x07, 0x87, 0x83, 0xC3, 0xC1, 0xC1, 0xE1, 0xE1, 0xE0,
  0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x1C, 0x1F, 0xFE, 0x1F, 0xFF, 0x0F,
  0xFF, 0x87, 0x83, 0xC3, 0xC3, 0xC1, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0, 0x78,
  0x78, 0x3C, 0x3C, 0x3C, 0x3C, 0x1E, 0x1E, 0x0F, 0x00, 0x0F, 0xF0, 0xFF,
  0x07, 0xE0, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0,
  0xFF, 0x8F, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0xBE, 0x0F, 0xE0, 0xFC, 0x0F, 0x00, 0x0F, 0x0F, 0x87, 0x87, 0x83, 0xC7,
  0x81, 0xC7, 0x81, 0xE7, 0x80, 0xF3, 0xC0, 0x7B, 0xC0, 0x3F, 0xC0, 0x1D,
  0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xDE, 0x01, 0xCF, 0x01,
  0xE7, 0x80, 0xF1, 0xC0, 0x78, 0xF0, 0x38, 0x78, 0x3C, 0x3C, 0x1E, 0x1F,
  0x00, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1F, 0xFF,
  0xFF, 0xFF, 0x0F, 0x80, 0xFC, 0x3E, 0x03, 0xE0, 0xF8, 0x1F, 0x83, 0xE0,
  0x7E, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xDC, 0x7F, 0x07, 0x71, 0xDC,
  0x1D, 0xC7, 0xF0, 0xF7, 0x3B, 0xC3, 0xDC, 0xEE, 0x0E, 0x77, 0x38, 0x39,
  0xDD, 0xE0, 0xE7, 0xE7, 0x87, 0x9F, 0x9E, 0x1E, 0x7C, 0x70, 0x71, 0xF1,
  0xC1, 0xC7, 0xCF, 0x0F, 0x1E, 0x3C, 0x3C, 0x78, 0xF0, 0x0F, 0x83, 0xC3,
  0xE0, 0xF0, 0xF8, 0x3C, 0x3E, 0x0E, 0x1F, 0xC3, 0x87, 0xF1, 0xE1, 0xDC,
  0x78, 0x77, 0x1C, 0x1D, 0xE7, 0x0F, 0x79, 0xC3, 0xCE, 0xF0, 0xE3, 0xBC,
  0x38, 0xEE, 0x0E, 0x3F, 0x87, 0x8F, 0xE1, 0xE1, 0xF8, 0x70, 0x7E, 0x1C,
  0x1F, 0x0F, 0x07, 0xC3, 0xC1, 0xF0, 0x03, 0xF8, 0x0F, 0xF8, 0x3F, 0xF8,
  0xF9, 0xF3, 0xE1, 0xE7, 0x83, 0xDF, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xF0,
  0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xFE, 0x07, 0xBC, 0x1F, 0x78, 0x3C,
  0x78, 0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xF8,
  0x3F, 0xF0, 0x71, 0xF1, 0xE1, 0xE3, 0xC3, 0xC7, 0x87, 0x8F, 0x0F, 0x1C,
  0x3C, 0x79, 0xF8, 0xFF, 0xE1, 0xFF, 0x83, 0xFC, 0x07, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x03, 0xF8,
  0x0F, 0xF8, 0x3F, 0xF8, 0xF9, 0xF3, 0xE1, 0xE7, 0x83, 0xDF, 0x07, 0xBC,
  0x0F, 0x78, 0x1E, 0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xDE, 0x07,
  0xBC, 0x1F, 0x78, 0x3C, 0x79, 0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0xFE, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x0F, 0xF0, 0x3F,
  0xE0, 0xFF, 0xC3, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1C,
  0x78, 0xFF, 0xE3, 0xFF, 0x0F, 0xF0, 0x39, 0xE0, 0xE7, 0x87, 0x9E, 0x1E,
  0x38, 0x78, 0xF1, 0xC3, 0xCF, 0x0F, 0x3C, 0x3E, 0x03, 0xF8, 0x3F, 0xF1,
  0xFF, 0x87, 0xCC, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x20, 0x78,
  0xE3, 0xE3, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0x7F, 0xF7, 0xFF, 0xFF, 0xF0,
  0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F,
  0x00, 0x1E, 0x0F, 0x1E, 0x0E, 0x1E, 0x1E, 0x1C, 0x1E, 0x3C, 0x1E, 0x3C,
  0x1E, 0x3C, 0x3C, 0x3C, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x38, 0x78,
  0x78, 0x78, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0xF0, 0xF9, 0xF0, 0x7F,
  0xE0, 0x7F, 0xC0, 0x3F, 0x80, 0xE0, 0x7F, 0x81, 0xEE, 0x07, 0x38, 0x3C,
  0xE0, 0xE3, 0x87, 0x8E, 0x1E, 0x38, 0xF0, 0xE3, 0xC3, 0x9E, 0x0E, 0x78,
  0x39, 0xC0, 0xEF, 0x03, 0xB8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x78, 0x3F, 0xC1, 0xE1, 0xEF, 0x0F, 0x87,
  0xBC, 0x3E, 0x1C, 0xF0, 0xF8, 0xF3, 0xC7, 0xE3, 0xCF, 0x1F, 0x9E, 0x3C,
  0xEE, 0x78, 0xF3, 0xB9, 0xC3, 0xCE, 0xEF, 0x0F, 0x73, 0xB8, 0x3D, 0xCF,
  0xE0, 0xFF, 0x77, 0x83, 0xF9, 0xDC, 0x0F, 0xE7, 0xF0, 0x3F, 0x1F, 0x80,
  0xFC, 0x7E, 0x03, 0xE1, 0xF8, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0x07,
  0x87, 0xC1, 0xE1, 0xE0, 0x38, 0xF0, 0x0E, 0x3C, 0x03, 0xDE, 0x00, 0xF7,
  0x00, 0x3F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xDC, 0x00, 0xF7, 0x80, 0x79, 0xE0, 0x1E,
  0x78, 0x0F, 0x1E, 0x07, 0x83, 0xC3, 0xE0, 0xF0, 0xE0, 0xFF, 0x87, 0xBC,
  0x79, 0xE3, 0xCF, 0x3C, 0x79, 0xC1, 0xDE, 0x0E, 0xE0, 0x7F, 0x03, 0xF0,
  0x1F, 0x00, 0xF8, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03,
  0x80, 0x3C, 0x01, 0xE0, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF0, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78,
  0x11, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x01,
  0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x00,
  0xE0, 0x3F, 0x87, 0xE0, 0xE3, 0x8E, 0x3C, 0xF1, 0xC7, 0x1C, 0x71, 0xC7,
  0x9E, 0x38, 0xE3, 0x8E, 0x38, 0xF3, 0xC7, 0x07, 0xE0, 0xFC, 0x1F, 0x80,
  0xF0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0,
  0x78, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0,
  0x3C, 0x3F, 0x87, 0xE0, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0xC0, 0x7E,
  0x07, 0x70, 0x3B, 0x83, 0x8E, 0x3C, 0x71, 0xC3, 0x9C, 0x1D, 0xE0, 0x70,
  0x7F, 0xFF, 0xF0, 0xF3, 0xCE, 0x70, 0x02, 0x00, 0xF9, 0xCF, 0xFE, 0x7F,
  0xE7, 0x8F, 0x3C, 0x7B, 0xC3, 0xDE, 0x1E, 0xF0, 0xE7, 0x8F, 0x3C, 0x79,
  0xE3, 0xCF, 0x3E, 0x7F, 0xE3, 0xF7, 0x0F, 0x38, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x20, 0x7F, 0xC3, 0xFF, 0x1F, 0xF9, 0xF3,
  0xCF, 0x0E, 0x78, 0xF3, 0x87, 0x9C, 0x3D, 0xE1, 0xEF, 0x0E, 0x78, 0xF3,
  0xCF, 0x9F, 0xF9, 0xFF, 0x8E, 0x78, 0x00, 0x01, 0x01, 0xFC, 0x7F, 0x1F,
  0xE7, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x11, 0xFE, 0x1F, 0xC1, 0xF8, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E,
  0x00, 0x38, 0x11, 0xE1, 0xFF, 0x8F, 0xFE, 0x3F, 0xF1, 0xE3, 0xC7, 0x8F,
  0x1C, 0x3C, 0xF0, 0xF3, 0xC3, 0x8F, 0x0E, 0x3C, 0x78, 0xE1, 0xE3, 0xCF,
  0x8F, 0xFC, 0x3F, 0xF0, 0x7D, 0xC0, 0x01, 0x00, 0xFC, 0x1F, 0xE3, 0xCE,
  0x78, 0xF7, 0x0E, 0xF1, 0xEF, 0xFC, 0xFF, 0x8F, 0x80, 0xE0, 0x0E, 0x00,
  0xF0, 0x4F, 0xF8, 0x7F, 0x83, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x01, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x07,
  0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x03,
  0x00, 0x3F, 0x71, 0xFF, 0xC7, 0xFE, 0x3C, 0x78, 0xF1, 0xE7, 0x87, 0x9E,
  0x1E, 0x78, 0x71, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x79, 0xF1, 0xFF, 0x87,
  0xFE, 0x0F, 0x78, 0x01, 0xE0, 0x07, 0x08, 0x3C, 0x39, 0xF0, 0xFF, 0x83,
  0xFC, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0,
  0x0F, 0x20, 0x7F, 0xC3, 0xFF, 0x1F, 0xF9, 0xF3, 0xCF, 0x1E, 0x78, 0xF3,
  0xC7, 0x9C, 0x39, 0xE1, 0xCF, 0x1E, 0x78, 0xF3, 0x87, 0x9C, 0x39, 0xE1,
  0xCF, 0x1E, 0x00, 0x0F, 0x0F, 0x0F, 0x06, 0x00, 0x00, 0x1E, 0x1E, 0x1C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x78, 0x78, 0x78, 0x78, 0x70, 0xF0, 0xF0,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x06, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x1E,
  0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0,
  0xFE, 0x0F, 0xC0, 0xFC, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0xE0, 0x03, 0xC0, 0x47, 0x8F, 0x0E, 0x3C, 0x1C, 0xF0, 0x7B,
  0xC0, 0xF7, 0x81, 0xDE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xF0, 0x3D, 0xE0,
  0x7B, 0xC0, 0xE3, 0xC1, 0xC7, 0x87, 0x8F, 0x0F, 0x0F, 0x00, 0x0F, 0x0F,
  0x0F, 0x0E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x3C, 0x3C, 0x38,
  0x78, 0x78, 0x78, 0x78, 0x70, 0xF0, 0xF0, 0x00, 0x40, 0x81, 0xDF, 0x3E,
  0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3E, 0x7C, 0xF3, 0xC7, 0x8F, 0x3C, 0x78,
  0xF3, 0x87, 0x0E, 0x38, 0x70, 0xE7, 0x8F, 0x1E, 0x78, 0xF1, 0xE7, 0x8F,
  0x1E, 0x70, 0xE1, 0xC7, 0x0E, 0x3C, 0xF1, 0xE3, 0xCF, 0x1E, 0x3C, 0x00,
  0x40, 0xEF, 0x87, 0xFE, 0x3F, 0xF3, 0xE7, 0x9E, 0x3C, 0xF1, 0xE7, 0x8F,
  0x38, 0x73, 0xC3, 0x9E, 0x3C, 0xF1, 0xE7, 0x0F, 0x38, 0x73, 0xC3, 0x9E,
  0x3C, 0x03, 0x00, 0xFC, 0x3F, 0xE3, 0xFF, 0x78, 0xF7, 0x8F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0E, 0xE1, 0xEE, 0x1E, 0xF3, 0xCF, 0xFC, 0x7F, 0x83,
  0xF0, 0x00, 0x30, 0x3B, 0xE0, 0xFF, 0xC3, 0xFF, 0x1F, 0x3C, 0x78, 0x71,
  0xE3, 0xC7, 0x0F, 0x1C, 0x3C, 0xF0, 0xF3, 0xC3, 0x8F, 0x1E, 0x3C, 0xF8,
  0xFF, 0xC7, 0xFE, 0x1E, 0xF0, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0x02, 0x00, 0xFD, 0xC7, 0xFE, 0x7F,
  0xE7, 0x8F, 0x3C, 0x79, 0xC3, 0xDE, 0x1E, 0xF0, 0xE7, 0x87, 0x3C, 0x79,
  0xC3, 0xCF, 0x3E, 0x7F, 0xE3, 0xF7, 0x0F, 0x78, 0x03, 0xC0, 0x1C, 0x00,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0x23, 0xBC, 0x7F,
  0x8F, 0xE3, 0xF2, 0x7C, 0x0F, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0x02, 0x03, 0xFC, 0xFF, 0x9F, 0x63,
  0xC0, 0x78, 0x0F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x1E, 0x01, 0xC8, 0x79,
  0xFF, 0x3F, 0xC7, 0xF0, 0x0E, 0x07, 0x07, 0x03, 0x87, 0xFB, 0xFF, 0xFC,
  0x70, 0x38, 0x3C, 0x1E, 0x0F, 0x07, 0x07, 0x83, 0xC1, 0xE0, 0xFC, 0x7E,
  0x1F, 0x00, 0x3C, 0x79, 0xC3, 0xCE, 0x1C, 0xF1, 0xE7, 0x8F, 0x3C, 0x79,
  0xC3, 0xCE, 0x1C, 0xF1, 0xE7, 0x8F, 0x3C, 0x79, 0xE7, 0x8F, 0xFC, 0x7E,
  0xE1, 0xE7, 0x00, 0xE0, 0xFE, 0x1E, 0xE1, 0xCE, 0x3C, 0xE3, 0x8E, 0x78,
  0xE7, 0x0E, 0xF0, 0xEE, 0x0E, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0x80,
  0xF8, 0x00, 0xE1, 0xE3, 0xF8, 0xF8, 0xEE, 0x3E, 0x7B, 0x9F, 0x9C, 0xE7,
  0xE7, 0x39, 0xBB, 0xCE, 0xEE, 0xE3, 0xBB, 0xF8, 0xFC, 0xFC, 0x3F, 0x3F,
  0x0F, 0x8F, 0xC3, 0xE3, 0xE0, 0xF8, 0xF8, 0x3C, 0x3C, 0x0F, 0x0F, 0x00,
  0x1E, 0x3E, 0x3C, 0x70, 0x39, 0xE0, 0x7F, 0x80, 0xFE, 0x00, 0xFC, 0x01,
  0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x77, 0x01, 0xEF, 0x07, 0x9E,
  0x0F, 0x3C, 0x3C, 0x3C, 0x00, 0x0E, 0x0F, 0x0E, 0x1E, 0x0E, 0x1C, 0x0E,
  0x3C, 0x0E, 0x38, 0x0E, 0x78, 0x0F, 0x78, 0x0F, 0x70, 0x0F, 0xF0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0xBE, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xE0,
  0x00, 0x1F, 0xF1, 0xFF, 0x1F, 0xF0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x80,
  0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x7F, 0xCF, 0xFC, 0xFF, 0x80,
  0x00, 0xF0, 0x3E, 0x07, 0xE0, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xF0,
  0x0F, 0x01, 0xE0, 0x7E, 0x07, 0xC0, 0xF0, 0x0F, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0xE0, 0x3E, 0x01, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0x00, 0xF0, 0x1F, 0x05, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80,
  0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x0F, 0xC3, 0xE0, 0x78, 0x0E, 0x01, 0xC0,
  0x78, 0x0F, 0x01, 0xE1, 0xF8, 0x3F, 0x07, 0xC0, 0x7C, 0x1F, 0xFF, 0xFF,
  0xF8, 0x3F,
};

const GFXglyph NotoSans_Condensed_BoldItalic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 8, 20, 7, 0, -20 },
  { 21, 10, 7, 12, 3, -20 },
  { 30, 15, 20, 15, 0, -20 },
  { 68, 13, 23, 13, 0, -21 },
  { 106, 19, 20, 21, 1, -20 },
  { 154, 16, 20, 16, 0, -20 },
  { 194, 5, 7, 7, 3, -20 },
  { 199, 9, 24, 8, 1, -20 },
  { 226, 10, 24, 8, -2, -20 },
  { 256, 12, 12, 13, 2, -21 },
  { 274, 12, 14, 14, 1, -17 },
  { 295, 6, 8, 7, -1, -4 },
  { 301, 8, 3, 8, 0, -9 },
  { 304, 5, 4, 7, 0, -4 },
  { 307, 14, 20, 11, -1, -20 },
  { 342, 12, 20, 13, 1, -20 },
  { 372, 9, 20, 13, 3, -20 },
  { 395, 14, 20, 13, -1, -20 },
  { 430, 13, 20, 13, 0, -20 },
  { 463, 13, 20, 13, 0, -20 },
  { 496, 13, 20, 13, 0, -20 },
  { 529, 13, 20, 13, 1, -20 },
  { 562, 14, 20, 13, 1, -20 },
  { 597, 13, 20, 13, 0, -20 },
  { 630, 13, 20, 13, 0, -20 },
  { 663, 7, 16, 7, 0, -16 },
  { 677, 9, 20, 7, -2, -16 },
  { 700, 12, 14, 14, 1, -17 },
  { 721, 12, 8, 14, 1, -14 },
  { 733, 12, 14, 14, 1, -17 },
  { 754, 11, 20, 10, 1, -20 },
  { 782, 19, 22, 20, 1, -20 },
  { 835, 15, 20, 14, -2, -20 },
  { 873, 15, 20, 15, 0, -20 },
  { 911, 14, 20, 14, 1, -20 },
  { 946, 15, 20, 16, 0, -20 },
  { 984, 14, 20, 12, 0, -20 },
  { 1019, 14, 20, 12, 0, -20 },
  { 1054, 16, 20, 16, 1, -20 },
  { 1094, 17, 20, 16, 0, -20 },
  { 1137, 12, 20, 9, -1, -20 },
  { 1167, 12, 26, 8, -4, -20 },
  { 1206, 17, 20, 14, 0, -20 },
  { 1249, 10, 20, 12, 0, -20 },
  { 1274, 22, 20, 21, 0, -20 },
  { 1329, 18, 20, 17, 0, -20 },
  { 1374, 15, 20, 17, 1, -20 },
  { 1412, 15, 20, 14, 0, -20 },
  { 1450, 15, 25, 17, 1, -20 },
  { 1497, 14, 20, 14, 0, -20 },
  { 1532, 14, 20, 13, 0, -20 },
  { 1567, 12, 20, 12, 2, -20 },
  { 1597, 16, 20, 16, 1, -20 },
  { 1637, 14, 20, 14, 3, -20 },
  { 1672, 22, 20, 21, 2, -20 },
  { 1727, 18, 20, 14, -2, -20 },
  { 1772, 13, 20, 13, 3, -20 },
  { 1805, 15, 20, 12, -1, -20 },
  { 1843, 11, 24, 8, -1, -20 },
  { 1876, 6, 20, 11, 3, -20 },
  { 1891, 11, 24, 8, -2, -20 },
  { 1924, 13, 12, 13, 0, -20 },
  { 1944, 10, 2, 10, -3, 2 },
  { 1947, 5, 4, 9, 4, -21 },
  { 1950, 13, 16, 14, 1, -16 },
  { 1976, 13, 21, 14, 0, -21 },
  { 2011, 11, 16, 11, 1, -16 },
  { 2033, 14, 21, 14, 1, -21 },
  { 2070, 12, 16, 13, 1, -16 },
  { 2094, 15, 28, 9, -3, -21 },
  { 2147, 14, 23, 14, 0, -16 },
  { 2188, 13, 21, 14, 0, -21 },
  { 2223, 8, 21, 7, 0, -21 },
  { 2244, 12, 28, 7, -4, -21 },
  { 2286, 15, 21, 13, 0, -21 },
  { 2326, 8, 21, 7, 0, -21 },
  { 2347, 20, 16, 21, 0, -16 },
  { 2387, 13, 16, 14, 0, -16 },
  { 2413, 12, 16, 14, 1, -16 },
  { 2437, 14, 23, 14, -1, -16 },
  { 2478, 13, 23, 14, 1, -16 },
  { 2516, 11, 16, 10, 0, -16 },
  { 2538, 11, 16, 11, 0, -16 },
  { 2560, 9, 19, 9, 1, -19 },
  { 2582, 13, 15, 14, 1, -15 },
  { 2607, 12, 15, 12, 2, -15 },
  { 2630, 18, 15, 19, 2, -15 },
  { 2664, 15, 15, 12, -1, -15 },
  { 2693, 16, 22, 12, -2, -15 },
  { 2737, 12, 15, 11, -1, -15 },
  { 2760, 12, 24, 10, 0, -20 },
  { 2796, 3, 27, 12, 4, -21 },
  { 2807, 11, 24, 10, -2, -20 },
  { 2840, 12, 4, 14, 1, -12 },
};

const GFXfont NotoSans_Condensed_BoldItalic28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BoldItalic28pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BoldItalic28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_CONDENSED_BOLDITALIC28PT7B_H_
