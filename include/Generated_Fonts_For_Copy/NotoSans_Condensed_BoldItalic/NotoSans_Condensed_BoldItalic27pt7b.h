#ifndef _NOTOSANS_CONDENSED_BOLDITALIC27PT7B_H_
#define _NOTOSANS_CONDENSED_BOLDITALIC27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BoldItalic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BoldItalic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C, 0x3C, 0x3C, 0x38,
  0x38, 0x38, 0x00, 0x00, 0x70, 0xF0, 0xF0, 0xF0, 0xF3, 0xFB, 0xF9, 0xDC,
  0xEE, 0x77, 0x3B, 0x18, 0x03, 0x9C, 0x07, 0x38, 0x0C, 0x60, 0x19, 0xC0,
  0x73, 0x87, 0xFF, 0xCF, 0xFF, 0x9F, 0xFE, 0x0E, 0x60, 0x18, 0xC0, 0x73,
  0x87, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x0E, 0x70, 0x1C, 0xC0, 0x33, 0x80,
  0xE7, 0x01, 0xCC, 0x00, 0x00, 0x40, 0x06, 0x00, 0x30, 0x0F, 0xF0, 0xFF,
  0x8F, 0xF8, 0x76, 0x43, 0xA0, 0x1D, 0x00, 0xF8, 0x07, 0xF0, 0x1F, 0xC0,
  0x3E, 0x01, 0xF0, 0x0B, 0x90, 0xDC, 0x65, 0xE7, 0xFF, 0x3F, 0xF0, 0x7E,
  0x00, 0xC0, 0x04, 0x00, 0x20, 0x00, 0x04, 0x00, 0x87, 0xC1, 0xC3, 0xF0,
  0x70, 0xCE, 0x38, 0x73, 0x8C, 0x1C, 0xE7, 0x06, 0x33, 0x83, 0x9C, 0xE0,
  0xE7, 0x73, 0xB9, 0x99, 0xF7, 0xEE, 0xFD, 0xF7, 0x73, 0x11, 0xDC, 0xC0,
  0xE6, 0x30, 0x33, 0x9C, 0x1C, 0xE7, 0x0E, 0x39, 0xC3, 0x0E, 0xE1, 0xC1,
  0xF0, 0xE0, 0x7C, 0x00, 0x80, 0x07, 0xE0, 0x1F, 0xC0, 0x7B, 0xC0, 0xE7,
  0x81, 0xCF, 0x03, 0x9C, 0x07, 0x70, 0x0F, 0xE0, 0x1F, 0x00, 0x7E, 0x39,
  0xFC, 0xF7, 0xBD, 0xCE, 0x3F, 0xBC, 0x7E, 0x78, 0x78, 0xF1, 0xF1, 0xFF,
  0xF1, 0xFF, 0xE1, 0xF9, 0xE0, 0x7F, 0xEE, 0xEE, 0xC0, 0x07, 0x87, 0x83,
  0x83, 0x83, 0xC1, 0xC0, 0xE0, 0xF0, 0x70, 0x38, 0x3C, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x01, 0xC0, 0x07,
  0x03, 0x80, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x78, 0x3C, 0x1C, 0x0E, 0x0F, 0x07, 0x07, 0x83, 0x83, 0xC1, 0xC1,
  0xE1, 0xE0, 0x04, 0x00, 0xE0, 0x1C, 0x33, 0x07, 0xEF, 0xFF, 0xC3, 0xF8,
  0xF8, 0x3F, 0x0F, 0x70, 0xCE, 0x09, 0x80, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x3D, 0xE7, 0x9C, 0xF3, 0x8E, 0x00, 0x7F, 0x7E, 0xFE,
  0x7F, 0xFF, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E,
  0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x00,
  0x01, 0x00, 0xFC, 0x1F, 0xE1, 0xFE, 0x3C, 0xE3, 0x8F, 0x78, 0xF7, 0x0E,
  0xF0, 0xEF, 0x0E, 0xF1, 0xEF, 0x1E, 0xE1, 0xEE, 0x1C, 0xE3, 0xCE, 0x3C,
  0xE7, 0x8F, 0xF0, 0xFF, 0x07, 0xC0, 0x07, 0x87, 0x8F, 0xCF, 0xEF, 0xF7,
  0x79, 0x38, 0x1C, 0x1E, 0x0F, 0x07, 0x83, 0x81, 0xC1, 0xE0, 0xF0, 0x70,
  0x38, 0x1C, 0x1E, 0x00, 0x00, 0x40, 0x1F, 0xC0, 0xFF, 0x87, 0xFE, 0x0C,
  0x3C, 0x20, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xFF, 0x8F,
  0xFE, 0x3F, 0xF8, 0x00, 0x80, 0x7F, 0x87, 0xFC, 0x1F, 0xF0, 0x87, 0x80,
  0x3C, 0x01, 0xC0, 0x1E, 0x03, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x83, 0xE7, 0xFE, 0x3F, 0xE1, 0xFE, 0x00,
  0x00, 0x78, 0x07, 0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x3B, 0x81,
  0x9C, 0x1D, 0xE1, 0xCF, 0x1C, 0x70, 0xE3, 0x8F, 0xFF, 0x7F, 0xFB, 0xFF,
  0xC0, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0xF8, 0x7F, 0xC3, 0xFC,
  0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0xF8, 0x3F, 0xE1, 0xFF, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x90, 0x78, 0xFF, 0xC7, 0xFC,
  0x3F, 0xC0, 0x00, 0xE0, 0x3F, 0x07, 0xF0, 0xFF, 0x1E, 0x03, 0xC0, 0x38,
  0x07, 0x90, 0x77, 0xCF, 0xFC, 0xFF, 0xEF, 0x1E, 0xF1, 0xEE, 0x1E, 0xE1,
  0xCE, 0x3C, 0xF3, 0xCF, 0xF8, 0x7F, 0x83, 0xE0, 0x3F, 0xF9, 0xFF, 0xCF,
  0xFC, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x07, 0x80, 0x3C,
  0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03,
  0x80, 0x3C, 0x00, 0x00, 0x80, 0x3F, 0x83, 0xFC, 0x3D, 0xF1, 0xC7, 0x8E,
  0x3C, 0x71, 0xE3, 0xDE, 0x1F, 0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x87, 0x9E,
  0x38, 0x73, 0xC3, 0x9E, 0x1C, 0xF1, 0xE7, 0xFF, 0x1F, 0xF0, 0x7E, 0x00,
  0x00, 0x80, 0x3F, 0x03, 0xFC, 0x3F, 0xE3, 0xC7, 0x1E, 0x3C, 0xE1, 0xC7,
  0x0E, 0x78, 0xF3, 0xC7, 0x8F, 0xFC, 0x7F, 0xE1, 0xEE, 0x00, 0xF0, 0x07,
  0x80, 0x78, 0x07, 0x87, 0xFC, 0x3F, 0xC1, 0xF8, 0x00, 0x0C, 0x3C, 0xF8,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x8F, 0x1E, 0x3C, 0x00, 0x06,
  0x0F, 0x1F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x38,
  0x78, 0x78, 0x70, 0xF0, 0xE0, 0xC0, 0x00, 0x30, 0x0F, 0x03, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC0, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07,
  0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x0F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x01, 0xF0, 0x7F, 0x1F, 0x87, 0xE0, 0xF8, 0x0E, 0x00, 0x80, 0x00,
  0x02, 0x0F, 0xE7, 0xFC, 0xFF, 0x21, 0xC0, 0x70, 0x3C, 0x1E, 0x0F, 0x07,
  0x81, 0xC0, 0xE0, 0x38, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x3C, 0x0F, 0x03,
  0xC0, 0x01, 0xFE, 0x01, 0xFF, 0xC0, 0xF0, 0x38, 0x70, 0x06, 0x18, 0x01,
  0xCE, 0x3F, 0x77, 0x1F, 0xCD, 0xCE, 0x63, 0x67, 0x39, 0xF9, 0x8E, 0x7E,
  0x63, 0x9B, 0x38, 0xC6, 0xCE, 0x73, 0xB3, 0x9D, 0xCC, 0x7F, 0xE3, 0x1E,
  0x70, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x81, 0x00, 0xFF, 0xC0, 0x1F, 0xE0,
  0x00, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x77, 0x01, 0xDC, 0x0F, 0x70,
  0x39, 0xC0, 0xE7, 0x07, 0x9C, 0x1C, 0x70, 0xF1, 0xC3, 0xFF, 0x1F, 0xFC,
  0x7F, 0xF3, 0xC1, 0xCF, 0x07, 0x78, 0x1D, 0xE0, 0x7F, 0x01, 0xC0, 0x0F,
  0xF0, 0x3F, 0xE0, 0xFF, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xC3, 0x87,
  0x3E, 0x3F, 0xE0, 0xFF, 0x83, 0xDF, 0x0E, 0x1E, 0x38, 0x79, 0xE1, 0xE7,
  0x8F, 0x1C, 0x3C, 0x7F, 0xE3, 0xFF, 0x8F, 0xF8, 0x00, 0x00, 0x40, 0x0F,
  0xF0, 0xFF, 0x87, 0xFE, 0x1E, 0x08, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF8, 0x41, 0xFF, 0x07, 0xFC, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0,
  0x3F, 0xF0, 0xF1, 0xE1, 0xE1, 0xE3, 0xC3, 0xC7, 0x87, 0x8E, 0x0F, 0x3C,
  0x1E, 0x78, 0x3C, 0xF0, 0xF1, 0xE1, 0xE3, 0x83, 0xCF, 0x0F, 0x1E, 0x3E,
  0x3C, 0xF8, 0x7F, 0xE1, 0xFF, 0x83, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xC3,
  0xFE, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xFC, 0x3F, 0xE1, 0xFF,
  0x0F, 0xF0, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7F, 0xC7,
  0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0x80, 0x3F, 0xE1, 0xFF, 0x0F, 0xF0, 0x70, 0x03, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x20,
  0x07, 0xFC, 0x1F, 0xF8, 0x7F, 0xE1, 0xF0, 0x47, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF1, 0xFB, 0xC7, 0xE7, 0x8F, 0xCF, 0x07, 0x9E, 0x0F,
  0x3C, 0x1E, 0x78, 0x38, 0x78, 0x70, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x00,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFC, 0x3F, 0xFC, 0x38, 0x3C,
  0x38, 0x3C, 0x78, 0x38, 0x78, 0x38, 0x78, 0x78, 0x70, 0x78, 0xF0, 0x78,
  0xF0, 0x70, 0x0F, 0xF0, 0xFF, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07,
  0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xC0, 0x3E, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00,
  0xF0, 0x0F, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0xF0, 0x00, 0x0F, 0x0F, 0x0E,
  0x1E, 0x0E, 0x3C, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0xF0, 0x1D, 0xE0, 0x1D,
  0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3D, 0xC0, 0x39, 0xE0, 0x79,
  0xE0, 0x79, 0xE0, 0x71, 0xE0, 0x70, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x0F,
  0x03, 0xC0, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x3C, 0x0F, 0x03,
  0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x7F, 0xFF, 0xEF, 0xF8, 0x0F,
  0x80, 0xF8, 0x7C, 0x0F, 0xC3, 0xE0, 0x7C, 0x3F, 0x07, 0xE1, 0xF8, 0x3F,
  0x0F, 0xC3, 0xF8, 0x7E, 0x1F, 0x83, 0xF1, 0xDC, 0x3F, 0x8E, 0xE1, 0xFC,
  0xEF, 0x0E, 0xE7, 0x78, 0x73, 0x7B, 0x83, 0x9B, 0x9C, 0x3C, 0xFC, 0xE1,
  0xC7, 0xCF, 0x0E, 0x3E, 0x78, 0x71, 0xE3, 0x87, 0x8F, 0x1C, 0x3C, 0x71,
  0xE0, 0x0F, 0x03, 0x87, 0xC1, 0xC3, 0xE1, 0xE3, 0xF0, 0xF1, 0xF8, 0x70,
  0xFE, 0x38, 0x77, 0x1C, 0x3B, 0x9E, 0x3D, 0xCF, 0x1E, 0xE7, 0x0E, 0x7B,
  0x87, 0x1D, 0xC3, 0x8F, 0xE3, 0xC7, 0xE1, 0xC3, 0xF0, 0xE1, 0xF8, 0x70,
  0x7C, 0x78, 0x3E, 0x3C, 0x1E, 0x00, 0x00, 0xC0, 0x0F, 0xF0, 0x3F, 0xF0,
  0xFF, 0xE1, 0xE3, 0xE7, 0x83, 0xCF, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xF0,
  0x3F, 0xC0, 0x77, 0x81, 0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x1E, 0x78, 0x3C,
  0xF8, 0xF0, 0xFF, 0xC1, 0xFF, 0x80, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xF0,
  0xFF, 0xC7, 0x8F, 0x1E, 0x1C, 0x78, 0xF1, 0xE3, 0xC7, 0x0F, 0x3C, 0x78,
  0xFF, 0xE3, 0xFF, 0x0F, 0xF0, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x70, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0x07, 0xF0, 0x3F, 0xF0,
  0xFF, 0xE1, 0xE3, 0xE7, 0x83, 0xCF, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xF0,
  0x3F, 0xC0, 0x77, 0x81, 0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x1E, 0x78, 0x3C,
  0xF8, 0xF0, 0xFF, 0xE1, 0xFF, 0x80, 0xFC, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x87, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0xC3, 0x87, 0x1E, 0x3D, 0xF8, 0xFF, 0xC3, 0xFC,
  0x0E, 0x70, 0x39, 0xC1, 0xE7, 0x87, 0x9E, 0x1E, 0x78, 0x70, 0xF3, 0xC3,
  0xCF, 0x0F, 0x00, 0x00, 0xC0, 0x3F, 0xC3, 0xFE, 0x3F, 0xE1, 0xE1, 0x1E,
  0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3C,
  0x00, 0xF0, 0x07, 0x90, 0x3C, 0xC3, 0xC7, 0xFE, 0x3F, 0xE1, 0xFE, 0x00,
  0x7F, 0xFF, 0xFE, 0xFF, 0xE0, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x00, 0xF0, 0x00, 0x1E, 0x1E, 0x3C, 0x3C, 0x70, 0x79, 0xE0,
  0xE3, 0xC3, 0xC7, 0x87, 0x8E, 0x0F, 0x3C, 0x1C, 0x78, 0x78, 0xF0, 0xF1,
  0xE1, 0xE3, 0x83, 0xCF, 0x07, 0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0xF0, 0x7F,
  0xE0, 0xFF, 0x80, 0xFE, 0x00, 0xF0, 0x3D, 0xC1, 0xE7, 0x07, 0x9C, 0x1C,
  0x70, 0xF1, 0xC3, 0x87, 0x1E, 0x1C, 0x70, 0x73, 0xC1, 0xCE, 0x07, 0x38,
  0x1D, 0xE0, 0x77, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0,
  0x07, 0x80, 0x00, 0xF0, 0x70, 0x7F, 0x87, 0x83, 0xBC, 0x3C, 0x3D, 0xE1,
  0xE1, 0xCF, 0x1F, 0x1E, 0x78, 0xF8, 0xF3, 0xCF, 0xC7, 0x1E, 0x7E, 0x78,
  0xF7, 0x73, 0x87, 0xBB, 0xBC, 0x3D, 0xDD, 0xE1, 0xFC, 0xEE, 0x0E, 0xE7,
  0xF0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0xF8, 0x7C, 0x07,
  0xC3, 0xE0, 0x3C, 0x1E, 0x00, 0x07, 0x87, 0x83, 0xC7, 0x81, 0xE3, 0x80,
  0x73, 0xC0, 0x3B, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7B, 0x80, 0x79,
  0xC0, 0x3C, 0xF0, 0x3C, 0x78, 0x3C, 0x3C, 0x3E, 0x0F, 0x00, 0xF0, 0x7B,
  0x87, 0x9C, 0x38, 0xF3, 0xC7, 0x9C, 0x3D, 0xE0, 0xFE, 0x07, 0xE0, 0x3F,
  0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC0, 0x1E,
  0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x7F, 0xE3, 0xFF,
  0x8F, 0xFE, 0x00, 0x07, 0xE0, 0xFC, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x03,
  0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x21, 0xF8, 0x3F, 0x00, 0xE3,
  0x8E, 0x38, 0xF1, 0xC7, 0x1C, 0x71, 0xC7, 0x1E, 0x38, 0xE3, 0x8E, 0x38,
  0xE3, 0xC0, 0x07, 0xE0, 0xFC, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xF0,
  0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x78,
  0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE1, 0xF8, 0x3F, 0x00, 0x01, 0xC0,
  0x3C, 0x03, 0xC0, 0x7C, 0x0E, 0xE0, 0xEE, 0x1C, 0xE1, 0xC6, 0x38, 0x77,
  0x07, 0x70, 0x7E, 0x03, 0x7F, 0xFF, 0xF0, 0xF7, 0x9C, 0x73, 0x80, 0x0F,
  0x78, 0xFB, 0x8F, 0xFC, 0xFB, 0xE7, 0x8F, 0x38, 0x73, 0xC3, 0x9E, 0x3C,
  0xF1, 0xE7, 0x0F, 0x38, 0xF1, 0xE7, 0x8F, 0xFC, 0x7E, 0xE1, 0xEF, 0x00,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x7B, 0x83,
  0xBE, 0x1F, 0xF9, 0xF3, 0xCF, 0x1E, 0x78, 0xF3, 0x87, 0x9C, 0x3D, 0xE1,
  0xCF, 0x1E, 0x78, 0xF3, 0xCF, 0x1F, 0xF9, 0xDF, 0x8E, 0xF8, 0x00, 0x0F,
  0xE3, 0xF8, 0xFF, 0x3E, 0x47, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C,
  0x03, 0x80, 0x78, 0x8F, 0xF0, 0xFE, 0x1F, 0x80, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0xF7, 0x07, 0xFC, 0x3F, 0xF1,
  0xE7, 0xC7, 0x8F, 0x1C, 0x38, 0xF0, 0xE3, 0xC3, 0x8E, 0x1E, 0x38, 0x78,
  0xE1, 0xC3, 0x8F, 0x0F, 0xFC, 0x3F, 0xF0, 0x79, 0xC0, 0x07, 0x83, 0xF8,
  0xFF, 0xBC, 0x77, 0x0E, 0xE3, 0xFF, 0xF7, 0xFC, 0xFE, 0x1C, 0x03, 0x80,
  0x70, 0x4F, 0xF8, 0xFF, 0x0F, 0xC0, 0x00, 0x18, 0x03, 0xF0, 0x0F, 0xC0,
  0x7D, 0x01, 0xE0, 0x07, 0x00, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x0F, 0x00,
  0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x07, 0xBC, 0x3E, 0xE1, 0xFF, 0x8F,
  0xBE, 0x3C, 0x78, 0xE1, 0xC7, 0x87, 0x1E, 0x3C, 0x78, 0xF1, 0xC3, 0xC7,
  0x1E, 0x1E, 0x78, 0x7F, 0xE1, 0xFF, 0x83, 0xDE, 0x00, 0x70, 0x03, 0xC2,
  0x0F, 0x0E, 0xF8, 0x3F, 0xE0, 0xFF, 0x00, 0x0F, 0x00, 0x78, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x7B, 0x83, 0xBE, 0x1F, 0xF9, 0xF3, 0xCF,
  0x1E, 0x78, 0xF3, 0x87, 0x1C, 0x39, 0xE3, 0xCF, 0x1E, 0x78, 0xE3, 0x87,
  0x1C, 0x79, 0xE3, 0xCF, 0x1E, 0x00, 0x02, 0x0F, 0x0F, 0x0E, 0x00, 0x00,
  0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x78, 0x78, 0x78, 0x70,
  0x70, 0xF0, 0xF0, 0x00, 0x40, 0x3C, 0x07, 0x80, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x01, 0xE0,
  0xFC, 0x1F, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x78, 0x01, 0xE3, 0xC7, 0x1E, 0x1C, 0xF0, 0xF3, 0x83, 0xDC,
  0x0E, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF8, 0x1E, 0xF0, 0x73, 0xC1, 0xCF,
  0x07, 0x1C, 0x3C, 0x78, 0xF1, 0xE0, 0x0F, 0x0F, 0x0F, 0x0E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x78, 0x78, 0x78, 0x70,
  0x70, 0xF0, 0xF0, 0x1C, 0xE3, 0xC3, 0xFE, 0xFC, 0x7F, 0xFF, 0x9F, 0x3E,
  0xF3, 0xC7, 0x8E, 0x78, 0xE3, 0xCE, 0x1C, 0x79, 0xC7, 0x8F, 0x78, 0xF1,
  0xCF, 0x1C, 0x39, 0xC3, 0x8F, 0x38, 0x71, 0xE7, 0x1E, 0x39, 0xE3, 0xC7,
  0x3C, 0x71, 0xE0, 0x1C, 0xE0, 0xEF, 0x87, 0xFE, 0x7C, 0xF3, 0xC7, 0x9E,
  0x38, 0xE1, 0xC7, 0x0E, 0x78, 0xF3, 0xC7, 0x9E, 0x38, 0xE1, 0xC7, 0x0E,
  0x78, 0xF3, 0xC7, 0x80, 0x0F, 0x83, 0xF8, 0xFF, 0xBC, 0xF7, 0x8F, 0xE1,
  0xFC, 0x3F, 0x87, 0xE1, 0xFC, 0x3F, 0x87, 0xF9, 0xEF, 0xFC, 0xFF, 0x0F,
  0x80, 0x0E, 0x70, 0x3B, 0xE0, 0xFF, 0xC7, 0xCF, 0x1E, 0x3C, 0x78, 0xF1,
  0xC3, 0xC7, 0x0F, 0x3C, 0x38, 0xF1, 0xE3, 0xC7, 0x8F, 0x3C, 0x3F, 0xF1,
  0xFF, 0x87, 0xBC, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xE0, 0x00, 0x0F, 0x38, 0xFF, 0x8F, 0xFC, 0xF3, 0xE7, 0x8F, 0x38, 0x73,
  0xC3, 0x9E, 0x1C, 0xE1, 0xE7, 0x0F, 0x38, 0x71, 0xE7, 0x8F, 0xFC, 0x7F,
  0xE1, 0xEF, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0,
  0x00, 0x1C, 0xE3, 0xB8, 0x7F, 0x1F, 0xE3, 0xE0, 0x78, 0x0E, 0x01, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x83,
  0xFC, 0xFF, 0x1C, 0x23, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0,
  0x1E, 0x43, 0xCF, 0xF9, 0xFE, 0x3F, 0x80, 0x0E, 0x06, 0x07, 0x07, 0xF7,
  0xF7, 0xF8, 0xE0, 0x70, 0x78, 0x3C, 0x1C, 0x0E, 0x0F, 0x07, 0x83, 0xC1,
  0xF8, 0xFC, 0x3E, 0x00, 0x3C, 0x73, 0x87, 0x38, 0xF7, 0x8F, 0x78, 0xF7,
  0x0E, 0x70, 0xE7, 0x1E, 0xF1, 0xEF, 0x1C, 0xE3, 0xCE, 0x3C, 0xFF, 0xCF,
  0xDC, 0x79, 0x80, 0xE1, 0xFC, 0x3F, 0x87, 0x71, 0xEE, 0x39, 0xCF, 0x39,
  0xC7, 0x78, 0xEE, 0x1F, 0xC3, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3C, 0x00,
  0xE3, 0xC3, 0xF1, 0xE3, 0xF8, 0xF1, 0xDC, 0xF8, 0xEE, 0x6C, 0xF7, 0x76,
  0x73, 0xBF, 0x79, 0xDB, 0xB8, 0xFD, 0xDC, 0x7E, 0xFC, 0x3E, 0x7E, 0x1F,
  0x3F, 0x0F, 0x1F, 0x07, 0x8F, 0x83, 0xC7, 0x80, 0x1E, 0x3C, 0x78, 0xE0,
  0xE7, 0x83, 0xBC, 0x0F, 0xE0, 0x3F, 0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x80,
  0x7F, 0x01, 0xDC, 0x0F, 0x70, 0x79, 0xE1, 0xC7, 0x8F, 0x1E, 0x00, 0x0E,
  0x1E, 0x1C, 0x3C, 0x38, 0x70, 0x71, 0xE0, 0xE3, 0x81, 0xCF, 0x03, 0x9C,
  0x07, 0x78, 0x0E, 0xE0, 0x1D, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0x80, 0x00, 0x1F, 0xF1, 0xFF, 0x1F, 0xE0, 0x1E, 0x03, 0xC0, 0x38,
  0x07, 0x80, 0xF0, 0x0E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x7F, 0xCF, 0xF8,
  0xFF, 0x80, 0x01, 0xE0, 0x7C, 0x1F, 0x83, 0xC0, 0x70, 0x1E, 0x03, 0xC0,
  0x70, 0x0E, 0x03, 0xC1, 0xF0, 0x78, 0x0F, 0x80, 0x78, 0x0F, 0x01, 0xE0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x80, 0xF0,
  0x3F, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x0F,
  0x80, 0x70, 0x7E, 0x1F, 0x03, 0xC0, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0E,
  0x0F, 0xC1, 0xF8, 0x3E, 0x00, 0x38, 0x1F, 0xE3, 0xFF, 0xFC, 0x7F, 0x81,
  0xC0,
};

const GFXglyph NotoSans_Condensed_BoldItalic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 8, 19, 7, 0, -19 },
  { 20, 9, 7, 11, 3, -19 },
  { 28, 15, 19, 14, 0, -19 },
  { 64, 13, 23, 12, 0, -21 },
  { 102, 18, 20, 20, 1, -20 },
  { 147, 15, 20, 16, 0, -20 },
  { 185, 4, 7, 7, 3, -19 },
  { 189, 9, 23, 8, 1, -19 },
  { 215, 9, 24, 8, -2, -20 },
  { 242, 11, 12, 12, 2, -21 },
  { 259, 12, 13, 13, 1, -16 },
  { 279, 6, 7, 7, -1, -3 },
  { 285, 8, 3, 8, 0, -9 },
  { 288, 4, 4, 7, 0, -4 },
  { 290, 14, 19, 10, -1, -19 },
  { 324, 12, 20, 12, 1, -20 },
  { 354, 9, 19, 13, 3, -19 },
  { 376, 14, 20, 12, -1, -20 },
  { 411, 13, 20, 12, 0, -20 },
  { 444, 13, 19, 13, 0, -19 },
  { 475, 13, 19, 12, 0, -19 },
  { 506, 12, 20, 12, 1, -20 },
  { 536, 13, 19, 12, 1, -19 },
  { 567, 13, 20, 12, 0, -20 },
  { 600, 13, 20, 12, 0, -20 },
  { 633, 7, 15, 7, 0, -15 },
  { 647, 8, 19, 7, -1, -15 },
  { 666, 12, 13, 13, 1, -16 },
  { 686, 12, 9, 13, 1, -14 },
  { 700, 12, 13, 13, 1, -16 },
  { 720, 10, 20, 10, 1, -20 },
  { 745, 18, 21, 19, 1, -19 },
  { 793, 14, 19, 14, -2, -19 },
  { 827, 14, 19, 14, 0, -19 },
  { 861, 14, 20, 13, 1, -20 },
  { 896, 15, 19, 15, 0, -19 },
  { 932, 13, 19, 12, 0, -19 },
  { 963, 13, 19, 12, 0, -19 },
  { 994, 15, 20, 16, 1, -20 },
  { 1032, 16, 19, 16, 0, -19 },
  { 1070, 12, 19, 9, -1, -19 },
  { 1099, 12, 25, 7, -4, -19 },
  { 1137, 16, 19, 14, 0, -19 },
  { 1175, 10, 19, 11, 0, -19 },
  { 1199, 21, 19, 20, 0, -19 },
  { 1249, 17, 19, 17, 0, -19 },
  { 1290, 15, 20, 16, 1, -20 },
  { 1328, 14, 19, 14, 0, -19 },
  { 1362, 15, 25, 16, 1, -20 },
  { 1409, 14, 19, 14, 0, -19 },
  { 1443, 13, 20, 12, 0, -20 },
  { 1476, 12, 19, 12, 2, -19 },
  { 1505, 15, 19, 15, 1, -19 },
  { 1541, 14, 19, 14, 2, -19 },
  { 1575, 21, 19, 20, 2, -19 },
  { 1625, 17, 19, 13, -2, -19 },
  { 1666, 13, 19, 13, 2, -19 },
  { 1697, 14, 19, 12, -1, -19 },
  { 1731, 11, 23, 8, -1, -19 },
  { 1763, 6, 19, 11, 3, -19 },
  { 1778, 11, 23, 8, -2, -19 },
  { 1810, 12, 12, 13, 0, -19 },
  { 1828, 10, 2, 9, -3, 2 },
  { 1831, 5, 5, 8, 4, -21 },
  { 1835, 13, 15, 14, 1, -15 },
  { 1860, 13, 21, 14, 0, -21 },
  { 1895, 11, 15, 11, 1, -15 },
  { 1916, 14, 21, 14, 1, -21 },
  { 1953, 11, 15, 13, 1, -15 },
  { 1974, 14, 27, 8, -3, -21 },
  { 2022, 14, 21, 14, 0, -15 },
  { 2059, 13, 21, 14, 0, -21 },
  { 2094, 8, 21, 7, 0, -21 },
  { 2115, 11, 27, 7, -3, -21 },
  { 2153, 14, 21, 13, 0, -21 },
  { 2190, 8, 21, 7, 0, -21 },
  { 2211, 19, 15, 20, 0, -15 },
  { 2247, 13, 15, 14, 0, -15 },
  { 2272, 11, 15, 13, 1, -15 },
  { 2293, 14, 21, 14, -1, -15 },
  { 2330, 13, 21, 14, 1, -15 },
  { 2365, 11, 15, 10, 0, -15 },
  { 2386, 11, 15, 11, 0, -15 },
  { 2407, 9, 18, 9, 1, -18 },
  { 2428, 12, 15, 13, 1, -15 },
  { 2451, 11, 15, 12, 2, -15 },
  { 2472, 17, 15, 18, 2, -15 },
  { 2504, 14, 15, 12, -1, -15 },
  { 2531, 15, 21, 12, -2, -15 },
  { 2571, 12, 15, 10, -1, -15 },
  { 2594, 11, 23, 9, 0, -19 },
  { 2626, 3, 27, 12, 4, -21 },
  { 2637, 11, 23, 9, -2, -19 },
  { 2669, 12, 5, 13, 1, -12 },
};

const GFXfont NotoSans_Condensed_BoldItalic27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BoldItalic27pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BoldItalic27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_CONDENSED_BOLDITALIC27PT7B_H_
