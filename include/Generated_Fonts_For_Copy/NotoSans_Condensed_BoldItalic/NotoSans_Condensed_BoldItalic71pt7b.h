#ifndef _NOTOSANS_CONDENSED_BOLDITALIC71PT7B_H_
#define _NOTOSANS_CONDENSED_BOLDITALIC71PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BoldItalic.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BoldItalic71pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0xF0, 0xFF, 0x9F, 0xF8, 0x7F,
  0xCF, 0xF8, 0x7F, 0xC7, 0xFC, 0x3F, 0xE3, 0xFE, 0x1F, 0xF1, 0xFE, 0x0F,
  0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x83, 0xFC, 0x7F, 0xC3, 0xFE, 0x3F, 0xC1,
  0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xF0, 0x3F, 0xC3, 0xF8,
  0x1F, 0xC3, 0xFC, 0x0F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFE, 0x07, 0xF8, 0x7F,
  0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x03, 0xF8,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0xFC, 0x00,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x00, 0x7E,
  0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x7F, 0x03, 0xF0,
  0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00,
  0x3F, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0xFC, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFC, 0xF1, 0xF0, 0x07, 0xFC, 0x70, 0x30, 0x03, 0xFE, 0x38,
  0x08, 0x01, 0xFF, 0x1C, 0x00, 0x00, 0xFF, 0x9E, 0x00, 0x00, 0x7F, 0xCF,
  0x00, 0x00, 0x3F, 0xE7, 0x00, 0x00, 0x1F, 0xFB, 0x80, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x73, 0xFF, 0x00, 0x00, 0x39, 0xFF, 0x80,
  0x00, 0x3C, 0x7F, 0xC0, 0x00, 0x1E, 0x3F, 0xE0, 0x80, 0x0E, 0x3F, 0xF0,
  0x70, 0x07, 0x1F, 0xF8, 0x7E, 0x03, 0x9F, 0xF8, 0x3F, 0xC3, 0xDF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x03, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x1F, 0xC0, 0x07, 0xF8, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE1, 0xFC, 0x00,
  0xFE, 0x00, 0x3F, 0xC3, 0xF8, 0x03, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x0F,
  0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xFC, 0x1F, 0xC0, 0x7F,
  0x00, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x1F, 0xC0,
  0x00, 0xFE, 0x07, 0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0xFE, 0x00,
  0x03, 0xF8, 0x1F, 0xC3, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x8F, 0xF0, 0x00,
  0x0F, 0xE0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC1, 0xFC, 0x7F, 0x07, 0xFE,
  0x3F, 0x87, 0xF8, 0xFE, 0x3F, 0xFE, 0x7F, 0x0F, 0xE3, 0xF8, 0xFF, 0xFE,
  0xFE, 0x3F, 0xCF, 0xF1, 0xFF, 0xFD, 0xFF, 0xFF, 0x1F, 0xC7, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7F, 0x1F, 0xF7, 0xFB, 0xFF, 0xF8, 0xFE, 0x3F, 0x87, 0xF3,
  0xFF, 0xE3, 0xF8, 0xFF, 0x0F, 0xE7, 0xFF, 0x8F, 0xF1, 0xFC, 0x1F, 0xC3,
  0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x7F, 0x00,
  0x00, 0xFE, 0x1F, 0xC0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x00,
  0x0F, 0xF0, 0xFF, 0x03, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x0F, 0xF0, 0x00,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0x03,
  0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xF0, 0x1F, 0xC1, 0xFE, 0x00, 0x1F,
  0xC0, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0xFE, 0x1F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xF0,
  0x03, 0xF8, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xF8, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x01, 0xFF,
  0x03, 0xFC, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x00, 0x3F,
  0xE1, 0xFF, 0x00, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x00, 0xFF, 0x9F, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xF8, 0x3F, 0xFF, 0xF0,
  0x3F, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0x07,
  0xFE, 0x7F, 0xE3, 0xFE, 0x1F, 0xF8, 0xFF, 0xCF, 0xF8, 0x7F, 0xE0, 0xFF,
  0xDF, 0xF0, 0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xFF, 0x01, 0xFF, 0xFF, 0x87,
  0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xF8, 0x03, 0xFF, 0xFC, 0x1F, 0xF0, 0x07,
  0xFF, 0xF0, 0x3F, 0xE0, 0x0F, 0xFF, 0xC0, 0x7F, 0xC0, 0x0F, 0xFF, 0x80,
  0xFF, 0x80, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0x9F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFD, 0xFF, 0xC0, 0x1F, 0xFF, 0xE1, 0xFF,
  0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xF3, 0xFF, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F,
  0xC7, 0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF0, 0x7F, 0x0F, 0xF0, 0xFF,
  0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x02, 0x00, 0xFE, 0x00,
  0x38, 0x0F, 0xE0, 0x03, 0xC0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xFC,
  0xFC, 0x01, 0x7F, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF0, 0x1F, 0xFE, 0x0F, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xBF, 0x80, 0x3F, 0xF3, 0xFC, 0x07,
  0xFE, 0x3F, 0xC0, 0x3F, 0xE1, 0xFE, 0x01, 0xFC, 0x1F, 0xE0, 0x07, 0x81,
  0xFF, 0x00, 0x38, 0x0F, 0xE0, 0x01, 0x00, 0xF8, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFE,
  0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0,
  0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF,
  0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF,
  0xFC, 0x07, 0x81, 0xFE, 0x3F, 0xE7, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFE, 0xFF, 0xE7, 0xFC, 0x7F, 0x81, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0x87, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x0F,
  0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE1, 0xFF,
  0x80, 0x7F, 0xC3, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x01, 0xFF, 0x1F, 0xF8,
  0x03, 0xFE, 0x3F, 0xE0, 0x07, 0xFC, 0x7F, 0xC0, 0x1F, 0xF9, 0xFF, 0x80,
  0x3F, 0xF3, 0xFF, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0xFF, 0xDF, 0xF8, 0x01,
  0xFF, 0x3F, 0xF0, 0x03, 0xFE, 0x7F, 0xE0, 0x0F, 0xFC, 0xFF, 0x80, 0x1F,
  0xF9, 0xFF, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0xFF,
  0x9F, 0xF8, 0x03, 0xFF, 0x3F, 0xF0, 0x07, 0xFE, 0x7F, 0xC0, 0x0F, 0xFC,
  0xFF, 0x80, 0x1F, 0xF1, 0xFF, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0xFF, 0xC7,
  0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xFE, 0x1F, 0xF0, 0x0F, 0xFC, 0x3F,
  0xE0, 0x3F, 0xF0, 0x7F, 0xC0, 0x7F, 0xE0, 0xFF, 0x81, 0xFF, 0x81, 0xFF,
  0x07, 0xFF, 0x03, 0xFF, 0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0xF7, 0xFC, 0xFF, 0xEF, 0xF8,
  0xFF, 0xCF, 0xF8, 0x7F, 0x8F, 0xF8, 0x3F, 0x1F, 0xF8, 0x3C, 0x1F, 0xF0,
  0x18, 0x1F, 0xF0, 0x10, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xE1, 0xFF, 0xE0, 0x07, 0xF0, 0x1F, 0xFC, 0x00,
  0xFC, 0x01, 0xFF, 0x80, 0x0E, 0x00, 0x3F, 0xF0, 0x01, 0x80, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0x81, 0xFF, 0xE0, 0x03, 0x80, 0x1F, 0xFC, 0x00, 0x60, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x80, 0x00, 0x1F, 0xF8, 0x1C, 0x00,
  0x07, 0xFF, 0x03, 0xE0, 0x03, 0xFF, 0xE0, 0x7F, 0xE7, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFB, 0xFE,
  0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x1F, 0xDF, 0xF0, 0x00, 0x03, 0xFB,
  0xFE, 0x00, 0x00, 0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0x8F, 0xF8, 0x00, 0x0F,
  0xF3, 0xFE, 0x00, 0x01, 0xFC, 0x7F, 0xC0, 0x00, 0x7F, 0x0F, 0xF8, 0x00,
  0x1F, 0xE1, 0xFF, 0x00, 0x03, 0xF8, 0x3F, 0xE0, 0x00, 0xFE, 0x0F, 0xF8,
  0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x01, 0xFC, 0x07,
  0xFC, 0x00, 0x7F, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x03, 0xF8,
  0x07, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x87,
  0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x07, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x80, 0x00, 0x7F,
  0xF0, 0x38, 0x00, 0x3F, 0xFC, 0x0F, 0x80, 0x3F, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xF8,
  0x01, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x1F, 0x80, 0x03, 0xFE, 0x3F, 0xF0, 0x01, 0xFF,
  0x3F, 0xFC, 0x00, 0xFF, 0xBF, 0xFF, 0x00, 0xFF, 0xBF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0x0F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x83,
  0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0x80, 0x3F, 0xF0,
  0xFF, 0xC0, 0x1F, 0xF8, 0x7F, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0x07, 0xFE,
  0x1F, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF,
  0x83, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F,
  0xE0, 0x7F, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x7F, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF0, 0x07, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xC0,
  0x0F, 0xFC, 0x7F, 0xE0, 0x03, 0xFF, 0xBF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xDF, 0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xC1,
  0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFF,
  0x0F, 0xFC, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x0F,
  0xF8, 0x1F, 0xF0, 0x03, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xC1,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x87, 0xFE,
  0x03, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFC, 0x03, 0xFF,
  0x0F, 0xFC, 0x03, 0xFF, 0x0F, 0xFC, 0x03, 0xFF, 0x0F, 0xF8, 0x03, 0xFF,
  0x0F, 0xF8, 0x03, 0xFF, 0x1F, 0xF8, 0x03, 0xFF, 0x1F, 0xF8, 0x03, 0xFF,
  0x1F, 0xF8, 0x03, 0xFF, 0x1F, 0xF0, 0x07, 0xFF, 0x1F, 0xF0, 0x07, 0xFE,
  0x1F, 0xF0, 0x07, 0xFE, 0x1F, 0xF8, 0x0F, 0xFE, 0x1F, 0xF8, 0x1F, 0xFE,
  0x1F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xF7, 0xFC, 0x07, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xEF, 0xF8, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0xFE, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x80, 0x0F, 0xFE, 0x00, 0xFE, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0x7F, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x07, 0xF8, 0x03,
  0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0x0F, 0x80, 0xFF, 0xC3, 0x80, 0x1F, 0xF0, 0x40, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x7F,
  0x03, 0xFC, 0x03, 0xFF, 0xF0, 0x7F, 0x03, 0xF8, 0x07, 0xFF, 0xF8, 0x7F,
  0x07, 0xF0, 0x1F, 0xFF, 0xF8, 0x7F, 0x07, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F,
  0x0F, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0x0F, 0xE0, 0x7F, 0x87, 0xF0, 0x3F,
  0x1F, 0xC0, 0xFF, 0x07, 0xF0, 0x3F, 0x1F, 0xC1, 0xFE, 0x07, 0xE0, 0x7F,
  0x1F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0x7F,
  0x3F, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0x7E,
  0x7F, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x7F, 0x07, 0xF0, 0x1F, 0xC0, 0xFE,
  0x7E, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x7E, 0x0F, 0xE0, 0x1F, 0xC0, 0xFC,
  0x7E, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0xFE, 0x0F, 0xE0, 0x3F, 0x81, 0xFC,
  0xFE, 0x0F, 0xE0, 0x3F, 0x81, 0xF8, 0xFE, 0x0F, 0xE0, 0x7F, 0x83, 0xF8,
  0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0xFE, 0x0F, 0xE0, 0xFF, 0x07, 0xF0,
  0xFE, 0x0F, 0xE1, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xFB, 0xFF, 0xBF, 0xC0,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x07, 0xFF, 0xDF, 0xFF, 0x80,
  0xFE, 0x07, 0xFF, 0x8F, 0xFF, 0x00, 0xFE, 0x03, 0xFF, 0x0F, 0xFE, 0x00,
  0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x01, 0xFD, 0xFE, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x03, 0xFD, 0xFE,
  0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0xFF,
  0x9F, 0xE0, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x01, 0xFF, 0x1F, 0xE0, 0x00,
  0x1F, 0xF1, 0xFE, 0x00, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xE1, 0xFE,
  0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x07, 0xFC,
  0x1F, 0xE0, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x01,
  0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x03, 0xFF, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xFE, 0x00,
  0x1F, 0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0xFF,
  0xC0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x01, 0xFF,
  0x1F, 0xF8, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x01, 0xFF, 0x3F, 0xF0, 0x00,
  0x1F, 0xF7, 0xFE, 0x00, 0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xE0,
  0xFF, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0xFF,
  0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x3F, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFE,
  0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xF0,
  0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xFC, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x0F,
  0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x7F,
  0xE0, 0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x1F, 0x80, 0x1F, 0xFF, 0x00,
  0x70, 0x03, 0xFF, 0xC0, 0x01, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x0C,
  0x00, 0x7F, 0xFC, 0x07, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x01,
  0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xFF, 0x80,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0xFF, 0xC0,
  0x03, 0xFF, 0x81, 0xFF, 0x80, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x01, 0xFF,
  0xC0, 0x7F, 0xE0, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x03, 0xFF,
  0x00, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFC, 0x03, 0xFF,
  0xC0, 0x1F, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x07, 0xF0,
  0x03, 0xFF, 0xF0, 0x01, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x80, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xFC, 0x3F, 0xF8, 0x0F, 0xFF,
  0xF8, 0x7F, 0xE0, 0x1F, 0xFF, 0xE0, 0xFF, 0xC0, 0x3F, 0xFF, 0xC1, 0xFF,
  0x80, 0x7F, 0xFF, 0x87, 0xFF, 0x00, 0xFF, 0xFF, 0x0F, 0xFE, 0x03, 0xFF,
  0xFC, 0x1F, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xF0, 0x0F, 0xFF, 0xF0, 0x7F,
  0xE0, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x01,
  0xFF, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x00,
  0x7F, 0xC0, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x03, 0xFF, 0x00,
  0xFF, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x07,
  0xFC, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7B, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x1F,
  0xFC, 0x00, 0x0F, 0xF8, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x00, 0x07, 0xFC,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0xFF,
  0xC0, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x8F, 0xFE, 0x00,
  0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0x9F, 0xFC, 0x00, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0xC0,
  0x00, 0x07, 0xFC, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x07, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x00,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x01,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xBF,
  0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0x7F, 0x00, 0x3F, 0xDF, 0xF0, 0x03,
  0xFE, 0xFE, 0x00, 0x7F, 0xBF, 0xC0, 0x07, 0xFD, 0xFC, 0x01, 0xFE, 0xFF,
  0x80, 0x0F, 0xFB, 0xF8, 0x03, 0xFD, 0xFF, 0x00, 0x1F, 0xF7, 0xF0, 0x07,
  0xFB, 0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x1F, 0xE7, 0xFC, 0x00, 0xFF, 0x9F,
  0xE0, 0x3F, 0xDF, 0xF0, 0x01, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0xE0, 0x03,
  0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0xC0, 0x07, 0xFC, 0xFF, 0x07, 0xF8, 0xFF,
  0x80, 0x0F, 0xF1, 0xFE, 0x0F, 0xF3, 0xFE, 0x00, 0x3F, 0xE3, 0xFC, 0x3F,
  0xC7, 0xFC, 0x00, 0x7F, 0xC7, 0xF8, 0x7F, 0x8F, 0xF8, 0x00, 0xFF, 0x8F,
  0xF1, 0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0x1F, 0xE3, 0xFC, 0x3F, 0xE0, 0x03,
  0xFC, 0x3F, 0xCF, 0xF0, 0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0x9F, 0xE1, 0xFF,
  0x00, 0x1F, 0xF0, 0xFF, 0x3F, 0x83, 0xFE, 0x00, 0x3F, 0xE1, 0xFE, 0xFF,
  0x07, 0xFC, 0x00, 0x7F, 0x83, 0xFD, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x07,
  0xFF, 0xF8, 0x3F, 0xE0, 0x03, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xC0, 0x07,
  0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xFF, 0x81, 0xFF,
  0x00, 0x1F, 0xE0, 0x3F, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xFC,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xF0, 0x01, 0xFF, 0x01,
  0xFF, 0xE0, 0x3F, 0xE0, 0x03, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x07,
  0xF8, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xE0,
  0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0xC0,
  0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xDF, 0xE0, 0x0F,
  0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x7F, 0xC0, 0x07, 0xFD, 0xFF, 0x01, 0xFF,
  0x00, 0x1F, 0xF7, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xDF, 0xF0, 0x1F, 0xF0,
  0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0x80, 0x07, 0xF8, 0xFF, 0x83, 0xFE, 0x00,
  0x3F, 0xE3, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x8F, 0xF8, 0x3F, 0xE0, 0x03,
  0xFE, 0x1F, 0xE0, 0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0x83, 0xFC, 0x00, 0x3F,
  0xC1, 0xFF, 0x1F, 0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x7F, 0xC0, 0x07, 0xFC,
  0x1F, 0xF1, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xC7, 0xFC, 0x00, 0x7F, 0xC0,
  0xFF, 0x9F, 0xE0, 0x01, 0xFE, 0x03, 0xFE, 0xFF, 0x80, 0x0F, 0xF8, 0x0F,
  0xFB, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xEF, 0xF8, 0x00, 0xFF, 0x80, 0x7F,
  0xBF, 0xC0, 0x03, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xFF,
  0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xF0,
  0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x03, 0xFF,
  0x87, 0xFE, 0x00, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x3F, 0xF8,
  0x00, 0x1F, 0xFC, 0x7F, 0xE0, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x00, 0x7F,
  0xF3, 0xFF, 0x00, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x01, 0xFF, 0x9F, 0xFC,
  0x00, 0x03, 0xFF, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0xFF, 0xC0, 0x00, 0x3F, 0xF9, 0xFF, 0x80, 0x00, 0x7F, 0xF7, 0xFF,
  0x00, 0x00, 0xFF, 0xCF, 0xFE, 0x00, 0x01, 0xFF, 0x9F, 0xFC, 0x00, 0x03,
  0xFF, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0xFF,
  0xC0, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x00, 0xFF, 0xE3, 0xFF, 0x00, 0x01,
  0xFF, 0x87, 0xFE, 0x00, 0x07, 0xFF, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x1F,
  0xF8, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x01,
  0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFE, 0x01,
  0xFF, 0xE0, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0xFF,
  0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x03, 0xFF, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFC,
  0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x01, 0xFF,
  0x83, 0xFF, 0x80, 0x03, 0xFF, 0x87, 0xFE, 0x00, 0x07, 0xFF, 0x1F, 0xFC,
  0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x7F, 0xE0, 0x00, 0x3F,
  0xF9, 0xFF, 0xC0, 0x00, 0x7F, 0xF3, 0xFF, 0x00, 0x00, 0xFF, 0xC7, 0xFE,
  0x00, 0x01, 0xFF, 0x9F, 0xFC, 0x00, 0x03, 0xFF, 0x3F, 0xF8, 0x00, 0x07,
  0xFE, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x3F, 0xF9, 0xFF,
  0x80, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x00, 0xFF, 0xCF, 0xFE, 0x00, 0x01,
  0xFF, 0x9F, 0xFC, 0x00, 0x07, 0xFF, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x00,
  0xFF, 0xE3, 0xFF, 0x00, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x07, 0xFF, 0x0F,
  0xFC, 0x00, 0x0F, 0xFE, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x00,
  0x7F, 0xF0, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xFF, 0x80,
  0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xE1, 0xFF, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xC0,
  0x3F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFF,
  0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xF1, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xC7, 0xFE, 0x00,
  0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x0F, 0xF8, 0x3F,
  0xE0, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x01, 0xFF,
  0x81, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x80,
  0x1F, 0xF0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xFC, 0x03, 0xFE,
  0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x7F, 0xC0, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0xFF, 0x80, 0x1F, 0xFE, 0x01, 0xE0, 0x03, 0xFF,
  0x80, 0x0C, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x02, 0x00, 0x00, 0xFF, 0xC0, 0x30, 0x00, 0x3F,
  0xF0, 0x0F, 0x80, 0x0F, 0xFE, 0x01, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xFC,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x07, 0xFE,
  0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0xFF,
  0xC0, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x07,
  0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFE, 0x01,
  0xFF, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07,
  0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x07, 0xFC, 0x7F, 0xC0,
  0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x01, 0xFF, 0x87,
  0xFC, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x3F,
  0xF0, 0x7F, 0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xC0,
  0x07, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x0F, 0xF8, 0x07,
  0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x7F, 0xE0, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x07,
  0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xF0,
  0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x7F, 0xC3,
  0xFE, 0x00, 0x07, 0xFC, 0x7F, 0xE0, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x07,
  0xFC, 0x7F, 0xC0, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x03, 0xFC, 0xFF, 0x80,
  0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0x3F, 0xDF,
  0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0xBF, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xCF, 0xF8,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xF8,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFF,
  0x80, 0x3F, 0xF0, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0xFF, 0xF8, 0x07, 0xFE, 0x0F, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xF0, 0x3F,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF,
  0x03, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFF, 0xE0,
  0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x81, 0xFF,
  0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF7, 0xF8, 0x3F, 0xF0, 0x0F, 0xF8,
  0x3F, 0xDF, 0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0xFE, 0x7F, 0x83, 0xFE, 0x00,
  0xFF, 0x87, 0xF9, 0xFE, 0x1F, 0xF0, 0x03, 0xFE, 0x1F, 0xE7, 0xF8, 0x7F,
  0xC0, 0x0F, 0xF8, 0xFF, 0x1F, 0xE3, 0xFF, 0x00, 0x3F, 0xE3, 0xFC, 0x7F,
  0x8F, 0xF8, 0x00, 0xFF, 0x8F, 0xE1, 0xFE, 0x3F, 0xE0, 0x03, 0xFE, 0x7F,
  0x87, 0xF9, 0xFF, 0x00, 0x0F, 0xF9, 0xFE, 0x1F, 0xE7, 0xFC, 0x00, 0x3F,
  0xEF, 0xF0, 0x7F, 0xBF, 0xF0, 0x00, 0xFF, 0x3F, 0xC1, 0xFE, 0xFF, 0x80,
  0x03, 0xFC, 0xFE, 0x07, 0xFB, 0xFE, 0x00, 0x0F, 0xF7, 0xF8, 0x1F, 0xFF,
  0xF0, 0x00, 0x3F, 0xDF, 0xE0, 0x7F, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0x01,
  0xFD, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x00, 0x03,
  0xFE, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x7F,
  0xE0, 0x00, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF7, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE3,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC3, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x83, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0xDF, 0xF0, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x0F,
  0xFC, 0x7F, 0xE0, 0x07, 0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x3F,
  0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x3F, 0xF0, 0x01, 0xFF, 0x0F, 0xF8, 0x00,
  0x7F, 0xC7, 0xFE, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x80,
  0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F,
  0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07,
  0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03,
  0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0x3F, 0x80, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x7F, 0x8F, 0xF0,
  0x00, 0x7F, 0x87, 0xF8, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x3F, 0xC0, 0xFE,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xF0, 0x03, 0xFC, 0x0F, 0xF8, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x1F, 0xE3, 0xFC, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x03, 0xFB, 0xFE, 0x00,
  0x01, 0xFE, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0x87, 0xFE,
  0x0F, 0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x81, 0xFE, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xFE, 0x1F, 0xE0,
  0x07, 0xFF, 0xC7, 0xF8, 0x03, 0xFF, 0xFB, 0xFE, 0x01, 0xFF, 0xFE, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC0,
  0x7F, 0xE0, 0x7F, 0xE0, 0x1F, 0xF8, 0x1F, 0xF8, 0x07, 0xFE, 0x0F, 0xFC,
  0x01, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x1F, 0xF0, 0x7F,
  0xE0, 0x07, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xC1,
  0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x0F, 0xF8, 0x3F, 0xF0, 0x03, 0xFE,
  0x0F, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x1F,
  0xF0, 0x3F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC,
  0x1F, 0xFE, 0x03, 0xFF, 0xDF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFB, 0xFC, 0x00, 0xFF, 0xFC, 0xFF, 0x00,
  0x3F, 0xFF, 0x3F, 0xC0, 0x07, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x83, 0xFC,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x1F,
  0xE0, 0x00, 0xFF, 0x9F, 0xFC, 0x00, 0x3F, 0xEF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFD, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0x03,
  0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x0F, 0xF8, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x3F,
  0xF0, 0x7F, 0xC0, 0x0F, 0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x07, 0xF8, 0x00,
  0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xE0,
  0x07, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x7F, 0xC1, 0xFF,
  0x80, 0x3F, 0xF0, 0x7F, 0xC0, 0x0F, 0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x07,
  0xFC, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x3F, 0xF0,
  0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0xC7, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xEF, 0xFF,
  0xF8, 0x07, 0xFB, 0xFF, 0xFC, 0x01, 0xFC, 0xFF, 0xFE, 0x00, 0xFF, 0x1F,
  0xFE, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0x01, 0x80, 0xFF, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0xC0, 0xFF, 0xE0, 0x3C, 0x07,
  0xFF, 0x9F, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xF8, 0x00, 0x3F, 0xF8,
  0xFF, 0x80, 0x03, 0xFF, 0xE7, 0xFC, 0x00, 0x3F, 0xFF, 0xBF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFE, 0xFF, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x0F, 0xFC,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x7F,
  0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x01, 0xFE,
  0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xE0,
  0x07, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x7F, 0xF0, 0x03, 0xFF, 0x87, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xEF, 0xF0, 0x00, 0x7F, 0xFE, 0x7F, 0x80, 0x01, 0xFF, 0xE3, 0xFC, 0x00,
  0x07, 0xFE, 0x1F, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xC1, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x3F, 0xF0, 0x1F, 0xF1,
  0xFF, 0x80, 0x7F, 0xC7, 0xFC, 0x01, 0xFF, 0x1F, 0xF0, 0x07, 0xF8, 0xFF,
  0x80, 0x3F, 0xE3, 0xFE, 0x01, 0xFF, 0x8F, 0xF8, 0x1F, 0xFC, 0x7F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x10, 0x1F, 0xF8, 0x03, 0xC0, 0x7F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x08, 0x7F,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x3F, 0xFC, 0x7F, 0x80, 0x03, 0xFF, 0xE3, 0xFC, 0x00, 0x3F, 0xFF, 0xBF,
  0xE0, 0x03, 0xFF, 0xFD, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xE1, 0xFF, 0xE0,
  0x0F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF,
  0x80, 0x7F, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF0,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x80,
  0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFC, 0x0F, 0xFE,
  0x00, 0x7F, 0xE0, 0xFF, 0xF0, 0x03, 0xFF, 0xDF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xDF, 0xF0, 0x00, 0x7F, 0xFC, 0xFF, 0x80, 0x01, 0xFF, 0xCF,
  0xFC, 0x00, 0x07, 0xFC, 0x7F, 0xE0, 0x00, 0x07, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x40, 0x00,
  0x3F, 0xF0, 0x03, 0x80, 0x03, 0xFF, 0x00, 0x1F, 0x80, 0x7F, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x9F, 0xFE, 0x00,
  0x7F, 0xDF, 0xFF, 0x80, 0x3F, 0xDF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0xC0, 0x7F,
  0xC0, 0xFF, 0xC0, 0x3F, 0xE0, 0x7F, 0xE0, 0x1F, 0xF0, 0x7F, 0xE0, 0x0F,
  0xF8, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF8, 0x07, 0xFE, 0x0F, 0xF8, 0x03,
  0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0x83, 0xFF, 0x00,
  0xFF, 0xC1, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xC0,
  0x1F, 0xF0, 0x7F, 0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F, 0xFC, 0x1F, 0xF0,
  0x07, 0xFC, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x07, 0xFE,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x7F, 0xC0, 0xFF,
  0x80, 0x3F, 0xE0, 0xFF, 0xC0, 0x1F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F,
  0xE0, 0x0F, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x0F, 0xF8, 0x03, 0xFE, 0x0F,
  0xFC, 0x01, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x08, 0x7F,
  0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x3F,
  0xF0, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF,
  0x81, 0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xF8, 0x00, 0x7F, 0xE1, 0xFF, 0x80,
  0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x00, 0xFF, 0x8F,
  0xF8, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x03,
  0xFE, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x9F,
  0xF0, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x0F,
  0xF8, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x03, 0xFE, 0x07, 0xFE,
  0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xF8,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x80,
  0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xF8, 0x01,
  0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFE, 0x07, 0xF8, 0x03, 0xFE, 0x00,
  0x3F, 0x87, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xE3, 0xFF, 0xE1, 0xFF, 0xF8,
  0x03, 0xF9, 0xFF, 0xFC, 0xFF, 0xFE, 0x01, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF0,
  0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC,
  0x07, 0xFC, 0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xC1, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x7F, 0xE0, 0x1F,
  0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0xC0,
  0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xF8,
  0x03, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC1, 0xFF,
  0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x1F,
  0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x81,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF,
  0x83, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF0, 0x7F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x7F, 0xC0,
  0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0xFE, 0x07,
  0xF8, 0x00, 0x7F, 0x0F, 0xFF, 0x00, 0x3F, 0x8F, 0xFF, 0xC0, 0x1F, 0xCF,
  0xFF, 0xE0, 0x1F, 0xEF, 0xFF, 0xF8, 0x0F, 0xF7, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0x81, 0xFF,
  0xC0, 0x7F, 0xC0, 0xFF, 0xE0, 0x3F, 0xE0, 0x7F, 0xE0, 0x1F, 0xF0, 0x3F,
  0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0x07, 0xFC, 0x1F, 0xF8, 0x07, 0xFE, 0x0F,
  0xFC, 0x03, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x83,
  0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0x80, 0x3F, 0xE0,
  0x7F, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xF0, 0x07, 0xFC,
  0x1F, 0xF0, 0x07, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x07, 0xFC, 0x01, 0xFF,
  0x03, 0xFE, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x7F,
  0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xE0, 0x0F,
  0xF8, 0x3F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFE, 0x0F, 0xF8, 0x03,
  0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0x83, 0xFF, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF0, 0xFF, 0xC0, 0x3F,
  0xE1, 0xFF, 0x80, 0x7F, 0xE7, 0xFE, 0x00, 0xFF, 0xCF, 0xFC, 0x01, 0xFF,
  0x9F, 0xF0, 0x03, 0xFF, 0x7F, 0xE0, 0x07, 0xFE, 0xFF, 0xC0, 0x0F, 0xFD,
  0xFF, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x7F, 0xDF,
  0xF8, 0x00, 0xFF, 0xBF, 0xF0, 0x03, 0xFF, 0x7F, 0xE0, 0x07, 0xFE, 0xFF,
  0x80, 0x0F, 0xF9, 0xFF, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x7F, 0xE7, 0xFC,
  0x00, 0xFF, 0xCF, 0xF8, 0x03, 0xFF, 0x1F, 0xF8, 0x07, 0xFE, 0x3F, 0xF0,
  0x1F, 0xF8, 0x7F, 0xE0, 0x7F, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0x3F,
  0x87, 0xFF, 0x00, 0x00, 0xFE, 0x3F, 0xFE, 0x00, 0x03, 0xF9, 0xFF, 0xFC,
  0x00, 0x1F, 0xEF, 0xFF, 0xF8, 0x00, 0x7F, 0xBF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xCF, 0xFE, 0x00, 0x1F, 0xFC, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x0F,
  0xFE, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0xF9, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0x7F, 0xFF, 0x00, 0x07, 0xFD, 0xFF, 0xF8,
  0x00, 0x3F, 0xE3, 0xFF, 0xC0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x03, 0xFE,
  0x07, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x3F, 0xC0,
  0x0F, 0xFF, 0x1F, 0xE0, 0x07, 0xFF, 0xE7, 0xF8, 0x03, 0xFF, 0xF9, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFE, 0xFF, 0xFC, 0x07, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x01,
  0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x1F, 0xF8, 0x1F, 0xF0,
  0x07, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xE0, 0xFF,
  0x80, 0x1F, 0xF0, 0x7F, 0xE0, 0x07, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x07,
  0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0xC0, 0x0F, 0xF8,
  0x3F, 0xF0, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x3F,
  0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x01,
  0xFF, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0xC7, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFD, 0xFF, 0x00, 0x3F, 0xFF, 0x7F, 0xC0, 0x07, 0xFF, 0x1F, 0xF0,
  0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x07, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xF1, 0xFF,
  0x00, 0xFF, 0x3F, 0xF0, 0x0F, 0xF7, 0xFE, 0x01, 0xFE, 0x7F, 0xE0, 0x1F,
  0xEF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0x8C, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F,
  0xE0, 0xFC, 0x0F, 0xFC, 0x01, 0x80, 0xFF, 0xC0, 0x08, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x08, 0x00, 0x3F, 0xF0, 0xE0, 0x07, 0xFF, 0x0F, 0xE1,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0xC0, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x81, 0xFF,
  0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xF0, 0x7F,
  0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x0F,
  0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x03,
  0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x3F, 0xE0,
  0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF8,
  0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xF8, 0x07, 0xFE, 0x0F, 0xF8, 0x03, 0xFE,
  0x07, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x7F,
  0xC1, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F,
  0xF0, 0x3F, 0xE0, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF8, 0x0F,
  0xFE, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x07,
  0xFF, 0x81, 0xFF, 0xC7, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xEF, 0xF0, 0x0F, 0xFF, 0xF7, 0xF8, 0x03, 0xFF,
  0xF3, 0xFC, 0x00, 0xFF, 0xF1, 0xFC, 0x00, 0x3F, 0xE0, 0xFE, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFB, 0xFE,
  0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x7F, 0xCF, 0xF8, 0x01, 0xFF, 0x9F, 0xF0,
  0x03, 0xFE, 0x3F, 0xE0, 0x0F, 0xFC, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0x80,
  0x7F, 0xE0, 0xFF, 0x00, 0xFF, 0x81, 0xFE, 0x03, 0xFF, 0x03, 0xFC, 0x07,
  0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x1F, 0xE0, 0x7F,
  0xC0, 0x3F, 0xC1, 0xFF, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0xFF, 0x0F, 0xF8,
  0x01, 0xFE, 0x1F, 0xF0, 0x03, 0xFC, 0x7F, 0xC0, 0x07, 0xF8, 0xFF, 0x80,
  0x0F, 0xF1, 0xFE, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x3F, 0xCF, 0xF0, 0x00,
  0x7F, 0xBF, 0xE0, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0xFE, 0xFF, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFB, 0xFE,
  0x00, 0xFF, 0xE0, 0x1F, 0xF7, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xEF, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0x9F, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0x3F, 0xE0,
  0x3F, 0xFC, 0x07, 0xFC, 0x7F, 0xC0, 0x7F, 0xF8, 0x0F, 0xF8, 0xFF, 0x81,
  0xFF, 0xF0, 0x3F, 0xE1, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xC3, 0xFE, 0x0F,
  0xFF, 0xC0, 0xFF, 0x87, 0xFC, 0x1F, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F,
  0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0xFE, 0xFE, 0x1F, 0xF0, 0x3F, 0xE1, 0xFD,
  0xFC, 0x3F, 0xE0, 0x7F, 0xC7, 0xFB, 0xF8, 0x7F, 0x80, 0xFF, 0x8F, 0xE7,
  0xF1, 0xFF, 0x01, 0xFF, 0x1F, 0xCF, 0xE3, 0xFE, 0x03, 0xFE, 0x7F, 0x1F,
  0xC7, 0xF8, 0x07, 0xFC, 0xFE, 0x3F, 0x9F, 0xF0, 0x0F, 0xFB, 0xFC, 0x7F,
  0x3F, 0xC0, 0x1F, 0xF7, 0xF0, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xE1, 0xFD,
  0xFF, 0x00, 0x7F, 0xBF, 0x83, 0xFB, 0xFC, 0x00, 0xFF, 0x7F, 0x07, 0xFF,
  0xF8, 0x01, 0xFE, 0xFE, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07,
  0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x7F,
  0xE0, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x7F, 0xE0, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x00, 0x7F, 0xCF, 0xF8,
  0x00, 0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xEF,
  0xF8, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x00,
  0x7F, 0xE3, 0xFF, 0x00, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x1F,
  0xF0, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x0F,
  0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x3F,
  0xE1, 0xFF, 0x80, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x00, 0x1F, 0xE1, 0xFF,
  0x00, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x00,
  0x1F, 0xE7, 0xFC, 0x00, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x02, 0x3F,
  0xFC, 0x00, 0x0D, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF2, 0x00, 0x01,
  0xFF, 0xC4, 0x00, 0x00, 0x7C, 0x00,
};

const GFXglyph NotoSans_Condensed_BoldItalic71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 21, 52, 19, 0, -51 },
  { 138, 25, 19, 29, 7, -51 },
  { 198, 39, 51, 37, 0, -51 },
  { 447, 33, 58, 33, 1, -54 },
  { 687, 47, 52, 53, 4, -51 },
  { 993, 39, 52, 41, 1, -51 },
  { 1247, 12, 19, 18, 7, -51 },
  { 1276, 25, 62, 21, 1, -51 },
  { 1470, 24, 63, 21, -5, -52 },
  { 1659, 28, 31, 32, 6, -54 },
  { 1768, 31, 34, 35, 3, -42 },
  { 1900, 16, 19, 18, -4, -9 },
  { 1938, 19, 8, 21, 1, -23 },
  { 1957, 12, 12, 18, 0, -11 },
  { 1975, 37, 52, 28, -4, -51 },
  { 2216, 31, 52, 33, 2, -51 },
  { 2418, 24, 51, 33, 7, -51 },
  { 2571, 35, 51, 33, -2, -51 },
  { 2795, 35, 52, 33, -1, -51 },
  { 3023, 35, 51, 33, -1, -51 },
  { 3247, 34, 52, 33, 0, -51 },
  { 3468, 33, 52, 33, 2, -51 },
  { 3683, 35, 51, 33, 2, -51 },
  { 3907, 34, 52, 33, 0, -51 },
  { 4128, 32, 52, 33, 1, -51 },
  { 4336, 18, 40, 18, 0, -39 },
  { 4426, 22, 49, 18, -4, -39 },
  { 4561, 31, 35, 35, 3, -43 },
  { 4697, 31, 22, 35, 3, -36 },
  { 4783, 31, 35, 35, 3, -43 },
  { 4919, 26, 52, 26, 3, -51 },
  { 5088, 48, 57, 50, 2, -51 },
  { 5430, 36, 51, 37, -4, -51 },
  { 5660, 37, 51, 37, 0, -51 },
  { 5896, 36, 52, 35, 3, -51 },
  { 6130, 39, 51, 40, 0, -51 },
  { 6379, 35, 51, 31, 0, -51 },
  { 6603, 34, 51, 30, 0, -51 },
  { 6820, 39, 52, 41, 3, -51 },
  { 7074, 43, 51, 41, 0, -51 },
  { 7349, 32, 51, 24, -3, -51 },
  { 7553, 32, 66, 19, -11, -51 },
  { 7817, 43, 51, 36, 0, -51 },
  { 8092, 26, 51, 30, 0, -51 },
  { 8258, 55, 51, 53, 0, -51 },
  { 8609, 46, 51, 44, 0, -51 },
  { 8903, 39, 52, 43, 3, -51 },
  { 9157, 38, 51, 36, 0, -51 },
  { 9400, 39, 63, 43, 3, -51 },
  { 9708, 36, 51, 36, 0, -51 },
  { 9938, 35, 52, 32, -1, -51 },
  { 10166, 30, 51, 31, 6, -51 },
  { 10358, 39, 52, 40, 3, -51 },
  { 10612, 36, 51, 36, 6, -51 },
  { 10842, 54, 51, 54, 6, -51 },
  { 11187, 44, 51, 35, -4, -51 },
  { 11468, 34, 51, 33, 6, -51 },
  { 11685, 38, 51, 31, -3, -51 },
  { 11928, 28, 62, 21, -2, -51 },
  { 12145, 16, 52, 28, 7, -51 },
  { 12249, 29, 62, 21, -5, -51 },
  { 12474, 33, 31, 33, 0, -51 },
  { 12602, 26, 5, 25, -7, 6 },
  { 12619, 14, 11, 22, 10, -54 },
  { 12639, 34, 40, 36, 2, -39 },
  { 12809, 34, 55, 36, 0, -54 },
  { 13043, 28, 40, 29, 2, -39 },
  { 13183, 37, 55, 36, 2, -54 },
  { 13438, 30, 40, 33, 2, -39 },
  { 13588, 38, 71, 22, -8, -54 },
  { 13926, 37, 56, 36, -1, -39 },
  { 14185, 33, 54, 36, 0, -54 },
  { 14408, 21, 54, 18, 0, -54 },
  { 14550, 30, 71, 18, -9, -54 },
  { 14817, 37, 54, 33, 0, -54 },
  { 15067, 21, 54, 18, 0, -54 },
  { 15209, 50, 39, 53, 0, -39 },
  { 15453, 33, 39, 36, 0, -39 },
  { 15614, 31, 41, 35, 2, -40 },
  { 15773, 38, 56, 36, -4, -39 },
  { 16039, 34, 56, 36, 2, -39 },
  { 16277, 28, 39, 25, 0, -39 },
  { 16414, 28, 40, 28, 0, -39 },
  { 16554, 22, 48, 23, 3, -47 },
  { 16686, 33, 40, 35, 2, -39 },
  { 16851, 31, 39, 31, 4, -39 },
  { 17003, 47, 39, 47, 4, -39 },
  { 17233, 38, 39, 31, -3, -39 },
  { 17419, 40, 56, 31, -5, -39 },
  { 17699, 31, 39, 27, -2, -39 },
  { 17851, 28, 62, 24, 1, -51 },
  { 18068, 8, 70, 30, 11, -54 },
  { 18138, 28, 62, 24, -4, -51 },
  { 18355, 31, 12, 35, 3, -31 },
};

const GFXfont NotoSans_Condensed_BoldItalic71pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BoldItalic71pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BoldItalic71pt7bGlyphs,
  0x20, 0x7E, 97
};

#endif // _NOTOSANS_CONDENSED_BOLDITALIC71PT7B_H_
