#ifndef _NOTOSANS_CONDENSED_BOLDITALIC13PT7B_H_
#define _NOTOSANS_CONDENSED_BOLDITALIC13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BoldItalic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BoldItalic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x32, 0x66, 0x64, 0x0C, 0xC0, 0x5E, 0xB4, 0x1E, 0x29, 0xF9, 0x62,
  0x9F, 0x96, 0x28, 0xD0, 0x08, 0xF7, 0xDC, 0x70, 0xE1, 0xEA, 0xF8, 0x82,
  0x00, 0x72, 0xB4, 0xBC, 0xAB, 0xFF, 0x15, 0x2D, 0x6D, 0x46, 0x3C, 0x48,
  0xB1, 0xC7, 0x2B, 0xF7, 0x6E, 0x7E, 0x5C, 0x19, 0x98, 0xC4, 0x23, 0x18,
  0xC6, 0x10, 0x30, 0x86, 0x31, 0x08, 0xC6, 0x23, 0x30, 0x35, 0xBE, 0xED,
  0x0C, 0x21, 0x09, 0xF2, 0x10, 0x80, 0x6D, 0x60, 0xF0, 0xF0, 0x06, 0x18,
  0x30, 0xC1, 0x06, 0x08, 0x30, 0xC0, 0x3D, 0xB6, 0xD3, 0xCF, 0x3D, 0xB6,
  0x70, 0x3B, 0xBC, 0x63, 0x10, 0x8C, 0x60, 0x3D, 0xB0, 0xC3, 0x18, 0xC6,
  0x3E, 0xF8, 0x7C, 0xB0, 0xC6, 0x38, 0x20, 0xA6, 0xF0, 0x0C, 0x73, 0xCA,
  0x5B, 0x6F, 0xC4, 0x30, 0x3C, 0x86, 0x1E, 0x78, 0x21, 0xA6, 0xF0, 0x1C,
  0xC6, 0x1E, 0x6F, 0x3C, 0x96, 0x70, 0x7E, 0x18, 0x30, 0xC1, 0x86, 0x0C,
  0x30, 0xE0, 0x3D, 0xB6, 0xCE, 0x7B, 0x2C, 0xF6, 0x70, 0x3D, 0xB6, 0xD3,
  0x7D, 0xA1, 0xAC, 0xF0, 0x6C, 0x01, 0xB0, 0x33, 0x00, 0x06, 0x64, 0xC0,
  0x09, 0xF9, 0x87, 0x0C, 0x20, 0xFF, 0xC1, 0xF0, 0x86, 0x1C, 0x37, 0x62,
  0x00, 0x7A, 0x46, 0x22, 0x30, 0x0C, 0xC0, 0x1F, 0x18, 0x5B, 0xAB, 0x55,
  0x6E, 0xA7, 0x75, 0xA4, 0x42, 0x1E, 0x00, 0x0E, 0x1C, 0x78, 0xB3, 0x67,
  0xDF, 0xB3, 0xC6, 0x3C, 0x4D, 0x9B, 0xE7, 0xCD, 0x93, 0x6E, 0xF8, 0x3D,
  0x9C, 0x30, 0xC2, 0x08, 0x34, 0xF0, 0x3C, 0x4D, 0x9B, 0x36, 0x6C, 0xD3,
  0x7E, 0xF0, 0x3C, 0x86, 0x1E, 0x79, 0x84, 0x3E, 0xF0, 0x3C, 0x86, 0x18,
  0x79, 0x84, 0x30, 0xC0, 0x3E, 0xCB, 0x06, 0x0D, 0xD1, 0xA3, 0x6C, 0x78,
  0x33, 0x23, 0x62, 0x7E, 0x7E, 0x66, 0x44, 0xCC, 0xCC, 0x3C, 0x61, 0x84,
  0x30, 0xC3, 0x0C, 0xF8, 0x0C, 0x30, 0x86, 0x18, 0x61, 0x0C, 0x30, 0xCE,
  0x30, 0x37, 0x24, 0x6C, 0x78, 0x78, 0x78, 0x58, 0xC8, 0xCC, 0x31, 0x18,
  0xC6, 0x31, 0x1F, 0xF0, 0x31, 0xCC, 0x77, 0x39, 0xCA, 0x7F, 0x97, 0x65,
  0xDB, 0x74, 0xDB, 0x00, 0x31, 0x33, 0x7B, 0x7B, 0x7A, 0x4A, 0x4E, 0xCE,
  0xCE, 0x3C, 0xDB, 0x1E, 0x3C, 0x51, 0xA3, 0x6C, 0xF0, 0x3C, 0x4D, 0x9B,
  0x37, 0xCF, 0x10, 0x60, 0xC0, 0x3C, 0xDB, 0x1E, 0x3C, 0x51, 0xA3, 0x6C,
  0xF0, 0x60, 0x60, 0x3C, 0x4D, 0x9B, 0x67, 0xCF, 0x16, 0x64, 0xCC, 0x3D,
  0x96, 0x1C, 0x38, 0x61, 0xBE, 0xF0, 0xFC, 0xC2, 0x18, 0x61, 0x84, 0x30,
  0xC0, 0x66, 0x8B, 0x36, 0x6C, 0xD9, 0xA6, 0x6C, 0xF0, 0xC7, 0x9B, 0x26,
  0xCD, 0x1E, 0x3C, 0x70, 0xE0, 0xCC, 0xF3, 0x2D, 0xDB, 0x74, 0xFF, 0x3B,
  0xCE, 0xE3, 0xB8, 0xCC, 0x00, 0x33, 0x1E, 0x1E, 0x1C, 0x18, 0x1C, 0x3C,
  0x6C, 0xC6, 0xCF, 0x65, 0x9C, 0x61, 0x86, 0x10, 0xC0, 0x7C, 0x31, 0x84,
  0x31, 0x86, 0x3E, 0xF8, 0x39, 0x18, 0xC6, 0x21, 0x18, 0xC4, 0x38, 0xC9,
  0x26, 0xDB, 0x20, 0x38, 0xC6, 0x31, 0x08, 0xC6, 0x21, 0x38, 0x18, 0xE2,
  0x9B, 0xCC, 0xF0, 0xD0, 0x3E, 0xD9, 0xB6, 0x6C, 0xDB, 0x1A, 0x00, 0x30,
  0xC2, 0x1F, 0x6D, 0xB4, 0xD3, 0xDB, 0xE0, 0x3D, 0xA6, 0x30, 0xC3, 0x47,
  0x00, 0x06, 0x0C, 0x19, 0xE6, 0xCD, 0xB3, 0x66, 0xD8, 0xD0, 0x3D, 0xB4,
  0xFE, 0xC3, 0x27, 0x80, 0x0C, 0x71, 0x8F, 0x30, 0xC3, 0x08, 0x21, 0x86,
  0x18, 0xC0, 0x3E, 0xD9, 0xB6, 0x6C, 0xDB, 0x1E, 0x0C, 0x99, 0xE0, 0x30,
  0xC2, 0x1F, 0x6D, 0xB4, 0xD3, 0xCB, 0x60, 0x33, 0x06, 0x66, 0x44, 0xCC,
  0x0C, 0x30, 0x06, 0x18, 0x61, 0x04, 0x30, 0xC3, 0x18, 0xE0, 0x30, 0x40,
  0x83, 0x76, 0x8F, 0x1C, 0x2C, 0xD9, 0xB0, 0x33, 0x26, 0x66, 0x44, 0xCC,
  0x7F, 0xB6, 0xDB, 0x69, 0xB4, 0x9E, 0x4B, 0x6C, 0x7D, 0xB6, 0xD3, 0x4F,
  0x2D, 0x80, 0x39, 0xB4, 0xF3, 0xCF, 0x67, 0x00, 0x3E, 0x6C, 0xD9, 0x32,
  0x6D, 0x9F, 0x30, 0x41, 0x80, 0x3E, 0xD9, 0x36, 0x6C, 0xDB, 0x1E, 0x0C,
  0x18, 0x20, 0x7B, 0xD8, 0x84, 0x63, 0x00, 0x7B, 0x58, 0xE3, 0x5B, 0xC0,
  0x64, 0xFC, 0xCC, 0x88, 0xC0, 0x65, 0xB6, 0xD3, 0x4B, 0x66, 0x80, 0x9C,
  0xED, 0x6A, 0x73, 0x00, 0x9B, 0xBB, 0xAA, 0xAE, 0xEC, 0xDC, 0xDC, 0x36,
  0x78, 0x70, 0xC3, 0x8D, 0xBB, 0x00, 0x26, 0x4C, 0xF1, 0xE3, 0x87, 0x0C,
  0x18, 0x61, 0xC0, 0x78, 0xCC, 0x46, 0x63, 0xC0, 0x19, 0x8C, 0x66, 0x61,
  0x8C, 0x43, 0x18, 0xFF, 0xF8, 0x38, 0xC6, 0x21, 0x8C, 0xC4, 0x23, 0x30,
  0xCF, 0xE0,
};

const GFXglyph NotoSans_Condensed_BoldItalic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 9, 3, 0, -9 },
  { 6, 5, 3, 5, 1, -9 },
  { 8, 7, 9, 7, 0, -9 },
  { 16, 6, 11, 6, 0, -10 },
  { 25, 8, 9, 10, 1, -9 },
  { 34, 7, 9, 7, 0, -9 },
  { 42, 2, 3, 3, 1, -9 },
  { 43, 5, 11, 4, 0, -9 },
  { 50, 5, 11, 4, -1, -9 },
  { 57, 5, 6, 6, 1, -10 },
  { 61, 5, 7, 6, 1, -8 },
  { 66, 3, 4, 3, -1, -2 },
  { 68, 4, 1, 4, 0, -4 },
  { 69, 2, 2, 3, 0, -2 },
  { 70, 7, 9, 5, -1, -9 },
  { 78, 6, 9, 6, 0, -9 },
  { 85, 5, 9, 6, 1, -9 },
  { 91, 6, 9, 6, 0, -9 },
  { 98, 6, 9, 6, 0, -9 },
  { 105, 6, 9, 6, 0, -9 },
  { 112, 6, 9, 6, 0, -9 },
  { 119, 6, 9, 6, 0, -9 },
  { 126, 7, 9, 6, 0, -9 },
  { 134, 6, 9, 6, 0, -9 },
  { 141, 6, 9, 6, 0, -9 },
  { 148, 3, 7, 3, 0, -7 },
  { 151, 4, 9, 3, -1, -7 },
  { 156, 5, 7, 6, 1, -8 },
  { 161, 5, 4, 6, 1, -7 },
  { 164, 5, 7, 6, 1, -8 },
  { 169, 5, 9, 5, 0, -9 },
  { 175, 9, 10, 9, 0, -9 },
  { 187, 7, 9, 7, -1, -9 },
  { 195, 7, 9, 7, 0, -9 },
  { 203, 6, 9, 6, 1, -9 },
  { 210, 7, 9, 7, 0, -9 },
  { 218, 6, 9, 6, 0, -9 },
  { 225, 6, 9, 6, 0, -9 },
  { 232, 7, 9, 7, 1, -9 },
  { 240, 8, 9, 8, 0, -9 },
  { 249, 6, 9, 4, -1, -9 },
  { 256, 6, 12, 4, -2, -9 },
  { 265, 8, 9, 7, 0, -9 },
  { 274, 5, 9, 6, 0, -9 },
  { 280, 10, 9, 10, 0, -9 },
  { 292, 8, 9, 8, 0, -9 },
  { 301, 7, 9, 8, 1, -9 },
  { 309, 7, 9, 7, 0, -9 },
  { 317, 7, 11, 8, 1, -9 },
  { 327, 7, 9, 7, 0, -9 },
  { 335, 6, 9, 6, 0, -9 },
  { 342, 6, 9, 6, 1, -9 },
  { 349, 7, 9, 7, 1, -9 },
  { 357, 7, 9, 7, 1, -9 },
  { 365, 10, 9, 10, 1, -9 },
  { 377, 8, 9, 6, -1, -9 },
  { 386, 6, 9, 6, 1, -9 },
  { 393, 6, 9, 6, 0, -9 },
  { 400, 5, 11, 4, 0, -9 },
  { 407, 3, 9, 5, 1, -9 },
  { 411, 5, 11, 4, -1, -9 },
  { 418, 6, 5, 6, 0, -9 },
  { 422, 4, 1, 5, -1, 1 },
  { 423, 2, 2, 4, 2, -10 },
  { 424, 7, 7, 7, 0, -7 },
  { 431, 6, 10, 7, 0, -10 },
  { 439, 6, 7, 5, 0, -7 },
  { 445, 7, 10, 7, 0, -10 },
  { 454, 6, 7, 6, 0, -7 },
  { 460, 6, 13, 4, -1, -10 },
  { 470, 7, 10, 7, 0, -7 },
  { 479, 6, 10, 7, 0, -10 },
  { 487, 4, 10, 3, 0, -10 },
  { 492, 6, 13, 3, -2, -10 },
  { 502, 7, 10, 6, 0, -10 },
  { 511, 4, 10, 3, 0, -10 },
  { 516, 9, 7, 10, 0, -7 },
  { 524, 6, 7, 7, 0, -7 },
  { 530, 6, 7, 6, 0, -7 },
  { 536, 7, 10, 7, -1, -7 },
  { 545, 7, 10, 7, 0, -7 },
  { 554, 5, 7, 5, 0, -7 },
  { 559, 5, 7, 5, 0, -7 },
  { 564, 4, 9, 4, 1, -9 },
  { 569, 6, 7, 6, 0, -7 },
  { 575, 5, 7, 6, 1, -7 },
  { 580, 8, 7, 9, 1, -7 },
  { 587, 7, 7, 6, -1, -7 },
  { 594, 7, 10, 6, -1, -7 },
  { 603, 5, 7, 5, 0, -7 },
  { 608, 5, 11, 4, 0, -9 },
  { 615, 1, 13, 6, 2, -10 },
  { 617, 5, 11, 4, -1, -9 },
  { 624, 5, 3, 6, 1, -6 },
};

const GFXfont NotoSans_Condensed_BoldItalic13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BoldItalic13pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BoldItalic13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_CONDENSED_BOLDITALIC13PT7B_H_
