#ifndef _NOTOSANS_CONDENSED_BOLDITALIC50PT7B_H_
#define _NOTOSANS_CONDENSED_BOLDITALIC50PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BoldItalic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BoldItalic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x07, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x03, 0xE0, 0x01, 0x00, 0x00, 0x3F,
  0x1F, 0xCF, 0xC7, 0xE7, 0xF1, 0xF9, 0xF8, 0x7E, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xF1, 0xF0, 0xFC, 0xFC, 0x3E, 0x3F, 0x0F, 0x8F, 0x87, 0xE3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x00, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x7C,
  0x00, 0x0F, 0x87, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01,
  0xF0, 0xF0, 0x00, 0x1E, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x1F,
  0x00, 0x03, 0xC1, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0x87,
  0x80, 0x00, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00,
  0x1E, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0,
  0x07, 0x87, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF0,
  0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1E, 0x0F, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xF3, 0x1C, 0x07, 0xE7, 0x08, 0x07,
  0xE7, 0x00, 0x07, 0xE6, 0x00, 0x07, 0xF6, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1B, 0xF8, 0x00, 0x3B, 0xF8, 0x00, 0x39, 0xF8, 0x40, 0x33, 0xF8, 0x60,
  0x33, 0xF8, 0x78, 0x37, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xFC, 0x00, 0x7C, 0x03, 0xFF,
  0x00, 0x7C, 0x03, 0xFF, 0x80, 0x3E, 0x03, 0xF7, 0xE0, 0x3E, 0x01, 0xF1,
  0xF0, 0x3E, 0x01, 0xF8, 0xF8, 0x1F, 0x00, 0xF8, 0x7C, 0x1F, 0x00, 0x7C,
  0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x8F, 0x80, 0x1F,
  0x0F, 0x87, 0xC0, 0x0F, 0x87, 0xC7, 0xC0, 0x07, 0xC3, 0xE3, 0xE0, 0x03,
  0xE3, 0xE3, 0xE1, 0xF1, 0xF1, 0xF3, 0xE3, 0xFC, 0xF9, 0xF9, 0xF3, 0xFF,
  0x7D, 0xF9, 0xF3, 0xFF, 0xBF, 0xFD, 0xF9, 0xFF, 0xFF, 0xFC, 0xF9, 0xF1,
  0xF7, 0xFC, 0xF8, 0xF8, 0xF9, 0xF8, 0x7C, 0xF8, 0x7C, 0x00, 0x7C, 0x7C,
  0x3E, 0x00, 0x7E, 0x3E, 0x1F, 0x00, 0x3E, 0x3E, 0x0F, 0x80, 0x3E, 0x1F,
  0x0F, 0xC0, 0x1F, 0x0F, 0x87, 0xC0, 0x1F, 0x07, 0xC3, 0xE0, 0x1F, 0x83,
  0xE1, 0xF0, 0x0F, 0x81, 0xF1, 0xF0, 0x0F, 0x80, 0xF8, 0xF8, 0x07, 0xC0,
  0x7C, 0xF8, 0x07, 0xC0, 0x3F, 0xFC, 0x07, 0xE0, 0x0F, 0xFC, 0x03, 0xE0,
  0x07, 0xFC, 0x03, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xC7, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0x87, 0xE0, 0x01,
  0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0xFE, 0x00, 0x1F, 0x8F,
  0xC0, 0x01, 0xFD, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x3F, 0x07, 0xFF,
  0x87, 0xF0, 0xFF, 0xF8, 0x7F, 0x1F, 0xFF, 0xC7, 0xE1, 0xFD, 0xFC, 0xFE,
  0x3F, 0x8F, 0xEF, 0xC7, 0xF0, 0xFF, 0xFC, 0x7F, 0x0F, 0xFF, 0x87, 0xE0,
  0x7F, 0xF8, 0x7E, 0x07, 0xFF, 0x0F, 0xE0, 0x3F, 0xE0, 0xFE, 0x03, 0xFC,
  0x0F, 0xF0, 0x7F, 0xC0, 0x7F, 0x8F, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFE, 0x7F, 0x80, 0xFF, 0xC3,
  0xFC, 0x00, 0x80, 0x00, 0x00, 0x3F, 0x3F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E,
  0x7C, 0x7C, 0xFC, 0xFC, 0xF8, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03,
  0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x20, 0x7C, 0x07, 0x8F, 0x80, 0x7E, 0xF8,
  0x17, 0xFF, 0x9F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0xFB, 0xE0, 0x7F,
  0x3F, 0x03, 0xF1, 0xF0, 0x1E, 0x1F, 0x80, 0xC1, 0xF0, 0x04, 0x0C, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0xFC,
  0x1F, 0xC1, 0xFC, 0x1F, 0x83, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xC0,
  0xFC, 0x00, 0x7F, 0xFB, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0x7F, 0xFB,
  0xFF, 0xC0, 0x04, 0x3F, 0x7F, 0x7F, 0xFF, 0xFF, 0xFE, 0x7E, 0x10, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0x1F, 0xC3, 0xF8, 0x3F, 0x0F,
  0xE0, 0xFC, 0x3F, 0x03, 0xF1, 0xFC, 0x0F, 0xC7, 0xF0, 0x3F, 0x3F, 0x80,
  0xFC, 0xFE, 0x07, 0xF3, 0xF8, 0x1F, 0xCF, 0xC0, 0x7F, 0x7F, 0x01, 0xFD,
  0xFC, 0x07, 0xF7, 0xF0, 0x1F, 0x9F, 0x80, 0xFE, 0x7E, 0x03, 0xFB, 0xF8,
  0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0x81, 0xFC, 0xFE, 0x07, 0xF3, 0xF8, 0x1F,
  0xCF, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x1F, 0xC3, 0xF8, 0xFF, 0x07,
  0xF7, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xC0, 0x03, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFC,
  0x7F, 0xFE, 0x7F, 0xBF, 0x3F, 0xBF, 0x8F, 0x9F, 0xC3, 0x0F, 0xC1, 0x07,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xE0, 0xFE, 0x01, 0xE0,
  0x7F, 0x00, 0xC0, 0x3F, 0x80, 0x20, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x01,
  0xC0, 0xFF, 0x01, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF8, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x80, 0x07, 0xF0, 0x80, 0x0F, 0xF0, 0xF8,
  0x7F, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF,
  0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xDF, 0x80, 0x07, 0xCF,
  0xC0, 0x03, 0xEF, 0xE0, 0x03, 0xE7, 0xF0, 0x03, 0xE3, 0xF0, 0x03, 0xF1,
  0xF8, 0x01, 0xF0, 0xFC, 0x01, 0xF0, 0xFE, 0x01, 0xF8, 0x7F, 0x00, 0xF8,
  0x3F, 0x00, 0xF8, 0x1F, 0x80, 0xF8, 0x1F, 0xC0, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE6, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x06, 0x0F,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x80, 0x0F, 0xF0, 0xC0, 0x1F, 0xE0, 0xFC, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x8F, 0xC0, 0x3F, 0xBF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x7F, 0xEF,
  0xF8, 0x7F, 0x83, 0xF8, 0x7F, 0x83, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03,
  0xF8, 0x7E, 0x03, 0xF8, 0x7E, 0x03, 0xF8, 0xFE, 0x03, 0xF0, 0xFE, 0x07,
  0xF0, 0x7E, 0x07, 0xF0, 0x7E, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0xBF,
  0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x03, 0xF8, 0xFF, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xE0, 0x7F, 0x07, 0xE0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0xFE,
  0x07, 0xF1, 0xFC, 0x03, 0xFB, 0xFC, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x1F, 0xC7, 0xF0, 0x3F, 0x87, 0xF8, 0x7F, 0x03, 0xF8,
  0x7F, 0x03, 0xF8, 0x7E, 0x01, 0xF8, 0xFE, 0x01, 0xF8, 0xFE, 0x03, 0xF8,
  0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFE, 0x1F, 0xC7, 0xF0,
  0x7F, 0x1F, 0xC1, 0xFC, 0x7E, 0x07, 0xF3, 0xF8, 0x1F, 0xCF, 0xE0, 0x7F,
  0x3F, 0x81, 0xFC, 0xFE, 0x07, 0xF3, 0xF0, 0x3F, 0xCF, 0xE0, 0xFF, 0x3F,
  0x87, 0xFC, 0xFF, 0x3F, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF8, 0x3F, 0xEF, 0xC0, 0x7F, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFE, 0x0C, 0x1F, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x1F,
  0x81, 0xFC, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0xFC, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x1F, 0x81, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0x80, 0xF8, 0x01, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0xFE, 0x01, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF,
  0xFC, 0x3F, 0x7F, 0xC7, 0x03, 0xF8, 0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x3E, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0xF8, 0x07,
  0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x07, 0xC1, 0xF8, 0x04, 0x01, 0xF0,
  0x7C, 0x0F, 0xFC, 0x7C, 0x3E, 0x0F, 0xFF, 0x0F, 0x0F, 0x07, 0xFF, 0xC3,
  0xC7, 0xC3, 0xF9, 0xF0, 0xF1, 0xE0, 0xF8, 0x7C, 0x3C, 0xF8, 0x7C, 0x1E,
  0x0F, 0x3E, 0x1F, 0x0F, 0x87, 0xCF, 0x0F, 0x83, 0xE1, 0xF7, 0xC3, 0xE0,
  0xF8, 0x7D, 0xF0, 0xF0, 0x3C, 0x1E, 0x7C, 0x7C, 0x1F, 0x07, 0x9E, 0x1F,
  0x07, 0xC3, 0xE7, 0x87, 0xC1, 0xF0, 0xF1, 0xE1, 0xF0, 0xF8, 0x7C, 0x78,
  0x7C, 0x3E, 0x1F, 0x3E, 0x1F, 0x1F, 0x8F, 0x8F, 0x87, 0xFF, 0xF7, 0xC1,
  0xE1, 0xFF, 0xFF, 0xF0, 0x78, 0x3F, 0xCF, 0xF8, 0x1E, 0x07, 0xE1, 0xF8,
  0x07, 0xC0, 0x20, 0x10, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x20, 0x00, 0x7F, 0x00,
  0x78, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xDF,
  0x80, 0x03, 0xF7, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x1F,
  0x9F, 0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x01, 0xFC, 0x7E, 0x00,
  0x7E, 0x1F, 0x80, 0x3F, 0x87, 0xE0, 0x0F, 0xC1, 0xF8, 0x07, 0xF0, 0x7E,
  0x01, 0xFC, 0x1F, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F,
  0x80, 0x7E, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x07, 0xF3, 0xF8, 0x01, 0xFC,
  0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xDF, 0xC0, 0x07, 0xF7, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x1F, 0x83, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x1F, 0xE0, 0x7E, 0x0F, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xC1, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0x1F, 0x80,
  0x7E, 0x07, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F,
  0x81, 0xFE, 0x0F, 0xC0, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xF0, 0x38, 0x0F,
  0xF0, 0x04, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x06, 0x01, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x7E, 0x3F, 0xF0, 0x1F, 0xC0, 0xFF,
  0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x83, 0xF8,
  0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8,
  0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80,
  0x3F, 0x87, 0xF0, 0x0F, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87,
  0xF0, 0x0F, 0xF0, 0xFE, 0x01, 0xFE, 0x1F, 0xC0, 0x7F, 0x83, 0xF0, 0x0F,
  0xF0, 0xFE, 0x03, 0xFC, 0x1F, 0xC0, 0xFF, 0x83, 0xF8, 0x3F, 0xE0, 0x7F,
  0x1F, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFE, 0x03, 0x80,
  0x7F, 0xC0, 0x08, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x03, 0xFF, 0x87, 0xF0,
  0x3F, 0xF8, 0x7F, 0x07, 0xFF, 0x8F, 0xF0, 0x7F, 0xF8, 0xFF, 0x07, 0xFF,
  0x0F, 0xE0, 0x7F, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE,
  0x00, 0x7E, 0x0F, 0xE0, 0x0F, 0xE0, 0xFF, 0x00, 0xFE, 0x0F, 0xF0, 0x0F,
  0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF8, 0x0F, 0xC0, 0x7F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0x7F, 0x00, 0x7F,
  0x01, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x80,
  0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x01, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0,
  0x0F, 0xC0, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x01, 0xFC, 0x01, 0xFC, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFE, 0x03, 0xF8,
  0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0x7F, 0x00, 0x7F,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x80,
  0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00,
  0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x67, 0xFC,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x03,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x03, 0xFC, 0x01, 0xFC,
  0x1F, 0xE0, 0x07, 0xE0, 0x7F, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0xFE, 0x1F,
  0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x1F, 0xC0,
  0x01, 0xFC, 0xFF, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x00,
  0x7E, 0xFF, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFE, 0xFE, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x1F, 0x87, 0xF0, 0x00, 0x7E, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00,
  0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFC, 0x0F, 0xE0, 0x07,
  0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x03, 0xFC, 0x01, 0xF8,
  0x07, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF,
  0xDF, 0xFF, 0xE7, 0xFF, 0xFB, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0xFE,
  0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xFF,
  0x80, 0x7F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x01, 0xFF,
  0xE0, 0x3F, 0x7C, 0x07, 0xFF, 0x80, 0x7E, 0xF8, 0x0F, 0xFF, 0x00, 0xFD,
  0xF0, 0x3F, 0x7E, 0x01, 0xFB, 0xE0, 0x7F, 0xFC, 0x03, 0xF7, 0xC1, 0xFB,
  0xF8, 0x0F, 0xEF, 0x83, 0xF7, 0xE0, 0x1F, 0x9F, 0x07, 0xCF, 0xC0, 0x3F,
  0x3E, 0x1F, 0x9F, 0x80, 0x7E, 0x7C, 0x3E, 0x7F, 0x00, 0xFC, 0xF8, 0xFC,
  0xFC, 0x03, 0xF9, 0xF1, 0xF1, 0xF8, 0x07, 0xE3, 0xF7, 0xE3, 0xF0, 0x0F,
  0xC7, 0xEF, 0x8F, 0xE0, 0x1F, 0x8F, 0xFF, 0x1F, 0xC0, 0x3F, 0x1F, 0xFC,
  0x3F, 0x00, 0xFC, 0x3F, 0xF8, 0x7E, 0x01, 0xF8, 0x7F, 0xE0, 0xFC, 0x03,
  0xF0, 0xFF, 0xC3, 0xF8, 0x07, 0xE1, 0xFF, 0x87, 0xF0, 0x1F, 0xC3, 0xFE,
  0x0F, 0xC0, 0x3F, 0x07, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xF0, 0x3F, 0x00,
  0xFC, 0x0F, 0xE0, 0xFE, 0x01, 0xF8, 0x1F, 0x81, 0xF8, 0x07, 0xF0, 0x3F,
  0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0xFF, 0x00, 0x3F, 0x01,
  0xFF, 0x00, 0x3F, 0x01, 0xFF, 0x00, 0x7F, 0x01, 0xFF, 0x00, 0x7E, 0x01,
  0xFF, 0x80, 0x7E, 0x01, 0xFF, 0x80, 0x7E, 0x03, 0xFF, 0x80, 0xFE, 0x03,
  0xFF, 0x80, 0xFC, 0x03, 0xFF, 0x80, 0xFC, 0x03, 0xFF, 0xC0, 0xFC, 0x07,
  0xEF, 0xC0, 0xFC, 0x07, 0xEF, 0xC1, 0xFC, 0x07, 0xEF, 0xC1, 0xF8, 0x07,
  0xEF, 0xE1, 0xF8, 0x07, 0xE7, 0xE1, 0xF8, 0x0F, 0xE7, 0xE3, 0xF8, 0x0F,
  0xC7, 0xE3, 0xF8, 0x0F, 0xC7, 0xE3, 0xF0, 0x0F, 0xC3, 0xF3, 0xF0, 0x0F,
  0xC3, 0xF3, 0xF0, 0x1F, 0xC3, 0xF3, 0xF0, 0x1F, 0x83, 0xF7, 0xF0, 0x1F,
  0x83, 0xFF, 0xE0, 0x1F, 0x81, 0xFF, 0xE0, 0x1F, 0x81, 0xFF, 0xE0, 0x3F,
  0x01, 0xFF, 0xE0, 0x3F, 0x01, 0xFF, 0xC0, 0x3F, 0x00, 0xFF, 0xC0, 0x3F,
  0x00, 0xFF, 0xC0, 0x7F, 0x00, 0xFF, 0xC0, 0x7E, 0x00, 0xFF, 0xC0, 0x7E,
  0x00, 0xFF, 0x80, 0x7E, 0x00, 0x7F, 0x80, 0x7E, 0x00, 0x7F, 0x80, 0xFE,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81,
  0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x0F, 0xE3, 0xFC, 0x01,
  0xFC, 0x7F, 0x80, 0x3F, 0x8F, 0xE0, 0x07, 0xF3, 0xFC, 0x00, 0xFE, 0x7F,
  0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xFB, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x0F,
  0xEF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xEF, 0xF0,
  0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xF7, 0xF0, 0x01, 0xFC,
  0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xF3, 0xF8, 0x03, 0xFC, 0x7F, 0x80,
  0x7F, 0x8F, 0xF0, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x02, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7E, 0x0F, 0xF0, 0x1F, 0xC0, 0xFF, 0x03,
  0xF8, 0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x07,
  0xF0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x3F,
  0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF0, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0,
  0xFF, 0x0F, 0xF0, 0x0F, 0xE3, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x8F,
  0xE0, 0x07, 0xF3, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x03,
  0xFB, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFD, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xEF, 0xF0, 0x01, 0xFD, 0xFE, 0x00, 0x3F,
  0xBF, 0x80, 0x0F, 0xF7, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x9F, 0xC0,
  0x0F, 0xF3, 0xF8, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xF0, 0x1F, 0xE0,
  0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFC, 0x07, 0xE1, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x3F,
  0x81, 0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0xC1, 0xFE, 0x0F, 0xE3, 0xFE, 0x07,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x1F, 0x87, 0xE0,
  0x0F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x3F,
  0x01, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x03,
  0xFC, 0x3F, 0x00, 0xFE, 0x1F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFC, 0x3C, 0x07, 0xF8, 0x04, 0x07,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0xC0,
  0x0F, 0xE0, 0xF0, 0x1F, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0x00, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0x7F,
  0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7E,
  0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x1F,
  0xC0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x01, 0xF8, 0x1F,
  0xC0, 0x3F, 0x81, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x03,
  0xF8, 0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x03,
  0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00,
  0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7E, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0,
  0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xF0,
  0x7F, 0x80, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xDF, 0x80, 0x0F, 0xE7, 0xE0, 0x03,
  0xF9, 0xF8, 0x01, 0xFC, 0x7E, 0x00, 0x7F, 0x1F, 0x80, 0x3F, 0x87, 0xE0,
  0x0F, 0xE1, 0xF8, 0x07, 0xF0, 0x7E, 0x01, 0xFC, 0x1F, 0x80, 0x7E, 0x07,
  0xE0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x1F, 0x81, 0xFC,
  0x07, 0xE0, 0xFE, 0x01, 0xF8, 0x3F, 0x80, 0x7E, 0x0F, 0xC0, 0x1F, 0x87,
  0xF0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0xFE, 0x00, 0x7E, 0x3F, 0x00, 0x1F,
  0x9F, 0xC0, 0x07, 0xE7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0xFC, 0x00,
  0x1F, 0xBF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xF0, 0x07, 0xFF, 0xE0, 0x0F,
  0xC0, 0x1F, 0xBF, 0x80, 0x7F, 0x00, 0xFE, 0xFE, 0x01, 0xFC, 0x03, 0xFB,
  0xF8, 0x0F, 0xF0, 0x0F, 0xCF, 0xE0, 0x3F, 0xC0, 0x7F, 0x3F, 0x80, 0xFF,
  0x01, 0xF8, 0xFE, 0x07, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xF0, 0x3F, 0x8F,
  0xE0, 0xFF, 0xC0, 0xFC, 0x3F, 0x83, 0xFF, 0x07, 0xF0, 0xFE, 0x1F, 0xFC,
  0x1F, 0x83, 0xF8, 0x7D, 0xF0, 0xFE, 0x0F, 0xE1, 0xF7, 0xC3, 0xF8, 0x3F,
  0x8F, 0xDF, 0x0F, 0xC0, 0xFC, 0x3E, 0x7C, 0x7F, 0x03, 0xF1, 0xF9, 0xF1,
  0xF8, 0x0F, 0xC7, 0xE7, 0xC7, 0xE0, 0x3F, 0x1F, 0x1F, 0x3F, 0x80, 0xFC,
  0xFC, 0x7C, 0xFC, 0x03, 0xF3, 0xE1, 0xF7, 0xF0, 0x0F, 0xDF, 0x87, 0xDF,
  0x80, 0x3F, 0x7E, 0x1F, 0x7E, 0x00, 0xFD, 0xF0, 0xFF, 0xF8, 0x03, 0xFF,
  0xC3, 0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x0F, 0xFC,
  0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x80,
  0x03, 0xFE, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xC0,
  0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x03, 0xF8, 0x01,
  0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x80, 0x0F,
  0xE0, 0xFE, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x3F,
  0x9F, 0xC0, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0xFD, 0xFC, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x1F, 0xC7, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x03,
  0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x7F, 0x7E, 0x00, 0xFE, 0x7F, 0x01, 0xFE, 0x7F, 0x01, 0xFC, 0x7F,
  0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x3F, 0x07, 0xF0, 0x3F, 0x07, 0xF0, 0x3F,
  0x0F, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x9F, 0xC0, 0x3F, 0x9F, 0x80, 0x1F,
  0xBF, 0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0xFC, 0x1F, 0x83,
  0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0xF8,
  0x1F, 0x03, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0x7C, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x81, 0xF0, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x00,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0,
  0x07, 0xE7, 0xC0, 0x0F, 0x8F, 0x80, 0x3F, 0x1F, 0x80, 0x7C, 0x3F, 0x01,
  0xF8, 0x3E, 0x07, 0xE0, 0x7C, 0x0F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0xFC,
  0x01, 0xF1, 0xF0, 0x03, 0xE7, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xC0, 0x7F,
  0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xC3, 0xF0,
  0xFE, 0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x00, 0x38, 0x00, 0x00, 0xFE, 0x3F,
  0x03, 0xFF, 0x3F, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x1F, 0xE3, 0xFE, 0x1F, 0xC1, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x81, 0xFC,
  0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xF8,
  0x7F, 0x01, 0xF8, 0x7F, 0x03, 0xF8, 0x7E, 0x03, 0xF8, 0xFE, 0x03, 0xF8,
  0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x1F, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xF7, 0xE0,
  0x3F, 0xE7, 0xE0, 0x1F, 0xC7, 0xC0, 0x02, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0xE0, 0x03, 0xF3, 0xF8, 0x07, 0xF7, 0xFC,
  0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xF8, 0xFF,
  0x0F, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xC0, 0x7F,
  0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0xFE,
  0x1F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFC, 0x3F, 0x81, 0xFC,
  0x3F, 0x81, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x83, 0xF8, 0x7F, 0xC7, 0xF0,
  0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7D, 0xFF, 0xC0, 0xFC, 0xFF, 0x80,
  0xF8, 0x7F, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0x01,
  0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xF0, 0x41,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x30, 0x7F, 0x8F, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xC0, 0x03, 0xC3, 0xF0, 0x03, 0xF9, 0xFC, 0x03, 0xFF,
  0x7F, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F,
  0xE3, 0xFE, 0x07, 0xF0, 0x7F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x07,
  0xE0, 0x7F, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x3F, 0x83, 0xF8,
  0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x3F, 0xC0, 0xFF, 0x1F, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xF7, 0xE0, 0x07, 0xF1, 0xF0, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x87, 0xF9, 0xFC, 0x3F, 0x87, 0xE3, 0xF8, 0x3F, 0x1F,
  0x81, 0xF9, 0xFC, 0x0F, 0xCF, 0xC0, 0xFE, 0xFE, 0x1F, 0xE7, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF1, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x7F, 0x80, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x21,
  0xFC, 0x06, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x0F, 0xFC, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xF9, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0xF3, 0xF0, 0x0F, 0xFC, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0x8F, 0xF8, 0x1F, 0xC1, 0xFE, 0x07, 0xF0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x1F,
  0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0x81, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF8,
  0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x83, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xBF, 0x80,
  0x1F, 0xCF, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0x80, 0x80, 0x0F, 0xE0, 0x38, 0x07, 0xF8, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0xF0, 0x03, 0xF3, 0xFC, 0x07, 0xF7, 0xFC, 0x07, 0xEF, 0xFE,
  0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xF8, 0xFF, 0x0F, 0xF0, 0x7F,
  0x0F, 0xE0, 0x7E, 0x0F, 0xE0, 0x7E, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0xFE,
  0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC,
  0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xF8, 0x3F, 0x01, 0xF8,
  0x3F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF0,
  0x7E, 0x03, 0xF0, 0x7E, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0,
  0x00, 0x78, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x04,
  0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x7E, 0x0F,
  0xE0, 0x1F, 0x87, 0xF0, 0x07, 0xE3, 0xF8, 0x03, 0xF9, 0xFC, 0x00, 0xFE,
  0x7E, 0x00, 0x3F, 0x3F, 0x80, 0x0F, 0xDF, 0xC0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xC7,
  0xF0, 0x03, 0xF0, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F,
  0x83, 0xF8, 0x07, 0xE0, 0x7F, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x80, 0xFE, 0x00, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x3E, 0x7F, 0x83,
  0xFC, 0x07, 0xEF, 0xFC, 0x7F, 0xE0, 0x7F, 0xFF, 0xEF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xF8, 0xFF, 0x8F, 0xF0,
  0xFF, 0x0F, 0xF0, 0x7F, 0x0F, 0xE0, 0xFF, 0x07, 0xE0, 0xFE, 0x0F, 0xE0,
  0x7E, 0x0F, 0xC0, 0xFE, 0x07, 0xE1, 0xFC, 0x0F, 0xE0, 0xFE, 0x1F, 0xC0,
  0xFC, 0x0F, 0xE1, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xFC, 0x0F, 0xC1,
  0xF8, 0x1F, 0xC0, 0xFC, 0x3F, 0x81, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0x81,
  0xFC, 0x3F, 0x01, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x81, 0xF8, 0x3F, 0x03,
  0xF8, 0x1F, 0x87, 0xF0, 0x3F, 0x03, 0xF8, 0x7F, 0x03, 0xF0, 0x3F, 0x87,
  0xE0, 0x7F, 0x03, 0xF0, 0x7E, 0x07, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x07,
  0xF0, 0xFE, 0x07, 0xE0, 0x7F, 0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0x00, 0x00,
  0xF0, 0x03, 0xE3, 0xF8, 0x07, 0xE7, 0xFC, 0x07, 0xEF, 0xFE, 0x07, 0xDF,
  0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xF8, 0xFE, 0x0F, 0xF0, 0x7F, 0x0F, 0xE0,
  0x7E, 0x0F, 0xE0, 0x7E, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0xFE, 0x1F, 0xC0,
  0xFE, 0x1F, 0xC0, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x3F, 0x81,
  0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0x01,
  0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF0, 0x7E, 0x03,
  0xF0, 0x7E, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE1, 0xFE, 0x3F, 0xC7, 0xF0, 0x7F, 0x3F, 0x81, 0xFC, 0xFE,
  0x07, 0xF3, 0xF8, 0x1F, 0xDF, 0xC0, 0x7F, 0x7F, 0x01, 0xFD, 0xFC, 0x07,
  0xF7, 0xE0, 0x1F, 0xDF, 0x80, 0x7E, 0x7E, 0x01, 0xFB, 0xF8, 0x0F, 0xEF,
  0xE0, 0x3F, 0xBF, 0x81, 0xFC, 0xFE, 0x07, 0xF1, 0xF8, 0x3F, 0xC7, 0xF1,
  0xFE, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xE0,
  0x01, 0xFF, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0x8F,
  0xE0, 0x03, 0xF3, 0xFE, 0x00, 0x7E, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x3F, 0xC7, 0xF8, 0x0F, 0xF0, 0x7F, 0x01, 0xFC, 0x0F,
  0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x3F,
  0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFE,
  0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8,
  0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xFE, 0x7F, 0x80,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0x7F,
  0xC0, 0x0F, 0xE7, 0xF0, 0x01, 0xF8, 0x10, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xFF, 0x3F, 0x01, 0xFF, 0xBF, 0x03, 0xFF, 0xBE, 0x07, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x0F, 0xE3, 0xFE, 0x1F, 0xC1, 0xFE, 0x1F, 0xC1, 0xFC,
  0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x01, 0xFC, 0x7F, 0x01, 0xFC,
  0x7F, 0x01, 0xF8, 0x7F, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0xFE, 0x03, 0xF8,
  0xFE, 0x03, 0xF0, 0xFE, 0x03, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0,
  0xFE, 0x0F, 0xF0, 0xFF, 0x1F, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xEF, 0xE0, 0x1F, 0xCF, 0xC0, 0x02, 0x0F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xF0,
  0x3E, 0x3F, 0x07, 0xE7, 0xE0, 0x7E, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xC0, 0xFF, 0xC4, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xFC,
  0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0x7C, 0x1F, 0xC0,
  0xC1, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x88,
  0x03, 0xF8, 0xF0, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x01, 0xF0, 0x01, 0xF0,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0xFF, 0x7F, 0xFE,
  0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80,
  0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x20, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xE0,
  0x3F, 0xE0, 0x04, 0x00, 0x0F, 0xC0, 0xFE, 0x3F, 0x81, 0xF8, 0x7E, 0x03,
  0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0x7E,
  0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x07, 0xF1, 0xFC, 0x0F, 0xE3,
  0xF8, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0xFE, 0x1F, 0x81, 0xFC, 0x7F,
  0x03, 0xF8, 0xFE, 0x07, 0xE1, 0xF8, 0x1F, 0xC3, 0xF0, 0x3F, 0x87, 0xE0,
  0xFF, 0x0F, 0xC1, 0xFC, 0x1F, 0xC7, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xE0, 0xFF, 0xEF, 0xC0, 0xFF, 0x9F, 0x00, 0xFE, 0x3E, 0x00, 0x20, 0x00,
  0x00, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFD, 0xF8, 0x0F, 0xEF,
  0xC0, 0xFE, 0x7E, 0x07, 0xF3, 0xF0, 0x3F, 0x1F, 0x83, 0xF8, 0xFC, 0x1F,
  0x87, 0xE1, 0xFC, 0x3F, 0x0F, 0xC0, 0xF8, 0xFE, 0x07, 0xC7, 0xE0, 0x3E,
  0x3F, 0x01, 0xF3, 0xF0, 0x0F, 0x9F, 0x80, 0x7D, 0xF8, 0x03, 0xEF, 0xC0,
  0x1F, 0x7C, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFC, 0x0F, 0xF0, 0x3F, 0xFE, 0x07, 0xF8, 0x1F, 0xBF, 0x03, 0xFC, 0x1F,
  0xDF, 0x83, 0xFE, 0x0F, 0xCF, 0xC1, 0xFF, 0x0F, 0xE7, 0xE1, 0xFF, 0x87,
  0xE3, 0xF0, 0xFF, 0xC3, 0xF1, 0xF8, 0x7F, 0xE3, 0xF8, 0xFC, 0x7D, 0xF1,
  0xF8, 0x7E, 0x3E, 0xF8, 0xFC, 0x3F, 0x3F, 0x7C, 0xFC, 0x1F, 0x9F, 0x3E,
  0x7E, 0x0F, 0xCF, 0x9F, 0x7E, 0x07, 0xEF, 0x9F, 0xBF, 0x03, 0xF7, 0xCF,
  0x9F, 0x81, 0xFB, 0xE7, 0xDF, 0x80, 0xFF, 0xE3, 0xEF, 0xC0, 0x7F, 0xF1,
  0xF7, 0xC0, 0x3F, 0xF0, 0xFF, 0xE0, 0x1F, 0xF8, 0x7F, 0xE0, 0x0F, 0xFC,
  0x3F, 0xF0, 0x07, 0xFC, 0x1F, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F,
  0x80, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x07, 0xF0, 0x0F,
  0xE1, 0xFE, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x03, 0xF9, 0xF8,
  0x00, 0x7F, 0x7F, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xF7, 0xF0, 0x00,
  0xFE, 0x7E, 0x00, 0x3F, 0x8F, 0xC0, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x3F,
  0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x00,
  0x01, 0xF8, 0x07, 0xF8, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x03,
  0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF0,
  0x7E, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE3, 0xF8,
  0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x7E, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFD,
  0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x01, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x70, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xF0, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8,
  0x00, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0x0E, 0x00, 0x04, 0xFF, 0x80, 0x1F,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xA0, 0x03, 0xFC, 0x80, 0x00, 0x00,
};

const GFXglyph NotoSans_Condensed_BoldItalic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 15, 37, 13, 0, -36 },
  { 71, 18, 13, 21, 5, -36 },
  { 101, 28, 36, 26, 0, -36 },
  { 227, 24, 41, 23, 0, -38 },
  { 350, 33, 36, 38, 3, -36 },
  { 499, 28, 37, 29, 0, -36 },
  { 629, 8, 13, 12, 5, -36 },
  { 642, 17, 44, 15, 1, -36 },
  { 736, 18, 44, 15, -4, -36 },
  { 835, 20, 21, 23, 4, -38 },
  { 888, 22, 24, 25, 2, -30 },
  { 954, 12, 13, 13, -3, -6 },
  { 974, 13, 7, 15, 1, -17 },
  { 986, 8, 9, 13, 0, -8 },
  { 995, 27, 36, 19, -3, -36 },
  { 1117, 22, 37, 23, 1, -36 },
  { 1219, 17, 36, 23, 5, -36 },
  { 1296, 25, 36, 23, -2, -36 },
  { 1409, 24, 37, 23, 0, -36 },
  { 1520, 25, 36, 23, -1, -36 },
  { 1633, 24, 37, 23, 0, -36 },
  { 1744, 24, 37, 23, 1, -36 },
  { 1855, 25, 36, 23, 1, -36 },
  { 1968, 24, 37, 23, 0, -36 },
  { 2079, 22, 37, 23, 1, -36 },
  { 2181, 13, 29, 13, 0, -28 },
  { 2229, 16, 35, 13, -3, -28 },
  { 2299, 22, 24, 25, 2, -30 },
  { 2365, 22, 15, 25, 2, -25 },
  { 2407, 22, 24, 25, 2, -30 },
  { 2473, 19, 37, 19, 2, -36 },
  { 2561, 34, 40, 36, 1, -36 },
  { 2731, 26, 36, 26, -3, -36 },
  { 2848, 26, 36, 26, 0, -36 },
  { 2965, 25, 37, 25, 2, -36 },
  { 3081, 27, 36, 28, 0, -36 },
  { 3203, 24, 36, 22, 0, -36 },
  { 3311, 24, 36, 21, 0, -36 },
  { 3419, 28, 37, 29, 2, -36 },
  { 3549, 30, 36, 29, 0, -36 },
  { 3684, 22, 36, 17, -2, -36 },
  { 3783, 23, 47, 14, -8, -36 },
  { 3919, 30, 36, 25, 0, -36 },
  { 4054, 18, 36, 21, 0, -36 },
  { 4135, 39, 36, 38, 0, -36 },
  { 4311, 32, 36, 31, 0, -36 },
  { 4455, 27, 37, 30, 2, -36 },
  { 4580, 27, 36, 25, 0, -36 },
  { 4702, 27, 45, 30, 2, -36 },
  { 4854, 25, 36, 26, 0, -36 },
  { 4967, 24, 37, 22, 0, -36 },
  { 5078, 22, 36, 22, 4, -36 },
  { 5177, 28, 37, 28, 2, -36 },
  { 5307, 26, 36, 25, 4, -36 },
  { 5424, 38, 36, 38, 4, -36 },
  { 5595, 31, 36, 24, -3, -36 },
  { 5735, 24, 36, 23, 4, -36 },
  { 5843, 27, 36, 22, -2, -36 },
  { 5965, 21, 44, 15, -2, -36 },
  { 6081, 11, 36, 19, 5, -36 },
  { 6131, 21, 44, 15, -4, -36 },
  { 6247, 23, 22, 23, 0, -36 },
  { 6311, 18, 4, 17, -5, 4 },
  { 6320, 10, 8, 15, 7, -38 },
  { 6330, 24, 29, 25, 1, -28 },
  { 6417, 24, 39, 25, 0, -38 },
  { 6534, 20, 29, 20, 1, -28 },
  { 6607, 26, 39, 25, 1, -38 },
  { 6734, 21, 29, 23, 1, -28 },
  { 6811, 27, 50, 15, -6, -38 },
  { 6980, 26, 40, 25, -1, -28 },
  { 7110, 24, 38, 25, 0, -38 },
  { 7224, 14, 38, 13, 0, -38 },
  { 7291, 20, 50, 13, -6, -38 },
  { 7416, 26, 38, 23, 0, -38 },
  { 7540, 15, 38, 12, 0, -38 },
  { 7612, 36, 28, 37, 0, -28 },
  { 7738, 24, 28, 25, 0, -28 },
  { 7822, 22, 29, 24, 1, -28 },
  { 7902, 27, 40, 25, -3, -28 },
  { 8037, 24, 40, 25, 1, -28 },
  { 8157, 20, 28, 18, 0, -28 },
  { 8227, 20, 29, 20, 0, -28 },
  { 8300, 16, 34, 16, 2, -33 },
  { 8368, 23, 28, 25, 2, -27 },
  { 8449, 21, 27, 22, 3, -27 },
  { 8520, 33, 27, 33, 3, -27 },
  { 8632, 27, 27, 22, -2, -27 },
  { 8724, 29, 39, 22, -4, -27 },
  { 8866, 22, 27, 19, -2, -27 },
  { 8941, 21, 44, 17, 0, -36 },
  { 9057, 5, 49, 21, 8, -38 },
  { 9088, 20, 44, 17, -3, -36 },
  { 9198, 22, 9, 25, 2, -22 },
};

const GFXfont NotoSans_Condensed_BoldItalic50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BoldItalic50pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BoldItalic50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_CONDENSED_BOLDITALIC50PT7B_H_
