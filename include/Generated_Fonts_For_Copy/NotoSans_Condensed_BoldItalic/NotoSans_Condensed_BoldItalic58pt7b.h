#ifndef _NOTOSANS_CONDENSED_BOLDITALIC58PT7B_H_
#define _NOTOSANS_CONDENSED_BOLDITALIC58PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BoldItalic.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BoldItalic58pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x1F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFE, 0x00, 0x7E, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0x8F, 0xF7, 0xF8, 0xFF,
  0x7F, 0x8F, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x7E, 0x0F,
  0xC7, 0xE1, 0xFC, 0xFE, 0x1F, 0xCF, 0xE1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1,
  0xF8, 0xFC, 0x1F, 0x8F, 0xC3, 0xF0, 0xF8, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xE0,
  0xF8, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0xC1,
  0xF0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x1F, 0x83,
  0xE0, 0x00, 0x1F, 0x87, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7C, 0x1F,
  0x80, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xF8, 0x3F,
  0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xE0, 0xF8, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x07, 0xC1, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x0F, 0x83, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3F, 0x07, 0xC0,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xEE, 0x78, 0x03,
  0xF8, 0xC1, 0x80, 0x3F, 0x9C, 0x00, 0x07, 0xF9, 0xC0, 0x00, 0x7F, 0x9C,
  0x00, 0x07, 0xF9, 0xC0, 0x00, 0x7F, 0xD8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0E, 0xFF, 0x80, 0x00,
  0xE7, 0xF8, 0x00, 0x0E, 0x7F, 0x84, 0x00, 0xC7, 0xF8, 0x60, 0x1C, 0x7F,
  0x07, 0x81, 0xCF, 0xF0, 0x7E, 0x1D, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x20, 0x03, 0xFC, 0x00, 0x1F, 0x80,
  0x1F, 0xFC, 0x00, 0x3F, 0x00, 0x7F, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xF8,
  0x01, 0xF0, 0x03, 0xFB, 0xF0, 0x07, 0xE0, 0x07, 0xE3, 0xF0, 0x1F, 0x80,
  0x1F, 0x87, 0xE0, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x1F,
  0x81, 0xF0, 0x01, 0xF8, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7C, 0x1F, 0x80,
  0x07, 0xE1, 0xF8, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0xFC, 0x00, 0x3F, 0x07,
  0xE3, 0xF0, 0x00, 0x7E, 0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0x3F, 0x1F, 0x80,
  0x01, 0xF8, 0x7E, 0x3F, 0x1F, 0xE3, 0xF0, 0xFC, 0xFC, 0x7F, 0xE7, 0xE3,
  0xF3, 0xF1, 0xFF, 0xEF, 0xEF, 0xE7, 0xE7, 0xFF, 0xCF, 0xFF, 0x9F, 0x8F,
  0xFF, 0x9F, 0xFE, 0x3F, 0x3F, 0x1F, 0xBF, 0xF8, 0xFC, 0xFC, 0x3F, 0x3F,
  0xE3, 0xF1, 0xF8, 0x7E, 0x1F, 0x07, 0xE3, 0xF0, 0xFC, 0x00, 0x1F, 0x8F,
  0xC1, 0xF8, 0x00, 0x3F, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x3F, 0x07, 0xC0,
  0x03, 0xF0, 0x7E, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x3F, 0x00, 0x1F, 0x83,
  0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x0F, 0xC3, 0xF0,
  0x03, 0xF0, 0x1F, 0x87, 0xE0, 0x07, 0xE0, 0x3F, 0x1F, 0x80, 0x1F, 0x80,
  0x7E, 0x3F, 0x00, 0x3F, 0x00, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xF8,
  0x03, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xE0, 0x01, 0xFF, 0x80, 0x1F, 0x80,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0x3F,
  0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xE1,
  0xFC, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x07, 0xF8, 0x0F,
  0xFF, 0x03, 0xF8, 0x1F, 0xFF, 0xC1, 0xFC, 0x1F, 0xFF, 0xE1, 0xFE, 0x0F,
  0xFF, 0xF8, 0xFE, 0x0F, 0xF3, 0xFC, 0xFF, 0x0F, 0xF1, 0xFF, 0x7F, 0x07,
  0xF0, 0x7F, 0xFF, 0x87, 0xF8, 0x3F, 0xFF, 0x83, 0xFC, 0x0F, 0xFF, 0xC1,
  0xFC, 0x07, 0xFF, 0xC0, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0x00, 0xFF, 0xE0,
  0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x7F, 0xF8,
  0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xDF, 0xF0, 0x1F, 0xFF, 0x8F, 0xF8, 0x03, 0xFF, 0x03,
  0xFE, 0x00, 0x18, 0x00, 0x00, 0x00, 0x3F, 0xCF, 0xE7, 0xF9, 0xFC, 0x7F,
  0x1F, 0xC7, 0xF1, 0xF8, 0x7E, 0x3F, 0x8F, 0xE3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x02, 0x03, 0xF0, 0x06, 0x0F, 0xC0, 0x1F, 0x1F, 0x80, 0x3F, 0xBF,
  0x01, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x1F, 0xFF, 0x80, 0x7F, 0xBF, 0x01, 0xFF, 0x7F, 0x03, 0xFC, 0x7E, 0x03,
  0xF0, 0xFE, 0x01, 0xE1, 0xFE, 0x01, 0x81, 0xF0, 0x02, 0x03, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE0, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0,
  0x7F, 0x03, 0xF0, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x00, 0x0F, 0x0F, 0xE7, 0xF9, 0xFF, 0xFF,
  0xBF, 0xEF, 0xFB, 0xFC, 0x7E, 0x06, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xF8, 0xFF, 0x03,
  0xFC, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xFC, 0x3F, 0xC0, 0xFF,
  0x0F, 0xF0, 0x3F, 0xC7, 0xF8, 0x0F, 0xF1, 0xFE, 0x03, 0xFC, 0x7F, 0x80,
  0xFF, 0x3F, 0xC0, 0x3F, 0xCF, 0xF0, 0x0F, 0xF3, 0xFC, 0x03, 0xFC, 0xFF,
  0x00, 0xFE, 0x7F, 0x80, 0x7F, 0x9F, 0xE0, 0x1F, 0xE7, 0xF8, 0x07, 0xF9,
  0xFE, 0x01, 0xFE, 0x7F, 0x80, 0xFF, 0x1F, 0xC0, 0x3F, 0xC7, 0xF0, 0x0F,
  0xF3, 0xFC, 0x03, 0xFC, 0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0x8F, 0xF0,
  0x1F, 0xE3, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xC1, 0xFE, 0x07,
  0xF0, 0xFF, 0x81, 0xFE, 0x7F, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x3F,
  0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xDF, 0xC7, 0xFB, 0xFC, 0x3E,
  0x3F, 0xC1, 0xC3, 0xF8, 0x18, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xE0, 0x1F, 0xC1, 0xFF, 0x00, 0x7C, 0x07, 0xF8, 0x03, 0x80, 0x3F,
  0xC0, 0x08, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0x81, 0xFF,
  0x00, 0xC0, 0x1F, 0xE0, 0x10, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x10, 0x00, 0x7F, 0xC3, 0x00, 0x1F, 0xF8, 0x7C, 0x0F, 0xFE, 0x0F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x02, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7D, 0xFC, 0x00, 0x0F, 0xDF, 0xC0, 0x01, 0xFB, 0xFC,
  0x00, 0x1F, 0xBF, 0x80, 0x03, 0xF3, 0xF8, 0x00, 0x7E, 0x3F, 0x80, 0x07,
  0xE7, 0xF8, 0x00, 0xFC, 0x7F, 0x80, 0x1F, 0x87, 0xF0, 0x03, 0xF0, 0x7F,
  0x00, 0x3F, 0x07, 0xF0, 0x07, 0xE0, 0xFF, 0x00, 0xFC, 0x0F, 0xE0, 0x0F,
  0xC0, 0xFE, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xFE, 0x03, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x00, 0x7C, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x80, 0x03, 0xFE, 0x0E, 0x00, 0x7F,
  0xC0, 0xFC, 0x1F, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x1F, 0x00, 0x3F,
  0xCF, 0xF8, 0x07, 0xF7, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xF0, 0x7F, 0x87, 0xFC,
  0x0F, 0xF0, 0xFF, 0x80, 0xFE, 0x1F, 0xE0, 0x1F, 0xC3, 0xFC, 0x07, 0xF8,
  0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xE1, 0xFC, 0x03, 0xFC, 0x3F, 0x80,
  0x7F, 0x87, 0xF0, 0x1F, 0xE0, 0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0xFF, 0x83,
  0xFC, 0x1F, 0xE0, 0x7F, 0xCF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFF, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x81, 0xFE, 0x03, 0xFC, 0x3F, 0xC0,
  0x3F, 0xE7, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFB, 0xFE, 0x01, 0xFE,
  0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0x7F,
  0x07, 0xF8, 0x07, 0xF8, 0x7F, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF0, 0xFF,
  0x00, 0x7F, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x80, 0xFF, 0x07, 0xF8, 0x1F,
  0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x50,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF1, 0xFE,
  0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x1F, 0xE0, 0x3F, 0xC7, 0xF0, 0x0F, 0xF3,
  0xFC, 0x03, 0xFC, 0xFF, 0x01, 0xFF, 0x3F, 0xC0, 0x7F, 0xCF, 0xF0, 0x1F,
  0xE3, 0xFC, 0x0F, 0xF8, 0xFF, 0x03, 0xFE, 0x3F, 0xE3, 0xFF, 0x87, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01,
  0xFF, 0xBF, 0xC0, 0x3F, 0x8F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x03, 0x01, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xF8,
  0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03,
  0xFC, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x3F, 0x80, 0xFF, 0x01, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x3F, 0x00, 0x18, 0x00,
  0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x80, 0xFF, 0xFF, 0x07, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xC0, 0xFF, 0x0C,
  0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x7C, 0x03, 0xF0, 0x7C,
  0x07, 0xFF, 0x87, 0xE1, 0xF8, 0x1F, 0xFF, 0x8F, 0xC7, 0xE0, 0x7F, 0xFE,
  0x0F, 0x8F, 0xC1, 0xFF, 0xFC, 0x1F, 0x1F, 0x07, 0xF1, 0xF8, 0x3E, 0x7E,
  0x1F, 0x83, 0xF0, 0x7C, 0xF8, 0x3F, 0x07, 0xC1, 0xFB, 0xF0, 0xFC, 0x0F,
  0x83, 0xF7, 0xE1, 0xF8, 0x3F, 0x07, 0xCF, 0x83, 0xE0, 0x7E, 0x0F, 0x9F,
  0x0F, 0xC0, 0xF8, 0x1F, 0x7E, 0x1F, 0x81, 0xF0, 0x7E, 0xFC, 0x3E, 0x07,
  0xE0, 0xF9, 0xF0, 0x7C, 0x0F, 0xC1, 0xF3, 0xE0, 0xF8, 0x1F, 0x07, 0xE7,
  0xC3, 0xF0, 0x7E, 0x0F, 0x8F, 0x87, 0xE0, 0xFC, 0x1F, 0x1F, 0x0F, 0xC3,
  0xF8, 0x7C, 0x3E, 0x0F, 0xCF, 0xF1, 0xF8, 0x7C, 0x1F, 0xFF, 0xFF, 0xE0,
  0xF8, 0x3F, 0xFB, 0xFF, 0x81, 0xF0, 0x3F, 0xE7, 0xFE, 0x03, 0xE0, 0x3F,
  0x87, 0xF8, 0x07, 0xE0, 0x08, 0x01, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xC0, 0x00, 0x3F, 0xE0, 0x0F, 0x80,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x07, 0xF7, 0xE0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0xFE, 0x7E, 0x00,
  0x03, 0xF9, 0xF8, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x7F, 0x1F, 0x80, 0x03,
  0xFC, 0x7E, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC,
  0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0xFE, 0x07,
  0xF0, 0x07, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0x7F, 0x00, 0xFF, 0x01, 0xFC,
  0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0x07, 0xF8, 0x01, 0xFC, 0x3F, 0xC0, 0x07, 0xF0, 0xFF, 0x00,
  0x1F, 0xC7, 0xF8, 0x00, 0x7F, 0x1F, 0xE0, 0x01, 0xFC, 0x7F, 0x80, 0x07,
  0xF3, 0xFC, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x7F, 0x7F, 0x80, 0x01, 0xFF,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF0, 0x0F, 0xE0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0x00,
  0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFE, 0x07, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x81, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x07,
  0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0x00, 0x7F, 0x81, 0xFC, 0x01, 0xFE,
  0x0F, 0xF0, 0x0F, 0xF8, 0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xF0, 0x78, 0x03, 0xFF, 0x00, 0x60,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x01,
  0xC0, 0x0F, 0xFF, 0x7F, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE,
  0x01, 0xFE, 0x07, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFF, 0x03, 0xFC, 0x01, 0xFF,
  0x03, 0xFC, 0x01, 0xFF, 0x03, 0xFC, 0x01, 0xFF, 0x03, 0xFC, 0x01, 0xFF,
  0x03, 0xFC, 0x01, 0xFF, 0x07, 0xF8, 0x01, 0xFF, 0x07, 0xF8, 0x01, 0xFF,
  0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF8, 0x01, 0xFE,
  0x0F, 0xF0, 0x03, 0xFE, 0x0F, 0xF0, 0x03, 0xFE, 0x0F, 0xF0, 0x03, 0xFC,
  0x0F, 0xF0, 0x07, 0xFC, 0x1F, 0xE0, 0x07, 0xFC, 0x1F, 0xE0, 0x0F, 0xF8,
  0x1F, 0xE0, 0x0F, 0xF8, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xF0,
  0x3F, 0xC0, 0x7F, 0xE0, 0x3F, 0xC0, 0xFF, 0xC0, 0x3F, 0xC3, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x10, 0x07, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x7C,
  0x03, 0xFF, 0x80, 0x18, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0xFC,
  0x7F, 0xC0, 0xFF, 0xF8, 0x7F, 0xC0, 0xFF, 0xF8, 0x7F, 0x80, 0xFF, 0xF8,
  0x7F, 0x80, 0xFF, 0xF8, 0x7F, 0x81, 0xFF, 0xF0, 0x7F, 0x80, 0x0F, 0xF0,
  0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x80, 0x0F, 0xF0, 0xFF, 0x80, 0x0F, 0xF0,
  0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0,
  0x7F, 0xC0, 0x1F, 0xE0, 0x7F, 0xC0, 0x1F, 0xE0, 0x7F, 0xE0, 0x3F, 0xC0,
  0x3F, 0xFD, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x0F, 0xF0, 0x0F, 0xF0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x1F, 0xF0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x07, 0xF8, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x07, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x7F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x03, 0xFE, 0x00,
  0x7F, 0x80, 0xFF, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x3F, 0x81, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x00, 0xFE,
  0x3F, 0xE0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x00,
  0xFF, 0x7F, 0xC0, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x03, 0xFB, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x01,
  0xFE, 0x7F, 0x80, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x07, 0xF0, 0x7F,
  0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x07, 0xF8,
  0x1F, 0xE0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x07,
  0xF8, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xF0,
  0x03, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xF8,
  0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xBF, 0x00, 0xFF, 0xFC, 0x01,
  0xFD, 0xF8, 0x07, 0xEF, 0xE0, 0x0F, 0xEF, 0xC0, 0x7F, 0x7F, 0x00, 0x7F,
  0x7E, 0x03, 0xF7, 0xF8, 0x03, 0xFB, 0xF0, 0x3F, 0xBF, 0x80, 0x3F, 0x9F,
  0x81, 0xF9, 0xFC, 0x01, 0xFC, 0xFC, 0x1F, 0xCF, 0xE0, 0x0F, 0xE7, 0xE0,
  0xFE, 0xFF, 0x00, 0x7F, 0x3F, 0x07, 0xE7, 0xF8, 0x07, 0xF9, 0xF8, 0x7F,
  0x3F, 0x80, 0x3F, 0x8F, 0xC3, 0xF1, 0xFC, 0x01, 0xFC, 0x7E, 0x3F, 0x8F,
  0xE0, 0x0F, 0xE3, 0xF1, 0xF8, 0xFF, 0x00, 0x7F, 0x1F, 0x9F, 0xC7, 0xF0,
  0x07, 0xF8, 0xFC, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xEF, 0xE1, 0xFC, 0x01,
  0xFC, 0x3F, 0x7E, 0x1F, 0xE0, 0x0F, 0xE1, 0xFF, 0xF0, 0xFF, 0x00, 0x7F,
  0x0F, 0xFF, 0x07, 0xF0, 0x07, 0xF8, 0x7F, 0xF8, 0x3F, 0x80, 0x3F, 0x83,
  0xFF, 0x81, 0xFC, 0x01, 0xFC, 0x1F, 0xFC, 0x1F, 0xE0, 0x0F, 0xE0, 0xFF,
  0xE0, 0xFF, 0x00, 0xFF, 0x07, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0xF0,
  0x3F, 0x80, 0x3F, 0x81, 0xFF, 0x01, 0xFC, 0x01, 0xFC, 0x07, 0xF8, 0x1F,
  0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x00, 0xFF, 0x01, 0xFC, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x03, 0xFE, 0x00, 0x1F, 0xC0, 0x3F,
  0xF8, 0x00, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xF0, 0x0F, 0xFE, 0x00, 0x7F,
  0x00, 0x7F, 0xF0, 0x03, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xC0, 0x3F, 0xFE,
  0x01, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0x00,
  0x7F, 0xFC, 0x03, 0xF8, 0x03, 0xFF, 0xF0, 0x1F, 0xC0, 0x3F, 0xBF, 0x81,
  0xFE, 0x01, 0xFD, 0xFC, 0x0F, 0xE0, 0x0F, 0xEF, 0xE0, 0x7F, 0x00, 0x7F,
  0x7F, 0x03, 0xF8, 0x03, 0xF9, 0xFC, 0x3F, 0xC0, 0x3F, 0x8F, 0xE1, 0xFE,
  0x01, 0xFC, 0x7F, 0x0F, 0xE0, 0x0F, 0xE3, 0xF8, 0x7F, 0x00, 0x7F, 0x1F,
  0xE3, 0xF8, 0x07, 0xF8, 0x7F, 0x1F, 0xC0, 0x3F, 0x83, 0xF9, 0xFE, 0x01,
  0xFC, 0x1F, 0xCF, 0xE0, 0x0F, 0xE0, 0xFE, 0x7F, 0x00, 0x7F, 0x07, 0xFB,
  0xF8, 0x07, 0xF8, 0x1F, 0xDF, 0xC0, 0x3F, 0x80, 0xFE, 0xFC, 0x01, 0xFC,
  0x07, 0xFF, 0xE0, 0x0F, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0x00, 0xFF, 0xF8,
  0x07, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0x80, 0x3F, 0xFC, 0x01, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xF8, 0x07,
  0xF0, 0x01, 0xFF, 0xC0, 0x3F, 0x80, 0x0F, 0xFC, 0x01, 0xFC, 0x00, 0x7F,
  0xE0, 0x0F, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x87, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x07,
  0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0x1F,
  0xE0, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0x3F, 0xE0, 0x01, 0xFF, 0x3F,
  0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFE, 0x7F,
  0xC0, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFE, 0x7F,
  0x80, 0x03, 0xFE, 0x7F, 0x80, 0x03, 0xFC, 0xFF, 0x80, 0x07, 0xFC, 0xFF,
  0x80, 0x07, 0xFC, 0xFF, 0x80, 0x07, 0xF8, 0xFF, 0x80, 0x0F, 0xF8, 0xFF,
  0x80, 0x0F, 0xF8, 0x7F, 0x80, 0x1F, 0xF0, 0x7F, 0x80, 0x3F, 0xF0, 0x7F,
  0xC0, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x80, 0x3F, 0xC7, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFE,
  0x03, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF0,
  0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0xC0, 0xFF, 0x00,
  0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xFC, 0x0F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xE0, 0x7F, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0x87, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x07, 0xFC,
  0x01, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x1F, 0xF0,
  0x00, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x3F, 0xE0,
  0x00, 0xFF, 0x3F, 0xE0, 0x01, 0xFF, 0x3F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0,
  0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFE, 0x7F, 0xC0, 0x01, 0xFE, 0x7F, 0x80,
  0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFE, 0x7F, 0x80, 0x03, 0xFE, 0x7F, 0x80,
  0x03, 0xFC, 0xFF, 0x80, 0x07, 0xFC, 0xFF, 0x80, 0x07, 0xFC, 0xFF, 0x80,
  0x07, 0xF8, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0x80,
  0x1F, 0xF0, 0x7F, 0x80, 0x3F, 0xF0, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xE1, 0xFF,
  0x80, 0x7F, 0x81, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xF0,
  0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x03, 0xFE, 0x03, 0xF8,
  0x1F, 0xF0, 0x1F, 0xE0, 0xFF, 0xC0, 0x7F, 0x8F, 0xFE, 0x01, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0x8F, 0xF0, 0x01,
  0xFE, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x7F,
  0x87, 0xF8, 0x01, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0,
  0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xE0, 0x7F, 0x80, 0x7F, 0x81, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xFC,
  0x1F, 0xC0, 0x1F, 0xF0, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xF8, 0xFC,
  0x03, 0xFE, 0x01, 0x80, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x80, 0x03, 0xFE, 0x0E, 0x00, 0x3F, 0xC0, 0xF8, 0x07, 0xFC, 0x0F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xF8, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFE,
  0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFC,
  0x0F, 0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x03, 0xFC,
  0x0F, 0xF0, 0x07, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8,
  0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0,
  0x3F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0,
  0x3F, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0,
  0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xE0,
  0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x81, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xA8, 0x00, 0x00,
  0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xBF, 0xC0, 0x03, 0xFD, 0xFE,
  0x00, 0x3F, 0xCF, 0xF0, 0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xF3, 0xFC, 0x00,
  0xFF, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x00, 0x7F, 0x83, 0xF8, 0x03, 0xFC,
  0x1F, 0xC0, 0x3F, 0xC0, 0xFE, 0x01, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x3F,
  0x80, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x80, 0x7F, 0x03,
  0xFC, 0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0xC1, 0xFE, 0x00, 0xFE, 0x0F, 0xE0,
  0x07, 0xF0, 0xFF, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x7F, 0x80, 0x0F,
  0xE3, 0xF8, 0x00, 0x7F, 0x3F, 0xC0, 0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0xFE, 0xFF, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xFF, 0x80,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xF0,
  0x03, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xEF, 0xF0, 0x07,
  0xF8, 0x01, 0xFE, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xCF, 0xE0, 0x0F, 0xF8,
  0x03, 0xFC, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xF8, 0x07,
  0xF8, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0x8F, 0xE0, 0x1F, 0xF8, 0x0F, 0xF0,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0x0F, 0xE0, 0x3F, 0xF8, 0x0F, 0xE0, 0xFE,
  0x07, 0xFF, 0x81, 0xFE, 0x0F, 0xE0, 0x7F, 0xF8, 0x1F, 0xE0, 0xFE, 0x07,
  0xFF, 0x81, 0xFC, 0x0F, 0xE0, 0xFF, 0xF8, 0x3F, 0xC0, 0xFE, 0x0F, 0xDF,
  0x83, 0xF8, 0x0F, 0xE1, 0xFD, 0xF8, 0x7F, 0x80, 0xFE, 0x1F, 0x9F, 0x87,
  0xF0, 0x0F, 0xE1, 0xF9, 0xF8, 0x7F, 0x00, 0xFE, 0x3F, 0x9F, 0x8F, 0xF0,
  0x0F, 0xE3, 0xF1, 0xF8, 0xFE, 0x00, 0xFE, 0x7F, 0x1F, 0x9F, 0xE0, 0x0F,
  0xE7, 0xE1, 0xF9, 0xFC, 0x00, 0xFE, 0x7E, 0x1F, 0x9F, 0xC0, 0x0F, 0xEF,
  0xE1, 0xFB, 0xFC, 0x00, 0xFE, 0xFC, 0x1F, 0xBF, 0x80, 0x0F, 0xFF, 0xC1,
  0xFB, 0xF8, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x81, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x03, 0xFE,
  0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0xFF, 0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x01,
  0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x01, 0xFE, 0x7F, 0x80,
  0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0xFF, 0x7F,
  0x80, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x03, 0xFE, 0x3F, 0x80, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x83, 0xFC, 0x00,
  0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x1F,
  0xE0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xEF,
  0xE0, 0x07, 0xF9, 0xFC, 0x01, 0xFF, 0x3F, 0xC0, 0x3F, 0xC7, 0xF8, 0x0F,
  0xF0, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F,
  0x83, 0xFC, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x1F, 0xE0, 0x1F, 0xE3, 0xF8,
  0x03, 0xFC, 0xFF, 0x00, 0x3F, 0xBF, 0xC0, 0x07, 0xF7, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8,
  0x3F, 0x81, 0xF8, 0x1F, 0x81, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC,
  0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x3F,
  0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x10, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x0F, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xEF,
  0xC0, 0x01, 0xFD, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xC7, 0xF0, 0x03,
  0xF8, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0xC1, 0xF8, 0x07, 0xF0, 0x3F,
  0x80, 0xFC, 0x03, 0xF0, 0x3F, 0x80, 0x7E, 0x07, 0xE0, 0x0F, 0xC1, 0xFC,
  0x01, 0xFC, 0x7F, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF3, 0xF8, 0x00, 0x7E,
  0xFE, 0x00, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x87, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F,
  0xE0, 0x7E, 0x03, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x1F, 0xF1, 0xFC, 0x0F,
  0xFF, 0x3F, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x87, 0xFF, 0x7F, 0xF0, 0xFF, 0x87, 0xFE, 0x3F, 0xE0, 0x7F, 0x87, 0xF8,
  0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x3F, 0xE0, 0x3F, 0xC7, 0xF8, 0x07, 0xF8,
  0xFF, 0x00, 0xFE, 0x3F, 0xE0, 0x3F, 0xC7, 0xF8, 0x07, 0xF8, 0xFF, 0x00,
  0xFF, 0x1F, 0xE0, 0x1F, 0xC3, 0xFC, 0x03, 0xF8, 0x7F, 0x80, 0xFF, 0x0F,
  0xF0, 0x1F, 0xE1, 0xFE, 0x07, 0xFC, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x3F,
  0xE0, 0xFF, 0x07, 0xFC, 0x1F, 0xF1, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xF7, 0xF0, 0x0F, 0xFC, 0xFE,
  0x00, 0xFE, 0x1F, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x3F, 0xCF, 0xF8, 0x03, 0xFD, 0xFF,
  0xC0, 0x3F, 0xBF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07,
  0xFF, 0x3F, 0xE0, 0x7F, 0xC1, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80,
  0xFF, 0x07, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xE0,
  0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xE1, 0xFE, 0x01, 0xFE, 0x1F, 0xE0,
  0x1F, 0xE1, 0xFC, 0x01, 0xFE, 0x1F, 0xC0, 0x3F, 0xC1, 0xFC, 0x03, 0xFC,
  0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x83, 0xFC,
  0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x07, 0xFE, 0x1F, 0xF0, 0x7F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xEF, 0xFF, 0x80, 0xFE,
  0x7F, 0xF0, 0x0F, 0xC3, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x81, 0xFF, 0xFF, 0x03, 0xFF, 0x3C, 0x0F, 0xF8, 0x08, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x81, 0xFF, 0x07,
  0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x1F, 0xE0, 0x03, 0xFE,
  0x7F, 0x80, 0x1F, 0xFD, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0x9F, 0xFC, 0x07, 0xFC, 0x3F, 0xF0,
  0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F,
  0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x01, 0xFE, 0x01, 0xFC, 0x07, 0xF0,
  0x07, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x03,
  0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x01, 0xFE,
  0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x00,
  0xFF, 0x07, 0xFC, 0x03, 0xFC, 0x3F, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFD, 0xF8, 0x01, 0xFF, 0xF7, 0xE0, 0x03, 0xFF,
  0x1F, 0x80, 0x07, 0xF8, 0xFC, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0xF0, 0x7F, 0x1F, 0xE0, 0x7F, 0x1F, 0xC0,
  0x7F, 0x3F, 0xC0, 0x7F, 0x3F, 0x80, 0xFF, 0x7F, 0x80, 0xFE, 0x7F, 0x83,
  0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x10, 0xFF, 0x00, 0x60, 0xFF, 0xE7, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xE2, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x7F, 0xC7, 0xF0, 0x03, 0xFF, 0x9F, 0xC0, 0x1F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFB, 0xFF,
  0x80, 0xFF, 0x87, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F,
  0xC0, 0x3F, 0x81, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xE0,
  0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xF8,
  0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xE0, 0xFF, 0x80, 0x7F, 0xCF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0x7F, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x7F, 0xEF, 0xF0, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x40,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x02, 0x00, 0x0F, 0xF0, 0x0E, 0x00, 0x7F, 0xC0,
  0x3F, 0xDF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x07,
  0xF9, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xDF, 0xFF, 0x03, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0x0F, 0xF0, 0x7F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x7F, 0x80, 0xFF,
  0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xF0,
  0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xE0,
  0xFE, 0x01, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0xFF, 0x01,
  0xFE, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0xFF, 0x01, 0xFE, 0x1F,
  0xE0, 0x3F, 0xC3, 0xFC, 0x07, 0xF8, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x3F,
  0xC3, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x03,
  0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x07, 0xF8,
  0x03, 0xF8, 0x3F, 0xE0, 0x0F, 0xE0, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x01,
  0xFE, 0x3F, 0xC0, 0x07, 0xF1, 0xFE, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x7F,
  0x3F, 0xC0, 0x03, 0xFD, 0xFE, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x3F, 0xE7, 0xF8, 0x00, 0xFF, 0x1F, 0xE0, 0x03, 0xF8, 0x7F, 0x80, 0x0F,
  0xE0, 0xFE, 0x00, 0x3F, 0x83, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF8,
  0x3F, 0xC0, 0x1F, 0xC0, 0x7F, 0x80, 0x7F, 0x01, 0xFE, 0x01, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x01, 0xF8, 0x7F, 0x01, 0xFC,
  0x01, 0xFC, 0xFF, 0xC1, 0xFF, 0x00, 0xFC, 0xFF, 0xF3, 0xFF, 0xC0, 0x7E,
  0xFF, 0xF9, 0xFF, 0xF0, 0x3F, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFC, 0xFF, 0xF3, 0xFE, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF,
  0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x1F, 0xC1, 0xFE,
  0x07, 0xF8, 0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0xFF, 0x01, 0xFC,
  0x07, 0xF8, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFF, 0x01, 0xFC,
  0x1F, 0xC0, 0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0x3F, 0x80, 0xFF, 0x0F, 0xF0,
  0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xF0,
  0x1F, 0xC3, 0xFC, 0x07, 0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xF8, 0x0F, 0xF0,
  0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x3F, 0x80,
  0xFF, 0x01, 0xFC, 0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0x80,
  0xFF, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x83,
  0xF8, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x07, 0xF0, 0x1F, 0xE1, 0xFE, 0x03,
  0xF8, 0x0F, 0xF0, 0x01, 0xF0, 0x7F, 0x00, 0x3E, 0x1F, 0xF0, 0x0F, 0xC7,
  0xFF, 0x01, 0xF9, 0xFF, 0xF0, 0x3F, 0x7F, 0xFE, 0x07, 0xFF, 0xFF, 0xC1,
  0xFF, 0xEF, 0xF8, 0x3F, 0xF0, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0xFF, 0x03,
  0xFC, 0x1F, 0xE0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x1F,
  0xE0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x01, 0xFE, 0x1F, 0xE0, 0x3F,
  0xC3, 0xFC, 0x07, 0xF8, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC3, 0xFC,
  0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xE1, 0xFC, 0x03, 0xF8,
  0x3F, 0x80, 0x7F, 0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0,
  0x7F, 0x87, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x3F, 0xC0, 0x7F, 0x87,
  0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x7F, 0xF7,
  0xFC, 0x3F, 0xE1, 0xFE, 0x3F, 0xE0, 0x7F, 0x9F, 0xE0, 0x3F, 0xCF, 0xF0,
  0x1F, 0xEF, 0xF0, 0x0F, 0xF7, 0xF8, 0x07, 0xFB, 0xF8, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x00, 0xFE, 0xFF, 0x00, 0x7F, 0x7F, 0x80, 0x7F, 0xBF,
  0x80, 0x3F, 0xDF, 0xC0, 0x1F, 0xEF, 0xE0, 0x1F, 0xE7, 0xF0, 0x0F, 0xF3,
  0xF8, 0x07, 0xF9, 0xFC, 0x07, 0xF8, 0xFF, 0x07, 0xFC, 0x7F, 0xC7, 0xFC,
  0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x0F, 0xE0, 0x00, 0x7E, 0x3F, 0xE0, 0x01, 0xF9, 0xFF, 0xE0, 0x03,
  0xF3, 0xFF, 0xC0, 0x07, 0xEF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F,
  0xF1, 0xFF, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0xFF, 0x01, 0xFC, 0x01, 0xFE,
  0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x01,
  0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF0, 0x07, 0xF8, 0x0F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xE0,
  0x1F, 0xF8, 0x7F, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF8, 0x01, 0xFD, 0xFF, 0xE0, 0x07, 0xF9, 0xFF, 0x80, 0x0F,
  0xF1, 0xFC, 0x00, 0x1F, 0xC0, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x83, 0xF0, 0x07, 0xFE, 0x7F, 0x00, 0xFF, 0xE7, 0xF0, 0x1F, 0xFF, 0x7E,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFC, 0xFF, 0xE0, 0xFF,
  0x87, 0xFE, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x3F,
  0xC3, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0x83, 0xFC, 0x03, 0xF8, 0x3F,
  0x80, 0x3F, 0x87, 0xF8, 0x03, 0xF8, 0x7F, 0x80, 0x7F, 0x87, 0xF8, 0x07,
  0xF0, 0x7F, 0x80, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0xFF, 0x0F,
  0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x83,
  0xFE, 0x07, 0xFC, 0x7F, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xDF, 0xC0, 0x1F, 0xFB, 0xFC, 0x00, 0xFE,
  0x3F, 0x80, 0x01, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x07, 0xF1, 0xFC, 0x0F, 0xE7, 0xF0,
  0x1F, 0xDF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFC, 0x1E, 0x07, 0xF8, 0x0C, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x80, 0x1F, 0xE1, 0xE0,
  0x7F, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x01, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x00, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF,
  0x3F, 0xFF, 0xE0, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x20, 0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x03,
  0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xC0, 0x00, 0x07, 0xF0, 0x1F, 0xE1, 0xFE,
  0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x03, 0xFC,
  0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0xFF, 0x01, 0xFC, 0x1F, 0xC0,
  0x3F, 0x83, 0xF8, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0x83,
  0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x3F, 0xC3, 0xFC, 0x07,
  0xF8, 0x7F, 0x80, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x07, 0xF8, 0x7F,
  0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFF,
  0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x07, 0xFC, 0x1F, 0xE1, 0xFF, 0x83, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xDF, 0x80, 0xFF, 0xF7, 0xF0,
  0x1F, 0xFC, 0xFC, 0x00, 0xFF, 0x1F, 0x80, 0x02, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xDF, 0xE0, 0x1F, 0xE7,
  0xF0, 0x0F, 0xE3, 0xF8, 0x0F, 0xF1, 0xFC, 0x07, 0xF0, 0xFE, 0x07, 0xF8,
  0x7F, 0x03, 0xF8, 0x3F, 0x83, 0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0xE1, 0xFE,
  0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x7F, 0x80, 0xFE, 0x3F,
  0x80, 0x7F, 0x3F, 0xC0, 0x3F, 0x9F, 0xC0, 0x1F, 0xDF, 0xE0, 0x0F, 0xEF,
  0xE0, 0x07, 0xF7, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xF8, 0x0F,
  0xEF, 0xE0, 0x7F, 0xE0, 0x7F, 0xBF, 0x81, 0xFF, 0x81, 0xFC, 0xFE, 0x07,
  0xFE, 0x0F, 0xF3, 0xF8, 0x3F, 0xF0, 0x3F, 0x8F, 0xE0, 0xFF, 0xC0, 0xFE,
  0x3F, 0x87, 0xFF, 0x07, 0xF8, 0xFE, 0x1F, 0xFC, 0x1F, 0xC3, 0xF8, 0x7D,
  0xF0, 0xFF, 0x0F, 0xE3, 0xF7, 0xC3, 0xF8, 0x3F, 0x8F, 0xDF, 0x0F, 0xE0,
  0xFC, 0x7E, 0xFC, 0x7F, 0x03, 0xF1, 0xFB, 0xF1, 0xFC, 0x0F, 0xC7, 0xEF,
  0xCF, 0xF0, 0x3F, 0x3F, 0x3F, 0x3F, 0x80, 0xFC, 0xFC, 0xFC, 0xFE, 0x03,
  0xF3, 0xE3, 0xF7, 0xF0, 0x0F, 0xDF, 0x8F, 0xDF, 0xC0, 0x3F, 0x7E, 0x3F,
  0x7F, 0x00, 0xFD, 0xF0, 0xFF, 0xF8, 0x03, 0xFF, 0xC3, 0xFF, 0xE0, 0x0F,
  0xFF, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0xFF,
  0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x3F,
  0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xFE, 0x03, 0xFE,
  0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x07,
  0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x80, 0x0F, 0xE1, 0xFE, 0x00, 0x1F,
  0xC7, 0xF8, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x7F, 0x7F, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x07, 0xF9, 0xFE, 0x00,
  0x0F, 0xF1, 0xFC, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x01,
  0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F,
  0xC0, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x00,
  0xFE, 0x03, 0xFC, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0xFE, 0x07, 0xF8, 0x00,
  0xFE, 0x07, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x00,
  0x7E, 0x3F, 0xC0, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x7E, 0x7F, 0x80, 0x00,
  0x7E, 0x7F, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00,
  0x7E, 0xFE, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0x80, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x4F, 0xFF, 0x00,
  0x37, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFB, 0x00, 0x3F, 0xFC, 0x80, 0x01, 0xFE, 0x00,
};

const GFXglyph NotoSans_Condensed_BoldItalic58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 17, 42, 15, 0, -41 },
  { 91, 20, 15, 24, 6, -41 },
  { 129, 32, 41, 31, 0, -41 },
  { 293, 28, 47, 27, 0, -44 },
  { 458, 39, 43, 44, 3, -42 },
  { 668, 33, 43, 33, 0, -42 },
  { 846, 10, 15, 14, 6, -41 },
  { 865, 20, 50, 17, 1, -41 },
  { 990, 20, 51, 17, -4, -42 },
  { 1118, 23, 25, 26, 5, -44 },
  { 1190, 25, 27, 29, 3, -34 },
  { 1275, 13, 15, 15, -3, -7 },
  { 1300, 15, 7, 17, 1, -19 },
  { 1314, 10, 10, 15, 0, -9 },
  { 1327, 30, 42, 23, -3, -42 },
  { 1485, 26, 43, 27, 1, -42 },
  { 1625, 20, 41, 27, 5, -41 },
  { 1728, 29, 42, 27, -2, -42 },
  { 1881, 27, 43, 27, 0, -42 },
  { 2027, 28, 42, 27, -1, -42 },
  { 2174, 28, 42, 27, 0, -41 },
  { 2321, 27, 43, 27, 2, -42 },
  { 2467, 28, 41, 27, 2, -41 },
  { 2611, 28, 43, 27, 0, -42 },
  { 2762, 26, 43, 27, 1, -42 },
  { 2902, 15, 33, 15, 0, -32 },
  { 2964, 18, 40, 15, -3, -32 },
  { 3054, 26, 28, 29, 2, -35 },
  { 3145, 26, 17, 29, 2, -29 },
  { 3201, 25, 28, 29, 3, -35 },
  { 3289, 22, 43, 22, 2, -42 },
  { 3408, 39, 47, 41, 2, -42 },
  { 3638, 30, 42, 30, -4, -42 },
  { 3796, 30, 41, 30, 0, -41 },
  { 3950, 30, 43, 28, 2, -42 },
  { 4112, 32, 41, 33, 0, -41 },
  { 4276, 28, 41, 26, 0, -41 },
  { 4420, 28, 41, 25, 0, -41 },
  { 4564, 32, 43, 33, 2, -42 },
  { 4736, 35, 41, 34, 0, -41 },
  { 4916, 25, 41, 20, -2, -41 },
  { 5045, 26, 53, 16, -9, -41 },
  { 5218, 35, 41, 29, 0, -41 },
  { 5398, 21, 41, 25, 0, -41 },
  { 5506, 45, 41, 44, 0, -41 },
  { 5737, 37, 41, 36, 0, -41 },
  { 5927, 32, 43, 35, 2, -42 },
  { 6099, 31, 41, 29, 0, -41 },
  { 6258, 32, 52, 35, 2, -42 },
  { 6466, 30, 41, 30, 0, -41 },
  { 6620, 28, 43, 26, 0, -42 },
  { 6771, 25, 41, 25, 5, -41 },
  { 6900, 32, 42, 33, 3, -41 },
  { 7068, 29, 41, 29, 5, -41 },
  { 7217, 44, 41, 44, 5, -41 },
  { 7443, 36, 41, 28, -3, -41 },
  { 7628, 27, 41, 27, 5, -41 },
  { 7767, 31, 41, 25, -2, -41 },
  { 7926, 23, 51, 17, -2, -42 },
  { 8073, 12, 42, 23, 6, -42 },
  { 8136, 23, 51, 17, -4, -42 },
  { 8283, 27, 25, 27, 0, -41 },
  { 8368, 20, 4, 20, -5, 5 },
  { 8378, 12, 9, 18, 8, -44 },
  { 8392, 27, 33, 29, 2, -32 },
  { 8504, 28, 45, 29, 0, -44 },
  { 8662, 23, 33, 23, 2, -32 },
  { 8757, 30, 45, 29, 2, -44 },
  { 8926, 24, 33, 27, 2, -32 },
  { 9025, 31, 58, 18, -7, -44 },
  { 9250, 30, 46, 29, -1, -32 },
  { 9423, 27, 44, 29, 0, -44 },
  { 9572, 17, 44, 15, 0, -44 },
  { 9666, 24, 58, 15, -7, -44 },
  { 9840, 30, 44, 27, 0, -44 },
  { 10005, 17, 44, 14, 0, -44 },
  { 10099, 41, 32, 43, 0, -32 },
  { 10263, 27, 32, 29, 0, -32 },
  { 10371, 25, 33, 28, 2, -32 },
  { 10475, 31, 46, 29, -3, -32 },
  { 10654, 28, 46, 29, 1, -32 },
  { 10815, 23, 32, 20, 0, -32 },
  { 10907, 23, 33, 23, 0, -32 },
  { 11002, 19, 39, 19, 2, -38 },
  { 11095, 27, 33, 29, 2, -32 },
  { 11207, 25, 32, 25, 3, -32 },
  { 11307, 38, 32, 39, 4, -32 },
  { 11459, 31, 32, 26, -3, -32 },
  { 11583, 32, 46, 25, -4, -32 },
  { 11767, 25, 32, 22, -2, -32 },
  { 11867, 24, 50, 20, 0, -41 },
  { 12017, 6, 57, 25, 9, -44 },
  { 12060, 22, 50, 20, -3, -41 },
  { 12198, 26, 9, 29, 2, -25 },
};

const GFXfont NotoSans_Condensed_BoldItalic58pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BoldItalic58pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BoldItalic58pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _NOTOSANS_CONDENSED_BOLDITALIC58PT7B_H_
