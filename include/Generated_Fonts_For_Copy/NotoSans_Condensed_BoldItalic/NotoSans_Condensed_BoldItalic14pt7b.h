#ifndef _NOTOSANS_CONDENSED_BOLDITALIC14PT7B_H_
#define _NOTOSANS_CONDENSED_BOLDITALIC14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BoldItalic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BoldItalic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x36, 0x66, 0x60, 0xCC, 0x7A, 0xD7, 0xA0, 0x1A, 0x12, 0x16,
  0x7F, 0x24, 0x2C, 0xFE, 0x68, 0x58, 0xD0, 0x08, 0x18, 0xFB, 0x67, 0x07,
  0x07, 0x0E, 0x9D, 0xF0, 0x81, 0x00, 0x73, 0x69, 0x25, 0x96, 0x8A, 0xBF,
  0xF4, 0x52, 0x6B, 0x25, 0x23, 0x80, 0x1C, 0x36, 0x34, 0x3C, 0x38, 0x7B,
  0xDE, 0xCE, 0xDC, 0x76, 0x69, 0x60, 0x19, 0x8C, 0xC6, 0x23, 0x18, 0xC6,
  0x30, 0xC0, 0x10, 0xC6, 0x31, 0x8C, 0x46, 0x31, 0x19, 0x80, 0x12, 0x4F,
  0xCF, 0xF1, 0x60, 0x20, 0x8F, 0xFF, 0x20, 0x80, 0x6D, 0xE0, 0x7F, 0xF0,
  0x03, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x20, 0x60, 0xC0, 0x1C, 0x79,
  0x9B, 0x26, 0xD9, 0xB3, 0x66, 0xF8, 0xE0, 0x19, 0xFE, 0xA3, 0x18, 0xC6,
  0x23, 0x00, 0x3C, 0xF9, 0x18, 0x60, 0xC3, 0x0C, 0x30, 0xF9, 0xF0, 0x3C,
  0x7C, 0x18, 0x63, 0x87, 0x03, 0x06, 0xF9, 0xE0, 0x0E, 0x18, 0x71, 0xE2,
  0xC9, 0x3F, 0x7E, 0x18, 0x30, 0x3E, 0x78, 0x83, 0x07, 0x89, 0x83, 0x06,
  0xF9, 0xE0, 0x1E, 0x74, 0xC3, 0x47, 0xCD, 0xB3, 0x66, 0x78, 0xF0, 0x3E,
  0xFC, 0x30, 0x61, 0x83, 0x0C, 0x18, 0x61, 0xC0, 0x3C, 0x6D, 0x99, 0x63,
  0x8F, 0x33, 0x66, 0xDC, 0xF0, 0x3D, 0xF6, 0x5B, 0x6D, 0xF0, 0xC6, 0xBB,
  0xC0, 0x27, 0x20, 0x00, 0xCC, 0x11, 0xC4, 0x00, 0x01, 0x8C, 0x46, 0x00,
  0x0C, 0xEE, 0x38, 0x38, 0x30, 0xFC, 0x00, 0x3F, 0xC3, 0xC3, 0xCF, 0xF3,
  0x00, 0xF6, 0xC6, 0x66, 0x23, 0x00, 0xC6, 0x00, 0x0F, 0x04, 0x22, 0x0D,
  0xBD, 0x5A, 0x54, 0xBD, 0x6B, 0x7E, 0x40, 0x18, 0x83, 0xE0, 0x0E, 0x1C,
  0x38, 0xF1, 0x66, 0xCF, 0xBF, 0x67, 0x8C, 0x3E, 0x7C, 0xDB, 0x37, 0xCF,
  0x99, 0xA6, 0xFD, 0xF0, 0x3E, 0xF9, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xF8,
  0xF0, 0x3C, 0x3E, 0x33, 0x63, 0x63, 0x66, 0x66, 0x6E, 0xFC, 0xF8, 0x3E,
  0x78, 0xC3, 0x07, 0xCF, 0x18, 0x30, 0xF9, 0xF0, 0x3E, 0x78, 0xC3, 0x07,
  0xCF, 0x18, 0x30, 0xC1, 0x80, 0x3E, 0xFD, 0x86, 0x0D, 0xFB, 0xB3, 0x66,
  0xFC, 0xF8, 0x33, 0x99, 0x8C, 0xCC, 0x67, 0xF3, 0xF1, 0x98, 0xCC, 0xC6,
  0x66, 0x00, 0x3E, 0x30, 0x60, 0xC1, 0x82, 0x0C, 0x18, 0x31, 0xF0, 0x0C,
  0x30, 0xC2, 0x18, 0x61, 0x86, 0x30, 0xC3, 0x3C, 0xE0, 0x33, 0x36, 0x36,
  0x6C, 0x78, 0x78, 0x78, 0x4C, 0xCC, 0xCC, 0x31, 0x8C, 0xC6, 0x31, 0x8C,
  0xFF, 0xC0, 0x38, 0xE7, 0x1C, 0xE7, 0x3C, 0xE7, 0xBC, 0xF5, 0x9F, 0xA2,
  0xEC, 0xDD, 0x99, 0x30, 0x31, 0x9C, 0xCE, 0x4F, 0x26, 0xB3, 0x79, 0xBC,
  0x9C, 0xCE, 0x63, 0x00, 0x3C, 0xFD, 0x9E, 0x3C, 0x78, 0xF1, 0xE6, 0xFC,
  0xF0, 0x3E, 0x7C, 0xDB, 0x36, 0x6F, 0x98, 0x30, 0xC1, 0x80, 0x3C, 0xFD,
  0x9E, 0x3C, 0x78, 0xF1, 0xE6, 0xFC, 0xF0, 0x60, 0xC0, 0x3C, 0x7C, 0xDB,
  0x36, 0xEF, 0x9E, 0x26, 0xCD, 0x98, 0x3E, 0x79, 0x83, 0x03, 0x03, 0x07,
  0x04, 0xF9, 0xE0, 0xFF, 0xF3, 0x0C, 0x61, 0x86, 0x18, 0x43, 0x00, 0x66,
  0xCD, 0x9E, 0x3C, 0xD9, 0xB3, 0x66, 0xF9, 0xE0, 0xC7, 0x8F, 0x36, 0x6D,
  0x9B, 0x34, 0x38, 0x60, 0xC0, 0xC4, 0x79, 0x9B, 0x33, 0x6E, 0x4D, 0x59,
  0xEB, 0x3D, 0xC7, 0x38, 0xE6, 0x18, 0xC0, 0x39, 0x8D, 0x87, 0x83, 0xC1,
  0xC0, 0xE0, 0xF0, 0x68, 0x66, 0x73, 0x00, 0xC6, 0x99, 0x63, 0xC7, 0x0E,
  0x18, 0x30, 0x61, 0x80, 0x1F, 0x3F, 0x06, 0x0C, 0x1C, 0x18, 0x30, 0x30,
  0x7C, 0xFC, 0x39, 0x08, 0xC6, 0x31, 0x08, 0xC6, 0x31, 0xC0, 0xC9, 0x36,
  0xDB, 0x24, 0x3C, 0x21, 0x86, 0x18, 0x41, 0x0C, 0x30, 0xC2, 0x38, 0x08,
  0x63, 0xCB, 0x67, 0x10, 0xF8, 0xC9, 0x80, 0x16, 0x7D, 0x9B, 0x2C, 0xD9,
  0xBF, 0x36, 0x30, 0x60, 0xC1, 0x67, 0xEC, 0xD9, 0xB2, 0x4D, 0xFB, 0xE0,
  0x1C, 0xF6, 0x18, 0xC3, 0x0E, 0x9E, 0x03, 0x02, 0x06, 0x16, 0x3E, 0x66,
  0x64, 0xCC, 0xCC, 0xFC, 0x78, 0x18, 0xF6, 0x57, 0xF3, 0x06, 0x9E, 0x07,
  0x0F, 0x0C, 0x0E, 0x1E, 0x18, 0x18, 0x18, 0x18, 0x10, 0x30, 0x30, 0x30,
  0xE0, 0x1E, 0x7D, 0x9B, 0x2C, 0xD9, 0xBF, 0x36, 0x19, 0x33, 0xC0, 0x30,
  0x60, 0xC1, 0x67, 0xEC, 0xD9, 0x36, 0x4D, 0x9B, 0x30, 0x13, 0x03, 0x66,
  0x66, 0x4C, 0xC0, 0x04, 0x30, 0x03, 0x18, 0x61, 0x86, 0x10, 0xC3, 0x0C,
  0x33, 0x80, 0x30, 0x60, 0xC1, 0x36, 0xCD, 0x1E, 0x3C, 0x59, 0xB3, 0x30,
  0x33, 0x32, 0x66, 0x66, 0x4C, 0xC0, 0x2D, 0x9F, 0xF6, 0x6D, 0xB3, 0x6C,
  0xD3, 0x2C, 0xDB, 0x26, 0x2C, 0xFD, 0x9B, 0x26, 0xC9, 0xB3, 0x66, 0x18,
  0xF6, 0x59, 0xCF, 0x37, 0xDE, 0x16, 0x3F, 0x33, 0x33, 0x32, 0x26, 0x7E,
  0x7C, 0x60, 0x60, 0xC0, 0x1E, 0x7D, 0x9B, 0x2C, 0xD9, 0xBF, 0x34, 0x18,
  0x30, 0x60, 0x2D, 0xE7, 0x18, 0x61, 0x0C, 0x30, 0x3D, 0xE6, 0x1C, 0x38,
  0x6B, 0xBC, 0x67, 0xFC, 0xCC, 0x8E, 0xE0, 0x26, 0xCD, 0x9B, 0x66, 0xC9,
  0xBF, 0x34, 0xCF, 0x6D, 0xB4, 0xF3, 0x8E, 0x30, 0xD9, 0xEC, 0xF6, 0xDF,
  0x6A, 0xA7, 0x73, 0x31, 0x98, 0x33, 0x36, 0x14, 0x1C, 0x18, 0x3C, 0x6C,
  0xEC, 0x33, 0x36, 0x36, 0x34, 0x3C, 0x38, 0x38, 0x30, 0x30, 0x20, 0xE0,
  0x7D, 0xE1, 0x8C, 0x61, 0x8C, 0x3C, 0x1C, 0x63, 0x0C, 0x33, 0x8E, 0x18,
  0x61, 0x86, 0x18, 0xFF, 0xFF, 0xFF, 0xF0, 0x38, 0xE1, 0x86, 0x18, 0x71,
  0x8C, 0x30, 0x86, 0x38, 0xE6, 0xF0,
};

const GFXglyph NotoSans_Condensed_BoldItalic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 10, 4, 0, -10 },
  { 6, 5, 4, 6, 1, -10 },
  { 9, 8, 10, 7, 0, -10 },
  { 19, 7, 12, 6, 0, -11 },
  { 30, 9, 10, 11, 1, -10 },
  { 42, 8, 10, 8, 0, -10 },
  { 52, 3, 4, 3, 1, -10 },
  { 54, 5, 12, 4, 0, -10 },
  { 62, 5, 12, 4, -1, -10 },
  { 70, 6, 6, 6, 1, -11 },
  { 75, 6, 6, 7, 1, -8 },
  { 80, 3, 4, 4, -1, -2 },
  { 82, 4, 2, 4, 0, -5 },
  { 83, 2, 2, 4, 0, -2 },
  { 84, 8, 10, 5, -1, -10 },
  { 94, 7, 10, 6, 0, -10 },
  { 103, 5, 10, 7, 1, -10 },
  { 110, 7, 10, 6, 0, -10 },
  { 119, 7, 10, 6, 0, -10 },
  { 128, 7, 10, 7, 0, -10 },
  { 137, 7, 10, 6, 0, -10 },
  { 146, 7, 10, 6, 0, -10 },
  { 155, 7, 10, 6, 0, -10 },
  { 164, 7, 10, 6, 0, -10 },
  { 173, 6, 10, 6, 0, -10 },
  { 181, 4, 8, 4, 0, -8 },
  { 185, 5, 10, 4, -1, -8 },
  { 192, 6, 6, 7, 1, -8 },
  { 197, 6, 4, 7, 1, -7 },
  { 200, 6, 6, 7, 1, -8 },
  { 205, 5, 10, 5, 1, -10 },
  { 212, 10, 11, 10, 0, -10 },
  { 226, 7, 10, 7, -1, -10 },
  { 235, 7, 10, 7, 0, -10 },
  { 244, 7, 10, 7, 1, -10 },
  { 253, 8, 10, 8, 0, -10 },
  { 263, 7, 10, 6, 0, -10 },
  { 272, 7, 10, 6, 0, -10 },
  { 281, 7, 10, 8, 1, -10 },
  { 290, 9, 10, 8, 0, -10 },
  { 302, 7, 10, 5, -1, -10 },
  { 311, 6, 13, 4, -2, -10 },
  { 321, 8, 10, 7, 0, -10 },
  { 331, 5, 10, 6, 0, -10 },
  { 338, 11, 10, 11, 0, -10 },
  { 352, 9, 10, 9, 0, -10 },
  { 364, 7, 10, 8, 1, -10 },
  { 373, 7, 10, 7, 0, -10 },
  { 382, 7, 12, 8, 1, -10 },
  { 393, 7, 10, 7, 0, -10 },
  { 402, 7, 10, 6, 0, -10 },
  { 411, 6, 10, 6, 1, -10 },
  { 419, 7, 10, 8, 1, -10 },
  { 428, 7, 10, 7, 1, -10 },
  { 437, 11, 10, 11, 1, -10 },
  { 451, 9, 10, 7, -1, -10 },
  { 463, 7, 10, 7, 1, -10 },
  { 472, 8, 10, 6, -1, -10 },
  { 482, 5, 12, 4, 0, -10 },
  { 490, 3, 10, 5, 1, -10 },
  { 494, 6, 12, 4, -1, -10 },
  { 503, 6, 6, 7, 0, -10 },
  { 508, 5, 1, 5, -1, 1 },
  { 509, 3, 3, 4, 2, -11 },
  { 511, 7, 8, 7, 0, -8 },
  { 518, 7, 11, 7, 0, -11 },
  { 528, 6, 8, 6, 0, -8 },
  { 534, 8, 11, 7, 0, -11 },
  { 545, 6, 8, 6, 0, -8 },
  { 551, 8, 14, 4, -2, -11 },
  { 565, 7, 11, 7, 0, -8 },
  { 575, 7, 11, 7, 0, -11 },
  { 585, 4, 11, 4, 0, -11 },
  { 591, 6, 14, 4, -2, -11 },
  { 602, 7, 11, 7, 0, -11 },
  { 612, 4, 11, 3, 0, -11 },
  { 618, 10, 8, 10, 0, -8 },
  { 628, 7, 8, 7, 0, -8 },
  { 635, 6, 8, 7, 0, -8 },
  { 641, 8, 11, 7, -1, -8 },
  { 652, 7, 11, 7, 0, -8 },
  { 662, 6, 8, 5, 0, -8 },
  { 668, 6, 8, 6, 0, -8 },
  { 674, 4, 9, 5, 1, -9 },
  { 679, 7, 8, 7, 0, -8 },
  { 686, 6, 8, 6, 1, -8 },
  { 692, 9, 8, 9, 1, -8 },
  { 701, 8, 8, 6, -1, -8 },
  { 709, 8, 11, 6, -1, -8 },
  { 720, 6, 8, 5, 0, -8 },
  { 726, 6, 12, 5, 0, -10 },
  { 735, 2, 14, 6, 2, -11 },
  { 739, 6, 12, 5, -1, -10 },
  { 748, 6, 2, 7, 1, -6 },
};

const GFXfont NotoSans_Condensed_BoldItalic14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BoldItalic14pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BoldItalic14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_CONDENSED_BOLDITALIC14PT7B_H_
