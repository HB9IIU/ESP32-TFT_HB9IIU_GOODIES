#ifndef _NOTOSANS_CONDENSED_BOLDITALIC25PT7B_H_
#define _NOTOSANS_CONDENSED_BOLDITALIC25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BoldItalic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BoldItalic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x3C, 0x78, 0xF1, 0xC3, 0x8F, 0x1E, 0x38, 0x70, 0xE1, 0xC4,
  0x00, 0x18, 0x78, 0xF1, 0xE0, 0x7B, 0xB9, 0xDC, 0xEE, 0xE6, 0x73, 0x3B,
  0x9C, 0x03, 0x98, 0x0C, 0xE0, 0x33, 0x01, 0xCC, 0x06, 0x70, 0xFF, 0xF3,
  0xFF, 0xC3, 0x38, 0x0C, 0xE0, 0x73, 0x01, 0xDC, 0x3F, 0xFC, 0xFF, 0xF0,
  0xE6, 0x03, 0x38, 0x0C, 0xC0, 0x73, 0x01, 0x9C, 0x00, 0x00, 0x80, 0x08,
  0x07, 0xE0, 0xFF, 0x1F, 0xE3, 0xD2, 0x39, 0x03, 0xF0, 0x1F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7C, 0x05, 0xE0, 0x5E, 0x45, 0xCF, 0xFC, 0xFF, 0x87, 0xF0,
  0x08, 0x00, 0x80, 0x1E, 0x06, 0x1F, 0x86, 0x0D, 0xC7, 0x0E, 0xE3, 0x06,
  0x73, 0x83, 0x39, 0x83, 0x99, 0x81, 0xCD, 0xDE, 0xEE, 0xDF, 0xBE, 0xEF,
  0xDE, 0xEE, 0xE0, 0x66, 0x70, 0x73, 0x38, 0x33, 0x9C, 0x39, 0xCC, 0x38,
  0xEE, 0x18, 0x3E, 0x1C, 0x1E, 0x00, 0x03, 0xC0, 0x1F, 0x80, 0xFF, 0x03,
  0x9C, 0x1E, 0x70, 0x3B, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0x00, 0xFC, 0x77,
  0xFB, 0x9C, 0xEE, 0xF3, 0xF3, 0xC7, 0xCF, 0x1E, 0x3F, 0xFC, 0x7F, 0xF0,
  0xF9, 0xE0, 0x7B, 0x9C, 0xE7, 0x33, 0x80, 0x07, 0x0E, 0x1C, 0x1C, 0x38,
  0x38, 0x70, 0x70, 0x70, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0x70, 0x07, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x38, 0x1C, 0x1E,
  0x0E, 0x0E, 0x07, 0x07, 0x07, 0x00, 0x0E, 0x03, 0x84, 0xE3, 0xF9, 0xFF,
  0xC7, 0xF3, 0xE1, 0xF8, 0xF7, 0x08, 0xE0, 0x20, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0x3B, 0xDC, 0xEE, 0x70, 0x7E, 0xFF, 0xF0, 0x6F, 0xFF, 0x00, 0x78,
  0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07,
  0x00, 0x78, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00,
  0x70, 0x07, 0x00, 0x00, 0x07, 0x83, 0xF8, 0xFF, 0x1C, 0xF7, 0x9E, 0xE3,
  0xDC, 0x7F, 0x8E, 0xE1, 0xDC, 0x3B, 0x8F, 0x71, 0xEE, 0x39, 0xCF, 0x39,
  0xC7, 0xF8, 0xFE, 0x0F, 0x80, 0x03, 0x87, 0xC7, 0xC7, 0xEF, 0xF3, 0xB9,
  0x3C, 0x1C, 0x0E, 0x07, 0x07, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x78, 0x38,
  0x1C, 0x00, 0x03, 0xE0, 0x7F, 0x87, 0xFC, 0x18, 0xF0, 0x87, 0x80, 0x38,
  0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0F, 0xFC, 0xFF, 0xC7, 0xFE, 0x00, 0x0F, 0xC1, 0xFE, 0x1F,
  0xF0, 0x8F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x7C, 0x0F, 0x01, 0xF8, 0x03,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x83, 0xCF, 0xF8, 0xFF, 0x8F, 0xE0, 0x00,
  0xF0, 0x0F, 0x01, 0xE0, 0x3E, 0x07, 0xE0, 0x6E, 0x0D, 0xC1, 0xDC, 0x19,
  0xC3, 0x1C, 0x73, 0xCE, 0x38, 0xFF, 0xEF, 0xFE, 0x03, 0x80, 0x78, 0x07,
  0x00, 0x70, 0x0F, 0xF0, 0xFF, 0x1F, 0xE1, 0xC0, 0x1C, 0x01, 0xC0, 0x38,
  0x03, 0xF8, 0x3F, 0xC3, 0xFC, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x83,
  0xCF, 0xF8, 0xFF, 0x0F, 0xE0, 0x03, 0xE1, 0xFC, 0x7F, 0x8E, 0x03, 0x80,
  0xF0, 0x1C, 0x83, 0xFC, 0xFF, 0xDF, 0x7B, 0xC7, 0x71, 0xEE, 0x3D, 0xC7,
  0x39, 0xE7, 0xFC, 0x7F, 0x0F, 0xC0, 0x3F, 0xF3, 0xFF, 0x7F, 0xE0, 0x0E,
  0x01, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xE0,
  0x1C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x00, 0x07, 0xC0, 0xFE,
  0x1F, 0xF1, 0xC7, 0x3C, 0x73, 0xCF, 0x1D, 0xE1, 0xFC, 0x0F, 0x81, 0xF8,
  0x7B, 0xC7, 0x1C, 0xF1, 0xEF, 0x1E, 0xF1, 0xCF, 0xFC, 0x7F, 0x83, 0xF0,
  0x07, 0xC0, 0xFE, 0x1F, 0xE3, 0xCE, 0x38, 0xF3, 0x8F, 0x78, 0xF7, 0x8E,
  0x79, 0xE3, 0xFE, 0x3F, 0xE1, 0xDC, 0x01, 0xC0, 0x3C, 0x07, 0x8F, 0xF0,
  0xFE, 0x0F, 0xC0, 0x1C, 0xF3, 0xCF, 0x00, 0x00, 0x00, 0x00, 0x07, 0x3C,
  0xF3, 0x80, 0x0E, 0x1C, 0x78, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xC7, 0x8E, 0x1C, 0x70, 0xE0, 0x00, 0x20, 0x1C, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0x80, 0x30, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0xF8, 0x7E, 0x3F, 0x1F, 0x83, 0xC0,
  0x40, 0x00, 0x1F, 0x3F, 0xDF, 0xE4, 0x70, 0x38, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x0E, 0x0E, 0x00, 0x00, 0x01, 0x81, 0xE0, 0xF0, 0x70, 0x00, 0x01,
  0xF8, 0x03, 0xFF, 0x03, 0xC3, 0xC3, 0x80, 0xE3, 0x80, 0x31, 0x8F, 0xDD,
  0xCF, 0xCE, 0xCE, 0x67, 0xE6, 0x33, 0x67, 0x39, 0xB3, 0x18, 0xD9, 0x8C,
  0xEC, 0xCE, 0x66, 0x7F, 0xE3, 0x1C, 0xF1, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x10, 0x0F, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x81, 0xDC, 0x0E, 0xE0, 0xE7, 0x07, 0x38, 0x79, 0xC3, 0x8E,
  0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0xF0, 0xE7, 0x07, 0x78, 0x3F, 0x81, 0xC0,
  0x0F, 0xC0, 0x7F, 0x87, 0xFE, 0x3C, 0xF1, 0xC3, 0x8E, 0x3C, 0x71, 0xC7,
  0xFE, 0x3F, 0xC1, 0xFF, 0x0E, 0x38, 0x71, 0xE7, 0x8F, 0x38, 0x79, 0xC7,
  0x8F, 0xFC, 0xFF, 0xC7, 0xF8, 0x00, 0x03, 0xF0, 0x7F, 0xC7, 0xFC, 0x7C,
  0x43, 0xC0, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC1, 0x0F, 0xF0, 0x7F, 0x81, 0xFC, 0x00,
  0x0F, 0xC0, 0x3F, 0xC1, 0xFF, 0x87, 0x9E, 0x1C, 0x3C, 0x70, 0xF1, 0xC3,
  0xCF, 0x0F, 0x3C, 0x3C, 0xE0, 0xE3, 0x87, 0x8E, 0x1E, 0x78, 0x71, 0xE3,
  0xC7, 0x1E, 0x1F, 0xF0, 0xFF, 0x83, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x1F,
  0xF1, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xFC, 0x3F, 0xC3, 0xFC, 0x38,
  0x03, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0xF8, 0xFF, 0x8F, 0xF0, 0x0F,
  0xF0, 0xFF, 0x1F, 0xF1, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3F,
  0xC3, 0xFC, 0x3F, 0xC3, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0xF0,
  0x0F, 0x00, 0x03, 0xF8, 0x3F, 0xF1, 0xFF, 0x87, 0x86, 0x3C, 0x01, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0xF1, 0xFB, 0xC7, 0xCF, 0x3F, 0x3C, 0x3C, 0xF0,
  0xF3, 0xC3, 0x8F, 0x0E, 0x1F, 0xF8, 0x7F, 0xE0, 0x7F, 0x00, 0x0E, 0x0E,
  0x1C, 0x3C, 0x78, 0x78, 0xF0, 0xE1, 0xC1, 0xC3, 0x83, 0x87, 0x0F, 0x1F,
  0xFE, 0x3F, 0xF8, 0x7F, 0xF0, 0xE0, 0xE1, 0xC3, 0xC7, 0x87, 0x8F, 0x0E,
  0x1C, 0x1C, 0x38, 0x78, 0xF0, 0xF1, 0xE1, 0xE0, 0x0F, 0xE3, 0xFC, 0x1E,
  0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x0F,
  0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0xFF, 0x1F, 0xC0, 0x00, 0xF0, 0x0E,
  0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0,
  0x0F, 0x00, 0xE0, 0xFE, 0x0F, 0xC0, 0xF8, 0x00, 0x0E, 0x1E, 0x1C, 0x78,
  0x78, 0xE0, 0xF3, 0xC1, 0xCF, 0x03, 0xBC, 0x07, 0x70, 0x1F, 0xE0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xDE, 0x07, 0xBC, 0x0E, 0x38, 0x1C, 0x70,
  0x38, 0xF0, 0xF1, 0xE1, 0xE1, 0xC0, 0x0E, 0x07, 0x07, 0x83, 0xC1, 0xC0,
  0xE0, 0x70, 0x78, 0x3C, 0x1C, 0x0E, 0x07, 0x07, 0x83, 0xC1, 0xC0, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0x01, 0xE1, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x83,
  0xF1, 0xF8, 0x7C, 0x3F, 0x1F, 0x87, 0xE3, 0xF1, 0xDC, 0xEE, 0x3B, 0x9F,
  0xC7, 0x77, 0x70, 0xEE, 0xEE, 0x1D, 0xD9, 0xC7, 0x3F, 0x38, 0xE7, 0xCF,
  0x1C, 0xF9, 0xC3, 0x9E, 0x38, 0xF3, 0xC7, 0x1C, 0x71, 0xE0, 0x0F, 0x07,
  0x0F, 0x07, 0x1F, 0x0F, 0x1F, 0x0E, 0x1F, 0x8E, 0x1F, 0x8E, 0x1F, 0x8E,
  0x3B, 0x9E, 0x3B, 0xDC, 0x39, 0xDC, 0x39, 0xDC, 0x39, 0xDC, 0x71, 0xD8,
  0x70, 0xF8, 0x70, 0xF8, 0x70, 0xF8, 0xF0, 0xF8, 0xE0, 0xF0, 0x03, 0xE0,
  0x3F, 0xC1, 0xFF, 0x8F, 0x9E, 0x3C, 0x3D, 0xE0, 0xF7, 0x83, 0xDC, 0x0F,
  0xF0, 0x3B, 0xC0, 0xEF, 0x07, 0xBC, 0x1E, 0xF0, 0x73, 0xC3, 0xCF, 0x1E,
  0x1F, 0xF8, 0x7F, 0xC0, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x87, 0xFE, 0x3C,
  0xF1, 0xC3, 0x8E, 0x1C, 0x70, 0xE7, 0x8F, 0x3D, 0xF1, 0xFF, 0x8F, 0xF0,
  0x7E, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x00,
  0x03, 0xE0, 0x3F, 0xC1, 0xFF, 0x8F, 0x9E, 0x3C, 0x3D, 0xE0, 0xF7, 0x83,
  0xDC, 0x0F, 0xF0, 0x3B, 0xC0, 0xEF, 0x07, 0xBC, 0x1E, 0xF0, 0x73, 0xC3,
  0xCF, 0x1E, 0x1F, 0xF8, 0x7F, 0xC0, 0xFC, 0x00, 0x78, 0x01, 0xE0, 0x03,
  0xC0, 0x0F, 0x00, 0x0F, 0xC0, 0x7F, 0x87, 0xFC, 0x3C, 0xF1, 0xC7, 0x8E,
  0x3C, 0x71, 0xC7, 0x9E, 0x3F, 0xF1, 0xFF, 0x0F, 0xE0, 0x77, 0x07, 0xBC,
  0x38, 0xE1, 0xC7, 0x0E, 0x3C, 0xF1, 0xE7, 0x87, 0x00, 0x07, 0xE0, 0xFF,
  0x1F, 0xE3, 0xE2, 0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x83, 0xCF, 0xF8, 0xFF, 0x0F, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x3C,
  0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x1E,
  0x00, 0x1C, 0x3C, 0x70, 0xF3, 0xC3, 0x8F, 0x0E, 0x38, 0x38, 0xE1, 0xE7,
  0x87, 0x9E, 0x1C, 0x78, 0x71, 0xC3, 0xC7, 0x0F, 0x3C, 0x3C, 0xF0, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3F, 0xF0, 0x7F, 0x80, 0xFC, 0x00, 0xF0, 0x7F, 0x83,
  0xBC, 0x3D, 0xE1, 0xCF, 0x1E, 0x78, 0xE3, 0xCF, 0x0E, 0x70, 0x73, 0x83,
  0xBC, 0x1D, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x78,
  0x03, 0xC0, 0x00, 0xE0, 0xE0, 0xFC, 0x1C, 0x3F, 0x87, 0x87, 0x70, 0xF0,
  0xEE, 0x3E, 0x39, 0xC7, 0xC7, 0x38, 0xF9, 0xE7, 0x3F, 0x38, 0xE7, 0xE7,
  0x1D, 0xDD, 0xC3, 0xBB, 0xB8, 0x76, 0x7F, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8,
  0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF0, 0xF8, 0x1E, 0x1E, 0x00, 0x0E, 0x1E,
  0x1C, 0x38, 0x3C, 0xF0, 0x7B, 0xC0, 0x77, 0x00, 0xFE, 0x01, 0xF8, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x07, 0xBC,
  0x0E, 0x78, 0x3C, 0x70, 0x70, 0xE1, 0xC1, 0xE0, 0xF0, 0xFF, 0x0E, 0x71,
  0xE7, 0x3C, 0x73, 0x87, 0x78, 0x77, 0x07, 0xF0, 0x3E, 0x03, 0xC0, 0x3C,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0x0F,
  0xF8, 0x7F, 0xC7, 0xFE, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x78,
  0x07, 0x80, 0x38, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x0F,
  0xF8, 0xFF, 0xC7, 0xFE, 0x00, 0x07, 0xC1, 0xF0, 0xFC, 0x38, 0x0E, 0x03,
  0x81, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x70, 0x1C, 0x07, 0x01, 0xF0, 0xFC, 0x3F, 0x00, 0xE7, 0x39, 0xCE,
  0x73, 0x8C, 0x73, 0x9C, 0xE7, 0x38, 0xC7, 0x39, 0xC0, 0x07, 0xC1, 0xF0,
  0xFC, 0x07, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C,
  0x07, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xC1, 0xF0, 0x7C, 0x3F,
  0x00, 0x01, 0x80, 0x38, 0x07, 0x80, 0x7C, 0x0F, 0xC0, 0xDC, 0x1C, 0xC3,
  0x8E, 0x38, 0xE7, 0x0E, 0xE0, 0x70, 0xFF, 0xFF, 0x80, 0xEF, 0x73, 0x0E,
  0x73, 0xFE, 0x3F, 0xE7, 0x9E, 0x71, 0xEF, 0x1C, 0xF1, 0xCE, 0x1C, 0xE3,
  0xCE, 0x3C, 0xE3, 0x8F, 0xF8, 0xFF, 0x87, 0xB8, 0x0E, 0x00, 0xE0, 0x1E,
  0x01, 0xE0, 0x1C, 0x01, 0xDC, 0x1F, 0xE3, 0xFF, 0x3C, 0xF3, 0x87, 0x38,
  0xF3, 0x8F, 0x78, 0xF7, 0x0E, 0x71, 0xE7, 0x1E, 0x7F, 0xCF, 0xF8, 0xEF,
  0x00, 0x0F, 0x87, 0xF3, 0xF9, 0xE2, 0x70, 0x3C, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x13, 0xF8, 0xFE, 0x1F, 0x80, 0x00, 0x78, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x0F, 0x07, 0x78, 0xFF, 0x87, 0xFC, 0x79, 0xE3, 0x8F, 0x3C,
  0x71, 0xC3, 0x8E, 0x1C, 0x70, 0xE3, 0x8F, 0x1C, 0x70, 0xFF, 0x87, 0xFC,
  0x1E, 0xE0, 0x0F, 0x07, 0xF3, 0xFD, 0xE7, 0x71, 0xFC, 0xFF, 0xFB, 0xFC,
  0xE0, 0x38, 0x0E, 0x03, 0xCC, 0xFF, 0x1F, 0xC0, 0x00, 0x7C, 0x03, 0xE0,
  0x1F, 0x80, 0x70, 0x03, 0xC0, 0x0F, 0xC0, 0xFF, 0x03, 0xF8, 0x03, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0,
  0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x0F, 0xC0,
  0x3E, 0x00, 0xF0, 0x00, 0x07, 0x38, 0xFF, 0x87, 0xFC, 0x79, 0xE3, 0x8F,
  0x3C, 0x71, 0xE3, 0x8E, 0x1C, 0x71, 0xE3, 0x8F, 0x1C, 0xF0, 0xFF, 0x87,
  0xFC, 0x1F, 0xE0, 0x0F, 0x00, 0x70, 0x87, 0x87, 0xF8, 0x3F, 0xC1, 0xF8,
  0x00, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xDC, 0x1F, 0xE3,
  0xFF, 0x3C, 0xF3, 0xCF, 0x38, 0xF3, 0x8E, 0x78, 0xE7, 0x0E, 0x71, 0xE7,
  0x1C, 0x71, 0xCF, 0x1C, 0xE3, 0xC0, 0x0E, 0x1C, 0x78, 0x20, 0x03, 0x87,
  0x1E, 0x3C, 0x70, 0xE1, 0xC7, 0x8F, 0x1C, 0x38, 0x71, 0xE3, 0x80, 0x01,
  0xC0, 0x70, 0x3C, 0x02, 0x00, 0x00, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xC0,
  0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xC0, 0x70,
  0x1C, 0x0F, 0x0F, 0x83, 0xE0, 0xF0, 0x00, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x3C, 0x01, 0xC0, 0x0E, 0x3C, 0x73, 0xC7, 0x9C, 0x39, 0xC1, 0xDE, 0x0F,
  0xE0, 0x7E, 0x07, 0xF0, 0x3F, 0xC1, 0xCE, 0x0E, 0x70, 0x73, 0xC7, 0x9E,
  0x38, 0x70, 0x0E, 0x1C, 0x78, 0xF1, 0xC3, 0x87, 0x1E, 0x3C, 0x70, 0xE1,
  0xC7, 0x8F, 0x1C, 0x38, 0x71, 0xE3, 0x80, 0x19, 0xC7, 0x86, 0xFB, 0xE3,
  0xFF, 0xFC, 0xF3, 0xCF, 0x3C, 0xF3, 0xCE, 0x38, 0xF3, 0x8E, 0x39, 0xE3,
  0x8E, 0x71, 0xE3, 0x9C, 0x71, 0xE7, 0x1C, 0x71, 0xC7, 0x1C, 0xF1, 0xC7,
  0x38, 0xF3, 0xC0, 0x19, 0xC1, 0xBE, 0x3F, 0xF3, 0xCF, 0x3C, 0xF3, 0x8F,
  0x38, 0xE7, 0x8E, 0x70, 0xE7, 0x1E, 0x71, 0xC7, 0x1C, 0xF1, 0xCE, 0x3C,
  0x0F, 0x03, 0xF0, 0xFF, 0x3C, 0xE7, 0x1F, 0xE3, 0xB8, 0x77, 0x0E, 0xE1,
  0xDC, 0x7B, 0x8E, 0x7F, 0xC7, 0xF0, 0xFC, 0x00, 0x0C, 0xE0, 0x6F, 0x87,
  0xFE, 0x3C, 0xF1, 0xC3, 0x8E, 0x3C, 0x71, 0xE7, 0x8F, 0x38, 0x71, 0xC7,
  0x8E, 0x3C, 0x7F, 0xC7, 0x7C, 0x3B, 0xC1, 0xC0, 0x0E, 0x00, 0xF0, 0x07,
  0x80, 0x38, 0x01, 0xC0, 0x00, 0x0E, 0x71, 0xFE, 0x3F, 0xE7, 0x9E, 0x71,
  0xEF, 0x1C, 0xE1, 0xCE, 0x1C, 0xE1, 0xCE, 0x3C, 0xE3, 0x8F, 0xF8, 0xFF,
  0x87, 0xB8, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x1D,
  0xC6, 0xF3, 0xF8, 0xFE, 0x3C, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1C, 0x07,
  0x01, 0xC0, 0xF0, 0x38, 0x00, 0x0F, 0x8F, 0xF3, 0xF9, 0xE2, 0x78, 0x0F,
  0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xC8, 0x73, 0xFC, 0xFF, 0x3F, 0x00, 0x0C,
  0x1C, 0x1C, 0x3F, 0xFF, 0xFE, 0x38, 0x78, 0x70, 0x70, 0x70, 0xF0, 0xE0,
  0xE0, 0xFC, 0xFC, 0x7C, 0x38, 0xE7, 0x1D, 0xE3, 0xB8, 0x77, 0x1E, 0xE3,
  0x9C, 0x77, 0x8E, 0xE3, 0xDC, 0x73, 0x8E, 0x7F, 0xCF, 0xF8, 0xF7, 0x00,
  0xF0, 0xFE, 0x3D, 0xC7, 0x39, 0xE7, 0x38, 0xE7, 0x1D, 0xC3, 0xB8, 0x7E,
  0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x00, 0xE3, 0x87, 0xE7, 0x8E,
  0xE7, 0x8E, 0xE7, 0x9E, 0xEF, 0x9C, 0xED, 0x9C, 0xFD, 0xB8, 0xDD, 0xB8,
  0xD9, 0xB8, 0xF9, 0xF0, 0xF1, 0xF0, 0xF1, 0xE0, 0xF1, 0xE0, 0xE1, 0xC0,
  0x1C, 0x78, 0xF3, 0x87, 0xBC, 0x1D, 0xC0, 0xFC, 0x07, 0xE0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0xFC, 0x0F, 0xE0, 0xF7, 0x87, 0x1C, 0x78, 0xE0, 0x1E,
  0x1C, 0x38, 0xF0, 0xE3, 0x83, 0x9E, 0x0E, 0x70, 0x39, 0xC0, 0xEE, 0x03,
  0xB8, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0x80, 0x1E, 0x03, 0xF0, 0x0F, 0x80, 0x3C, 0x00, 0x1F, 0xE3,
  0xFC, 0x7F, 0x81, 0xE0, 0x38, 0x0F, 0x03, 0xC0, 0x70, 0x1E, 0x07, 0x80,
  0xE0, 0x3F, 0xCF, 0xF9, 0xFF, 0x00, 0x01, 0xC1, 0xF0, 0x7C, 0x3C, 0x0F,
  0x03, 0x80, 0xE0, 0x38, 0x1E, 0x1F, 0x07, 0x83, 0xC0, 0x78, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xF0, 0x3C, 0x07, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0C, 0x0F, 0x87, 0xC0,
  0xE0, 0x70, 0x38, 0x3C, 0x1C, 0x0E, 0x07, 0x81, 0xE0, 0xF1, 0xF8, 0xE0,
  0x70, 0x78, 0x38, 0x1C, 0x0E, 0x1F, 0x0F, 0x07, 0x00, 0x78, 0x3F, 0xEF,
  0xFF, 0xC3, 0xE0,
};

const GFXglyph NotoSans_Condensed_BoldItalic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 7, 18, 7, 0, -18 },
  { 17, 9, 7, 10, 2, -18 },
  { 25, 14, 18, 13, 0, -18 },
  { 57, 12, 20, 12, 0, -19 },
  { 87, 17, 18, 19, 1, -18 },
  { 126, 14, 18, 14, 0, -18 },
  { 158, 5, 7, 6, 2, -18 },
  { 163, 8, 22, 7, 1, -18 },
  { 185, 9, 22, 7, -2, -18 },
  { 210, 10, 11, 11, 2, -19 },
  { 224, 11, 12, 12, 1, -15 },
  { 241, 5, 6, 6, -1, -3 },
  { 245, 7, 3, 7, 0, -8 },
  { 248, 4, 4, 6, 0, -4 },
  { 250, 13, 18, 10, -1, -18 },
  { 280, 11, 18, 12, 1, -18 },
  { 305, 9, 18, 12, 2, -18 },
  { 326, 13, 18, 12, -1, -18 },
  { 356, 12, 18, 12, 0, -18 },
  { 383, 12, 18, 12, 0, -18 },
  { 410, 12, 18, 12, 0, -18 },
  { 437, 11, 18, 12, 1, -18 },
  { 462, 12, 18, 12, 1, -18 },
  { 489, 12, 18, 12, 0, -18 },
  { 516, 12, 18, 12, 0, -18 },
  { 543, 6, 14, 6, 0, -14 },
  { 554, 7, 17, 6, -1, -14 },
  { 569, 11, 12, 12, 1, -15 },
  { 586, 11, 8, 12, 1, -13 },
  { 597, 11, 12, 12, 1, -15 },
  { 614, 9, 18, 9, 1, -18 },
  { 635, 17, 20, 18, 1, -18 },
  { 678, 13, 18, 13, -2, -18 },
  { 708, 13, 18, 13, 0, -18 },
  { 738, 13, 18, 12, 1, -18 },
  { 768, 14, 18, 14, 0, -18 },
  { 800, 12, 18, 11, 0, -18 },
  { 827, 12, 18, 11, 0, -18 },
  { 854, 14, 18, 14, 1, -18 },
  { 886, 15, 18, 15, 0, -18 },
  { 920, 11, 18, 8, -1, -18 },
  { 945, 12, 23, 7, -4, -18 },
  { 980, 15, 18, 13, 0, -18 },
  { 1014, 9, 18, 11, 0, -18 },
  { 1035, 19, 18, 19, 0, -18 },
  { 1078, 16, 18, 16, 0, -18 },
  { 1114, 14, 18, 15, 1, -18 },
  { 1146, 13, 18, 13, 0, -18 },
  { 1176, 14, 22, 15, 1, -18 },
  { 1215, 13, 18, 13, 0, -18 },
  { 1245, 12, 18, 11, 0, -18 },
  { 1272, 11, 18, 11, 2, -18 },
  { 1297, 14, 18, 14, 1, -18 },
  { 1329, 13, 18, 13, 2, -18 },
  { 1359, 19, 18, 19, 2, -18 },
  { 1402, 15, 18, 12, -1, -18 },
  { 1436, 12, 18, 12, 2, -18 },
  { 1463, 13, 18, 11, -1, -18 },
  { 1493, 10, 22, 7, -1, -18 },
  { 1521, 5, 18, 10, 3, -18 },
  { 1533, 10, 22, 7, -2, -18 },
  { 1561, 12, 11, 12, 0, -18 },
  { 1578, 9, 2, 9, -2, 2 },
  { 1581, 4, 4, 8, 4, -19 },
  { 1583, 12, 14, 13, 1, -14 },
  { 1604, 12, 19, 13, 0, -19 },
  { 1633, 10, 14, 10, 1, -14 },
  { 1651, 13, 19, 13, 1, -19 },
  { 1682, 10, 14, 12, 1, -14 },
  { 1700, 14, 25, 8, -3, -19 },
  { 1744, 13, 20, 13, 0, -14 },
  { 1777, 12, 19, 13, 0, -19 },
  { 1806, 7, 19, 6, 0, -19 },
  { 1823, 10, 25, 6, -3, -19 },
  { 1855, 13, 19, 12, 0, -19 },
  { 1886, 7, 19, 6, 0, -19 },
  { 1903, 18, 14, 19, 0, -14 },
  { 1935, 12, 14, 13, 0, -14 },
  { 1956, 11, 14, 12, 1, -14 },
  { 1976, 13, 20, 13, -1, -14 },
  { 2009, 12, 20, 13, 1, -14 },
  { 2039, 10, 14, 9, 0, -14 },
  { 2057, 10, 14, 10, 0, -14 },
  { 2075, 8, 17, 8, 1, -17 },
  { 2092, 11, 14, 12, 1, -14 },
  { 2112, 11, 14, 11, 1, -14 },
  { 2132, 16, 14, 17, 2, -14 },
  { 2160, 13, 14, 11, -1, -14 },
  { 2183, 14, 20, 11, -2, -14 },
  { 2218, 11, 14, 9, -1, -14 },
  { 2238, 10, 22, 9, 0, -18 },
  { 2266, 3, 25, 11, 4, -19 },
  { 2276, 9, 22, 9, -1, -18 },
  { 2301, 11, 4, 12, 1, -11 },
};

const GFXfont NotoSans_Condensed_BoldItalic25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BoldItalic25pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BoldItalic25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_CONDENSED_BOLDITALIC25PT7B_H_
