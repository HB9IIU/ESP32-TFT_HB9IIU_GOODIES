#ifndef _NOTOSANS_CONDENSED_BOLDITALIC7PT7B_H_
#define _NOTOSANS_CONDENSED_BOLDITALIC7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BoldItalic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BoldItalic7pt7bBitmaps[] PROGMEM = {
  0x00, 0x56, 0x80, 0xF0, 0x5F, 0x6E, 0xC0, 0x69, 0xFC, 0x5D, 0xBE, 0x75,
  0x80, 0x66, 0x5A, 0xF0, 0xC0, 0x6A, 0x49, 0x00, 0x24, 0x95, 0x80, 0xFC,
  0x5D, 0x00, 0xC0, 0xC0, 0x80, 0x25, 0x48, 0x6E, 0xDC, 0x76, 0x80, 0x64,
  0xAE, 0x65, 0x1C, 0x2E, 0xF4, 0x6B, 0x9C, 0x6B, 0xDE, 0x72, 0x24, 0x80,
  0x6D, 0x5E, 0x77, 0x9C, 0x42, 0x42, 0x80, 0x38, 0x80, 0xE3, 0x80, 0xC7,
  0x00, 0x65, 0x08, 0x33, 0xF7, 0xF8, 0x30, 0x2D, 0xFA, 0x75, 0x6A, 0xE0,
  0x74, 0x88, 0x60, 0x65, 0x5A, 0xE0, 0x69, 0xCE, 0x69, 0xC8, 0x74, 0xB9,
  0x60, 0x55, 0x79, 0xA0, 0x69, 0x2C, 0x24, 0xA5, 0x80, 0x56, 0x6A, 0xA0,
  0x49, 0x4E, 0x4A, 0xEF, 0x5B, 0x80, 0x5A, 0xAD, 0x6B, 0x00, 0x75, 0x99,
  0x60, 0x75, 0x68, 0x80, 0x75, 0x99, 0x62, 0x65, 0x6A, 0xA0, 0x69, 0x1C,
  0xF2, 0x48, 0x55, 0x5A, 0xE0, 0xBB, 0x68, 0xAF, 0xBD, 0x6A, 0x00, 0x56,
  0x46, 0xA0, 0xBA, 0x48, 0x65, 0x4E, 0x6A, 0x49, 0x00, 0xF8, 0x24, 0x95,
  0x80, 0x2E, 0x80, 0xE0, 0x80, 0x5A, 0xAE, 0x4E, 0xDE, 0x72, 0x60, 0x16,
  0xAA, 0xE0, 0x77, 0x70, 0x36, 0x24, 0x44, 0x80, 0x5A, 0xAE, 0x2C, 0x4D,
  0xDA, 0x5A, 0x80, 0x25, 0x24, 0xA0, 0x47, 0xAC, 0xA0, 0x5A, 0x80, 0x7D,
  0x6B, 0x70, 0x6E, 0xD0, 0x76, 0xF0, 0x76, 0xF9, 0x00, 0x5A, 0xAE, 0x24,
  0x6A, 0x40, 0x79, 0x60, 0x76, 0xC0, 0x76, 0xF0, 0xB5, 0x20, 0xAD, 0x7D,
  0xE0, 0xED, 0x50, 0x55, 0x22, 0x4C, 0xE9, 0x60, 0x69, 0x69, 0x80, 0xFE,
  0x55, 0xA0, 0xE0,
};

const GFXglyph NotoSans_Condensed_BoldItalic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 2, 5, 2, 0, -5 },
  { 3, 2, 2, 3, 1, -5 },
  { 4, 4, 5, 4, 0, -5 },
  { 7, 3, 5, 3, 0, -5 },
  { 9, 5, 5, 5, 0, -5 },
  { 13, 4, 5, 4, 0, -5 },
  { 16, 1, 2, 2, 1, -5 },
  { 17, 3, 6, 2, 0, -5 },
  { 20, 3, 6, 2, -1, -5 },
  { 23, 2, 3, 3, 1, -5 },
  { 24, 3, 3, 3, 0, -4 },
  { 26, 1, 2, 2, 0, -1 },
  { 27, 2, 1, 2, 0, -2 },
  { 28, 1, 1, 2, 0, -1 },
  { 29, 3, 5, 3, 0, -5 },
  { 31, 3, 5, 3, 0, -5 },
  { 33, 2, 5, 3, 1, -5 },
  { 35, 3, 5, 3, 0, -5 },
  { 37, 3, 5, 3, 0, -5 },
  { 39, 3, 5, 3, 0, -5 },
  { 41, 3, 5, 3, 0, -5 },
  { 43, 3, 5, 3, 0, -5 },
  { 45, 4, 5, 3, 0, -5 },
  { 48, 3, 5, 3, 0, -5 },
  { 50, 3, 5, 3, 0, -5 },
  { 52, 2, 4, 2, 0, -4 },
  { 53, 2, 5, 2, 0, -4 },
  { 55, 3, 3, 3, 0, -4 },
  { 57, 3, 3, 3, 0, -4 },
  { 59, 3, 3, 3, 0, -4 },
  { 61, 3, 5, 3, 0, -5 },
  { 63, 5, 6, 5, 0, -5 },
  { 67, 3, 5, 4, 0, -5 },
  { 69, 4, 5, 4, 0, -5 },
  { 72, 4, 5, 3, 0, -5 },
  { 75, 4, 5, 4, 0, -5 },
  { 78, 3, 5, 3, 0, -5 },
  { 80, 3, 5, 3, 0, -5 },
  { 82, 4, 5, 4, 0, -5 },
  { 85, 4, 5, 4, 0, -5 },
  { 88, 3, 5, 2, 0, -5 },
  { 90, 3, 6, 2, -1, -5 },
  { 93, 4, 5, 4, 0, -5 },
  { 96, 3, 5, 3, 0, -5 },
  { 98, 5, 5, 5, 0, -5 },
  { 102, 5, 5, 4, 0, -5 },
  { 106, 4, 5, 4, 0, -5 },
  { 109, 4, 5, 4, 0, -5 },
  { 112, 4, 6, 4, 0, -5 },
  { 115, 4, 5, 4, 0, -5 },
  { 118, 3, 5, 3, 0, -5 },
  { 120, 3, 5, 3, 1, -5 },
  { 122, 4, 5, 4, 0, -5 },
  { 125, 3, 5, 4, 1, -5 },
  { 127, 5, 5, 5, 1, -5 },
  { 131, 4, 5, 3, 0, -5 },
  { 134, 3, 5, 3, 1, -5 },
  { 136, 3, 5, 3, 0, -5 },
  { 138, 3, 6, 2, 0, -5 },
  { 141, 1, 5, 3, 1, -5 },
  { 142, 3, 6, 2, -1, -5 },
  { 145, 3, 3, 3, 0, -5 },
  { 147, 3, 1, 2, -1, 0 },
  { 148, 1, 1, 2, 1, -5 },
  { 149, 4, 4, 4, 0, -4 },
  { 151, 3, 5, 4, 0, -5 },
  { 153, 3, 4, 3, 0, -4 },
  { 155, 4, 5, 4, 0, -5 },
  { 158, 3, 4, 3, 0, -4 },
  { 160, 4, 7, 2, -1, -5 },
  { 164, 4, 6, 4, 0, -4 },
  { 167, 3, 5, 4, 0, -5 },
  { 169, 2, 5, 2, 0, -5 },
  { 171, 3, 7, 2, -1, -5 },
  { 174, 4, 5, 3, 0, -5 },
  { 177, 2, 5, 2, 0, -5 },
  { 179, 5, 4, 5, 0, -4 },
  { 182, 3, 4, 4, 0, -4 },
  { 184, 3, 4, 3, 0, -4 },
  { 186, 3, 6, 4, 0, -4 },
  { 189, 4, 6, 4, 0, -4 },
  { 192, 3, 4, 2, 0, -4 },
  { 194, 3, 4, 3, 0, -4 },
  { 196, 2, 5, 2, 0, -5 },
  { 198, 3, 4, 3, 0, -4 },
  { 200, 3, 4, 3, 0, -4 },
  { 202, 5, 4, 5, 0, -4 },
  { 205, 3, 4, 3, 0, -4 },
  { 207, 4, 6, 3, -1, -4 },
  { 210, 3, 4, 3, 0, -4 },
  { 212, 3, 6, 2, 0, -5 },
  { 215, 1, 7, 3, 1, -5 },
  { 216, 2, 6, 2, 0, -5 },
  { 218, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_Condensed_BoldItalic7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BoldItalic7pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BoldItalic7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_CONDENSED_BOLDITALIC7PT7B_H_
