#ifndef _NOTOSANS_CONDENSED_BOLDITALIC24PT7B_H_
#define _NOTOSANS_CONDENSED_BOLDITALIC24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BoldItalic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BoldItalic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x3C, 0x70, 0xE1, 0xC7, 0x8E, 0x1C, 0x38, 0x70, 0xC2, 0x00,
  0x04, 0x3C, 0x78, 0xE0, 0x73, 0xBB, 0x9D, 0xCC, 0xE6, 0x77, 0x30, 0x03,
  0x38, 0x39, 0x81, 0x9C, 0x0C, 0xC0, 0x66, 0x1F, 0xFC, 0xFF, 0xE1, 0x98,
  0x1C, 0xC0, 0xCE, 0x3F, 0xFD, 0xFF, 0xC3, 0x38, 0x19, 0x80, 0xCC, 0x0E,
  0xE0, 0x66, 0x00, 0x01, 0x80, 0x10, 0x0F, 0xF1, 0xFE, 0x1D, 0xE3, 0xB0,
  0x3A, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x5C, 0x05, 0xC4, 0x5C,
  0xFF, 0xCF, 0xF8, 0x7E, 0x00, 0x80, 0x18, 0x00, 0x1E, 0x0E, 0x3E, 0x1C,
  0x77, 0x18, 0x67, 0x30, 0x66, 0x70, 0xE6, 0x60, 0xEE, 0xE4, 0xEE, 0xDF,
  0xFD, 0xBF, 0x7B, 0xB3, 0x03, 0x33, 0x07, 0x73, 0x06, 0x77, 0x0C, 0x67,
  0x1C, 0x66, 0x18, 0x7E, 0x38, 0x3C, 0x07, 0xC0, 0x3F, 0x80, 0xEE, 0x07,
  0x38, 0x1C, 0xE0, 0x77, 0x00, 0xFC, 0x03, 0xC0, 0x1F, 0x3C, 0xFC, 0xE7,
  0x3F, 0xBC, 0xFC, 0xE3, 0xE3, 0xC7, 0x8F, 0xFE, 0x1F, 0xFC, 0x3E, 0xF0,
  0x77, 0x76, 0x6E, 0x07, 0x83, 0x83, 0x83, 0x81, 0xC1, 0xC0, 0xE0, 0x70,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x03, 0x80, 0xC0, 0x60, 0x38, 0x1C,
  0x0E, 0x03, 0x00, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x30, 0x1C, 0x0C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x38, 0x1C, 0x1C, 0x0E,
  0x0E, 0x0E, 0x00, 0x0E, 0x03, 0x86, 0xC3, 0xFF, 0x7F, 0xC7, 0xF3, 0xE3,
  0xD8, 0x67, 0x09, 0x80, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0xFF, 0xFF, 0xFF,
  0xFC, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3B, 0xDC, 0xEE, 0x70, 0x7E, 0xFB,
  0xF0, 0x2F, 0xFE, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38,
  0x03, 0x80, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80,
  0x70, 0x07, 0x00, 0xE0, 0x00, 0x0F, 0x87, 0xF3, 0xFC, 0xE7, 0x71, 0xDC,
  0x7F, 0x1F, 0x87, 0xE3, 0xF8, 0xFE, 0x3B, 0x8E, 0xE7, 0xB9, 0xCF, 0xF3,
  0xF8, 0x7C, 0x00, 0x07, 0x87, 0x87, 0xCF, 0xEF, 0xF3, 0x70, 0x38, 0x1C,
  0x0E, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x00, 0x07,
  0xE0, 0xFF, 0x1E, 0xF0, 0x87, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x1E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x7F, 0xCF, 0xFC, 0xFF,
  0xC0, 0x0F, 0xC3, 0xFC, 0x77, 0x88, 0x70, 0x0E, 0x01, 0xC0, 0xF0, 0xFC,
  0x1F, 0x03, 0xF0, 0x0F, 0x00, 0xE0, 0x1D, 0x07, 0xBF, 0xE7, 0xF8, 0xFE,
  0x00, 0x00, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x7C, 0x1F, 0x87, 0x70, 0xCE,
  0x33, 0x8E, 0x71, 0x8E, 0x7F, 0xFF, 0xFC, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0x0F, 0xE3, 0xFC, 0x7F, 0x8E, 0x01, 0xC0, 0x70, 0x0F, 0xC1, 0xFC,
  0x3F, 0xC0, 0x78, 0x07, 0x00, 0xE0, 0x3D, 0x07, 0x3F, 0xE7, 0xF8, 0xFE,
  0x00, 0x07, 0xE1, 0xF8, 0x79, 0x1E, 0x03, 0x80, 0xE0, 0x1D, 0xC7, 0xFC,
  0xFF, 0x9E, 0x73, 0x8E, 0x71, 0xCE, 0x39, 0xCF, 0x3F, 0xC7, 0xF8, 0x7E,
  0x00, 0x3F, 0xE7, 0xFD, 0xFF, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x38,
  0x0F, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x80, 0xE0,
  0x00, 0x0F, 0xC3, 0xFC, 0x73, 0x9E, 0x73, 0x8E, 0x79, 0xC7, 0xF0, 0x7C,
  0x1F, 0x07, 0xF1, 0xCF, 0x78, 0xEE, 0x1D, 0xC3, 0xBC, 0xF3, 0xFC, 0x3F,
  0x00, 0x0F, 0xC3, 0xFC, 0xFF, 0x9C, 0x73, 0x8E, 0xF1, 0xDE, 0x7B, 0xCF,
  0x7F, 0xE7, 0xF8, 0x77, 0x00, 0xE0, 0x38, 0x0F, 0x3F, 0xC7, 0xF0, 0xFC,
  0x00, 0x1C, 0xF3, 0xC4, 0x00, 0x00, 0x00, 0x00, 0x8F, 0x3C, 0xE0, 0x0E,
  0x3C, 0x78, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE3, 0xC7, 0x0E, 0x38,
  0x70, 0x00, 0x40, 0x30, 0x3C, 0x3F, 0x3F, 0x3F, 0x0F, 0x03, 0xF0, 0x1F,
  0x01, 0xF0, 0x1C, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0x80, 0x30, 0x0F, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x1C, 0x3F, 0x3F,
  0x3F, 0x0F, 0x03, 0x00, 0x3F, 0x3F, 0xDD, 0xE0, 0x70, 0x38, 0x38, 0x3C,
  0x3C, 0x3C, 0x1C, 0x1C, 0x0E, 0x00, 0x01, 0x03, 0xC1, 0xE0, 0xE0, 0x00,
  0x03, 0xF8, 0x07, 0xFC, 0x1E, 0x0E, 0x18, 0x07, 0x30, 0xE3, 0x73, 0xF3,
  0x67, 0x73, 0xE6, 0x73, 0xCE, 0x67, 0xCC, 0x66, 0xCC, 0xE6, 0xCC, 0xEE,
  0xCF, 0xFC, 0xCF, 0x78, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x20, 0x3F, 0xE0,
  0x1F, 0x80, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x36, 0x07, 0x60, 0x77, 0x0E,
  0x70, 0xE7, 0x1E, 0x71, 0xC7, 0x3F, 0xF3, 0xFF, 0x3F, 0xF7, 0x07, 0x70,
  0x7F, 0x07, 0xE0, 0x70, 0x0F, 0xE0, 0xFF, 0x87, 0xFC, 0x38, 0xF1, 0xC7,
  0x0E, 0x38, 0xF3, 0xC7, 0xF8, 0x3F, 0xC1, 0xCF, 0x0E, 0x38, 0xF1, 0xC7,
  0x0E, 0x38, 0xF1, 0xFF, 0x1F, 0xF8, 0xFF, 0x00, 0x07, 0xF0, 0xFF, 0x1F,
  0xE3, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0E, 0x00, 0xF0, 0x0F, 0x00, 0x7F, 0x87, 0xF8, 0x3F, 0x80, 0x0F, 0xE0,
  0xFF, 0x87, 0xFE, 0x38, 0xF1, 0xC3, 0x8E, 0x1C, 0xF0, 0xE7, 0x07, 0x38,
  0x79, 0xC3, 0xCE, 0x1C, 0xF1, 0xE7, 0x0F, 0x38, 0xF1, 0xFF, 0x1F, 0xF0,
  0xFE, 0x00, 0x0F, 0xF1, 0xFE, 0x1F, 0xE1, 0xC0, 0x1C, 0x01, 0xC0, 0x3C,
  0x03, 0xFC, 0x3F, 0xC3, 0xF8, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0x7F,
  0x8F, 0xF0, 0xFF, 0x00, 0x0F, 0xF1, 0xFE, 0x1F, 0xE1, 0xC0, 0x1C, 0x01,
  0xC0, 0x3C, 0x03, 0xFC, 0x3F, 0xC3, 0xF8, 0x38, 0x07, 0x80, 0x70, 0x07,
  0x00, 0x70, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0xF8, 0x7F, 0xC7, 0xFC, 0x78,
  0x23, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x3E, 0xF3, 0xF7, 0x9F, 0xBC, 0x39,
  0xC1, 0xCF, 0x0E, 0x78, 0x71, 0xFF, 0x8F, 0xF8, 0x3F, 0xC0, 0x0E, 0x1E,
  0x3C, 0x38, 0x78, 0x70, 0xE1, 0xE1, 0xC3, 0xC3, 0x87, 0x0F, 0x0E, 0x1F,
  0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xE1, 0xC3, 0xC3, 0x87, 0x07, 0x0E, 0x1E,
  0x1C, 0x38, 0x78, 0x70, 0xF0, 0xE0, 0x0F, 0xE3, 0xF8, 0x1C, 0x03, 0x80,
  0x70, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xE0,
  0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x78,
  0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x78, 0x3F, 0x0F, 0xC1, 0xF0,
  0x00, 0x0E, 0x3C, 0x78, 0xE1, 0xC7, 0x07, 0x3C, 0x1D, 0xE0, 0x77, 0x03,
  0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xB8, 0x1C, 0xE0, 0x73, 0xC1,
  0xC7, 0x07, 0x1C, 0x3C, 0x70, 0xE1, 0xE0, 0x0E, 0x0F, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x03, 0x81, 0xFF,
  0xFE, 0xFF, 0x00, 0x0F, 0x03, 0xE3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x87,
  0xE1, 0xF0, 0xFC, 0x36, 0x1F, 0x0E, 0xC7, 0xE1, 0xD8, 0xDC, 0x3B, 0x3B,
  0x87, 0x66, 0x70, 0xCD, 0xDC, 0x39, 0xB3, 0x87, 0x3E, 0x70, 0xE7, 0xCE,
  0x1C, 0xF3, 0x87, 0x1E, 0x70, 0xE3, 0x8E, 0x00, 0x0F, 0x0E, 0x3E, 0x1C,
  0x7C, 0x38, 0xF8, 0x71, 0xF1, 0xC3, 0x73, 0x8E, 0xE7, 0x1D, 0xCE, 0x3B,
  0x9C, 0x73, 0xF0, 0xC7, 0xE3, 0x8F, 0xC7, 0x1F, 0x8E, 0x3F, 0x1C, 0x3C,
  0x70, 0x78, 0xE0, 0xF0, 0x07, 0xE0, 0x7F, 0x87, 0xFE, 0x78, 0xF7, 0x83,
  0xBC, 0x1D, 0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1D, 0xC1, 0xEF,
  0x0F, 0x78, 0xF1, 0xFF, 0x0F, 0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0xFF, 0x87,
  0xFE, 0x38, 0xF1, 0xC7, 0x8E, 0x3C, 0xF1, 0xC7, 0x1E, 0x3F, 0xE1, 0xFE,
  0x0F, 0xE0, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x00,
  0x07, 0xE0, 0x7F, 0x87, 0xFE, 0x78, 0xF7, 0x83, 0xBC, 0x1D, 0xC0, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1D, 0xC1, 0xEF, 0x0F, 0x78, 0xF1, 0xFF,
  0x0F, 0xF0, 0x3F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0x0F,
  0xC1, 0xFF, 0x1F, 0xF1, 0xC7, 0x1C, 0x71, 0xC7, 0x3C, 0xF3, 0x9E, 0x3F,
  0xE3, 0xF8, 0x3B, 0x87, 0xB8, 0x73, 0xC7, 0x1C, 0x71, 0xCF, 0x1C, 0xE1,
  0xE0, 0x0F, 0xF1, 0xFE, 0x1F, 0xE3, 0xC2, 0x3C, 0x03, 0xC0, 0x3C, 0x01,
  0xF0, 0x1F, 0x80, 0xF8, 0x07, 0x80, 0x38, 0x03, 0x88, 0x38, 0xFF, 0x8F,
  0xF0, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x70, 0x1C, 0x07, 0x03, 0xC0,
  0xE0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xF0,
  0x00, 0x1C, 0x39, 0xE1, 0xCE, 0x1E, 0x70, 0xF3, 0x87, 0x3C, 0x39, 0xE1,
  0xCE, 0x1E, 0x70, 0xE3, 0x87, 0x3C, 0x39, 0xE3, 0xCE, 0x1E, 0x78, 0xE3,
  0xFF, 0x0F, 0xF0, 0x3F, 0x00, 0xE0, 0x7E, 0x0E, 0xE0, 0xEE, 0x1E, 0xE1,
  0xCE, 0x3C, 0xE3, 0x8E, 0x78, 0xE7, 0x06, 0x70, 0x6E, 0x06, 0xE0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x00, 0xE0, 0xE1, 0xF8, 0x78, 0xFE,
  0x1E, 0x3B, 0x8F, 0x8E, 0xE3, 0xE7, 0x38, 0xF9, 0xCE, 0x7C, 0x73, 0x9B,
  0x38, 0xEE, 0xCE, 0x3B, 0xB7, 0x0F, 0xCD, 0xC3, 0xF3, 0x70, 0xF8, 0xF8,
  0x3E, 0x3E, 0x0F, 0x8F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x00, 0x0E, 0x1E,
  0x1C, 0x78, 0x39, 0xE0, 0x7B, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0xEE, 0x01, 0xDC, 0x07, 0x38,
  0x1E, 0x78, 0x38, 0x70, 0xE0, 0xE0, 0xF0, 0xFE, 0x39, 0xCF, 0x39, 0xC7,
  0x78, 0xEE, 0x1F, 0x83, 0xF0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x07, 0x80,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x00, 0x0F, 0xF8, 0x7F, 0xC7, 0xFC, 0x01,
  0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x07, 0x80,
  0x38, 0x03, 0xC0, 0x3C, 0x01, 0xFF, 0x1F, 0xF8, 0xFF, 0xC0, 0x07, 0xC3,
  0xF0, 0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0xC3, 0xF0, 0xF8,
  0x00, 0xE1, 0x87, 0x1C, 0x71, 0xC7, 0x0C, 0x30, 0xE3, 0x8E, 0x38, 0xE3,
  0x86, 0x1C, 0x07, 0xC3, 0xF0, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x07,
  0x07, 0xC1, 0xF0, 0xFC, 0x00, 0x03, 0x80, 0x70, 0x1E, 0x07, 0xC0, 0xDC,
  0x3B, 0x8E, 0x71, 0xC6, 0x70, 0xFC, 0x1C, 0xFF, 0xFF, 0xF3, 0xCE, 0x1E,
  0xE7, 0xFD, 0xFF, 0xB8, 0xEF, 0x1D, 0xC3, 0xB8, 0xF7, 0x1C, 0xE3, 0x9C,
  0xF3, 0xFE, 0x7D, 0xC7, 0xB0, 0x0E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0,
  0x3F, 0x8F, 0xF9, 0xFF, 0x38, 0xE7, 0x1C, 0xE3, 0xB8, 0x77, 0x0E, 0xE3,
  0xDC, 0x73, 0xDE, 0xFF, 0x9D, 0xE0, 0x1F, 0x9F, 0xDE, 0x4E, 0x0F, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x3F, 0x9F, 0xC7, 0xE0, 0x00, 0x70, 0x07,
  0x00, 0xF0, 0x0E, 0x00, 0xE1, 0xEE, 0x3F, 0xE7, 0xBC, 0x71, 0xCF, 0x1C,
  0xE1, 0xCE, 0x1C, 0xE3, 0x8E, 0x38, 0xE3, 0x8F, 0xF8, 0xFF, 0x87, 0xB0,
  0x1F, 0x8F, 0xE7, 0x9D, 0xC7, 0xE3, 0xBF, 0xEF, 0xF3, 0x80, 0xE0, 0x38,
  0x0F, 0x33, 0xFC, 0x7E, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0x80,
  0x38, 0x03, 0xF0, 0x3F, 0x80, 0x70, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80,
  0x38, 0x01, 0xC0, 0x7E, 0x03, 0xE0, 0x1E, 0x00, 0x0F, 0x71, 0xFF, 0x3D,
  0xF3, 0x8E, 0x78, 0xE7, 0x0E, 0x71, 0xE7, 0x1C, 0x71, 0xC7, 0x3C, 0x7F,
  0xC7, 0xFC, 0x3F, 0x80, 0x38, 0x03, 0x88, 0x78, 0xFF, 0x0F, 0xE0, 0x78,
  0x00, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x3F, 0xCF, 0xF9, 0xFF,
  0x3C, 0xE7, 0x1C, 0xE3, 0xBC, 0x77, 0x1E, 0xE3, 0x9C, 0x73, 0x8E, 0xF3,
  0xDC, 0x70, 0x0E, 0x3C, 0x70, 0x00, 0x03, 0x8F, 0x1C, 0x38, 0x70, 0xE3,
  0xC7, 0x0E, 0x1C, 0x38, 0xF1, 0xC0, 0x01, 0xC0, 0xF0, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x3E, 0x0F, 0x83, 0x80,
  0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC7, 0x3C, 0xE3, 0x9C,
  0x3B, 0x83, 0xF8, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0x78, 0x73, 0x87, 0x38,
  0xE3, 0x8E, 0x3C, 0x0E, 0x3C, 0x78, 0xE1, 0xC3, 0x8F, 0x1C, 0x38, 0x70,
  0xE3, 0xC7, 0x0E, 0x1C, 0x38, 0xF1, 0xC0, 0x1B, 0xCF, 0x1F, 0xFF, 0xCF,
  0xFF, 0xE7, 0x9C, 0x73, 0x8E, 0x39, 0xC7, 0x1D, 0xC7, 0x1C, 0xE3, 0x8E,
  0x71, 0xC7, 0x38, 0xE3, 0x9C, 0x73, 0xDC, 0x71, 0xCE, 0x38, 0xE0, 0x1B,
  0xE7, 0xFC, 0xFF, 0x9E, 0x73, 0x8E, 0x71, 0xDE, 0x3B, 0x8F, 0x71, 0xCE,
  0x39, 0xC7, 0x78, 0xEE, 0x38, 0x1F, 0x8F, 0xE7, 0xBD, 0xC7, 0xF1, 0xF8,
  0x7E, 0x1F, 0x8F, 0xE3, 0xB8, 0xEF, 0xFB, 0xFC, 0x7E, 0x00, 0x0D, 0xE1,
  0xFF, 0x1F, 0xF1, 0xC7, 0x1C, 0x71, 0xC7, 0x38, 0x73, 0x87, 0x38, 0xF3,
  0x8E, 0x3F, 0xE7, 0xFC, 0x77, 0x87, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x00, 0x1E, 0xE7, 0xFD, 0xEF, 0x38, 0xEF, 0x1D, 0xC3, 0xB8,
  0x77, 0x1C, 0xE3, 0x9C, 0x73, 0xFE, 0x7F, 0xC7, 0xF0, 0x0E, 0x01, 0xC0,
  0x38, 0x0F, 0x01, 0xC0, 0x38, 0x00, 0x1B, 0xCE, 0xE3, 0xF8, 0xF0, 0x38,
  0x0E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x00, 0x1F,
  0xCF, 0xE3, 0x99, 0xE0, 0x78, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x01, 0xCF,
  0xF3, 0xF8, 0xFC, 0x00, 0x1C, 0x18, 0x38, 0x7F, 0xFE, 0x78, 0x70, 0x70,
  0x70, 0x70, 0xF0, 0xE0, 0xE0, 0xF8, 0xF8, 0x78, 0x38, 0xEE, 0x1D, 0xC7,
  0x38, 0xE7, 0x1C, 0xE3, 0xB8, 0xF7, 0x1C, 0xE3, 0x9C, 0xF3, 0xFE, 0x7F,
  0x87, 0xB0, 0xE1, 0xFC, 0x39, 0x8E, 0x31, 0xC7, 0x78, 0xEE, 0x1D, 0xC3,
  0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xE3, 0xC7, 0xE3, 0xCF,
  0xE3, 0xCE, 0xE7, 0xCE, 0xE7, 0xDC, 0xEF, 0xDC, 0xED, 0xD8, 0xED, 0xF8,
  0xFD, 0xF8, 0xF9, 0xF0, 0xF9, 0xF0, 0xF1, 0xE0, 0xF1, 0xE0, 0x1C, 0x78,
  0xE7, 0x87, 0xB8, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3C, 0x01, 0xF0, 0x1F,
  0x81, 0xDC, 0x0E, 0xE0, 0xE7, 0x8F, 0x1C, 0x00, 0x1E, 0x3C, 0x38, 0xE0,
  0xE7, 0x83, 0x9C, 0x0E, 0xF0, 0x3B, 0x80, 0xEE, 0x03, 0xF0, 0x0F, 0xC0,
  0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00,
  0xFC, 0x03, 0xE0, 0x0E, 0x00, 0x00, 0x1F, 0xE3, 0xF8, 0x07, 0x01, 0xC0,
  0x78, 0x1E, 0x03, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xFE, 0x3F, 0x8F, 0xF0,
  0x03, 0xC1, 0xF0, 0xF8, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x3C, 0x1E,
  0x0F, 0x03, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0xC0,
  0xF0, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x0F, 0x87,
  0xC0, 0xE0, 0x70, 0x70, 0x38, 0x1C, 0x0E, 0x03, 0xC1, 0xE1, 0xF1, 0xC0,
  0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x3E, 0x1E, 0x0C, 0x00, 0xFC, 0x7F, 0xF8,
  0xFE, 0x04,
};

const GFXglyph NotoSans_Condensed_BoldItalic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 7, 17, 6, 0, -17 },
  { 16, 9, 6, 10, 2, -17 },
  { 23, 13, 17, 13, 0, -17 },
  { 51, 12, 19, 11, 0, -18 },
  { 80, 16, 17, 18, 1, -17 },
  { 114, 14, 17, 14, 0, -17 },
  { 144, 4, 6, 6, 2, -17 },
  { 147, 9, 21, 7, 0, -17 },
  { 171, 9, 21, 7, -2, -17 },
  { 195, 10, 10, 11, 2, -18 },
  { 208, 10, 11, 12, 1, -14 },
  { 222, 5, 6, 6, -1, -3 },
  { 226, 7, 3, 7, 0, -8 },
  { 229, 4, 4, 6, 0, -4 },
  { 231, 12, 17, 9, -1, -17 },
  { 257, 10, 17, 11, 1, -17 },
  { 279, 9, 17, 11, 2, -17 },
  { 299, 12, 17, 11, -1, -17 },
  { 325, 11, 17, 11, 0, -17 },
  { 349, 11, 17, 11, 0, -17 },
  { 373, 11, 17, 11, 0, -17 },
  { 397, 11, 17, 11, 1, -17 },
  { 421, 11, 17, 11, 1, -17 },
  { 445, 11, 17, 11, 0, -17 },
  { 469, 11, 17, 11, 0, -17 },
  { 493, 6, 13, 6, 0, -13 },
  { 503, 7, 16, 6, -1, -13 },
  { 517, 10, 12, 12, 1, -15 },
  { 532, 10, 7, 12, 1, -12 },
  { 541, 10, 12, 12, 1, -15 },
  { 556, 9, 17, 9, 1, -17 },
  { 576, 16, 19, 17, 1, -17 },
  { 614, 12, 17, 12, -1, -17 },
  { 640, 13, 17, 12, 0, -17 },
  { 668, 12, 17, 12, 1, -17 },
  { 694, 13, 17, 13, 0, -17 },
  { 722, 12, 17, 11, 0, -17 },
  { 748, 12, 17, 10, 0, -17 },
  { 774, 13, 17, 14, 1, -17 },
  { 802, 15, 17, 14, 0, -17 },
  { 834, 11, 17, 8, -1, -17 },
  { 858, 11, 22, 7, -4, -17 },
  { 889, 14, 17, 12, 0, -17 },
  { 919, 9, 17, 10, 0, -17 },
  { 939, 19, 17, 18, 0, -17 },
  { 980, 15, 17, 15, 0, -17 },
  { 1012, 13, 17, 14, 1, -17 },
  { 1040, 13, 17, 12, 0, -17 },
  { 1068, 13, 21, 14, 1, -17 },
  { 1103, 12, 17, 12, 0, -17 },
  { 1129, 12, 17, 11, 0, -17 },
  { 1155, 10, 17, 10, 2, -17 },
  { 1177, 13, 17, 14, 1, -17 },
  { 1205, 12, 17, 12, 2, -17 },
  { 1231, 18, 17, 18, 2, -17 },
  { 1270, 15, 17, 12, -1, -17 },
  { 1302, 11, 17, 11, 2, -17 },
  { 1326, 13, 17, 10, -1, -17 },
  { 1354, 10, 21, 7, -1, -17 },
  { 1381, 6, 17, 9, 2, -17 },
  { 1394, 10, 21, 7, -2, -17 },
  { 1421, 11, 10, 11, 0, -17 },
  { 1435, 8, 2, 8, -2, 2 },
  { 1437, 5, 3, 7, 3, -18 },
  { 1439, 11, 13, 12, 1, -13 },
  { 1457, 11, 18, 12, 0, -18 },
  { 1482, 9, 13, 10, 1, -13 },
  { 1497, 12, 18, 12, 1, -18 },
  { 1524, 10, 13, 11, 1, -13 },
  { 1541, 13, 24, 7, -3, -18 },
  { 1580, 12, 19, 12, 0, -13 },
  { 1609, 11, 18, 12, 0, -18 },
  { 1634, 7, 18, 6, 0, -18 },
  { 1650, 10, 24, 6, -3, -18 },
  { 1680, 12, 18, 11, 0, -18 },
  { 1707, 7, 18, 6, 0, -18 },
  { 1723, 17, 13, 18, 0, -13 },
  { 1751, 11, 13, 12, 0, -13 },
  { 1769, 10, 13, 12, 1, -13 },
  { 1786, 12, 19, 12, -1, -13 },
  { 1815, 11, 19, 12, 1, -13 },
  { 1842, 10, 13, 8, 0, -13 },
  { 1859, 10, 13, 9, 0, -13 },
  { 1876, 8, 16, 8, 1, -16 },
  { 1892, 11, 13, 12, 1, -13 },
  { 1910, 11, 13, 10, 1, -13 },
  { 1928, 16, 13, 16, 1, -13 },
  { 1954, 13, 13, 11, -1, -13 },
  { 1976, 14, 19, 10, -2, -13 },
  { 2010, 11, 13, 9, -1, -13 },
  { 2028, 10, 21, 8, 0, -17 },
  { 2055, 2, 23, 10, 4, -18 },
  { 2061, 9, 21, 8, -1, -17 },
  { 2085, 10, 4, 12, 1, -10 },
};

const GFXfont NotoSans_Condensed_BoldItalic24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BoldItalic24pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BoldItalic24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_CONDENSED_BOLDITALIC24PT7B_H_
