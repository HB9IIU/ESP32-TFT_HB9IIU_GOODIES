#ifndef _NOTOSANS_CONDENSED_BOLDITALIC44PT7B_H_
#define _NOTOSANS_CONDENSED_BOLDITALIC44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BoldItalic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BoldItalic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x01, 0xF0, 0x00, 0x3F, 0x3F, 0x3E, 0x3E, 0x7E, 0x3E, 0x7E, 0x7E,
  0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0x7C, 0x78, 0x78, 0xF8, 0x78,
  0xF8, 0xF8, 0x00, 0x1E, 0x3E, 0x00, 0x3E, 0x3C, 0x00, 0x3C, 0x3C, 0x00,
  0x3C, 0x3C, 0x00, 0x7C, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00,
  0x78, 0xF8, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0x01, 0xE1, 0xE0, 0x01, 0xE1, 0xE0, 0x03, 0xE3, 0xC0, 0x03,
  0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC7, 0xC0, 0x7F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x0F, 0x0F, 0x00, 0x0F,
  0x1F, 0x00, 0x1F, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E,
  0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x7C, 0x7C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x7F, 0xC0, 0x0F, 0xFF,
  0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xEC, 0xE0, 0x7E,
  0x61, 0x03, 0xF3, 0x00, 0x1F, 0xB0, 0x00, 0xFD, 0x80, 0x07, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFE, 0x00, 0x37, 0xF0, 0x01, 0x9F, 0x88,
  0x0C, 0xFC, 0x60, 0x67, 0xC3, 0xC7, 0x7E, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x20, 0x1F, 0xC0, 0x0F, 0x00, 0xFF, 0x80, 0x78, 0x07, 0xFE, 0x03,
  0xE0, 0x1E, 0x7C, 0x0F, 0x00, 0xF9, 0xF0, 0x7C, 0x03, 0xC7, 0xC1, 0xE0,
  0x1F, 0x1F, 0x0F, 0x00, 0x7C, 0x7C, 0x7C, 0x01, 0xE1, 0xE1, 0xE0, 0x07,
  0x87, 0x8F, 0x80, 0x3E, 0x3E, 0x3C, 0x00, 0xF8, 0xF9, 0xE0, 0x03, 0xE3,
  0xCF, 0x8F, 0xCF, 0x9F, 0x3C, 0xFF, 0xBE, 0x79, 0xF3, 0xFE, 0x7F, 0xE7,
  0x9F, 0xF9, 0xFF, 0x3C, 0xF9, 0xF3, 0xF9, 0xF3, 0xC7, 0xC7, 0x87, 0x9F,
  0x1F, 0x00, 0x3E, 0x7C, 0x7C, 0x00, 0xF1, 0xE1, 0xE0, 0x07, 0x87, 0x87,
  0x80, 0x3E, 0x1E, 0x1E, 0x00, 0xF0, 0xF8, 0xF8, 0x07, 0xC3, 0xE3, 0xE0,
  0x1E, 0x0F, 0x8F, 0x00, 0xF0, 0x3E, 0x7C, 0x07, 0xC0, 0x7F, 0xE0, 0x1E,
  0x01, 0xFF, 0x80, 0xF8, 0x07, 0xFC, 0x07, 0xC0, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03,
  0xF1, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x7E, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x3F,
  0x07, 0xFE, 0x1F, 0x87, 0xFF, 0x0F, 0x87, 0xFF, 0xCF, 0xC7, 0xE7, 0xE7,
  0xC3, 0xF3, 0xFF, 0xE3, 0xF0, 0xFF, 0xE1, 0xF8, 0x7F, 0xF1, 0xF8, 0x1F,
  0xF0, 0xFC, 0x0F, 0xF0, 0x7E, 0x03, 0xF8, 0x3F, 0x83, 0xFC, 0x0F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xF7, 0xF0, 0x3F,
  0xE1, 0xFC, 0x3F, 0x3E, 0x3E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0x78,
  0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7C,
  0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF8,
  0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07,
  0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0x00, 0x01, 0x80, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x04,
  0x1F, 0x03, 0x8F, 0x03, 0xF7, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xC1, 0xFF, 0xE1, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC3, 0xFB, 0xE0, 0xF8,
  0xF8, 0x3C, 0x7C, 0x0C, 0x3F, 0x02, 0x0C, 0x00, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x0F, 0xC7,
  0xE1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC3, 0xE1, 0xF8, 0x7C, 0x1F, 0x0F, 0x83,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1C, 0xFD,
  0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x7F,
  0xFE, 0x0F, 0xEF, 0xC3, 0xF0, 0xF8, 0x7E, 0x1F, 0x1F, 0x83, 0xE3, 0xF0,
  0x7C, 0xFC, 0x0F, 0x9F, 0x81, 0xF3, 0xF0, 0x7E, 0xFC, 0x0F, 0xDF, 0x81,
  0xFB, 0xF0, 0x3F, 0x7E, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0x7E, 0x07,
  0xEF, 0xC0, 0xFD, 0xF8, 0x3F, 0xBF, 0x07, 0xE7, 0xE0, 0xFC, 0xFC, 0x3F,
  0x1F, 0x87, 0xE3, 0xF1, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0,
  0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x07, 0xF8, 0x3F,
  0xE0, 0xFF, 0xC3, 0xFF, 0x8F, 0xFF, 0x7F, 0xFE, 0x7E, 0xF8, 0xF3, 0xF0,
  0xC7, 0xE1, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0x3F, 0x80, 0x78, 0x3F,
  0x80, 0xE0, 0x7F, 0x00, 0x80, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xFF,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0,
  0x00, 0x3F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x81, 0xE3, 0xFC, 0x0C, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x3F,
  0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC4, 0x00, 0xFE, 0x30, 0x0F, 0xE1, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3D,
  0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xBF, 0x00, 0x3E, 0xF8, 0x01, 0xF3, 0xE0,
  0x07, 0x9F, 0x80, 0x3E, 0x7E, 0x01, 0xF1, 0xF8, 0x07, 0x87, 0xC0, 0x3C,
  0x1F, 0x01, 0xF0, 0xFC, 0x0F, 0x83, 0xF0, 0x3C, 0x0F, 0xC9, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xC0,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x78, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x0C, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x80, 0x1F, 0x87, 0x03, 0xFC,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF,
  0xE0, 0x1F, 0xFF, 0x01, 0xFE, 0x08, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF3, 0xF0,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xF8,
  0x7E, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x8F, 0xE0, 0xFC, 0x7E, 0x07, 0xE3,
  0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0x8F,
  0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x01,
  0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0x00, 0x7F, 0xFC,
  0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xF0, 0xFC, 0x1F, 0x07, 0xE1, 0xF8,
  0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0xFC, 0x0F, 0xCF, 0xE0,
  0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFF,
  0x00, 0x7F, 0xFC, 0x07, 0xF7, 0xE0, 0x7F, 0x3F, 0x87, 0xF0, 0xFC, 0x3F,
  0x03, 0xE1, 0xF0, 0x1F, 0x9F, 0x80, 0xFC, 0xFC, 0x07, 0xC7, 0xE0, 0x7E,
  0x3F, 0x83, 0xF0, 0xFE, 0x7F, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF,
  0xF8, 0x01, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03,
  0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0x9F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F, 0x3F,
  0x07, 0xE7, 0xE0, 0xFC, 0xFC, 0x1F, 0x9F, 0x03, 0xF7, 0xE0, 0x7E, 0xFC,
  0x1F, 0xDF, 0x83, 0xFB, 0xF8, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF,
  0xFF, 0x0F, 0xF7, 0xE0, 0x78, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF,
  0x81, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFC, 0x00, 0x03, 0xC0, 0xFC, 0x3F,
  0x87, 0xF0, 0xFE, 0x1F, 0x81, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x81, 0xF8, 0x3F, 0x0F,
  0xE1, 0xFC, 0x3F, 0x83, 0xE0, 0x00, 0xF0, 0x0F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xF8, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F,
  0x00, 0xF8, 0x0F, 0x80, 0x78, 0x00, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x07, 0x80, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0x3F, 0x80, 0x01, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x40, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x18, 0x00, 0x03, 0xC0,
  0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x03,
  0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xF0,
  0x03, 0xF8, 0x00, 0x7C, 0x00, 0x0E, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x0F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFF, 0x3F, 0xFF, 0x3C, 0x3F, 0x10,
  0x3F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFE, 0x03, 0xF0, 0x07, 0xE0,
  0x03, 0xE0, 0x3E, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x3C, 0x3C, 0x0F, 0xF8, 0xF1, 0xF0, 0xFF, 0xE3, 0xC7, 0x87, 0xFF, 0x8F,
  0x3E, 0x1F, 0x3E, 0x3C, 0xF0, 0xF0, 0xF0, 0xF3, 0xC7, 0xC3, 0xC3, 0xDF,
  0x1E, 0x0F, 0x0F, 0x78, 0x78, 0x7C, 0x79, 0xE3, 0xC1, 0xE1, 0xE7, 0x8F,
  0x07, 0x87, 0x9E, 0x3C, 0x3E, 0x1E, 0xF0, 0xF0, 0xF8, 0xF3, 0xC3, 0xC3,
  0xC3, 0xCF, 0x0F, 0x1F, 0x1E, 0x3C, 0x3E, 0xFE, 0xF8, 0xF0, 0xFF, 0xFF,
  0xC3, 0xC1, 0xFD, 0xFE, 0x07, 0x83, 0xE3, 0xE0, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x80, 0x07,
  0xE0, 0x1C, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00,
  0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x07, 0xE7, 0xC0, 0x0F, 0x8F, 0x80, 0x3F,
  0x1F, 0x00, 0x7C, 0x3E, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x0F, 0xC1,
  0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x0F, 0xC0, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF9,
  0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xEF, 0xE0, 0x0F, 0xDF, 0x80, 0x1F, 0xFF,
  0x00, 0x3F, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF0, 0x3F, 0x3F, 0xE0, 0x7E, 0x1F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0,
  0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0x03, 0xF0, 0x7E, 0x0F,
  0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x3F, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0xC3,
  0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3E,
  0x07, 0xF0, 0xFC, 0x1F, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xF7,
  0xC0, 0xFF, 0x03, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x30, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x03, 0xF0, 0xFE, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7F,
  0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F,
  0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x7F,
  0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0xFE, 0x1F, 0x80, 0xFE,
  0x3F, 0x80, 0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0x03, 0xF8, 0x3F, 0x03, 0xF8,
  0x3F, 0x0F, 0xF0, 0x7F, 0x3F, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80,
  0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFE, 0xFC, 0x0F,
  0xF0, 0x0C, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x0F, 0xFC, 0xFE, 0x0F, 0xFC, 0xFE, 0x0F, 0xFC, 0xFE, 0x1F, 0xF8, 0xFC,
  0x1F, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF8, 0xFC,
  0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFE, 0x03, 0xF0, 0xFE, 0x03, 0xF0, 0x7F,
  0x07, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xF8,
  0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80,
  0xFC, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x7F,
  0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xE0,
  0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x00,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xF8,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x03, 0xFF, 0x80,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x07,
  0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00,
  0x01, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0xC1,
  0xFC, 0x03, 0xF0, 0xFE, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x1F,
  0x8F, 0xE0, 0x07, 0xE7, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0x7C, 0xFC, 0x00,
  0x3F, 0x7F, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFD,
  0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x03,
  0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0,
  0x07, 0xE0, 0xFE, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x1F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7F, 0x00, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0x7F,
  0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0xC0,
  0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xF8, 0x0F, 0xF8, 0x03, 0xFE,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xE0, 0x1F,
  0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x81,
  0xF7, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3E, 0xFC, 0x0F, 0xFE,
  0x0F, 0xBE, 0x03, 0xEF, 0x83, 0xCF, 0x80, 0xF9, 0xE1, 0xF7, 0xE0, 0x3E,
  0x78, 0x7D, 0xF8, 0x1F, 0x9E, 0x3E, 0x7E, 0x07, 0xE7, 0x8F, 0x9F, 0x01,
  0xF1, 0xE7, 0xC7, 0xC0, 0x7C, 0x79, 0xF3, 0xF0, 0x3F, 0x1E, 0xF8, 0xFC,
  0x0F, 0xC7, 0xFE, 0x3E, 0x03, 0xF1, 0xFF, 0x0F, 0x80, 0xF8, 0x7F, 0xC7,
  0xE0, 0x3E, 0x1F, 0xE1, 0xF8, 0x1F, 0x87, 0xF8, 0x7E, 0x07, 0xE1, 0xFC,
  0x1F, 0x01, 0xF0, 0x7F, 0x07, 0xC0, 0x7C, 0x1F, 0x83, 0xF0, 0x1F, 0x07,
  0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x3F, 0x00, 0x01, 0xFC, 0x01, 0xF0, 0x3F,
  0xC0, 0x3F, 0x03, 0xFC, 0x03, 0xF0, 0x3F, 0xC0, 0x3F, 0x03, 0xFE, 0x03,
  0xE0, 0x3F, 0xE0, 0x3E, 0x07, 0xFE, 0x07, 0xE0, 0x7F, 0xE0, 0x7E, 0x07,
  0xFF, 0x07, 0xC0, 0x7F, 0xF0, 0x7C, 0x07, 0xDF, 0x07, 0xC0, 0xFD, 0xF0,
  0xFC, 0x0F, 0x9F, 0x0F, 0xC0, 0xF9, 0xF8, 0xF8, 0x0F, 0x9F, 0x8F, 0x80,
  0xF8, 0xF9, 0xF8, 0x1F, 0x8F, 0x9F, 0x81, 0xF8, 0xFD, 0xF8, 0x1F, 0x0F,
  0xDF, 0x01, 0xF0, 0x7D, 0xF0, 0x3F, 0x07, 0xDF, 0x03, 0xF0, 0x7F, 0xF0,
  0x3E, 0x07, 0xFF, 0x03, 0xE0, 0x7F, 0xE0, 0x3E, 0x03, 0xFE, 0x07, 0xE0,
  0x3F, 0xE0, 0x7E, 0x03, 0xFE, 0x07, 0xC0, 0x3F, 0xC0, 0x7C, 0x01, 0xFC,
  0x07, 0xC0, 0x1F, 0xC0, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07,
  0xF9, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0x7F, 0x3F,
  0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7E,
  0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE,
  0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFC, 0xFC,
  0x01, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF8, 0xFE,
  0x07, 0xF0, 0xFF, 0x0F, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7E,
  0x1F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0,
  0xFC, 0x1F, 0x81, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x0F, 0xE1, 0xF8, 0x3F,
  0x83, 0xF1, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0x7F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F,
  0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x3F,
  0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7E,
  0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFC,
  0x00, 0xFE, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xFC, 0xFC,
  0x03, 0xF8, 0xFC, 0x03, 0xF8, 0xFE, 0x07, 0xF0, 0xFF, 0x0F, 0xE0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xF7,
  0xFC, 0x0F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0xC3, 0xF0, 0x7F, 0x0F, 0xC1, 0xF8, 0x3F,
  0x1F, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC,
  0x01, 0xFF, 0xF0, 0x07, 0xE7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x03,
  0xF0, 0xF8, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFE, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF0, 0x1F, 0x8F, 0xC0, 0x7F,
  0x00, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0x80, 0x7F, 0xFE, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0x81, 0x81, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x86, 0x01, 0xFC, 0x3C, 0x1F, 0xE1,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x0F, 0xFC,
  0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF,
  0xFF, 0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x0F, 0xC0,
  0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x1F, 0xC0,
  0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0xFE, 0x1F, 0x80, 0xFC, 0x1F, 0x80,
  0xFC, 0x3F, 0x80, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0x01,
  0xF8, 0x3F, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x03,
  0xF0, 0x7E, 0x03, 0xF0, 0xFE, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x07,
  0xF0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x0F, 0xE0, 0xFE, 0x1F,
  0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xEF, 0xC0, 0x1F,
  0xBF, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F,
  0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC7, 0xE0, 0x1F, 0x1F, 0x80,
  0x7C, 0xFC, 0x01, 0xF3, 0xF0, 0x07, 0xCF, 0x80, 0x1F, 0x7E, 0x00, 0x7D,
  0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0xFE, 0x03,
  0xF0, 0x0F, 0xFE, 0x01, 0xF8, 0x0F, 0xDF, 0x01, 0xFC, 0x07, 0xEF, 0x80,
  0xFE, 0x07, 0xE7, 0xC0, 0x7F, 0x03, 0xF3, 0xE0, 0x7F, 0x81, 0xF1, 0xF0,
  0x3F, 0xC1, 0xF8, 0xF8, 0x3F, 0xE0, 0xFC, 0x7C, 0x1F, 0xF0, 0xFC, 0x3E,
  0x0F, 0xF8, 0x7E, 0x1F, 0x0F, 0xFC, 0x3E, 0x0F, 0x87, 0xFE, 0x3F, 0x07,
  0xC7, 0xDF, 0x1F, 0x83, 0xE3, 0xEF, 0x8F, 0x81, 0xF3, 0xE7, 0xCF, 0xC0,
  0xF9, 0xF3, 0xE7, 0xC0, 0x7C, 0xF9, 0xF7, 0xE0, 0x3E, 0xF8, 0xFB, 0xF0,
  0x1F, 0x7C, 0x7D, 0xF0, 0x0F, 0xBC, 0x3F, 0xF8, 0x07, 0xFE, 0x1F, 0xF8,
  0x03, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0x7F, 0x81, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x0F, 0xE0, 0x3F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF0, 0x0F,
  0xE0, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0xFE, 0x00, 0xFC, 0x0F,
  0xC0, 0x07, 0xC1, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00,
  0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFB, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x7E,
  0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0xC1, 0xF8,
  0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0x80, 0xFE,
  0x01, 0xFC, 0x00, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0x3F, 0x01, 0xF8, 0xF8,
  0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0,
  0x7E, 0x7E, 0x01, 0xF3, 0xF0, 0x0F, 0xBF, 0x00, 0x7D, 0xF0, 0x03, 0xFF,
  0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFC, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xF0, 0x7C,
  0x1F, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x01, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F,
  0x78, 0x01, 0xF7, 0xC0, 0x3E, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x3C, 0x0F,
  0x83, 0xE1, 0xF0, 0x3E, 0x1F, 0x03, 0xE3, 0xE0, 0x1E, 0x3E, 0x01, 0xF7,
  0xC0, 0x1F, 0xF8, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFE,
  0x3F, 0x1F, 0x87, 0xE1, 0xF0, 0xF8, 0x3E, 0x01, 0xF8, 0xF8, 0x3F, 0xE7,
  0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xE3, 0xF8, 0xFE,
  0x1F, 0xC7, 0xE0, 0xFE, 0x3F, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8,
  0xFC, 0x0F, 0xC7, 0xE0, 0x7C, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81,
  0xF8, 0xFC, 0x1F, 0xC7, 0xE0, 0xFC, 0x3F, 0x8F, 0xE1, 0xFF, 0xFF, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0x7C, 0x03, 0xF3, 0xE0, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x7E,
  0x01, 0xF7, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x3F,
  0x87, 0xE1, 0xF8, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E,
  0x3E, 0x03, 0xF1, 0xF0, 0x1F, 0x9F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0,
  0x7E, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0x87,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0x3F, 0xC0, 0xF8, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF,
  0x07, 0xF0, 0x43, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC,
  0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x03, 0xF3, 0xF0,
  0x0F, 0xF7, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07,
  0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xF8, 0x3F, 0x01,
  0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x7E,
  0x07, 0xE1, 0xFC, 0x0F, 0xF7, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFB, 0xC0,
  0x1F, 0xE7, 0x80, 0x1F, 0x9F, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x1F,
  0xFF, 0x07, 0xFF, 0xE1, 0xFC, 0x7E, 0x3F, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8,
  0x3E, 0x7E, 0x0F, 0xCF, 0xC3, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF,
  0xC1, 0xFF, 0xC0, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x08, 0x3F, 0x07, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF,
  0x80, 0x7F, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xC4, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7E, 0x3E, 0x01, 0xFE, 0x7C,
  0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFC, 0x3F, 0x83,
  0xF8, 0x7F, 0x07, 0xE0, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xF0, 0x7E,
  0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0,
  0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x07, 0xF0, 0x7E, 0x0F, 0xC0, 0xFE, 0x3F,
  0x81, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFD, 0xF0,
  0x07, 0xF7, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xFC, 0x0C, 0x03, 0xF8, 0x1F, 0x1F, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x7F, 0x01, 0xF7, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC,
  0x3F, 0x8F, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0xFC, 0x0F, 0x87, 0xE0,
  0xFC, 0x3F, 0x07, 0xE1, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0x87,
  0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xF0, 0x3F, 0x1F, 0x81, 0xF0, 0xFC, 0x1F,
  0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xF0, 0x3F, 0x1F, 0x81, 0xF0, 0xFC,
  0x1F, 0x80, 0x01, 0xF0, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03,
  0xFC, 0x00, 0x08, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xFC, 0x1F, 0x07,
  0xF0, 0x3E, 0x0F, 0xC0, 0xFC, 0x3F, 0x01, 0xF8, 0xFC, 0x03, 0xF3, 0xF0,
  0x07, 0xCF, 0xC0, 0x0F, 0xBF, 0x80, 0x3F, 0x7E, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x3F, 0x3F, 0x00, 0x7C, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF0,
  0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0x83, 0xF0, 0x1F, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x00, 0x07, 0xCF,
  0xE1, 0xF8, 0x0F, 0x3F, 0xC7, 0xF8, 0x1E, 0xFF, 0xDF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE1, 0xFC, 0x7F, 0x8F, 0xC3, 0xF0, 0x7E,
  0x1F, 0x87, 0xE1, 0xFC, 0x3F, 0x1F, 0x83, 0xF0, 0x7E, 0x3F, 0x07, 0xE0,
  0xFC, 0x7E, 0x0F, 0xC1, 0xF0, 0xF8, 0x1F, 0x03, 0xE3, 0xF0, 0x7E, 0x0F,
  0xC7, 0xE0, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0x3F, 0x1F, 0x83, 0xF0, 0x7C,
  0x3E, 0x07, 0xC0, 0xF8, 0xFC, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x07, 0xE3,
  0xF0, 0x7E, 0x0F, 0xC7, 0xC0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0x7E, 0x3F,
  0x07, 0xE0, 0xFC, 0x7E, 0x0F, 0xC1, 0xF8, 0x07, 0x8F, 0xE0, 0x3C, 0xFF,
  0x81, 0xEF, 0xFC, 0x1F, 0x7F, 0xE0, 0xFF, 0xFF, 0x87, 0xF0, 0xFC, 0x3F,
  0x07, 0xE1, 0xF8, 0x3E, 0x1F, 0x81, 0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC,
  0x3E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF0, 0xFC, 0x1F, 0x87, 0xE0,
  0xFC, 0x3E, 0x07, 0xE3, 0xF0, 0x3E, 0x1F, 0x81, 0xF0, 0xFC, 0x1F, 0x87,
  0xE0, 0xFC, 0x3E, 0x07, 0xE3, 0xF0, 0x3E, 0x1F, 0x83, 0xF0, 0x00, 0x10,
  0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC7, 0xE1, 0xF9, 0xF8, 0x3F, 0x3F, 0x07, 0xEF, 0xC0, 0xFD, 0xF8, 0x1F,
  0xBF, 0x03, 0xF7, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x7E,
  0xFC, 0x0F, 0xDF, 0x81, 0xFB, 0xF0, 0x7E, 0x7F, 0x1F, 0xC7, 0xFF, 0xF0,
  0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x01, 0xF3,
  0xF8, 0x03, 0xCF, 0xF8, 0x07, 0xBF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xCF,
  0xE0, 0x7F, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF0, 0x3F, 0x07, 0xE0, 0x7E,
  0x0F, 0xC0, 0xFC, 0x1F, 0x01, 0xF8, 0x3E, 0x03, 0xE0, 0xFC, 0x0F, 0xC1,
  0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x3F,
  0x87, 0xF0, 0x7F, 0x0F, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF,
  0xF8, 0x0F, 0xDF, 0xE0, 0x1F, 0x9F, 0x80, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0xF8, 0x1F, 0xE7, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x0F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC7, 0xE0, 0xFC, 0x3F, 0x07, 0xE3,
  0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xC0, 0x7C, 0x7E, 0x03,
  0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0xFC, 0x3F,
  0x8F, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0x7C,
  0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x07, 0xCF, 0xC1, 0xF7,
  0xE0, 0x7F, 0xF8, 0x3E, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFE, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F,
  0xC7, 0x07, 0xE0, 0x41, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x88, 0x0F, 0xE3, 0xFF, 0xF0, 0xFF,
  0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x03, 0xC0, 0x0F, 0x00,
  0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x7F, 0xF7, 0xFF, 0x9F, 0xFE, 0xFF, 0xFB,
  0xFF, 0xE3, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFE, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0x80, 0x0F,
  0xC1, 0xF8, 0x7C, 0x0F, 0xC7, 0xE0, 0x7C, 0x3F, 0x07, 0xE1, 0xF8, 0x3F,
  0x0F, 0x81, 0xF8, 0x7C, 0x0F, 0xC7, 0xE0, 0x7C, 0x3F, 0x07, 0xE1, 0xF8,
  0x3F, 0x0F, 0x81, 0xF8, 0x7C, 0x0F, 0x87, 0xE0, 0x7C, 0x3F, 0x07, 0xE1,
  0xF8, 0x3F, 0x0F, 0x81, 0xF8, 0x7C, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x0F,
  0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xF7, 0x81, 0xFF, 0x7C, 0x07,
  0xF3, 0xE0, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xFB, 0xE0, 0x7E, 0xF8,
  0x3F, 0x3E, 0x0F, 0xCF, 0x83, 0xE3, 0xE1, 0xF8, 0xF8, 0x7C, 0x3E, 0x3F,
  0x0F, 0x8F, 0x83, 0xE7, 0xE0, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0xBE, 0x03,
  0xEF, 0x80, 0xFF, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x1F, 0x81, 0xFF,
  0xC1, 0xFC, 0x1F, 0xBE, 0x0F, 0xE0, 0xFD, 0xF0, 0xFF, 0x0F, 0xCF, 0x87,
  0xF8, 0x7E, 0x7C, 0x3F, 0xC3, 0xE3, 0xE3, 0xFE, 0x3F, 0x1F, 0x1E, 0xF1,
  0xF0, 0xF9, 0xF7, 0x9F, 0x87, 0xCF, 0xFC, 0xFC, 0x3E, 0x7B, 0xE7, 0xC1,
  0xF7, 0xDF, 0x7E, 0x0F, 0xBC, 0xFB, 0xE0, 0x7D, 0xE7, 0xDF, 0x03, 0xFF,
  0x3F, 0xF0, 0x1F, 0xF1, 0xFF, 0x80, 0xFF, 0x8F, 0xFC, 0x07, 0xF8, 0x7F,
  0xC0, 0x3F, 0xC3, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xE0, 0xFF, 0x00,
  0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0x81, 0xFC, 0x00, 0x07,
  0xE0, 0x7F, 0x03, 0xF0, 0xFE, 0x03, 0xF0, 0xFC, 0x03, 0xF1, 0xF8, 0x03,
  0xF3, 0xF0, 0x01, 0xF3, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x0F, 0xDF, 0x80, 0x0F, 0xDF, 0x80, 0x1F, 0x8F, 0x80, 0x3F,
  0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0x03,
  0xE0, 0x3F, 0x81, 0xF0, 0x1F, 0x80, 0xF8, 0x1F, 0x80, 0x7C, 0x0F, 0xC0,
  0x3E, 0x07, 0xC0, 0x1F, 0x07, 0xE0, 0x0F, 0x83, 0xF0, 0x07, 0xE3, 0xF0,
  0x03, 0xF1, 0xF8, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x3E, 0x7C,
  0x00, 0x1F, 0x7E, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x04, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0xFF,
  0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x00, 0x0F,
  0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0xC0,
  0x1F, 0xE0, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x07, 0xC0, 0x0F, 0xE0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0x80,
  0x00, 0x3F, 0x00, 0x2F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xA0, 0x07, 0xE0,
};

const GFXglyph NotoSans_Condensed_BoldItalic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 13, 31, 11, 0, -31 },
  { 52, 16, 11, 18, 4, -31 },
  { 74, 24, 31, 23, 0, -31 },
  { 167, 21, 36, 20, 0, -33 },
  { 262, 30, 32, 33, 2, -32 },
  { 382, 25, 32, 25, 0, -32 },
  { 482, 8, 11, 11, 4, -31 },
  { 493, 15, 38, 13, 1, -31 },
  { 565, 15, 39, 13, -3, -32 },
  { 639, 17, 19, 20, 4, -34 },
  { 680, 19, 21, 22, 2, -26 },
  { 730, 10, 12, 11, -2, -6 },
  { 745, 11, 6, 13, 1, -15 },
  { 754, 7, 7, 11, 0, -7 },
  { 761, 23, 32, 17, -2, -32 },
  { 853, 19, 32, 20, 1, -32 },
  { 929, 15, 31, 21, 4, -31 },
  { 988, 23, 32, 20, -2, -32 },
  { 1080, 21, 32, 20, 0, -32 },
  { 1164, 22, 32, 21, -1, -32 },
  { 1252, 21, 31, 20, 0, -31 },
  { 1334, 21, 32, 20, 1, -32 },
  { 1418, 22, 31, 20, 1, -31 },
  { 1504, 21, 32, 20, 0, -32 },
  { 1588, 19, 32, 20, 1, -32 },
  { 1664, 11, 24, 11, 0, -24 },
  { 1697, 13, 30, 11, -2, -24 },
  { 1746, 19, 22, 22, 2, -27 },
  { 1799, 19, 13, 22, 2, -22 },
  { 1830, 19, 22, 22, 2, -27 },
  { 1883, 16, 32, 16, 2, -32 },
  { 1947, 30, 36, 31, 1, -32 },
  { 2082, 23, 32, 23, -3, -32 },
  { 2174, 23, 31, 23, 0, -31 },
  { 2264, 22, 32, 22, 2, -32 },
  { 2352, 24, 31, 25, 0, -31 },
  { 2445, 21, 31, 19, 0, -31 },
  { 2527, 21, 31, 19, 0, -31 },
  { 2609, 24, 32, 25, 2, -32 },
  { 2705, 27, 31, 26, 0, -31 },
  { 2810, 20, 31, 15, -2, -31 },
  { 2888, 20, 40, 12, -7, -31 },
  { 2988, 26, 31, 22, 0, -31 },
  { 3089, 16, 31, 19, 0, -31 },
  { 3151, 34, 31, 33, 0, -31 },
  { 3283, 28, 31, 27, 0, -31 },
  { 3392, 24, 32, 26, 2, -32 },
  { 3488, 23, 31, 22, 0, -31 },
  { 3578, 24, 39, 26, 2, -32 },
  { 3695, 22, 31, 22, 0, -31 },
  { 3781, 21, 32, 20, 0, -32 },
  { 3865, 20, 31, 19, 3, -31 },
  { 3943, 24, 31, 25, 2, -31 },
  { 4036, 22, 31, 22, 4, -31 },
  { 4122, 33, 31, 33, 4, -31 },
  { 4250, 28, 31, 22, -3, -31 },
  { 4359, 21, 31, 21, 4, -31 },
  { 4441, 24, 31, 19, -2, -31 },
  { 4534, 17, 39, 13, -1, -32 },
  { 4617, 10, 32, 17, 4, -32 },
  { 4657, 18, 39, 13, -3, -32 },
  { 4745, 20, 19, 21, 0, -31 },
  { 4793, 16, 3, 15, -4, 4 },
  { 4799, 9, 7, 13, 6, -34 },
  { 4807, 21, 24, 22, 1, -24 },
  { 4870, 21, 33, 22, 0, -33 },
  { 4957, 18, 24, 18, 1, -24 },
  { 5011, 23, 33, 22, 1, -33 },
  { 5106, 19, 24, 20, 1, -24 },
  { 5163, 24, 45, 14, -5, -34 },
  { 5298, 23, 35, 22, -1, -24 },
  { 5399, 21, 33, 22, 0, -33 },
  { 5486, 13, 33, 11, 0, -33 },
  { 5540, 19, 44, 11, -6, -33 },
  { 5645, 23, 33, 21, 0, -33 },
  { 5740, 13, 33, 11, 0, -33 },
  { 5794, 31, 24, 33, 0, -24 },
  { 5887, 21, 24, 22, 0, -24 },
  { 5950, 19, 25, 21, 1, -25 },
  { 6010, 23, 34, 22, -2, -24 },
  { 6108, 21, 35, 22, 1, -24 },
  { 6200, 18, 24, 15, 0, -24 },
  { 6254, 18, 24, 17, 0, -24 },
  { 6308, 14, 29, 14, 2, -29 },
  { 6359, 21, 24, 22, 1, -24 },
  { 6422, 18, 24, 19, 3, -24 },
  { 6476, 29, 24, 29, 3, -24 },
  { 6563, 24, 24, 19, -2, -24 },
  { 6635, 25, 35, 19, -3, -24 },
  { 6745, 19, 24, 17, -1, -24 },
  { 6802, 18, 38, 15, 0, -31 },
  { 6888, 5, 44, 19, 7, -34 },
  { 6916, 17, 38, 15, -2, -31 },
  { 6997, 19, 7, 22, 2, -19 },
};

const GFXfont NotoSans_Condensed_BoldItalic44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BoldItalic44pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BoldItalic44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_CONDENSED_BOLDITALIC44PT7B_H_
