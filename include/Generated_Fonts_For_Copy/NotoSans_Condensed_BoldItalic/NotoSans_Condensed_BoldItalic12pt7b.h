#ifndef _NOTOSANS_CONDENSED_BOLDITALIC12PT7B_H_
#define _NOTOSANS_CONDENSED_BOLDITALIC12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BoldItalic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BoldItalic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x32, 0x66, 0x64, 0x0C, 0xC0, 0x5D, 0xDB, 0x14, 0x28, 0xF3, 0xF2,
  0x9F, 0xBF, 0x28, 0xD0, 0x10, 0xF7, 0x9C, 0x30, 0x6B, 0xBE, 0x20, 0x80,
  0x62, 0xE4, 0xAC, 0xA8, 0xF6, 0xDF, 0x2B, 0x6A, 0xCE, 0x18, 0x78, 0xB1,
  0xC3, 0x6A, 0xB7, 0x6C, 0x7C, 0x7E, 0x13, 0x26, 0x44, 0xCC, 0xCC, 0x40,
  0x31, 0x11, 0x11, 0x32, 0x26, 0xC0, 0x37, 0x5F, 0xE5, 0x00, 0x63, 0x3E,
  0xC6, 0x30, 0x6D, 0x60, 0xFC, 0xF0, 0x06, 0x08, 0x20, 0xC1, 0x06, 0x08,
  0x30, 0xC0, 0x18, 0xE6, 0xD3, 0x4B, 0x2D, 0xB4, 0x70, 0x13, 0xFB, 0x22,
  0x66, 0x60, 0x19, 0xE4, 0xC2, 0x18, 0xC6, 0x32, 0xF0, 0x39, 0xF0, 0xC2,
  0x30, 0x61, 0xA6, 0xF0, 0x0C, 0x61, 0x8E, 0x5B, 0x6F, 0x84, 0x30, 0x3C,
  0xF6, 0x18, 0x78, 0x61, 0xA6, 0xF0, 0x0C, 0xF6, 0x14, 0x7B, 0x2D, 0xB6,
  0x70, 0x7D, 0xF0, 0x86, 0x10, 0xC2, 0x18, 0xC0, 0x19, 0xF6, 0xDA, 0x31,
  0x6D, 0xB6, 0x70, 0x19, 0xE6, 0xD3, 0x59, 0xA1, 0x8C, 0xE0, 0x2C, 0x01,
  0xB0, 0x13, 0x00, 0x06, 0x64, 0xC0, 0x0C, 0xEE, 0x1C, 0x1C, 0x10, 0xF8,
  0x3F, 0xF0, 0x87, 0x0E, 0xEC, 0x40, 0x33, 0xC6, 0x23, 0x30, 0x08, 0xC0,
  0x0C, 0x13, 0x21, 0x5F, 0x55, 0xF5, 0xBD, 0xD6, 0x40, 0x3C, 0x0C, 0x31,
  0xC5, 0x34, 0xF7, 0xD9, 0xC4, 0x38, 0xF6, 0x5B, 0x79, 0x34, 0xF6, 0xF0,
  0x1E, 0x79, 0x83, 0x04, 0x08, 0x30, 0x34, 0x78, 0x38, 0x79, 0x9B, 0x36,
  0x68, 0x93, 0x6C, 0xF0, 0x3C, 0xF6, 0x18, 0x79, 0x04, 0x30, 0xF0, 0x3C,
  0xF6, 0x18, 0x79, 0xE4, 0x30, 0xC0, 0x19, 0xFC, 0x30, 0x9E, 0x69, 0xB6,
  0xF8, 0x32, 0x4D, 0x9B, 0x37, 0xC8, 0x93, 0x66, 0xCC, 0x79, 0x88, 0x46,
  0x31, 0x88, 0xE0, 0x0C, 0x21, 0x86, 0x18, 0x61, 0x0C, 0x30, 0xCE, 0x10,
  0x26, 0x49, 0xB3, 0xC7, 0x0F, 0x16, 0x6C, 0xC8, 0x32, 0x66, 0x64, 0x4C,
  0xF0, 0x31, 0x98, 0xDC, 0xEE, 0x77, 0x72, 0xA9, 0x7D, 0xB6, 0xDB, 0x00,
  0x33, 0x33, 0x72, 0x72, 0x7E, 0x5E, 0x4C, 0xCC, 0xCC, 0x1C, 0x7D, 0x9B,
  0x34, 0x68, 0xF1, 0x36, 0x78, 0x38, 0xF6, 0x59, 0x7D, 0xE4, 0x30, 0xC0,
  0x1C, 0x7D, 0x9B, 0x34, 0x68, 0xF1, 0x36, 0x78, 0x30, 0x70, 0x30, 0xF6,
  0xDB, 0x7D, 0xC5, 0xB6, 0xC8, 0x19, 0xF6, 0x18, 0x30, 0x61, 0xA6, 0xF0,
  0xFF, 0xD8, 0xC6, 0x21, 0x18, 0xC0, 0x65, 0x3C, 0xF3, 0xCA, 0x69, 0xA6,
  0xF0, 0xCF, 0x3C, 0xB6, 0xD3, 0xCE, 0x38, 0xC0, 0xC8, 0xEC, 0xF6, 0x5B,
  0x6F, 0xB5, 0x53, 0xB9, 0x98, 0xCC, 0x00, 0x33, 0x16, 0x14, 0x1C, 0x18,
  0x18, 0x3C, 0x6C, 0xCC, 0xCF, 0x6D, 0x1C, 0x61, 0x84, 0x10, 0xC0, 0x7D,
  0xF1, 0x84, 0x31, 0x84, 0x32, 0xF0, 0x33, 0x66, 0x44, 0x4C, 0xC8, 0xC0,
  0xD9, 0x24, 0x93, 0x60, 0x39, 0xC6, 0x21, 0x18, 0xC4, 0x21, 0x38, 0x10,
  0x43, 0x9A, 0x4B, 0x30, 0xF0, 0xD0, 0x35, 0xF6, 0xF2, 0xCB, 0x67, 0x80,
  0x30, 0x86, 0x9F, 0x6D, 0x34, 0xB6, 0xB0, 0x1B, 0xD1, 0x8C, 0x69, 0xC0,
  0x06, 0x08, 0xF3, 0xE4, 0xD9, 0x32, 0x6C, 0x78, 0x13, 0xD3, 0xFC, 0x65,
  0xC0, 0x1C, 0x41, 0x8E, 0x30, 0xC2, 0x18, 0x61, 0x8C, 0x30, 0x35, 0xF6,
  0xF2, 0xCB, 0x67, 0x86, 0xB3, 0x80, 0x30, 0x86, 0x9F, 0x6D, 0x24, 0xB6,
  0xD8, 0x25, 0xB6, 0x96, 0xC0, 0x08, 0x46, 0x31, 0x88, 0x46, 0x31, 0xB9,
  0xC0, 0x20, 0x86, 0xDA, 0x59, 0xC7, 0x36, 0xD8, 0x32, 0x66, 0x64, 0x4C,
  0xC0, 0x7B, 0x3F, 0xDB, 0x49, 0x24, 0x96, 0xDB, 0x6C, 0x69, 0x76, 0xD2,
  0x4B, 0x6D, 0x80, 0x31, 0xE4, 0xF2, 0xCB, 0x67, 0x00, 0x34, 0x7C, 0xD9,
  0x32, 0x4D, 0x9E, 0x20, 0x41, 0x80, 0x35, 0xF4, 0xF2, 0xCB, 0x67, 0x86,
  0x10, 0xC0, 0x7B, 0x98, 0x84, 0x63, 0x00, 0x33, 0xD0, 0xE3, 0x5B, 0x80,
  0x23, 0x76, 0x44, 0xC6, 0x6D, 0xB4, 0xD2, 0xCB, 0x67, 0x80, 0x9C, 0xAD,
  0x4E, 0x63, 0x00, 0x9B, 0xB2, 0xB6, 0xB4, 0xD4, 0xD8, 0xD8, 0x36, 0x78,
  0xE0, 0xC3, 0x8D, 0x33, 0x00, 0x26, 0x48, 0xB1, 0x42, 0x86, 0x0C, 0x18,
  0xE1, 0x80, 0x7B, 0xCC, 0x46, 0x63, 0xC0, 0x09, 0xCC, 0x46, 0x61, 0x8C,
  0x42, 0x18, 0xFF, 0xF0, 0x21, 0x84, 0x23, 0x0C, 0xC4, 0x23, 0x30, 0xFE,
  0x60,
};

const GFXglyph NotoSans_Condensed_BoldItalic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 4, 9, 3, 0, -9 },
  { 6, 4, 4, 5, 1, -9 },
  { 8, 7, 9, 6, 0, -9 },
  { 16, 6, 10, 6, 0, -9 },
  { 24, 8, 9, 9, 1, -9 },
  { 33, 7, 9, 7, 0, -9 },
  { 41, 2, 4, 3, 1, -9 },
  { 42, 4, 11, 3, 0, -9 },
  { 48, 4, 11, 4, -1, -9 },
  { 54, 5, 5, 5, 1, -9 },
  { 58, 5, 6, 6, 1, -7 },
  { 62, 3, 4, 3, -1, -2 },
  { 64, 3, 2, 4, 0, -4 },
  { 65, 2, 2, 3, 0, -2 },
  { 66, 7, 9, 5, -1, -9 },
  { 74, 6, 9, 6, 0, -9 },
  { 81, 4, 9, 6, 1, -9 },
  { 86, 6, 9, 6, 0, -9 },
  { 93, 6, 9, 6, 0, -9 },
  { 100, 6, 9, 6, 0, -9 },
  { 107, 6, 9, 6, 0, -9 },
  { 114, 6, 9, 6, 0, -9 },
  { 121, 6, 9, 6, 0, -9 },
  { 128, 6, 9, 6, 0, -9 },
  { 135, 6, 9, 6, 0, -9 },
  { 142, 3, 7, 3, 0, -7 },
  { 145, 4, 9, 3, -1, -7 },
  { 150, 6, 6, 6, 0, -7 },
  { 155, 5, 4, 6, 1, -6 },
  { 158, 5, 6, 6, 1, -7 },
  { 162, 5, 9, 4, 0, -9 },
  { 168, 8, 10, 9, 0, -9 },
  { 178, 6, 9, 6, -1, -9 },
  { 185, 6, 9, 6, 0, -9 },
  { 192, 7, 9, 6, 0, -9 },
  { 200, 7, 9, 7, 0, -9 },
  { 208, 6, 9, 5, 0, -9 },
  { 215, 6, 9, 5, 0, -9 },
  { 222, 6, 9, 7, 1, -9 },
  { 229, 7, 9, 7, 0, -9 },
  { 237, 5, 9, 4, 0, -9 },
  { 243, 6, 12, 3, -2, -9 },
  { 252, 7, 9, 6, 0, -9 },
  { 260, 4, 9, 5, 0, -9 },
  { 265, 9, 9, 9, 0, -9 },
  { 276, 8, 9, 7, 0, -9 },
  { 285, 7, 9, 7, 0, -9 },
  { 293, 6, 9, 6, 0, -9 },
  { 300, 7, 11, 7, 0, -9 },
  { 310, 6, 9, 6, 0, -9 },
  { 317, 6, 9, 5, 0, -9 },
  { 324, 5, 9, 5, 1, -9 },
  { 330, 6, 9, 7, 1, -9 },
  { 337, 6, 9, 6, 1, -9 },
  { 344, 9, 9, 9, 1, -9 },
  { 355, 8, 9, 6, -1, -9 },
  { 364, 6, 9, 6, 1, -9 },
  { 371, 6, 9, 5, 0, -9 },
  { 378, 4, 11, 4, 0, -9 },
  { 384, 3, 9, 5, 1, -9 },
  { 388, 5, 11, 4, -1, -9 },
  { 395, 6, 6, 6, 0, -9 },
  { 400, 4, 1, 4, -1, 1 },
  { 401, 2, 2, 4, 2, -9 },
  { 402, 6, 7, 6, 0, -7 },
  { 408, 6, 9, 6, 0, -9 },
  { 415, 5, 7, 5, 0, -7 },
  { 420, 7, 9, 6, 0, -9 },
  { 428, 5, 7, 6, 0, -7 },
  { 433, 6, 12, 4, -1, -9 },
  { 442, 6, 10, 6, 0, -7 },
  { 450, 6, 9, 6, 0, -9 },
  { 457, 3, 9, 3, 0, -9 },
  { 461, 5, 12, 3, -2, -9 },
  { 469, 6, 9, 6, 0, -9 },
  { 476, 4, 9, 3, 0, -9 },
  { 481, 9, 7, 9, 0, -7 },
  { 489, 6, 7, 6, 0, -7 },
  { 495, 6, 7, 6, 0, -7 },
  { 501, 7, 10, 6, -1, -7 },
  { 510, 6, 10, 6, 0, -7 },
  { 518, 5, 7, 4, 0, -7 },
  { 523, 5, 7, 5, 0, -7 },
  { 528, 4, 8, 4, 0, -8 },
  { 532, 6, 7, 6, 0, -7 },
  { 538, 5, 7, 5, 1, -7 },
  { 543, 8, 7, 8, 1, -7 },
  { 550, 7, 7, 5, -1, -7 },
  { 557, 7, 10, 5, -1, -7 },
  { 566, 5, 7, 5, 0, -7 },
  { 571, 5, 11, 4, 0, -9 },
  { 578, 1, 12, 5, 2, -9 },
  { 580, 5, 11, 4, -1, -9 },
  { 587, 6, 2, 6, 0, -5 },
};

const GFXfont NotoSans_Condensed_BoldItalic12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BoldItalic12pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BoldItalic12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_CONDENSED_BOLDITALIC12PT7B_H_
