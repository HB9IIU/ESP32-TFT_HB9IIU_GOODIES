#ifndef _NOTOSANS_CONDENSED_BOLDITALIC41PT7B_H_
#define _NOTOSANS_CONDENSED_BOLDITALIC41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BoldItalic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BoldItalic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0,
  0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0x78, 0x00, 0x7E, 0x7D, 0xF1,
  0xF7, 0xC7, 0xDF, 0x1E, 0x7C, 0xF9, 0xE3, 0xEF, 0x8F, 0xBE, 0x3C, 0xF0,
  0xF3, 0xC3, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x01, 0xE1, 0xE0,
  0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x78, 0x00,
  0x78, 0xF1, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE0, 0x3C, 0x3C, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x03, 0xC3,
  0xC0, 0x07, 0x8F, 0x00, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFE, 0x01, 0xE3, 0xC0, 0x07, 0x87, 0x00, 0x0F, 0x1E, 0x00,
  0x1E, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x07,
  0x87, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x07,
  0xF8, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F,
  0xD8, 0xC0, 0xF9, 0x80, 0x0F, 0x98, 0x00, 0xFB, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x6F, 0x80, 0x0C, 0xF8, 0x40, 0xCF,
  0x86, 0x0D, 0xF8, 0x7C, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xC0, 0x3F, 0xF8, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x80, 0x7E, 0x00, 0xF0, 0x1F, 0xF0, 0x1F,
  0x01, 0xFF, 0x01, 0xE0, 0x3E, 0xF8, 0x3C, 0x03, 0xC7, 0x83, 0xC0, 0x7C,
  0xF8, 0x78, 0x07, 0x8F, 0x8F, 0x80, 0x78, 0xF0, 0xF0, 0x07, 0x8F, 0x1E,
  0x00, 0xF0, 0xF1, 0xE0, 0x0F, 0x0F, 0x3C, 0x00, 0xF1, 0xE7, 0xC7, 0x8F,
  0x1E, 0x79, 0xFC, 0xF3, 0xEF, 0x3F, 0xEF, 0xFC, 0xF7, 0xFE, 0x7F, 0x9E,
  0x79, 0xE3, 0xF3, 0xEF, 0x9F, 0x0C, 0x3C, 0xF1, 0xE0, 0x07, 0x8F, 0x1E,
  0x00, 0x78, 0xF1, 0xE0, 0x0F, 0x1F, 0x1E, 0x01, 0xF1, 0xE1, 0xE0, 0x1E,
  0x1E, 0x3E, 0x03, 0xC1, 0xE3, 0xC0, 0x3C, 0x1E, 0x3C, 0x07, 0x81, 0xF7,
  0x80, 0xF8, 0x1F, 0xF8, 0x0F, 0x00, 0xFF, 0x01, 0xE0, 0x07, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F,
  0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3,
  0xE0, 0x07, 0xCF, 0x80, 0x0F, 0xBF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x1F, 0x0F, 0xFC, 0x7E,
  0x3F, 0xFC, 0xF8, 0xFD, 0xFB, 0xF3, 0xF1, 0xFF, 0xC7, 0xC3, 0xFF, 0x8F,
  0x83, 0xFE, 0x3F, 0x07, 0xF8, 0x7E, 0x07, 0xF0, 0xFC, 0x1F, 0xC1, 0xFC,
  0x7F, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x83, 0xFF, 0xBF, 0x03, 0xFC,
  0x3F, 0x00, 0x7E, 0xFD, 0xF3, 0xE7, 0xCF, 0x1E, 0x7C, 0xF9, 0xE0, 0x00,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03,
  0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x00, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E,
  0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x04, 0x3E,
  0x07, 0x9E, 0x03, 0xFF, 0x0D, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0x83,
  0xFF, 0xC3, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x83, 0xF3, 0xC0, 0xF1, 0xF0,
  0x38, 0xF8, 0x08, 0x30, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x81, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x1F, 0x8F,
  0xC7, 0xC7, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0x78, 0x7C, 0x3C, 0x00, 0x7F,
  0xFF, 0xFB, 0xFF, 0x7F, 0xEF, 0xFD, 0xFF, 0x80, 0x3C, 0xFF, 0xFF, 0xFF,
  0xCF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x3F, 0xC0, 0x3F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0xC3, 0xF3, 0xF0, 0xF8,
  0x7C, 0x7E, 0x1F, 0x1F, 0x07, 0xCF, 0xC1, 0xF3, 0xE0, 0x7C, 0xF8, 0x3F,
  0x7E, 0x0F, 0xDF, 0x83, 0xF7, 0xC0, 0xFD, 0xF0, 0x3E, 0xFC, 0x0F, 0xBF,
  0x07, 0xEF, 0xC1, 0xFB, 0xE0, 0x7C, 0xF8, 0x3F, 0x3E, 0x0F, 0xCF, 0x83,
  0xE3, 0xE1, 0xF8, 0xFC, 0x7C, 0x3F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xC0,
  0x3F, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x3F, 0x81, 0xFE,
  0x1F, 0xF8, 0xFF, 0xE7, 0xFF, 0xBF, 0x7C, 0x79, 0xF1, 0xC7, 0xC2, 0x3F,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F,
  0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x0E, 0x00, 0x0F,
  0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xF0, 0x7E, 0x7F, 0x03,
  0x83, 0xF0, 0x30, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xFF,
  0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x00,
  0x3E, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x07,
  0x0F, 0xC0, 0x81, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x07, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x80, 0x3F, 0x1E, 0x3F,
  0xE3, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0,
  0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xBE, 0x00, 0x7F, 0xC0, 0x0F, 0x7C,
  0x01, 0xE7, 0xC0, 0x1E, 0x7C, 0x03, 0xCF, 0xC0, 0x78, 0xF8, 0x0F, 0x8F,
  0x80, 0xF0, 0xF8, 0x1E, 0x0F, 0x83, 0xE1, 0xF8, 0x3C, 0x1F, 0x07, 0xFF,
  0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0xC3, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x0C, 0x07, 0xF0,
  0xF9, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x3E, 0x03, 0xEF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F,
  0xCF, 0xC1, 0xF9, 0xF8, 0x3E, 0x3F, 0x07, 0xC7, 0xE1, 0xF8, 0xFC, 0x7F,
  0x0F, 0xDF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xC0,
  0x00, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7C, 0x3F, 0x0F, 0xC3, 0xF0, 0xF8, 0x3F, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0xC7, 0xE0, 0x7C, 0xFC, 0x07, 0xFF, 0x80, 0x3F,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xFB, 0xF0, 0x3F,
  0x1F, 0x87, 0xE1, 0xF8, 0x7C, 0x0F, 0x8F, 0xC0, 0xF8, 0xFC, 0x0F, 0x8F,
  0xC0, 0xF8, 0xFC, 0x1F, 0x8F, 0xE3, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0,
  0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x1F, 0xE0, 0x0F, 0xFE,
  0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0x8F, 0xC3, 0xE1, 0xF8, 0xFC, 0x3F,
  0x1F, 0x07, 0xE3, 0xE0, 0xFC, 0xFC, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0x7E,
  0x7E, 0x1F, 0xCF, 0xC7, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8,
  0x3F, 0xBE, 0x01, 0xC7, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFE, 0x1C, 0x7F, 0x83, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F,
  0xFE, 0x01, 0xFF, 0x00, 0x00, 0x03, 0x81, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xE0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x07, 0xE3, 0xF8, 0xFE, 0x3F, 0x0F, 0x80, 0x00, 0xE0,
  0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x81, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07,
  0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x00, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x01,
  0xE0, 0x03, 0xF0, 0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0x7F, 0x80, 0x3F, 0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x07, 0xC0, 0x00, 0xE0, 0x00,
  0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x30, 0x00, 0x0F,
  0x80, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x01, 0xFF, 0x01, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0F,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x1F, 0xF1, 0xFF, 0xF1, 0xFF, 0xE3,
  0xFF, 0xE7, 0x0F, 0xC8, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00,
  0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xF8, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x3E, 0x03, 0xC0,
  0x01, 0xE0, 0x78, 0x00, 0x1E, 0x0F, 0x03, 0xE0, 0xF1, 0xF0, 0xFF, 0xCF,
  0x1E, 0x1F, 0xF8, 0xF3, 0xC3, 0xFF, 0x8F, 0x3C, 0x7C, 0x78, 0xF3, 0x87,
  0x87, 0x8F, 0x78, 0xF0, 0xF0, 0xF7, 0x8F, 0x0F, 0x0E, 0x78, 0xF0, 0xF1,
  0xE7, 0x1E, 0x0F, 0x1E, 0xF1, 0xE1, 0xE1, 0xEF, 0x1E, 0x1E, 0x3C, 0xF1,
  0xE3, 0xE3, 0xCF, 0x1E, 0x3E, 0x78, 0xF1, 0xFF, 0xFF, 0x0F, 0x0F, 0xEF,
  0xF0, 0xF0, 0xFC, 0x7C, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x20, 0x03, 0xF0, 0x0E, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x01, 0xF3,
  0xE0, 0x07, 0xCF, 0x80, 0x3F, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0,
  0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x03, 0xF0, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xF8, 0x0F,
  0x87, 0xE0, 0x3F, 0x1F, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xE0, 0x0F, 0xDF,
  0x80, 0x3F, 0xFE, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x7E, 0x3F, 0x83, 0xF0, 0xFC, 0x1F, 0x03, 0xE0,
  0xF8, 0x1F, 0x07, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x1F,
  0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F,
  0x07, 0xE0, 0xF8, 0x3F, 0x0F, 0xC0, 0xF8, 0x7E, 0x07, 0xC3, 0xE0, 0x7E,
  0x1F, 0x03, 0xF0, 0xF8, 0x1F, 0x8F, 0xC1, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF,
  0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x03, 0xFF, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xF8, 0xF0, 0x7F, 0x01, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x02, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x03,
  0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFC, 0x3F, 0x81, 0xF8,
  0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x1F, 0x80, 0xFC, 0x3F, 0x01,
  0xF0, 0x7E, 0x07, 0xE0, 0xF8, 0x0F, 0xC1, 0xF0, 0x1F, 0x87, 0xE0, 0x3F,
  0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3E, 0x03, 0xF0, 0xFC, 0x07, 0xE1,
  0xF8, 0x1F, 0xC3, 0xF0, 0x3F, 0x07, 0xE0, 0xFE, 0x0F, 0x83, 0xF8, 0x3F,
  0x0F, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF,
  0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xF8, 0x0F,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xFC,
  0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03,
  0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0x80, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xE3, 0xE0,
  0xFE, 0x01, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC1, 0xFF,
  0x3F, 0x07, 0xFC, 0xFC, 0x3F, 0xF3, 0xF0, 0xFF, 0xCF, 0xC0, 0x3E, 0x3F,
  0x00, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01,
  0xF0, 0xFE, 0x0F, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F,
  0xC0, 0xFC, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x01,
  0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x7E, 0x07, 0xE0,
  0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0x80, 0xF8, 0x0F,
  0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x81,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0,
  0x3F, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E,
  0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0x80, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x80, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x8F, 0xE0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x3F, 0x00, 0xF8, 0x3F, 0x80, 0x7C, 0x1F,
  0x80, 0x7E, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x1F, 0x0F, 0xC0, 0x0F, 0x8F,
  0xC0, 0x07, 0xCF, 0xC0, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xF7,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xDF, 0x80, 0x0F, 0xCF, 0xC0, 0x07,
  0xE7, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0xF8, 0x7E, 0x00,
  0xFC, 0x3F, 0x00, 0x7E, 0x0F, 0x80, 0x3E, 0x07, 0xE0, 0x1F, 0x03, 0xF0,
  0x0F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0,
  0x0F, 0x80, 0x3F, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF3, 0xFF, 0xEF,
  0xFF, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xFC,
  0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xFC,
  0x07, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xBC,
  0x0F, 0xFC, 0x0F, 0xBC, 0x0F, 0x7C, 0x0F, 0xBC, 0x1F, 0xF8, 0x0F, 0xBC,
  0x1E, 0xF8, 0x0F, 0xBC, 0x3E, 0xF8, 0x0F, 0xBC, 0x3C, 0xF8, 0x1F, 0x3C,
  0x7D, 0xF8, 0x1F, 0x3C, 0x79, 0xF0, 0x1F, 0x3C, 0xF9, 0xF0, 0x1F, 0x3C,
  0xF9, 0xF0, 0x3F, 0x3D, 0xF1, 0xF0, 0x3E, 0x3D, 0xF3, 0xF0, 0x3E, 0x3D,
  0xE3, 0xE0, 0x3E, 0x3F, 0xE3, 0xE0, 0x3E, 0x3F, 0xC3, 0xE0, 0x7C, 0x3F,
  0xC3, 0xE0, 0x7C, 0x3F, 0x87, 0xE0, 0x7C, 0x3F, 0x87, 0xC0, 0x7C, 0x3F,
  0x07, 0xC0, 0x7C, 0x3F, 0x07, 0xC0, 0xF8, 0x3E, 0x0F, 0xC0, 0x03, 0xF8,
  0x07, 0xC0, 0xFE, 0x01, 0xF0, 0x3F, 0x80, 0x7C, 0x0F, 0xE0, 0x3F, 0x07,
  0xFC, 0x0F, 0x81, 0xFF, 0x03, 0xE0, 0x7F, 0xC0, 0xF8, 0x1F, 0xF0, 0x3E,
  0x07, 0xBE, 0x1F, 0x83, 0xEF, 0x87, 0xC0, 0xFB, 0xE1, 0xF0, 0x3E, 0xF8,
  0x7C, 0x0F, 0xBE, 0x1F, 0x03, 0xE7, 0xCF, 0xC1, 0xF1, 0xF3, 0xE0, 0x7C,
  0x7C, 0xF8, 0x1F, 0x1F, 0x3E, 0x07, 0xC3, 0xEF, 0x83, 0xF0, 0xFF, 0xC0,
  0xF8, 0x3F, 0xF0, 0x3E, 0x0F, 0xFC, 0x0F, 0x83, 0xFF, 0x03, 0xE0, 0x7F,
  0xC1, 0xF0, 0x1F, 0xE0, 0x7C, 0x07, 0xF8, 0x1F, 0x01, 0xFE, 0x07, 0xC0,
  0x3F, 0x81, 0xF0, 0x0F, 0xE0, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F,
  0xCF, 0xE1, 0xFC, 0x1F, 0xC7, 0xE0, 0x3F, 0x3F, 0x80, 0xFC, 0xFC, 0x03,
  0xF3, 0xF0, 0x0F, 0xDF, 0x80, 0x3F, 0x7E, 0x00, 0xFD, 0xF8, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0,
  0x1F, 0xBF, 0x00, 0xFE, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x7E,
  0x3F, 0x03, 0xF8, 0xFE, 0x1F, 0xC3, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x3F, 0x07, 0xC0, 0xFC, 0x3F, 0x03, 0xF0,
  0xFC, 0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0x83, 0xF8, 0x3E, 0x1F, 0xC1, 0xFF,
  0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0x80,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xCF, 0xE1, 0xFC, 0x1F, 0xC7,
  0xE0, 0x3F, 0x3F, 0x80, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xDF, 0x80,
  0x3F, 0x7E, 0x00, 0xFD, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0xFC, 0xFC,
  0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x7E, 0x3F, 0x03, 0xF8, 0xFE, 0x1F,
  0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x03, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x7E, 0x7F, 0x83,
  0xF0, 0xFC, 0x1F, 0x07, 0xE0, 0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x7E, 0x0F,
  0xC3, 0xF0, 0x7C, 0x1F, 0x07, 0xE0, 0xF8, 0x7F, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xCF, 0xC0,
  0x7E, 0x7E, 0x03, 0xF1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7E, 0x0F, 0xC3,
  0xF0, 0x7E, 0x1F, 0x83, 0xE0, 0x7E, 0x1F, 0x03, 0xF0, 0xF8, 0x1F, 0x8F,
  0xC0, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0xF0, 0x3F,
  0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xC0, 0x40, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x08, 0x03, 0xF0, 0xE0, 0x7F, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xC0, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF,
  0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xC0, 0x7C, 0x3F, 0x03, 0xF0, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F,
  0x80, 0xF8, 0x7E, 0x03, 0xE1, 0xF8, 0x1F, 0x87, 0xC0, 0x7E, 0x3F, 0x01,
  0xF8, 0xFC, 0x07, 0xC3, 0xF0, 0x3F, 0x0F, 0x80, 0xFC, 0x3E, 0x03, 0xF1,
  0xF8, 0x0F, 0xC7, 0xE0, 0x3E, 0x1F, 0x81, 0xF8, 0x7C, 0x07, 0xE3, 0xF0,
  0x1F, 0x8F, 0xC0, 0x7C, 0x3F, 0x01, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xF8, 0x03, 0xFF, 0x80,
  0x3E, 0xF8, 0x07, 0xEF, 0x80, 0x7C, 0xF8, 0x0F, 0xCF, 0x80, 0xFC, 0xF8,
  0x0F, 0x8F, 0x81, 0xF8, 0xF8, 0x1F, 0x0F, 0x83, 0xF0, 0xF8, 0x3E, 0x0F,
  0x87, 0xE0, 0xF8, 0x7C, 0x0F, 0x8F, 0xC0, 0xF8, 0xF8, 0x0F, 0x8F, 0x80,
  0xF9, 0xF8, 0x0F, 0x9F, 0x00, 0xFB, 0xF0, 0x0F, 0xBE, 0x00, 0xFB, 0xE0,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x07, 0xE0,
  0x3F, 0x7C, 0x07, 0xE0, 0x3E, 0x7C, 0x07, 0xC0, 0x7E, 0x7C, 0x0F, 0xC0,
  0x7C, 0x7C, 0x0F, 0xC0, 0xFC, 0x7C, 0x1F, 0xC0, 0xF8, 0x7C, 0x1F, 0xC0,
  0xF8, 0x7C, 0x1F, 0xC1, 0xF8, 0x7C, 0x3F, 0xC1, 0xF0, 0x7C, 0x3F, 0xC3,
  0xF0, 0x7C, 0x7F, 0xC3, 0xE0, 0x7C, 0x7B, 0xC3, 0xE0, 0x7C, 0x7B, 0xC7,
  0xE0, 0xFC, 0xFB, 0xC7, 0xC0, 0xFC, 0xF3, 0xCF, 0xC0, 0xFD, 0xF3, 0xCF,
  0x80, 0xF9, 0xF3, 0xCF, 0x80, 0xF9, 0xE3, 0xDF, 0x80, 0xFB, 0xE3, 0xDF,
  0x00, 0xFB, 0xC3, 0xDF, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0xFF, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0xFE, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x1F, 0x80,
  0x7E, 0x0F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x8F, 0xC0, 0x07, 0xC7, 0xC0,
  0x03, 0xE7, 0xE0, 0x01, 0xF3, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x7E,
  0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x1F,
  0x83, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x3F, 0x00,
  0xF8, 0x07, 0xFF, 0x01, 0xFB, 0xF0, 0x7E, 0x7E, 0x0F, 0xCF, 0xC3, 0xF0,
  0xF8, 0x7C, 0x1F, 0x1F, 0x83, 0xE3, 0xE0, 0x7C, 0xFC, 0x0F, 0x9F, 0x01,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x03,
  0xFE, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xF8, 0x7C, 0x3E, 0x0F, 0x07, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x0F, 0x07, 0x83, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x07, 0x83, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x07, 0x83, 0xE1,
  0xF0, 0xF8, 0x7C, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F,
  0xC0, 0x1F, 0x78, 0x03, 0xCF, 0x80, 0xF9, 0xF0, 0x1E, 0x1E, 0x07, 0xC3,
  0xC1, 0xF0, 0x7C, 0x3C, 0x0F, 0x8F, 0x80, 0xF3, 0xE0, 0x1E, 0x7C, 0x03,
  0xFF, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x7C, 0x7E, 0x3E, 0x1E,
  0x1F, 0x00, 0xE0, 0x10, 0x3F, 0x9E, 0x07, 0xFB, 0xE0, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE1, 0xF8, 0xFE, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x7E, 0x0F, 0xC7,
  0xE0, 0xFC, 0x7E, 0x0F, 0x87, 0xC0, 0xF8, 0xFC, 0x0F, 0x8F, 0xC1, 0xF8,
  0xFC, 0x1F, 0x8F, 0xC1, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFE, 0xFF,
  0x0F, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFB, 0xE0, 0x3F, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC7, 0x00, 0x7D, 0xFC,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFC, 0x7E, 0x1F, 0x83,
  0xE1, 0xF8, 0x3F, 0x1F, 0x03, 0xE1, 0xF0, 0x3E, 0x1F, 0x03, 0xE3, 0xF0,
  0x3E, 0x3E, 0x07, 0xE3, 0xE0, 0x7E, 0x3E, 0x07, 0xC3, 0xE0, 0xFC, 0x7E,
  0x0F, 0xC7, 0xE1, 0xF8, 0x7F, 0x3F, 0x87, 0xFF, 0xF0, 0x7B, 0xFE, 0x0F,
  0xBF, 0xC0, 0xF1, 0xF8, 0x00, 0x00, 0x78, 0x03, 0xFF, 0x07, 0xFF, 0x0F,
  0xFF, 0x1F, 0xFE, 0x1F, 0x82, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x08, 0xFE, 0x78, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F,
  0xF8, 0x1F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0xE3, 0xF0, 0x1F, 0xDF, 0x01, 0xFE, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x0F, 0xC7, 0xF0, 0xFC, 0x3F, 0x07, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3,
  0xF0, 0x7E, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x0F, 0xC0, 0xF8, 0x7E, 0x07,
  0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x07, 0xE1, 0xF8, 0x3F,
  0x1F, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xEF, 0x00, 0xFC, 0x78,
  0x00, 0x00, 0x78, 0x00, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xF1, 0xFD, 0xF8,
  0xF8, 0x7C, 0xFC, 0x3E, 0x7C, 0x1F, 0x7E, 0x1F, 0xBE, 0x1F, 0x9F, 0xFF,
  0xCF, 0xFF, 0xCF, 0xFF, 0x87, 0xFC, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x3F, 0x03, 0x0F, 0xFF, 0x87, 0xFF, 0xC1, 0xFF, 0xE0,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x1F, 0xC8, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x38, 0x04, 0x03, 0xF9,
  0xE0, 0x1F, 0xEF, 0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0x8F, 0xE0,
  0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3E, 0x07, 0xC0, 0xF8, 0x3F, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x7F, 0x03, 0xFB, 0xFC, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xBE, 0x00, 0xFD, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x30, 0x1F, 0xC0,
  0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC7, 0x00,
  0xFB, 0xF8, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xCF, 0xC3,
  0xF0, 0xF8, 0xFC, 0x1F, 0x1F, 0x83, 0xE3, 0xE0, 0xFC, 0x7C, 0x1F, 0x9F,
  0x83, 0xE3, 0xF0, 0x7C, 0x7C, 0x0F, 0x8F, 0x83, 0xF1, 0xF0, 0x7E, 0x7E,
  0x0F, 0x8F, 0xC1, 0xF1, 0xF0, 0x3E, 0x3E, 0x0F, 0xC7, 0xC1, 0xF1, 0xF8,
  0x3E, 0x3F, 0x07, 0xC0, 0x01, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xE0,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0x80,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F,
  0xC0, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFC, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0xC3, 0xF0, 0xFC,
  0x1F, 0x0F, 0xC0, 0xF8, 0xFC, 0x07, 0xCF, 0xC0, 0x3E, 0x7C, 0x03, 0xF7,
  0xE0, 0x1F, 0x7E, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xCF, 0xC0, 0x7E, 0x7E,
  0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0xC0, 0xF8, 0x7E, 0x07, 0xC1, 0xF0, 0x7E,
  0x0F, 0xC3, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x03,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F,
  0x80, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x7C,
  0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x3C, 0xFE, 0x3F, 0x83,
  0xEF, 0xF3, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0xE3,
  0xFC, 0xFC, 0x7F, 0x0F, 0xC3, 0xE3, 0xF0, 0xFC, 0x1F, 0x1F, 0x87, 0xE0,
  0xF8, 0xF8, 0x3E, 0x0F, 0xC7, 0xC1, 0xF0, 0x7C, 0x7E, 0x0F, 0x83, 0xE3,
  0xF0, 0xFC, 0x1F, 0x1F, 0x07, 0xE1, 0xF8, 0xF8, 0x3E, 0x0F, 0xC7, 0xC1,
  0xF0, 0x7C, 0x7E, 0x0F, 0x83, 0xE3, 0xE0, 0xFC, 0x1F, 0x1F, 0x07, 0xE1,
  0xF8, 0xF8, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0x7C, 0x7E, 0x0F, 0x83, 0xE3,
  0xE0, 0xFC, 0x3F, 0x00, 0x00, 0x07, 0x00, 0xF3, 0xF8, 0x3E, 0xFF, 0x87,
  0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xCF, 0xC3, 0xF0, 0xF8, 0xFC, 0x1F, 0x1F,
  0x83, 0xE3, 0xE0, 0xFC, 0x7C, 0x1F, 0x9F, 0x83, 0xE3, 0xF0, 0x7C, 0x7C,
  0x0F, 0x8F, 0x83, 0xF1, 0xF0, 0x7E, 0x7E, 0x0F, 0x8F, 0xC1, 0xF1, 0xF0,
  0x3E, 0x3E, 0x0F, 0xC7, 0xC1, 0xF1, 0xF8, 0x3E, 0x3F, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x1F, 0xFF, 0x87, 0xE3,
  0xF3, 0xF0, 0xFC, 0xF8, 0x3F, 0x7E, 0x0F, 0xDF, 0x03, 0xF7, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xBF, 0x03, 0xEF, 0xC1, 0xFB, 0xF0, 0x7E, 0xFC,
  0x1F, 0x3F, 0x0F, 0xC7, 0xE7, 0xE1, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xFE,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xC0, 0x0F, 0x3F, 0x80, 0xFB, 0xFC, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xF8, 0x7C, 0x0F, 0x83, 0xE0, 0xFC, 0x1F,
  0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x1F, 0x81, 0xF0, 0xF8,
  0x1F, 0x87, 0xC0, 0xFC, 0x3E, 0x07, 0xC1, 0xF0, 0x7E, 0x1F, 0x83, 0xF0,
  0xFC, 0x3F, 0x07, 0xF3, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFF,
  0x80, 0xF9, 0xF8, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x10, 0x3F, 0x9E, 0x07,
  0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xF8, 0xFE, 0x3F, 0x0F, 0xC3,
  0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7C, 0x0F, 0x87, 0xC0, 0xF8,
  0xFC, 0x0F, 0x8F, 0xC0, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF0, 0xFC, 0x1F,
  0x0F, 0xC3, 0xF0, 0xFE, 0x7F, 0x0F, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFB,
  0xE0, 0x3F, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x07, 0x07, 0x9F, 0x0F, 0xBF, 0x0F,
  0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xFE, 0x0F, 0xFF, 0x1F, 0xFF, 0x1F,
  0xFE, 0x1F, 0x06, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x80, 0xFC, 0xE1, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F,
  0xC0, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x9F, 0xFB, 0xFF,
  0xDF, 0xFE, 0xFF, 0xF1, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE2, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x1F, 0xE0, 0x1F, 0x83, 0xE3,
  0xF0, 0x7C, 0x7C, 0x1F, 0x8F, 0x83, 0xF1, 0xF0, 0x7C, 0x7E, 0x0F, 0x8F,
  0x81, 0xF1, 0xF0, 0x7E, 0x3E, 0x0F, 0xC7, 0xC1, 0xF1, 0xF8, 0x3E, 0x3E,
  0x07, 0xC7, 0xC1, 0xF8, 0xF8, 0x3E, 0x1F, 0x07, 0xC7, 0xE1, 0xF8, 0xFC,
  0x3F, 0x1F, 0x8F, 0xE3, 0xFF, 0xF8, 0x3F, 0xEF, 0x07, 0xF9, 0xE0, 0x7E,
  0x3C, 0x00, 0xFC, 0x0F, 0xFF, 0x03, 0xE7, 0xC1, 0xF9, 0xF0, 0x7C, 0x7C,
  0x3F, 0x1F, 0x0F, 0x87, 0xC7, 0xE1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x3E,
  0x07, 0xCF, 0x81, 0xF7, 0xC0, 0x7D, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x3F, 0x07, 0xFE, 0x1F, 0xC3, 0xFF, 0x87,
  0xF0, 0xFB, 0xE3, 0xFC, 0x3E, 0xF8, 0xFF, 0x1F, 0x3C, 0x3F, 0xC7, 0xCF,
  0x1E, 0xF3, 0xF3, 0xC7, 0xBC, 0xF8, 0xF3, 0xFF, 0x3E, 0x3C, 0xF7, 0xDF,
  0x0F, 0x3D, 0xE7, 0xC3, 0xDE, 0x7B, 0xE0, 0xF7, 0x9E, 0xF8, 0x3D, 0xE7,
  0xBE, 0x0F, 0xF1, 0xFF, 0x03, 0xFC, 0x7F, 0xC0, 0xFE, 0x1F, 0xE0, 0x3F,
  0x87, 0xF8, 0x0F, 0xE1, 0xFC, 0x03, 0xF0, 0x7F, 0x00, 0xFC, 0x1F, 0xC0,
  0x3F, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0x3E, 0x3F,
  0x00, 0xF8, 0xF8, 0x03, 0xF7, 0xE0, 0x07, 0xDF, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xC0,
  0x0F, 0x9F, 0x00, 0x7E, 0x7C, 0x03, 0xF1, 0xF8, 0x0F, 0x87, 0xE0, 0x7E,
  0x0F, 0x83, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0xF8, 0x0F,
  0x83, 0xF0, 0x1F, 0x07, 0xC0, 0x3E, 0x1F, 0x80, 0x7C, 0x3E, 0x00, 0xF8,
  0xFC, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xCF, 0x80, 0x0F, 0x9F,
  0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x3D, 0xF0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xF8,
  0x3F, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0xFF,
  0x80, 0x7F, 0x80, 0x3E, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x03, 0xF8, 0x03,
  0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x3E, 0x00, 0xFE, 0x03, 0xFE, 0x03,
  0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x5F, 0xE0, 0x3F, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xE8, 0x03, 0xE0,
};

const GFXglyph NotoSans_Condensed_BoldItalic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 12, 29, 11, 0, -29 },
  { 45, 14, 10, 17, 4, -29 },
  { 63, 23, 29, 22, 0, -29 },
  { 147, 20, 33, 19, 0, -31 },
  { 230, 28, 30, 31, 2, -30 },
  { 335, 23, 30, 24, 0, -30 },
  { 422, 7, 10, 10, 4, -29 },
  { 431, 14, 35, 12, 1, -29 },
  { 493, 14, 36, 12, -3, -30 },
  { 556, 17, 17, 18, 3, -31 },
  { 593, 17, 19, 20, 2, -24 },
  { 634, 9, 11, 10, -2, -5 },
  { 647, 11, 6, 12, 1, -14 },
  { 656, 7, 6, 10, 0, -6 },
  { 662, 21, 30, 16, -2, -30 },
  { 741, 18, 30, 19, 1, -30 },
  { 809, 14, 29, 19, 4, -29 },
  { 860, 20, 30, 19, -1, -30 },
  { 935, 19, 30, 19, 0, -30 },
  { 1007, 20, 29, 19, -1, -29 },
  { 1080, 20, 29, 19, 0, -29 },
  { 1153, 19, 30, 19, 1, -30 },
  { 1225, 20, 29, 19, 1, -29 },
  { 1298, 20, 30, 19, 0, -30 },
  { 1373, 19, 30, 19, 0, -30 },
  { 1445, 10, 23, 11, 0, -23 },
  { 1474, 12, 29, 11, -2, -23 },
  { 1518, 17, 20, 20, 2, -25 },
  { 1561, 18, 13, 20, 2, -21 },
  { 1591, 18, 20, 20, 2, -25 },
  { 1636, 15, 30, 15, 2, -30 },
  { 1693, 28, 33, 29, 1, -30 },
  { 1809, 22, 29, 21, -3, -29 },
  { 1889, 21, 29, 21, 0, -29 },
  { 1966, 21, 30, 20, 2, -30 },
  { 2045, 23, 29, 23, 0, -29 },
  { 2129, 20, 29, 18, 0, -29 },
  { 2202, 20, 29, 18, 0, -29 },
  { 2275, 22, 30, 24, 2, -30 },
  { 2358, 25, 29, 24, 0, -29 },
  { 2449, 19, 29, 14, -2, -29 },
  { 2518, 18, 38, 11, -6, -29 },
  { 2604, 25, 29, 21, 0, -29 },
  { 2695, 15, 29, 17, 0, -29 },
  { 2750, 32, 29, 31, 0, -29 },
  { 2866, 26, 29, 25, 0, -29 },
  { 2961, 22, 30, 25, 2, -30 },
  { 3044, 22, 29, 21, 0, -29 },
  { 3124, 22, 37, 25, 2, -30 },
  { 3226, 21, 29, 21, 0, -29 },
  { 3303, 20, 30, 18, 0, -30 },
  { 3378, 18, 29, 18, 3, -29 },
  { 3444, 22, 29, 23, 2, -29 },
  { 3524, 20, 29, 21, 4, -29 },
  { 3597, 32, 29, 31, 3, -29 },
  { 3713, 25, 29, 20, -2, -29 },
  { 3804, 19, 29, 19, 4, -29 },
  { 3873, 22, 29, 18, -2, -29 },
  { 3953, 16, 36, 12, -1, -29 },
  { 4025, 9, 30, 16, 4, -30 },
  { 4059, 17, 36, 12, -3, -29 },
  { 4136, 19, 18, 19, 0, -29 },
  { 4179, 15, 2, 14, -4, 4 },
  { 4183, 8, 6, 13, 6, -31 },
  { 4189, 20, 23, 21, 1, -23 },
  { 4247, 20, 31, 21, 0, -31 },
  { 4325, 16, 23, 16, 1, -23 },
  { 4371, 21, 31, 21, 1, -31 },
  { 4453, 17, 23, 19, 1, -23 },
  { 4502, 22, 41, 13, -5, -31 },
  { 4615, 22, 33, 21, -1, -23 },
  { 4706, 19, 31, 21, 0, -31 },
  { 4780, 12, 31, 10, 0, -31 },
  { 4827, 17, 41, 10, -5, -31 },
  { 4915, 21, 31, 19, 0, -31 },
  { 4997, 12, 31, 10, 0, -31 },
  { 5044, 29, 23, 30, 0, -23 },
  { 5128, 19, 23, 21, 0, -23 },
  { 5183, 18, 23, 20, 1, -23 },
  { 5235, 21, 33, 21, -2, -23 },
  { 5322, 20, 33, 21, 1, -23 },
  { 5405, 16, 23, 14, 0, -23 },
  { 5451, 16, 23, 16, 0, -23 },
  { 5497, 13, 27, 13, 2, -27 },
  { 5541, 19, 22, 20, 1, -22 },
  { 5594, 18, 22, 18, 2, -22 },
  { 5644, 26, 22, 27, 3, -22 },
  { 5716, 22, 22, 18, -2, -22 },
  { 5777, 23, 32, 18, -3, -22 },
  { 5869, 18, 22, 16, -1, -22 },
  { 5919, 17, 35, 14, 0, -29 },
  { 5994, 5, 40, 17, 6, -31 },
  { 6019, 16, 35, 14, -2, -29 },
  { 6089, 18, 7, 20, 2, -18 },
};

const GFXfont NotoSans_Condensed_BoldItalic41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BoldItalic41pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BoldItalic41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_CONDENSED_BOLDITALIC41PT7B_H_
