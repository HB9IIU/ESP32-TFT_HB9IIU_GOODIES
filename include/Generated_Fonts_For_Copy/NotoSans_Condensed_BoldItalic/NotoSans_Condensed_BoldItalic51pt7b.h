#ifndef _NOTOSANS_CONDENSED_BOLDITALIC51PT7B_H_
#define _NOTOSANS_CONDENSED_BOLDITALIC51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BoldItalic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BoldItalic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x03, 0xF0, 0x01, 0x00, 0x00, 0x3F,
  0x9F, 0xCF, 0xC7, 0xE7, 0xF1, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x9F, 0x8F,
  0xC7, 0xE3, 0xF1, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0x8F, 0x83, 0xE3,
  0xE0, 0xF8, 0xF8, 0x7C, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xF8, 0x7C,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1F, 0x0F, 0x80, 0x01,
  0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x1F,
  0x00, 0x03, 0xE1, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00,
  0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0,
  0x07, 0x83, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8,
  0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80,
  0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x01, 0xFE, 0xCF, 0x00, 0xFE, 0x61,
  0x80, 0x7E, 0x70, 0x00, 0x3F, 0x38, 0x00, 0x1F, 0x9C, 0x00, 0x0F, 0xEC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0D, 0xFE, 0x00, 0x06, 0x7F, 0x00,
  0x07, 0x3F, 0x84, 0x03, 0x9F, 0x83, 0x81, 0x9F, 0xC1, 0xF0, 0xDF, 0xE0,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0xFF, 0xC0, 0x0F, 0x80,
  0x7F, 0xF8, 0x07, 0xC0, 0x1F, 0xFE, 0x01, 0xF0, 0x0F, 0xCF, 0x80, 0xF8,
  0x03, 0xE3, 0xE0, 0x7E, 0x01, 0xF0, 0xF8, 0x1F, 0x00, 0x7C, 0x3E, 0x0F,
  0x80, 0x1F, 0x0F, 0x83, 0xE0, 0x0F, 0xC3, 0xE1, 0xF0, 0x03, 0xE0, 0xF8,
  0xFC, 0x00, 0xF8, 0x7E, 0x3E, 0x00, 0x3E, 0x1F, 0x1F, 0x00, 0x0F, 0x87,
  0xC7, 0xC0, 0x03, 0xE3, 0xF3, 0xE1, 0xF8, 0xF8, 0xF9, 0xF9, 0xFF, 0x3E,
  0x7E, 0x7C, 0xFF, 0xEF, 0xFF, 0x3E, 0x3F, 0xFB, 0xFF, 0xCF, 0x9F, 0xBF,
  0x7F, 0xE7, 0xCF, 0xC7, 0xCF, 0xF3, 0xF3, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8,
  0x7C, 0x00, 0x7C, 0x7C, 0x3F, 0x00, 0x1F, 0x1F, 0x0F, 0xC0, 0x0F, 0x87,
  0xC3, 0xE0, 0x07, 0xE1, 0xF0, 0xF8, 0x01, 0xF0, 0xFC, 0x3E, 0x00, 0xF8,
  0x3E, 0x1F, 0x80, 0x3E, 0x0F, 0x87, 0xC0, 0x1F, 0x03, 0xE1, 0xF0, 0x0F,
  0xC0, 0xF8, 0xFC, 0x03, 0xE0, 0x3F, 0x7E, 0x01, 0xF0, 0x07, 0xFF, 0x00,
  0x7C, 0x01, 0xFF, 0xC0, 0x3E, 0x00, 0x3F, 0xE0, 0x1F, 0x80, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x03,
  0xF0, 0xFC, 0x00, 0x3F, 0x87, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC3,
  0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF1, 0xFC, 0x00, 0x1F, 0xCF, 0xC0,
  0x00, 0xFE, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0xFE, 0x0F, 0xFF,
  0x07, 0xE0, 0xFF, 0xFC, 0x7F, 0x0F, 0xFF, 0xE3, 0xF8, 0xFF, 0x7F, 0xBF,
  0x87, 0xF1, 0xFD, 0xFC, 0x7F, 0x0F, 0xFF, 0xC3, 0xF8, 0x3F, 0xFC, 0x1F,
  0x81, 0xFF, 0xE0, 0xFC, 0x07, 0xFE, 0x0F, 0xE0, 0x3F, 0xF0, 0x7F, 0x00,
  0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x0F, 0xF1, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFE, 0x7F, 0x00,
  0xFF, 0xC3, 0xFC, 0x00, 0x60, 0x00, 0x00, 0x3F, 0x9F, 0x9F, 0xCF, 0xE7,
  0xE3, 0xF1, 0xF8, 0xFC, 0x7C, 0x7E, 0x3F, 0x1F, 0x0F, 0x80, 0x00, 0x1F,
  0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x02, 0x07, 0xC0, 0x1C, 0x3E, 0x01, 0xF9,
  0xF0, 0x0F, 0xEF, 0x0E, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x87, 0xFF, 0xFE,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0xC0, 0x7F, 0xBF, 0x01, 0xF8, 0xFC, 0x07, 0x87, 0xE0, 0x1C, 0x3F, 0x80,
  0x40, 0xE0, 0x00, 0x04, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x07,
  0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F,
  0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x7F, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xF8, 0x0E, 0x3F, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7E, 0x10, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x81, 0xFE, 0x7F, 0x03, 0xF8, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1,
  0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xE7, 0xF0, 0x1F,
  0xCF, 0xE0, 0x3F, 0x1F, 0xC0, 0x7E, 0x7F, 0x01, 0xFC, 0xFE, 0x03, 0xF9,
  0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xE7, 0xF0, 0x1F, 0xCF, 0xC0, 0x7F, 0x3F,
  0x80, 0xFE, 0x7F, 0x01, 0xFC, 0xFE, 0x03, 0xF9, 0xFC, 0x0F, 0xE3, 0xF8,
  0x1F, 0xC7, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0xC3, 0xFC, 0x3F, 0x87,
  0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF8, 0x7F,
  0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xBF, 0x1F, 0x3F, 0x8F, 0x1F, 0xC3,
  0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F,
  0xC7, 0xFC, 0x03, 0xC0, 0xFF, 0x00, 0xE0, 0x1F, 0xC0, 0x10, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xE0,
  0xFF, 0x01, 0x80, 0x7F, 0x01, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x80, 0x07, 0xF0, 0xC0, 0x0F,
  0xF0, 0xFC, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x80, 0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xDF, 0x80, 0x03, 0xFF, 0xC0,
  0x03, 0xEF, 0xE0, 0x03, 0xE7, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xF3, 0xF8,
  0x01, 0xF1, 0xFC, 0x01, 0xF8, 0xFC, 0x00, 0xF8, 0x7E, 0x00, 0xF8, 0x3F,
  0x00, 0xF8, 0x3F, 0x80, 0xFC, 0x1F, 0xC0, 0x7C, 0x0F, 0xC0, 0x7C, 0x07,
  0xE0, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF8, 0x04, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x80, 0x0F, 0xF0, 0xE0, 0x1F, 0xF0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80,
  0xFF, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0xFF, 0x81, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0xE0, 0x0F, 0xCF, 0xF0, 0x3F, 0xBF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xC7, 0xFE, 0x7F, 0x8F, 0xF0, 0x7F, 0x1F, 0xE0, 0xFE,
  0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x07, 0xF1, 0xF8, 0x0F, 0xE3,
  0xF0, 0x1F, 0xC7, 0xE0, 0x7F, 0x0F, 0xC0, 0xFE, 0x1F, 0x81, 0xFC, 0x3F,
  0x87, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF,
  0xFC, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xF8,
  0x7F, 0x07, 0xF0, 0x3F, 0x07, 0xF0, 0x3F, 0x07, 0xF0, 0x3F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xFE, 0x03, 0xF9, 0xFE, 0x03, 0xFF,
  0xFC, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xEF, 0xF0, 0x3F, 0xC7,
  0xF8, 0x3F, 0x83, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x7E, 0x01,
  0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xF8, 0xFE, 0x03, 0xF8, 0xFF, 0x03,
  0xF8, 0x7F, 0x87, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1F,
  0x80, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x83, 0xFC, 0x7F, 0x07, 0xF0, 0xFE, 0x1F, 0xC0, 0xFE,
  0x3F, 0x81, 0xFC, 0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xE7,
  0xF0, 0x3F, 0x8F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x83, 0xFC, 0x7F,
  0x0F, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x03, 0xFE, 0xFE, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0x70, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x01, 0xF0, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xC0,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x1F, 0x81,
  0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0x80, 0xFC, 0x01, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80,
  0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xFC,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x7F,
  0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xC0,
  0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x7F, 0xFF, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE,
  0x3F, 0xFF, 0xC7, 0x83, 0xF8, 0xC0, 0x7F, 0x00, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x0F,
  0x80, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x00, 0x07, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x7F, 0xF3, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x01,
  0xF0, 0x0F, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x01, 0xE0, 0xF8, 0x0F, 0xF0, 0x7C, 0x3E, 0x0F, 0xFF, 0x1F, 0x1F, 0x07,
  0xFF, 0xC7, 0xCF, 0x83, 0xFF, 0xE1, 0xF3, 0xE1, 0xF8, 0xF8, 0x7C, 0xF0,
  0x7C, 0x3E, 0x1F, 0x7C, 0x3E, 0x0F, 0x87, 0xDF, 0x0F, 0x83, 0xC1, 0xF7,
  0x87, 0xC1, 0xF0, 0x7B, 0xE1, 0xF0, 0x7C, 0x1E, 0xF8, 0x7C, 0x1F, 0x0F,
  0xBE, 0x3E, 0x07, 0xC3, 0xEF, 0x0F, 0x83, 0xE0, 0xF3, 0xC3, 0xE0, 0xF8,
  0x7C, 0xF0, 0xF8, 0x7E, 0x1F, 0x3C, 0x3E, 0x1F, 0x8F, 0x8F, 0x0F, 0x8F,
  0xE3, 0xE3, 0xC3, 0xFF, 0xFF, 0xF0, 0xF0, 0x7F, 0xDF, 0xF8, 0x3C, 0x1F,
  0xE7, 0xFC, 0x0F, 0x83, 0xF0, 0xFE, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x08, 0x00, 0x3F, 0xC0, 0x1E, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xF7, 0xE0, 0x00,
  0xFD, 0xF8, 0x00, 0x7F, 0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xE7, 0xE0,
  0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0x87,
  0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x7F,
  0x07, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xE0, 0x1F,
  0xC7, 0xF0, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80,
  0x1F, 0xDF, 0xE0, 0x07, 0xF7, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xF8, 0x7F, 0x80,
  0x7E, 0x07, 0xF8, 0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x0F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x0F,
  0xE0, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFC,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8,
  0x1F, 0x80, 0x7F, 0x03, 0xF0, 0x0F, 0xE0, 0xFE, 0x03, 0xFC, 0x1F, 0xC0,
  0x7F, 0x03, 0xF8, 0x1F, 0xE0, 0x7E, 0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xC0, 0x3F, 0xF1, 0xF0, 0x1F, 0xF0, 0x08, 0x0F, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x0E, 0x01, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xFC, 0x3F, 0xE0, 0x3F, 0x81,
  0xFF, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0x80, 0xFF, 0x03, 0xF8, 0x0F, 0xF0,
  0x7F, 0x80, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0,
  0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0xFF,
  0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xE1, 0xFC,
  0x01, 0xFE, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x03, 0xFC, 0x1F, 0xC0, 0x3F,
  0x81, 0xFC, 0x07, 0xF8, 0x3F, 0x80, 0xFF, 0x83, 0xF8, 0x0F, 0xF0, 0x3F,
  0x83, 0xFE, 0x03, 0xF8, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0x87, 0xC0, 0x7F, 0xC0, 0x0C, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x83, 0xFF,
  0xC7, 0xF0, 0x3F, 0xFC, 0x7F, 0x03, 0xFF, 0x87, 0xF0, 0x3F, 0xF8, 0xFF,
  0x07, 0xFF, 0x8F, 0xF0, 0x7F, 0xF8, 0xFF, 0x00, 0x3F, 0x8F, 0xF0, 0x07,
  0xF0, 0xFF, 0x00, 0x7F, 0x0F, 0xF0, 0x07, 0xF0, 0xFF, 0x00, 0x7F, 0x0F,
  0xF0, 0x07, 0xF0, 0xFF, 0x00, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0xC0,
  0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF0,
  0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80,
  0x3F, 0x80, 0x7F, 0x00, 0xFF, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03,
  0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFE, 0x01, 0xFE, 0x03,
  0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC,
  0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0xFF,
  0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x03, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x47, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFE,
  0x03, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0,
  0x7F, 0x80, 0x1F, 0xC1, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7E, 0x0F,
  0xF0, 0x01, 0xFC, 0x3F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF1, 0xFC,
  0x00, 0x0F, 0xC7, 0xF8, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x7F, 0x3F, 0x80,
  0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xF7, 0xF0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x3F,
  0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8,
  0x3F, 0x80, 0x07, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xF8, 0x07,
  0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x07, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0x80,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xFC,
  0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF,
  0x80, 0x7D, 0xF8, 0x07, 0xEF, 0x80, 0xFF, 0xF8, 0x07, 0xEF, 0xC0, 0xFB,
  0xF8, 0x07, 0xEF, 0xC1, 0xFB, 0xF0, 0x07, 0xEF, 0xC1, 0xF3, 0xF0, 0x0F,
  0xEF, 0xC3, 0xF7, 0xF0, 0x0F, 0xEF, 0xC3, 0xF7, 0xF0, 0x0F, 0xCF, 0xC7,
  0xE7, 0xF0, 0x0F, 0xCF, 0xC7, 0xE7, 0xE0, 0x0F, 0xCF, 0xCF, 0xC7, 0xE0,
  0x1F, 0xCF, 0xCF, 0xCF, 0xE0, 0x1F, 0x8F, 0xDF, 0x8F, 0xE0, 0x1F, 0x8F,
  0xDF, 0x8F, 0xC0, 0x1F, 0x8F, 0xDF, 0x0F, 0xC0, 0x1F, 0x8F, 0xFF, 0x0F,
  0xC0, 0x3F, 0x87, 0xFE, 0x1F, 0xC0, 0x3F, 0x07, 0xFE, 0x1F, 0xC0, 0x3F,
  0x07, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xFC, 0x1F, 0x80, 0x7F, 0x07, 0xF8,
  0x1F, 0x80, 0x7F, 0x07, 0xF8, 0x3F, 0x80, 0x7E, 0x07, 0xF8, 0x3F, 0x80,
  0x7E, 0x07, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xF0, 0x3F, 0x00, 0xFE, 0x07,
  0xE0, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x1F, 0x80,
  0x7F, 0xC0, 0x0F, 0xC0, 0x3F, 0xF0, 0x07, 0xE0, 0x1F, 0xF8, 0x07, 0xF0,
  0x0F, 0xFC, 0x03, 0xF8, 0x07, 0xFE, 0x01, 0xF8, 0x07, 0xFF, 0x00, 0xFC,
  0x03, 0xFF, 0xC0, 0x7E, 0x01, 0xFF, 0xE0, 0x7F, 0x00, 0xFF, 0xF0, 0x3F,
  0x80, 0xFD, 0xF8, 0x1F, 0x80, 0x7E, 0xFE, 0x0F, 0xC0, 0x3F, 0x3F, 0x07,
  0xE0, 0x1F, 0x9F, 0x87, 0xF0, 0x0F, 0xCF, 0xC3, 0xF0, 0x0F, 0xE7, 0xE1,
  0xF8, 0x07, 0xF3, 0xF8, 0xFC, 0x03, 0xF0, 0xFC, 0x7E, 0x01, 0xF8, 0x7E,
  0x7F, 0x00, 0xFC, 0x3F, 0x3F, 0x00, 0xFE, 0x1F, 0xDF, 0x80, 0x7E, 0x07,
  0xEF, 0xC0, 0x3F, 0x03, 0xF7, 0xE0, 0x1F, 0x81, 0xFB, 0xF0, 0x0F, 0xC0,
  0xFF, 0xF0, 0x0F, 0xE0, 0x7F, 0xF8, 0x07, 0xE0, 0x1F, 0xFC, 0x03, 0xF0,
  0x0F, 0xFE, 0x01, 0xF8, 0x07, 0xFF, 0x01, 0xFC, 0x03, 0xFF, 0x00, 0xFE,
  0x00, 0xFF, 0x80, 0x7E, 0x00, 0x7F, 0xC0, 0x3F, 0x00, 0x3F, 0xE0, 0x1F,
  0x80, 0x1F, 0xE0, 0x1F, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xFE, 0x3F, 0xE0, 0x7F, 0x81, 0xFE,
  0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x0F, 0xF1, 0xFE,
  0x00, 0x7F, 0x3F, 0xC0, 0x07, 0xF3, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F,
  0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF7, 0xF0, 0x00, 0xFF, 0x7F,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xEF, 0xF0, 0x01,
  0xFE, 0xFF, 0x00, 0x1F, 0xCF, 0xF0, 0x01, 0xFC, 0xFF, 0x00, 0x3F, 0xCF,
  0xE0, 0x03, 0xF8, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x00,
  0xFF, 0x07, 0xF0, 0x1F, 0xF0, 0x7F, 0x83, 0xFE, 0x07, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0x07, 0xF8, 0x1F, 0xC0, 0x7F,
  0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x83, 0xF8,
  0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x3F, 0xC1, 0xFC, 0x07, 0xF0,
  0x3F, 0x81, 0xFE, 0x0F, 0xE0, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xFE, 0x3F, 0xE0,
  0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x1F, 0xE0,
  0x0F, 0xF1, 0xFE, 0x00, 0x7F, 0x3F, 0xC0, 0x07, 0xF3, 0xFC, 0x00, 0x7F,
  0x3F, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF7, 0xF0,
  0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x1F,
  0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xCF, 0xF0, 0x01, 0xFC, 0xFF,
  0x00, 0x3F, 0xCF, 0xE0, 0x03, 0xF8, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x07,
  0xF8, 0xFF, 0x00, 0xFF, 0x07, 0xF0, 0x1F, 0xF0, 0x7F, 0x83, 0xFE, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0x1F, 0xF0,
  0x1F, 0x83, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x1F, 0x83, 0xFC, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xC7,
  0xF0, 0x07, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x3F,
  0x83, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0xC1, 0xFC, 0x07, 0xF0,
  0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xE0, 0x1F, 0xE3, 0xF8, 0x07,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F,
  0xF0, 0x18, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x08, 0x00, 0x7F, 0x06, 0x00, 0x7F, 0x83, 0xC0,
  0x7F, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0,
  0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE,
  0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xE0, 0xFE,
  0x01, 0xFC, 0x1F, 0xE0, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x1F,
  0xC1, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x3F,
  0x80, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x07,
  0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0xFF, 0x07,
  0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x01,
  0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0x80,
  0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xBF, 0x00, 0x1F, 0xDF, 0x80,
  0x1F, 0xCF, 0xC0, 0x0F, 0xE7, 0xE0, 0x0F, 0xE3, 0xF0, 0x07, 0xF1, 0xF8,
  0x03, 0xF8, 0xFC, 0x03, 0xF8, 0x7E, 0x01, 0xFC, 0x3F, 0x01, 0xFC, 0x1F,
  0x80, 0xFE, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x01,
  0xF8, 0x3F, 0x80, 0xFC, 0x1F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xC0,
  0x1F, 0xCF, 0xE0, 0x0F, 0xE7, 0xF0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF8,
  0x01, 0xF9, 0xF8, 0x00, 0xFD, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0x7E,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0xFC,
  0x01, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF8, 0x07, 0xF3, 0xF0, 0x0F, 0xF0,
  0x0F, 0xE7, 0xE0, 0x1F, 0xE0, 0x3F, 0x9F, 0xC0, 0x7F, 0xC0, 0x7F, 0x3F,
  0x80, 0xFF, 0x80, 0xFC, 0x7F, 0x01, 0xFF, 0x03, 0xF8, 0xFE, 0x07, 0xFE,
  0x07, 0xF1, 0xFC, 0x0F, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0xF8, 0x3F, 0x87,
  0xF0, 0x7F, 0xF0, 0x7E, 0x0F, 0xE0, 0xFF, 0xE1, 0xFC, 0x1F, 0xC3, 0xFF,
  0xC3, 0xF8, 0x3F, 0x87, 0xDF, 0x87, 0xE0, 0x7F, 0x1F, 0xBF, 0x1F, 0xC0,
  0xFE, 0x3F, 0x7E, 0x3F, 0x01, 0xFC, 0x7C, 0xFC, 0xFE, 0x03, 0xF9, 0xF9,
  0xF1, 0xFC, 0x07, 0xF3, 0xE3, 0xE3, 0xF0, 0x0F, 0xEF, 0xC7, 0xCF, 0xE0,
  0x1F, 0x9F, 0x8F, 0x9F, 0x80, 0x3F, 0x3E, 0x1F, 0x7F, 0x00, 0x7E, 0xFC,
  0x3E, 0xFE, 0x00, 0xFD, 0xF0, 0x7D, 0xF8, 0x01, 0xFF, 0xE0, 0xFF, 0xF0,
  0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x0F, 0xFE,
  0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x3F,
  0x87, 0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x3F,
  0x9F, 0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x03, 0xF8,
  0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0xC0,
  0x7F, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFB, 0xF8, 0x0F, 0xF7, 0xF0,
  0x1F, 0xCF, 0xE0, 0x7F, 0x8F, 0xC0, 0xFE, 0x1F, 0x83, 0xF8, 0x3F, 0x87,
  0xF0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0xFE, 0x01, 0xF9, 0xF8,
  0x03, 0xF7, 0xF0, 0x07, 0xEF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x00, 0xFC,
  0x1F, 0x81, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xE0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0xFD, 0xF0, 0x00, 0xFD, 0xF0, 0x01, 0xF9, 0xF8, 0x01, 0xF1,
  0xF8, 0x03, 0xF0, 0xF8, 0x07, 0xE0, 0xF8, 0x07, 0xE0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x1F, 0x80, 0x7C, 0x1F, 0x80, 0x7C, 0x3F, 0x00, 0x7E, 0x3E, 0x00,
  0x7E, 0x7E, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0x7F, 0xFF, 0xEF, 0xFF, 0xFB,
  0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0xFF, 0x1F, 0xC7, 0xF8, 0xFE, 0x1F, 0x87,
  0xE0, 0xFC, 0x1F, 0x00, 0xFE, 0x1F, 0x80, 0xFF, 0x9F, 0x80, 0xFF, 0xEF,
  0xC0, 0xFF, 0xF7, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0x87,
  0xF8, 0x3F, 0x83, 0xFC, 0x3F, 0xC0, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0,
  0x3F, 0x0F, 0xF0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC,
  0x07, 0xF0, 0xFE, 0x03, 0xF0, 0x7F, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x3F,
  0x80, 0xFE, 0x1F, 0xC0, 0xFF, 0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x7F, 0x81,
  0xFE, 0x7F, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFB, 0xF0,
  0x0F, 0xF9, 0xF8, 0x03, 0xF8, 0xFC, 0x00, 0x20, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF1, 0xF8, 0x03, 0xF7,
  0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xFC,
  0xFF, 0x07, 0xF0, 0x7F, 0x0F, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0,
  0x7F, 0x0F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0x80,
  0x7F, 0x1F, 0x80, 0x7F, 0x1F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80,
  0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x83, 0xFC, 0x7F, 0x83,
  0xF8, 0x7F, 0xC7, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7D, 0xFF,
  0xC0, 0xFC, 0xFF, 0x80, 0xF8, 0x7F, 0x00, 0x00, 0x08, 0x00, 0x00, 0x3F,
  0xE0, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFE, 0xF0, 0x7F, 0x80, 0x83, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x81, 0xFF, 0x3C, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xF8, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0xF3, 0xF0, 0x07,
  0xFF, 0x7E, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x0F, 0xF3, 0xFE,
  0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x03, 0xF8, 0x0F, 0xE0,
  0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x3F, 0x00,
  0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x07,
  0xF0, 0x3F, 0x80, 0xFF, 0x0F, 0xF0, 0x0F, 0xE3, 0xFE, 0x01, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xBE, 0x00, 0x7F, 0xE7, 0xC0, 0x07,
  0xF1, 0xF8, 0x00, 0x10, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0x87, 0xF1, 0xFC,
  0x0F, 0xC7, 0xF0, 0x3F, 0x3F, 0x81, 0xFC, 0xFE, 0x07, 0xE3, 0xF0, 0x3F,
  0x9F, 0xC7, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x1F,
  0xFF, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x01, 0x07, 0xF0, 0x1C, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0x0F,
  0xF9, 0xF8, 0x03, 0xFF, 0xBF, 0x00, 0xFF, 0xF7, 0xE0, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0x83, 0xFC, 0x0F, 0xF0,
  0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x81,
  0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03,
  0xF0, 0x3F, 0xC0, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x03, 0xF8, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xFB, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xBF, 0x00, 0x3F,
  0xEF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x18, 0x03,
  0xFC, 0x03, 0xF9, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF1, 0xF8, 0x03, 0xF7,
  0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x07, 0xF8, 0x7F, 0x0F, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0,
  0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xC0, 0x7E, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0,
  0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0x80, 0xFC, 0x3F, 0x80, 0xFC, 0x3F, 0x81,
  0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x01, 0xF8, 0x7F, 0x01,
  0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7E, 0x03, 0xF8, 0x7E, 0x03,
  0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0x00, 0x38, 0x01, 0xF8, 0x03,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7E, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xC0, 0x7F, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0xE0, 0x7F, 0x0F, 0xF0,
  0x1F, 0xC3, 0xF8, 0x07, 0xE1, 0xFC, 0x01, 0xF8, 0xFE, 0x00, 0xFE, 0x7F,
  0x00, 0x3F, 0xBF, 0xC0, 0x0F, 0xCF, 0xE0, 0x03, 0xF7, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xDF, 0xC0, 0x0F, 0xE7, 0xF0,
  0x03, 0xF0, 0xFE, 0x00, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3,
  0xF8, 0x07, 0xE0, 0x7F, 0x01, 0xF8, 0x1F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F,
  0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x03, 0xE1, 0xF8, 0x1F,
  0xC0, 0x3E, 0x7F, 0xC3, 0xFE, 0x07, 0xEF, 0xFE, 0x7F, 0xF0, 0x7F, 0xFF,
  0xEF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xDF, 0xFE, 0xFF, 0x07,
  0xF8, 0x7F, 0x87, 0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0x0F, 0xE0, 0x7F, 0x07,
  0xF0, 0xFE, 0x07, 0xF0, 0x7F, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0xFC, 0x0F,
  0xE0, 0x7F, 0x1F, 0xC0, 0xFE, 0x07, 0xE1, 0xFC, 0x0F, 0xC0, 0xFE, 0x1F,
  0x80, 0xFC, 0x0F, 0xE1, 0xF8, 0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x0F,
  0xC3, 0xF8, 0x1F, 0xC0, 0xFC, 0x3F, 0x81, 0xF8, 0x1F, 0xC3, 0xF0, 0x1F,
  0x81, 0xFC, 0x3F, 0x03, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x81, 0xF8, 0x7F,
  0x03, 0xF8, 0x1F, 0x87, 0xF0, 0x3F, 0x03, 0xF8, 0x7E, 0x03, 0xF0, 0x3F,
  0x87, 0xE0, 0x7F, 0x03, 0xF8, 0xFE, 0x07, 0xF0, 0x3F, 0x0F, 0xE0, 0x7E,
  0x07, 0xF0, 0x03, 0xE1, 0xF8, 0x03, 0xE7, 0xFC, 0x07, 0xEF, 0xFE, 0x07,
  0xEF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xF8, 0x7F, 0x0F,
  0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7E, 0x0F,
  0xC0, 0x7E, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F,
  0x80, 0xFC, 0x3F, 0x80, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F,
  0x81, 0xFC, 0x3F, 0x01, 0xF8, 0x7F, 0x01, 0xF8, 0x7F, 0x03, 0xF8, 0x7F,
  0x03, 0xF8, 0x7E, 0x03, 0xF8, 0x7E, 0x03, 0xF0, 0xFE, 0x03, 0xF0, 0xFE,
  0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFE, 0x1F, 0xC7, 0xF0, 0x3F,
  0x3F, 0x80, 0xFC, 0xFE, 0x03, 0xF3, 0xF8, 0x0F, 0xDF, 0xC0, 0x3F, 0x7F,
  0x00, 0xFD, 0xFC, 0x07, 0xF7, 0xF0, 0x1F, 0xDF, 0x80, 0x7F, 0x7E, 0x01,
  0xFF, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0x80, 0xFE, 0xFE, 0x07, 0xF1,
  0xFC, 0x3F, 0xC7, 0xF9, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7C,
  0x3F, 0x00, 0x0F, 0x9F, 0xF0, 0x03, 0xF7, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0x3F, 0xC0, 0x3F, 0x83, 0xF8, 0x0F, 0xF0,
  0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x3F, 0x80,
  0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFC, 0x03,
  0xF8, 0x1F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x07, 0xF8, 0x1F, 0xE0, 0xFE,
  0x03, 0xFE, 0x3F, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFB,
  0xFF, 0x80, 0x7F, 0x7F, 0xE0, 0x0F, 0xE7, 0xF0, 0x01, 0xFC, 0x10, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x1F, 0x80, 0xFF, 0xCF, 0x80, 0xFF, 0xEF, 0xC0, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0x9F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F,
  0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x07,
  0xE0, 0x1F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0,
  0xFC, 0x03, 0xF0, 0xFE, 0x01, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFE,
  0x1F, 0xC0, 0x7E, 0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x7F, 0x83, 0xFE, 0x7F,
  0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFB, 0xF0, 0x0F, 0xFB,
  0xF8, 0x03, 0xF9, 0xFC, 0x00, 0x20, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xE1, 0xF0, 0x3E, 0x7F, 0x07,
  0xEF, 0xF0, 0x7E, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0x07, 0xFF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xE1, 0xFE, 0x1E, 0x1F, 0xC0, 0x41, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x88, 0x03, 0xF8, 0xF0,
  0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x07,
  0xFF, 0x00, 0x01, 0x00, 0x00, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03,
  0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7F,
  0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x10, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F,
  0xE0, 0x04, 0x00, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x7F, 0x03, 0xF8,
  0xFE, 0x07, 0xF1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x8F, 0xE0, 0x7F, 0x1F,
  0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE3, 0xF8,
  0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F, 0x1F, 0x80, 0xFC, 0x3F, 0x03,
  0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0x87, 0xE0, 0x7F,
  0x0F, 0xC0, 0xFE, 0x1F, 0x83, 0xFC, 0x3F, 0x8F, 0xF8, 0x7F, 0xFF, 0xE0,
  0xFF, 0xF7, 0xC1, 0xFF, 0xDF, 0x81, 0xFF, 0x3F, 0x01, 0xFC, 0x7E, 0x00,
  0x40, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xEF, 0xC0, 0x3F, 0xBF,
  0x01, 0xFC, 0xFC, 0x07, 0xF3, 0xF0, 0x1F, 0x8F, 0xE0, 0xFE, 0x3F, 0x83,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7E, 0x0F, 0xE3, 0xF8, 0x1F, 0x8F, 0xC0,
  0x7E, 0x3F, 0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0xBF, 0x80, 0x7E,
  0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFC, 0x07, 0xF0, 0x1F,
  0xFF, 0x01, 0xFC, 0x0F, 0xEF, 0xC0, 0xFF, 0x03, 0xFB, 0xF0, 0x3F, 0xC0,
  0xFC, 0xFC, 0x1F, 0xF0, 0x7F, 0x3F, 0x07, 0xFC, 0x1F, 0x8F, 0xC1, 0xFF,
  0x0F, 0xE3, 0xF0, 0xFF, 0xC3, 0xF0, 0xFC, 0x3F, 0xF0, 0xFC, 0x3F, 0x1F,
  0xFC, 0x7F, 0x0F, 0xC7, 0xDF, 0x1F, 0x83, 0xF1, 0xF7, 0xCF, 0xE0, 0xFC,
  0xF9, 0xF3, 0xF0, 0x3F, 0x3E, 0x7C, 0xFC, 0x0F, 0xDF, 0x9F, 0x7F, 0x03,
  0xF7, 0xC7, 0xDF, 0x80, 0xFD, 0xF1, 0xF7, 0xE0, 0x3F, 0xF8, 0x7F, 0xF0,
  0x0F, 0xFE, 0x1F, 0xFC, 0x03, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0xC1, 0xFF,
  0x80, 0x3F, 0xF0, 0x7F, 0xE0, 0x0F, 0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x07,
  0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x0F, 0xF0,
  0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x1F,
  0xC0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xC3, 0xFC, 0x00, 0xFE, 0x3F,
  0x80, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xEF, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x7F, 0x3F, 0x80,
  0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x03, 0xF8,
  0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xC0,
  0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF0, 0x7F, 0x00, 0x1F,
  0x83, 0xF8, 0x00, 0xFC, 0x3F, 0x80, 0x07, 0xE1, 0xFC, 0x00, 0x3F, 0x1F,
  0xC0, 0x01, 0xF8, 0xFE, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0x7F, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0xFD, 0xF8, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x1B, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x7F,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x07,
  0xFE, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x7C, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x00,
  0xFF, 0xE0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0xFF, 0xE0,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0xC0, 0x05, 0xFF, 0xC0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x03, 0xFF, 0xA0, 0x01, 0xFC,
};

const GFXglyph NotoSans_Condensed_BoldItalic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 15, 37, 13, 0, -36 },
  { 71, 18, 13, 21, 5, -36 },
  { 101, 28, 36, 27, 0, -36 },
  { 227, 25, 42, 24, 0, -39 },
  { 359, 34, 37, 38, 3, -37 },
  { 517, 29, 38, 29, 0, -37 },
  { 655, 9, 13, 13, 5, -36 },
  { 670, 18, 44, 15, 1, -36 },
  { 769, 18, 45, 15, -4, -37 },
  { 871, 21, 22, 23, 4, -39 },
  { 929, 22, 24, 25, 2, -30 },
  { 995, 12, 14, 13, -3, -7 },
  { 1016, 13, 6, 15, 1, -17 },
  { 1026, 8, 9, 13, 0, -8 },
  { 1035, 27, 37, 20, -3, -37 },
  { 1160, 23, 38, 24, 1, -37 },
  { 1270, 17, 36, 24, 5, -36 },
  { 1347, 26, 37, 24, -2, -37 },
  { 1468, 24, 38, 24, 0, -37 },
  { 1582, 25, 37, 24, -1, -37 },
  { 1698, 24, 37, 24, 0, -36 },
  { 1809, 23, 38, 24, 2, -37 },
  { 1919, 25, 36, 24, 1, -36 },
  { 2032, 24, 38, 24, 0, -37 },
  { 2146, 23, 38, 24, 1, -37 },
  { 2256, 13, 29, 13, 0, -28 },
  { 2304, 16, 35, 13, -3, -28 },
  { 2374, 22, 25, 25, 2, -31 },
  { 2443, 22, 16, 25, 2, -26 },
  { 2487, 22, 25, 25, 2, -31 },
  { 2556, 19, 38, 19, 2, -37 },
  { 2647, 34, 41, 36, 2, -37 },
  { 2822, 26, 37, 26, -3, -37 },
  { 2943, 27, 36, 26, 0, -36 },
  { 3065, 26, 38, 25, 2, -37 },
  { 3189, 28, 36, 29, 0, -36 },
  { 3315, 25, 36, 23, 0, -36 },
  { 3428, 25, 36, 22, 0, -36 },
  { 3541, 28, 38, 29, 2, -37 },
  { 3674, 31, 36, 30, 0, -36 },
  { 3814, 23, 36, 17, -2, -36 },
  { 3918, 23, 47, 14, -8, -36 },
  { 4054, 31, 36, 26, 0, -36 },
  { 4194, 18, 36, 22, 0, -36 },
  { 4275, 40, 36, 38, 0, -36 },
  { 4455, 33, 36, 32, 0, -36 },
  { 4604, 28, 38, 31, 2, -37 },
  { 4737, 27, 36, 26, 0, -36 },
  { 4859, 28, 46, 31, 2, -37 },
  { 5020, 26, 36, 26, 0, -36 },
  { 5137, 25, 38, 23, 0, -37 },
  { 5256, 22, 36, 22, 4, -36 },
  { 5355, 28, 37, 29, 2, -36 },
  { 5485, 25, 36, 26, 5, -36 },
  { 5598, 39, 36, 39, 4, -36 },
  { 5774, 32, 36, 25, -3, -36 },
  { 5918, 23, 36, 24, 5, -36 },
  { 6022, 27, 36, 22, -2, -36 },
  { 6144, 21, 45, 15, -2, -37 },
  { 6263, 11, 37, 20, 5, -37 },
  { 6314, 21, 45, 15, -4, -37 },
  { 6433, 24, 22, 24, 0, -36 },
  { 6499, 19, 4, 18, -5, 4 },
  { 6509, 10, 8, 16, 7, -39 },
  { 6519, 25, 29, 26, 1, -28 },
  { 6610, 24, 40, 26, 0, -39 },
  { 6730, 21, 29, 21, 1, -28 },
  { 6807, 27, 40, 26, 1, -39 },
  { 6942, 22, 29, 24, 1, -28 },
  { 7022, 27, 51, 16, -6, -39 },
  { 7195, 27, 40, 26, -1, -28 },
  { 7330, 24, 39, 26, 0, -39 },
  { 7447, 15, 39, 13, 0, -39 },
  { 7521, 21, 51, 13, -6, -39 },
  { 7655, 26, 39, 24, 0, -39 },
  { 7782, 15, 39, 13, 0, -39 },
  { 7856, 36, 28, 38, 0, -28 },
  { 7982, 24, 28, 26, 0, -28 },
  { 8066, 22, 29, 25, 1, -28 },
  { 8146, 27, 40, 26, -3, -28 },
  { 8281, 25, 40, 26, 1, -28 },
  { 8406, 20, 28, 18, 0, -28 },
  { 8476, 20, 29, 20, 0, -28 },
  { 8549, 16, 35, 17, 2, -34 },
  { 8619, 23, 29, 25, 2, -28 },
  { 8703, 22, 28, 22, 3, -28 },
  { 8780, 34, 28, 34, 3, -28 },
  { 8899, 28, 28, 23, -3, -28 },
  { 8997, 29, 40, 22, -4, -28 },
  { 9142, 23, 28, 19, -2, -28 },
  { 9223, 21, 44, 18, 0, -36 },
  { 9339, 5, 51, 22, 8, -39 },
  { 9371, 20, 44, 18, -3, -36 },
  { 9481, 22, 8, 25, 2, -22 },
};

const GFXfont NotoSans_Condensed_BoldItalic51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BoldItalic51pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BoldItalic51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_CONDENSED_BOLDITALIC51PT7B_H_
