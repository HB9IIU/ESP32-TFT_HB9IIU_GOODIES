#ifndef _NOTOSANS_CONDENSED_BOLDITALIC29PT7B_H_
#define _NOTOSANS_CONDENSED_BOLDITALIC29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BoldItalic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BoldItalic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0x83, 0xC1, 0xE1, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x0E,
  0x0F, 0x07, 0x83, 0xC1, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x3E, 0x1F, 0x0F,
  0x00, 0x7B, 0xDC, 0xF7, 0x3B, 0xCE, 0xF3, 0xB9, 0xEE, 0x73, 0x9C, 0x01,
  0xCE, 0x01, 0xCE, 0x01, 0x8C, 0x03, 0x9C, 0x03, 0x9C, 0x03, 0x1C, 0x3F,
  0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x0E, 0x30, 0x0E, 0x70, 0x0E, 0x70, 0x7F,
  0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x18, 0xE0, 0x39, 0xC0, 0x39, 0xC0, 0x31,
  0xC0, 0x71, 0x80, 0x73, 0x80, 0x00, 0x60, 0x01, 0x00, 0x1F, 0x01, 0xFF,
  0x0F, 0xF8, 0x7F, 0xE1, 0xE8, 0x87, 0x20, 0x1F, 0x80, 0x7E, 0x01, 0xFC,
  0x03, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x2F, 0x00, 0xBC, 0x42, 0xF1, 0xFF,
  0xCF, 0xFE, 0x3F, 0xF0, 0x3F, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x1E,
  0x03, 0x87, 0xE0, 0xE1, 0xFC, 0x1C, 0x3B, 0x87, 0x0E, 0x71, 0xC1, 0xCE,
  0x38, 0x39, 0xCE, 0x07, 0x39, 0xC0, 0xC7, 0x73, 0x99, 0xDC, 0xFB, 0xFB,
  0xBF, 0xFE, 0xEE, 0x77, 0x9D, 0xCE, 0x07, 0x39, 0xC1, 0xCE, 0x38, 0x39,
  0xC6, 0x0E, 0x39, 0xC1, 0xC7, 0x38, 0x70, 0xEE, 0x1C, 0x1F, 0xC7, 0x81,
  0xF0, 0x01, 0xF0, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F,
  0x38, 0x0F, 0x78, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xC0, 0x0F, 0xC7, 0x3F,
  0xCF, 0x3F, 0xCF, 0x79, 0xFE, 0x71, 0xFC, 0xF0, 0xFC, 0xF0, 0xF8, 0xF9,
  0xF8, 0x7F, 0xFC, 0x7F, 0xFC, 0x3F, 0x3E, 0x7B, 0x9D, 0xEF, 0x73, 0x9C,
  0x03, 0xC1, 0xE0, 0xF0, 0x38, 0x1E, 0x07, 0x03, 0xC0, 0xE0, 0x78, 0x1E,
  0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0x70, 0x1C, 0x00, 0x07, 0x80, 0xE0,
  0x38, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x0F,
  0x03, 0xC1, 0xE0, 0x70, 0x38, 0x00, 0x07, 0x80, 0x78, 0x47, 0x07, 0x70,
  0x7F, 0xFF, 0xFF, 0x0F, 0xF1, 0xF0, 0x3F, 0x87, 0xBC, 0x31, 0xC1, 0x18,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1E,
  0x3C, 0xF1, 0xE3, 0x8F, 0x1C, 0x78, 0x7F, 0x7F, 0x7F, 0xFF, 0x7F, 0xFF,
  0xE0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0xFF, 0x1F, 0xF1, 0xEF, 0x3C,
  0x73, 0xC7, 0x78, 0x77, 0x87, 0x78, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x1E, 0xE1, 0xEE, 0x1E, 0xE3, 0xCF, 0x7C, 0xFF, 0x87, 0xF0, 0x7E,
  0x00, 0x03, 0xC1, 0xE0, 0xF8, 0xFE, 0x7F, 0xBF, 0xEF, 0x71, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x38, 0x00, 0x01, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0,
  0xE3, 0xE0, 0x87, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xFF, 0xC7, 0xFF, 0x8F, 0xFE, 0x00, 0x03, 0xE0, 0x3F, 0xE1,
  0xFF, 0x83, 0x9F, 0x08, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x01, 0xF0,
  0x3F, 0x80, 0xFC, 0x03, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x01, 0xF3, 0x0F, 0x8F, 0xFE, 0x3F, 0xF0, 0xFF, 0x00, 0x00, 0x3C, 0x01,
  0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x0F, 0xE0, 0x77, 0x01, 0xFC, 0x0E,
  0xF0, 0x73, 0xC1, 0xCF, 0x0E, 0x38, 0x71, 0xE3, 0xC7, 0x8F, 0xFF, 0xBF,
  0xFC, 0xFF, 0xF0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x07, 0xFC,
  0x3F, 0xF0, 0xFF, 0x83, 0xFE, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00,
  0x1F, 0xC0, 0xFF, 0x83, 0xFF, 0x04, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x81, 0xF3, 0x0F, 0x8F, 0xFC, 0x3F, 0xF0, 0xFF, 0x00, 0x00,
  0xF8, 0x1F, 0xC1, 0xFE, 0x1F, 0x11, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00,
  0x7F, 0xE3, 0xBF, 0x3F, 0xF9, 0xF1, 0xEF, 0x0F, 0x78, 0x7B, 0xC3, 0x9E,
  0x3C, 0xF1, 0xE7, 0x9E, 0x3F, 0xF0, 0xFF, 0x03, 0xF0, 0x00, 0x3F, 0xFC,
  0xFF, 0xF3, 0xFF, 0xCF, 0xFE, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0,
  0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x00, 0x03,
  0xF0, 0x1F, 0xE0, 0xFF, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0x87,
  0x9E, 0x0F, 0xF0, 0x3F, 0x80, 0xFC, 0x07, 0xF8, 0x7D, 0xF1, 0xE3, 0xCF,
  0x0F, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3, 0xC7, 0xFE, 0x1F, 0xF0, 0x3F, 0x80,
  0x03, 0xE0, 0x7F, 0x83, 0xFE, 0x3F, 0xF3, 0xE7, 0x9E, 0x1C, 0xF1, 0xE7,
  0x8F, 0x38, 0x79, 0xE7, 0xCF, 0xFE, 0x7F, 0xF1, 0xF7, 0x07, 0x78, 0x03,
  0xC0, 0x3C, 0x01, 0xE4, 0x3E, 0x3F, 0xE1, 0xFE, 0x0F, 0xE0, 0x00, 0x0E,
  0x3C, 0x78, 0xF0, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x9F, 0x3E,
  0x78, 0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0xF0, 0xF0, 0x78, 0x38, 0x3C, 0x1C, 0x1E, 0x00,
  0x00, 0x08, 0x00, 0xC0, 0x1E, 0x03, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0x80, 0x1C, 0x00,
  0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x06, 0x00, 0x3C, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0x01, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x0F,
  0x80, 0x70, 0x02, 0x00, 0x00, 0x0F, 0x8F, 0xF8, 0xFF, 0x9C, 0xF2, 0x1E,
  0x03, 0xC0, 0x70, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x03, 0x80, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x03, 0xE0, 0x78, 0x0F, 0x00, 0x00, 0x7E,
  0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x07, 0x80, 0xE1, 0xE0, 0x0E, 0x38, 0x01,
  0xCE, 0x3F, 0x99, 0x8F, 0xF3, 0x73, 0x8C, 0x6E, 0x73, 0x8F, 0x9C, 0x73,
  0xF3, 0x8E, 0x7E, 0x71, 0x8F, 0xCE, 0x71, 0xB9, 0xCE, 0x77, 0x3F, 0xFC,
  0xE7, 0xDF, 0x1C, 0x71, 0xC3, 0x80, 0x00, 0x38, 0x00, 0x07, 0x81, 0x80,
  0x7F, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0xFC, 0x01, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x77, 0x81, 0xEF, 0x03, 0xDE, 0x0F, 0x3C,
  0x1E, 0x78, 0x38, 0xF0, 0xFF, 0xE1, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0x3C,
  0x1E, 0x78, 0x3D, 0xE0, 0x7B, 0xC0, 0xFF, 0x81, 0xE0, 0x0F, 0xF0, 0x1F,
  0xF8, 0x3F, 0xF8, 0x7F, 0xF0, 0xF1, 0xE3, 0xC3, 0xC7, 0x87, 0x8F, 0x1F,
  0x1E, 0x7C, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0xC3, 0xC7, 0x87, 0x87, 0x8E,
  0x0F, 0x3C, 0x3C, 0x78, 0x78, 0xF1, 0xF1, 0xFF, 0xC7, 0xFF, 0x0F, 0xF8,
  0x00, 0x01, 0xF8, 0x07, 0xFC, 0x3F, 0xF0, 0x7F, 0xE1, 0xF0, 0x47, 0xC0,
  0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0xC1, 0xFF,
  0x81, 0xFF, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x0F, 0xF8, 0x0F, 0xFE, 0x0F,
  0xFE, 0x0F, 0x1F, 0x1E, 0x1F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E,
  0x0F, 0x3C, 0x1F, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x3C, 0x78,
  0x7C, 0x78, 0xF8, 0x7F, 0xF8, 0x7F, 0xF0, 0xFF, 0xC0, 0xFF, 0x00, 0x0F,
  0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFE, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x7F, 0xC3, 0xFF, 0x0F, 0xF8, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xFC, 0x3F, 0xF0, 0xFF, 0xC0,
  0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFE, 0x0F, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x7F, 0xC3, 0xFF, 0x0F, 0xF8, 0x3F, 0xE0, 0xF0,
  0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0,
  0x00, 0x00, 0xFC, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0x02, 0x3E,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0xFE, 0x78, 0xFE, 0xF8,
  0xFC, 0xF0, 0xFC, 0xF0, 0x3C, 0xF0, 0x3C, 0xF8, 0x3C, 0xF8, 0x78, 0x7C,
  0x78, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF0, 0x0F, 0x83, 0xC3, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x87, 0x83, 0xE1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF8, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC3, 0xE1, 0xF0, 0xF0, 0x78, 0x00, 0x0F, 0xF8, 0x7F, 0xC3, 0xFC,
  0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x1F, 0xC1, 0xFF, 0x0F, 0xF0, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x17, 0xE0,
  0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0x07, 0x87, 0x87, 0xC3, 0xC7,
  0xC1, 0xE3, 0xC0, 0xF3, 0xC0, 0xF3, 0xE0, 0x79, 0xE0, 0x3D, 0xE0, 0x1F,
  0xE0, 0x0E, 0xF0, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xEF, 0x00,
  0xE7, 0x80, 0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x1E, 0x0F,
  0x0F, 0x07, 0x80, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03,
  0xC0, 0x78, 0x0F, 0x05, 0xFF, 0x7F, 0xEF, 0xFC, 0x0F, 0xC0, 0x7C, 0x3F,
  0x01, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC1, 0xFC, 0x7F, 0x07,
  0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1D, 0xC7, 0xF8, 0x77, 0x1D, 0xE3,
  0xDC, 0xF7, 0x0F, 0x73, 0xBC, 0x3D, 0xDE, 0xF0, 0xE7, 0x73, 0xC3, 0x9D,
  0xCE, 0x1E, 0x7E, 0x38, 0x79, 0xF9, 0xE1, 0xE7, 0xC7, 0x87, 0x1F, 0x1E,
  0x3C, 0x78, 0x70, 0xF1, 0xE3, 0xC0, 0x0F, 0x81, 0xE1, 0xF0, 0x38, 0x3E,
  0x07, 0x07, 0xE1, 0xE0, 0xFC, 0x3C, 0x3F, 0x87, 0x87, 0xF0, 0xE0, 0xEF,
  0x1C, 0x1D, 0xE7, 0x83, 0xBC, 0xF0, 0xF3, 0x9E, 0x1E, 0x73, 0x83, 0xCF,
  0x70, 0x71, 0xFE, 0x0E, 0x1F, 0xC3, 0xC3, 0xF0, 0x78, 0x7E, 0x0E, 0x0F,
  0xC1, 0xC1, 0xF8, 0x78, 0x1F, 0x0F, 0x03, 0xC0, 0x01, 0xF8, 0x07, 0xFC,
  0x0F, 0xFE, 0x1F, 0xBE, 0x1E, 0x1F, 0x3E, 0x0F, 0x3C, 0x0F, 0x7C, 0x0F,
  0x78, 0x0F, 0x78, 0x0F, 0x78, 0x1F, 0xF8, 0x1F, 0xF8, 0x1E, 0xF0, 0x1E,
  0xF0, 0x3E, 0xF0, 0x3C, 0xF8, 0x7C, 0x7D, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0,
  0x1F, 0xC0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF0, 0xF1, 0xE3,
  0xC3, 0xC7, 0x87, 0x8F, 0x0F, 0x1E, 0x1E, 0x3C, 0x7C, 0xFF, 0xF1, 0xFF,
  0xC3, 0xFF, 0x07, 0xF0, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xFC, 0x0F, 0xFE,
  0x1F, 0xFE, 0x1E, 0x1F, 0x3E, 0x0F, 0x3C, 0x0F, 0x7C, 0x0F, 0x78, 0x0F,
  0x78, 0x0F, 0x78, 0x1F, 0xF8, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3E,
  0xF0, 0x3C, 0xF8, 0x7C, 0x7C, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0,
  0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x0F, 0xE0,
  0x1F, 0xF0, 0x3F, 0xF0, 0x7F, 0xF0, 0xF1, 0xE3, 0xC3, 0xC7, 0x87, 0x8F,
  0x1F, 0x1E, 0x3C, 0x38, 0xF8, 0xFF, 0xE1, 0xFF, 0x83, 0xFE, 0x07, 0xBC,
  0x0E, 0x78, 0x3C, 0x78, 0x78, 0xF0, 0xF1, 0xE1, 0xE3, 0xC7, 0x83, 0xCF,
  0x07, 0x80, 0x03, 0xF0, 0x1F, 0xF0, 0xFF, 0x87, 0xFE, 0x1E, 0x08, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x81, 0xE3, 0x8F, 0x8F, 0xFC, 0x3F,
  0xE0, 0xFF, 0x00, 0x7F, 0xFB, 0xFF, 0xDF, 0xFD, 0xFF, 0xE0, 0xF0, 0x07,
  0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x00, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x1E,
  0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x7C, 0x3C, 0x78, 0x3C,
  0x78, 0x3C, 0x78, 0x3C, 0x78, 0x7C, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0xF8,
  0xF9, 0xF0, 0x7F, 0xF0, 0x7F, 0xE0, 0x1F, 0x80, 0xE0, 0x3F, 0x80, 0xFE,
  0x07, 0xB8, 0x1E, 0xE0, 0xF3, 0xC3, 0xCF, 0x1E, 0x3C, 0x78, 0xF3, 0xC3,
  0xCF, 0x0F, 0x38, 0x3D, 0xE0, 0xF7, 0x83, 0xFC, 0x0F, 0xF0, 0x3B, 0x80,
  0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x00, 0x70, 0x38, 0x1E,
  0xE0, 0xF0, 0x79, 0xC1, 0xE0, 0xF3, 0x83, 0xC3, 0xC7, 0x0F, 0x87, 0x8E,
  0x1F, 0x0E, 0x1C, 0x7E, 0x3C, 0x78, 0xFC, 0x78, 0xF1, 0xF9, 0xE1, 0xE7,
  0x73, 0xC3, 0xCE, 0xE7, 0x07, 0xBD, 0xDE, 0x0F, 0x73, 0xBC, 0x1F, 0xE7,
  0x70, 0x3F, 0x8F, 0xE0, 0x7F, 0x1F, 0x80, 0xFE, 0x3F, 0x01, 0xF8, 0x7E,
  0x03, 0xF0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xC0, 0x00, 0x07, 0x83,
  0xC1, 0xE1, 0xF0, 0x3C, 0x78, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF7, 0x80,
  0x3D, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3D, 0xE0, 0x1E, 0x78,
  0x07, 0x8F, 0x03, 0xC3, 0xC1, 0xE0, 0xF0, 0xF8, 0x3C, 0x00, 0xF0, 0x7F,
  0x87, 0xBC, 0x3D, 0xE3, 0xCF, 0x1E, 0x79, 0xE1, 0xCE, 0x0E, 0xF0, 0x7F,
  0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x0F, 0xFE, 0x1F,
  0xFC, 0x3F, 0xF8, 0x7F, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xFF, 0xC7, 0xFF, 0x8F, 0xFE,
  0x00, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00,
  0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x03,
  0xC0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x0F,
  0xE0, 0xFE, 0x0F, 0xC0, 0xE3, 0xCF, 0x3C, 0x71, 0xC7, 0x1C, 0x71, 0xE7,
  0x8E, 0x38, 0xE3, 0x8E, 0x3C, 0xF3, 0xC7, 0x1C, 0x07, 0xF0, 0x7E, 0x07,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0x00,
  0xC0, 0x0E, 0x00, 0x78, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x39, 0xC3, 0xCE,
  0x1C, 0x71, 0xE3, 0x8E, 0x0E, 0xE0, 0x7F, 0x03, 0x80, 0xFF, 0xE0, 0xF9,
  0xE3, 0x8F, 0x0F, 0x3C, 0x7E, 0xE3, 0xFF, 0x8F, 0x3E, 0x78, 0xF9, 0xE3,
  0xCF, 0x0F, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x1E, 0x3C, 0x78, 0xF3,
  0xE3, 0xFF, 0x8F, 0xFE, 0x1F, 0x70, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x78, 0x01, 0xEF, 0x07, 0xFE, 0x1F, 0xF8, 0x79, 0xF3,
  0xC3, 0xCF, 0x0F, 0x3C, 0x3C, 0xE0, 0xF3, 0x87, 0x9E, 0x1E, 0x78, 0x79,
  0xE3, 0xC7, 0x8F, 0x1F, 0xF8, 0xFF, 0xE3, 0x9E, 0x00, 0x07, 0xE3, 0xFC,
  0xFF, 0x9E, 0x27, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x19, 0xFF, 0x1F, 0xE1, 0xF8, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x83, 0xCE, 0x0F, 0xDC, 0x3F, 0xF8,
  0x79, 0xF1, 0xE3, 0xE3, 0xC7, 0x8F, 0x0F, 0x1E, 0x1E, 0x3C, 0x3C, 0x78,
  0x78, 0xF0, 0xE1, 0xE3, 0xC3, 0xCF, 0x87, 0xFF, 0x0F, 0xFE, 0x0F, 0xB8,
  0x00, 0x07, 0xC1, 0xFE, 0x3F, 0xF3, 0xCF, 0x78, 0xF7, 0x8F, 0xF3, 0xEF,
  0xFC, 0xFF, 0x8F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x4F, 0xFC, 0x7F, 0xC3,
  0xF8, 0x00, 0x3E, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x1E, 0x00, 0x3C,
  0x00, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x01,
  0x78, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0x07, 0x9E, 0x1F, 0xB8,
  0x7F, 0xF0, 0xF3, 0xE3, 0xC7, 0xC7, 0x8F, 0x1F, 0x1E, 0x3C, 0x3C, 0x78,
  0x78, 0xF0, 0xF1, 0xE3, 0xC3, 0xC7, 0x87, 0x9F, 0x0F, 0xFE, 0x1F, 0xFC,
  0x1F, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x86, 0x3E, 0x0F, 0xFC, 0x1F,
  0xF0, 0x1F, 0x80, 0x00, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x38, 0x01, 0xEF, 0x07, 0xFE, 0x1F, 0xFC, 0x7D, 0xF3, 0xE3, 0xCF,
  0x0E, 0x3C, 0x78, 0xF1, 0xE3, 0x87, 0x9E, 0x1E, 0x78, 0x71, 0xE3, 0xC7,
  0x8F, 0x1C, 0x3C, 0xF0, 0xF3, 0xC7, 0x80, 0x07, 0x0F, 0x0F, 0x0F, 0x00,
  0x00, 0x1E, 0x1E, 0x1E, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x78, 0x78,
  0x78, 0x78, 0x70, 0xF0, 0xF0, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x0B, 0xE0, 0xFE, 0x0F, 0xC0, 0xF8,
  0x00, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x87, 0x8F, 0x1E, 0x1E, 0x78, 0x39, 0xE0, 0xF7, 0x81, 0xEF, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x7B, 0xC0, 0xF3, 0xC1, 0xC7,
  0x83, 0x8F, 0x0F, 0x0F, 0x1E, 0x1E, 0x00, 0x07, 0x87, 0x83, 0xC1, 0xE0,
  0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0E, 0x0F, 0x07, 0x80, 0x1C, 0xF1, 0xE0, 0xEF,
  0xDF, 0x87, 0xFF, 0xFE, 0x3E, 0xFD, 0xF3, 0xE3, 0xC7, 0x9E, 0x3C, 0x38,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x38, 0x78, 0xF3, 0xC3, 0x87, 0x9E, 0x3C,
  0x38, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x38, 0x78, 0xF3, 0xC3, 0x87, 0x9E,
  0x3C, 0x78, 0x1C, 0xF0, 0x77, 0xE1, 0xFF, 0x87, 0xDF, 0x3E, 0x3C, 0xF0,
  0xE3, 0xC7, 0x8F, 0x1E, 0x38, 0x79, 0xE1, 0xE7, 0x87, 0x1E, 0x3C, 0x78,
  0xF1, 0xC3, 0xCF, 0x0F, 0x3C, 0x38, 0x07, 0xC1, 0xFE, 0x3F, 0xF3, 0xCF,
  0x78, 0xF7, 0x87, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1E,
  0xF3, 0xEF, 0xFC, 0x7F, 0x83, 0xF0, 0x0E, 0x78, 0x1D, 0xF8, 0x3F, 0xF0,
  0x79, 0xF1, 0xF1, 0xE3, 0xC3, 0xC7, 0x87, 0x8E, 0x0F, 0x1C, 0x3C, 0x78,
  0x78, 0xF0, 0xF1, 0xE3, 0xC3, 0xC7, 0x87, 0xFE, 0x1F, 0xFC, 0x3D, 0xF0,
  0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0x00, 0x0F, 0xBC, 0x7E, 0xE3, 0xFF, 0x8F, 0x3E, 0x78, 0xF9, 0xE3,
  0xCF, 0x0F, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x0E, 0x3C, 0x78, 0xF3,
  0xE3, 0xFF, 0x8F, 0xFE, 0x1F, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0x1C, 0xF1, 0xDE, 0x1F, 0xE1,
  0xFE, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0xC1, 0xFF, 0x3F, 0xE3,
  0xC4, 0x3C, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xC0,
  0x3C, 0x87, 0xCF, 0xF8, 0xFF, 0x8F, 0xE0, 0x0E, 0x07, 0x07, 0x87, 0xF7,
  0xFF, 0xFC, 0xF0, 0x70, 0x38, 0x3C, 0x1E, 0x0F, 0x07, 0x07, 0x83, 0xC1,
  0xE0, 0xFE, 0x7F, 0x1F, 0x80, 0x3C, 0x39, 0xE3, 0xCF, 0x1E, 0x70, 0xF7,
  0x87, 0xBC, 0x39, 0xE3, 0xCE, 0x1E, 0x70, 0xF7, 0x87, 0x3C, 0x79, 0xE3,
  0xCF, 0x3E, 0x7F, 0xF3, 0xFF, 0x0F, 0xB8, 0xE0, 0xFE, 0x0F, 0xE1, 0xEE,
  0x1E, 0xE3, 0xCE, 0x3C, 0xE7, 0x8E, 0x78, 0xF7, 0x0E, 0xF0, 0xEE, 0x0F,
  0xE0, 0xFC, 0x0F, 0xC0, 0xF8, 0x07, 0x80, 0xE1, 0xE1, 0xFC, 0x3C, 0x3B,
  0x8F, 0x8F, 0x71, 0xF1, 0xCE, 0x7E, 0x79, 0xCF, 0xCF, 0x39, 0xF9, 0xC7,
  0x77, 0x78, 0xEE, 0xEE, 0x1D, 0x9F, 0xC3, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F,
  0x8F, 0xC1, 0xF1, 0xF0, 0x3C, 0x3E, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x3C,
  0x78, 0x3C, 0xF0, 0x7B, 0xC0, 0xFF, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFF, 0x03, 0xDE, 0x0F, 0x3C, 0x1E,
  0x3C, 0x78, 0x78, 0x0E, 0x0F, 0x0F, 0x0F, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F,
  0x3C, 0x0F, 0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x70, 0x0F, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x9E, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF0,
  0x00, 0x0F, 0xF8, 0xFF, 0x87, 0xFC, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x07, 0x80, 0x3F, 0xE3,
  0xFF, 0x1F, 0xF8, 0x00, 0x30, 0x1F, 0x03, 0xE0, 0x7E, 0x07, 0x80, 0x78,
  0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x07, 0xE0, 0x78, 0x0F, 0x80,
  0xFC, 0x03, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80,
  0x3E, 0x03, 0xE0, 0x1E, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x78,
  0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38,
  0x03, 0xC0, 0x3F, 0x01, 0xF0, 0x3E, 0x07, 0xE0, 0xF8, 0x0F, 0x00, 0xF0,
  0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0xFC, 0x0F, 0xC0, 0xF8, 0x08, 0x00,
  0x10, 0x0B, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0x00,
};

const GFXglyph NotoSans_Condensed_BoldItalic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 9, 21, 8, 0, -21 },
  { 25, 10, 8, 12, 3, -21 },
  { 35, 16, 21, 15, 0, -21 },
  { 77, 14, 24, 13, 0, -22 },
  { 119, 19, 21, 22, 2, -21 },
  { 169, 16, 21, 17, 0, -21 },
  { 211, 5, 8, 7, 3, -21 },
  { 216, 10, 26, 8, 1, -21 },
  { 249, 10, 26, 9, -2, -21 },
  { 282, 12, 12, 13, 2, -22 },
  { 300, 13, 14, 14, 1, -17 },
  { 323, 7, 8, 7, -2, -4 },
  { 330, 8, 4, 9, 0, -10 },
  { 334, 5, 4, 7, 0, -4 },
  { 337, 15, 21, 11, -1, -21 },
  { 377, 12, 21, 13, 1, -21 },
  { 409, 10, 21, 14, 3, -21 },
  { 436, 15, 21, 13, -1, -21 },
  { 476, 14, 21, 13, 0, -21 },
  { 513, 14, 21, 14, 0, -21 },
  { 550, 14, 21, 13, 0, -21 },
  { 587, 13, 21, 13, 1, -21 },
  { 622, 14, 21, 13, 1, -21 },
  { 659, 14, 21, 13, 0, -21 },
  { 696, 13, 21, 13, 0, -21 },
  { 731, 7, 16, 7, 0, -16 },
  { 745, 9, 20, 7, -2, -16 },
  { 768, 13, 15, 14, 1, -18 },
  { 793, 13, 9, 14, 1, -15 },
  { 808, 13, 15, 14, 1, -18 },
  { 833, 11, 21, 11, 1, -21 },
  { 862, 19, 23, 21, 1, -21 },
  { 917, 15, 21, 15, -2, -21 },
  { 957, 15, 21, 15, 0, -21 },
  { 997, 15, 21, 14, 1, -21 },
  { 1037, 16, 21, 16, 0, -21 },
  { 1079, 14, 21, 13, 0, -21 },
  { 1116, 14, 21, 12, 0, -21 },
  { 1153, 16, 21, 17, 1, -21 },
  { 1195, 18, 21, 17, 0, -21 },
  { 1243, 13, 21, 10, -1, -21 },
  { 1278, 14, 27, 8, -5, -21 },
  { 1326, 17, 21, 15, 0, -21 },
  { 1371, 11, 21, 12, 0, -21 },
  { 1400, 22, 21, 22, 0, -21 },
  { 1458, 19, 21, 18, 0, -21 },
  { 1508, 16, 21, 17, 1, -21 },
  { 1550, 15, 21, 15, 0, -21 },
  { 1590, 16, 26, 17, 1, -21 },
  { 1642, 15, 21, 15, 0, -21 },
  { 1682, 14, 21, 13, 0, -21 },
  { 1719, 13, 21, 13, 2, -21 },
  { 1754, 16, 21, 17, 1, -21 },
  { 1796, 14, 21, 15, 3, -21 },
  { 1833, 23, 21, 22, 2, -21 },
  { 1894, 18, 21, 14, -2, -21 },
  { 1942, 13, 21, 14, 3, -21 },
  { 1977, 15, 21, 13, -1, -21 },
  { 2017, 12, 26, 9, -1, -21 },
  { 2056, 6, 21, 11, 3, -21 },
  { 2072, 12, 26, 9, -2, -21 },
  { 2111, 13, 13, 14, 0, -21 },
  { 2133, 11, 1, 10, -3, 3 },
  { 2135, 6, 4, 9, 4, -22 },
  { 2138, 14, 16, 15, 1, -16 },
  { 2166, 14, 22, 15, 0, -22 },
  { 2205, 11, 16, 12, 1, -16 },
  { 2227, 15, 22, 15, 1, -22 },
  { 2269, 12, 16, 13, 1, -16 },
  { 2293, 15, 29, 9, -3, -22 },
  { 2348, 15, 23, 15, 0, -16 },
  { 2392, 14, 22, 15, 0, -22 },
  { 2431, 8, 22, 7, 0, -22 },
  { 2453, 12, 29, 7, -4, -22 },
  { 2497, 15, 22, 14, 0, -22 },
  { 2539, 9, 22, 7, 0, -22 },
  { 2564, 21, 16, 21, 0, -16 },
  { 2606, 14, 16, 15, 0, -16 },
  { 2634, 12, 16, 14, 1, -16 },
  { 2658, 15, 23, 15, -1, -16 },
  { 2702, 14, 23, 15, 1, -16 },
  { 2743, 12, 16, 10, 0, -16 },
  { 2767, 12, 16, 11, 0, -16 },
  { 2791, 9, 19, 9, 1, -19 },
  { 2813, 13, 16, 14, 1, -16 },
  { 2839, 12, 16, 13, 2, -16 },
  { 2863, 19, 16, 19, 2, -16 },
  { 2901, 15, 16, 13, -1, -16 },
  { 2931, 16, 23, 13, -2, -16 },
  { 2977, 13, 16, 11, -1, -16 },
  { 3003, 12, 26, 10, 0, -21 },
  { 3042, 4, 29, 12, 4, -22 },
  { 3057, 12, 26, 10, -2, -21 },
  { 3096, 13, 5, 14, 1, -13 },
};

const GFXfont NotoSans_Condensed_BoldItalic29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BoldItalic29pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BoldItalic29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_CONDENSED_BOLDITALIC29PT7B_H_
