#ifndef _NOTOSANS_CONDENSED_BOLDITALIC60PT7B_H_
#define _NOTOSANS_CONDENSED_BOLDITALIC60PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BoldItalic.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BoldItalic60pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07,
  0xF0, 0x00, 0x60, 0x00, 0x3F, 0xC7, 0xF9, 0xFE, 0x3F, 0xCF, 0xE1, 0xFC,
  0x7F, 0x0F, 0xE7, 0xF8, 0x7F, 0x3F, 0x87, 0xF9, 0xFC, 0x3F, 0x8F, 0xE1,
  0xFC, 0x7F, 0x0F, 0xE3, 0xF0, 0x7E, 0x1F, 0x83, 0xF1, 0xFC, 0x1F, 0x8F,
  0xC1, 0xFC, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0x00, 0x01,
  0xF8, 0x7E, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x7E, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x1F, 0x83, 0xE0, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x07, 0xE0, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF0, 0x7E, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x03, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x00, 0xF8, 0x3F, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0,
  0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xEE, 0x3C, 0x01, 0xFE, 0x70, 0x60, 0x0F,
  0xE3, 0x80, 0x00, 0x7F, 0x1C, 0x00, 0x03, 0xF8, 0xC0, 0x00, 0x1F, 0xEE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x19, 0xFE,
  0x00, 0x01, 0xCF, 0xF8, 0x00, 0x0E, 0x7F, 0x82, 0x00, 0x73, 0xFC, 0x1C,
  0x03, 0x9F, 0xE0, 0xF8, 0x39, 0xFF, 0x07, 0xF9, 0xDF, 0xF8, 0x3F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x03,
  0xFF, 0x00, 0x07, 0xE0, 0x07, 0xFF, 0x80, 0x07, 0xE0, 0x0F, 0xFF, 0xC0,
  0x0F, 0xC0, 0x0F, 0xFF, 0xC0, 0x1F, 0x80, 0x1F, 0xCF, 0xC0, 0x1F, 0x80,
  0x1F, 0x8F, 0xC0, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x0F,
  0xC0, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0xFC,
  0x00, 0x7E, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC1, 0xF8, 0x00, 0x7E,
  0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x1F, 0xC7, 0xE0, 0x00, 0xFC, 0x1F, 0x87,
  0xE0, 0x00, 0xFC, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x3F, 0x8F, 0xC3, 0xF8,
  0xFC, 0x3F, 0x1F, 0x8F, 0xFC, 0xFC, 0x3F, 0x3F, 0x1F, 0xFE, 0xFE, 0x7E,
  0x3F, 0x3F, 0xFE, 0x7F, 0xFE, 0x7E, 0x3F, 0xFF, 0x7F, 0xFC, 0xFE, 0x7F,
  0x3F, 0x7F, 0xF8, 0xFC, 0x7E, 0x3F, 0x3F, 0xF1, 0xF8, 0xFC, 0x3F, 0x1F,
  0xE1, 0xF8, 0xFC, 0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x3F, 0x00, 0x07, 0xF1,
  0xF8, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x3F,
  0x00, 0x0F, 0xC3, 0xF0, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x7E, 0x00, 0x3F,
  0x83, 0xF0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x03, 0xF0,
  0xFE, 0x00, 0x7E, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x03, 0xF1, 0xFC, 0x01,
  0xFC, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0x03, 0xFF, 0xF8, 0x03, 0xF0, 0x01,
  0xFF, 0xF0, 0x03, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xE0, 0x00, 0xFF, 0xC0,
  0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x07, 0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x03, 0xFC, 0x3F,
  0xC0, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x07, 0xF3,
  0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF0, 0x3F, 0xC0, 0x7F, 0xFC, 0x0F, 0xF0, 0x3F, 0xFF, 0x03, 0xF8,
  0x1F, 0xFF, 0xE1, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0x87, 0xFD, 0xFF, 0x3F,
  0xC1, 0xFE, 0x3F, 0xCF, 0xF0, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xC1, 0xFF,
  0xFE, 0x1F, 0xE0, 0x7F, 0xFF, 0x07, 0xF8, 0x0F, 0xFF, 0x81, 0xFE, 0x03,
  0xFF, 0xE0, 0x7F, 0x80, 0xFF, 0xF0, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xF8,
  0x07, 0xFE, 0x01, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xE3, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF7, 0xFC, 0x03, 0xFF, 0xF1, 0xFF, 0x00, 0x7F, 0xF0, 0x7F,
  0xE0, 0x03, 0x80, 0x00, 0x00, 0x3F, 0xCF, 0xF3, 0xF8, 0xFE, 0x7F, 0x9F,
  0xE7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xE3, 0xF8, 0xFE, 0x3F, 0x0F, 0xC3,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x40, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x20, 0x3F, 0x00, 0x38, 0x3F, 0x00, 0x7E,
  0x3F, 0x00, 0x7F, 0xBE, 0x03, 0x7F, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x1F, 0xEF, 0xC0, 0x3F,
  0xCF, 0xC0, 0x7F, 0x8F, 0xE0, 0x1F, 0x87, 0xF0, 0x0F, 0x07, 0xF0, 0x06,
  0x07, 0xE0, 0x02, 0x07, 0x80, 0x00, 0x02, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x7F,
  0x83, 0xFE, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0xFF,
  0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0x7F,
  0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFC, 0x1F, 0x0F, 0xE7, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFE, 0x7F, 0x06, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x1F, 0xF0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0xFF, 0x03,
  0xFC, 0x1F, 0xE0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x1F,
  0xE0, 0x3F, 0xC7, 0xF8, 0x07, 0xF8, 0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x1F,
  0xE7, 0xF8, 0x03, 0xFC, 0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x1F, 0xE3, 0xFC,
  0x03, 0xFC, 0xFF, 0x00, 0x7F, 0x9F, 0xE0, 0x0F, 0xF3, 0xFC, 0x03, 0xFE,
  0x7F, 0x80, 0x7F, 0x8F, 0xF0, 0x0F, 0xF1, 0xFE, 0x01, 0xFE, 0x3F, 0x80,
  0x7F, 0xCF, 0xF0, 0x0F, 0xF1, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0xC7,
  0xF8, 0x0F, 0xF0, 0xFF, 0x03, 0xFE, 0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x1F,
  0xF0, 0x3F, 0xC7, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x03,
  0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF,
  0xFB, 0xFC, 0xFF, 0x3F, 0xC7, 0xE3, 0xF8, 0x3C, 0x7F, 0x81, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0x81, 0xFF, 0x00, 0x7C, 0x07, 0xFC, 0x01, 0xE0, 0x0F, 0xF0, 0x02, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x0F, 0x01, 0xFF, 0x00, 0x40, 0x0F, 0xF0, 0x08, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x80, 0x01, 0xFF, 0x0E, 0x00, 0x7F, 0xE0, 0xFC, 0x1F, 0xFE, 0x0F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7D, 0xFE, 0x00,
  0x07, 0xEF, 0xE0, 0x00, 0x7E, 0x7F, 0x00, 0x07, 0xE7, 0xF8, 0x00, 0x3F,
  0x3F, 0xC0, 0x03, 0xF1, 0xFE, 0x00, 0x3F, 0x0F, 0xE0, 0x01, 0xF8, 0x7F,
  0x00, 0x1F, 0x87, 0xF8, 0x01, 0xF8, 0x3F, 0xC0, 0x1F, 0xC1, 0xFE, 0x00,
  0xFC, 0x0F, 0xE0, 0x0F, 0xC0, 0xFF, 0x00, 0xFE, 0x07, 0xF8, 0x07, 0xE0,
  0x3F, 0xC0, 0x7E, 0x01, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00,
  0x40, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x30, 0x00, 0xFF, 0xC1, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0x3C, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xC1, 0xE0, 0x03, 0xFC, 0xFF, 0x80, 0x3F, 0xDF, 0xFC, 0x03, 0xFB,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x07, 0xFE, 0x1F, 0xF0, 0xFF, 0xC0, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0xFF,
  0x80, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F,
  0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0x01, 0xFE, 0x0F,
  0xF0, 0x1F, 0xE0, 0xFF, 0x03, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x87,
  0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xF8, 0x3F, 0xE0, 0x7F, 0x81, 0xFF, 0x03,
  0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x07, 0xF8,
  0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x7F,
  0x80, 0x3F, 0xC7, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0x8F, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0x07,
  0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x1F, 0xE0,
  0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x03, 0xFC, 0x3F, 0xE0, 0x1F,
  0xE1, 0xFF, 0x01, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFE, 0x07, 0xFC, 0x3F, 0xC1, 0xFF, 0x07, 0xFC, 0x3F, 0xC0, 0x7F, 0x8F,
  0xF8, 0x0F, 0xF1, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xC7, 0xF8, 0x07,
  0xF8, 0xFF, 0x01, 0xFF, 0x3F, 0xC0, 0x3F, 0xE7, 0xF8, 0x07, 0xF8, 0xFF,
  0x01, 0xFF, 0x1F, 0xE0, 0x3F, 0xE3, 0xFE, 0x0F, 0xFC, 0x7F, 0xC3, 0xFF,
  0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFD, 0xFE, 0x03, 0xFF, 0x7F, 0x80, 0x1F, 0x0F, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x01, 0xE1, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFF, 0x03, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0x00, 0x30, 0x00, 0x00, 0x1F,
  0x80, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xF0,
  0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07,
  0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xF1, 0xFF,
  0x87, 0x00, 0xFF, 0x0C, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00,
  0x3E, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x07,
  0xE0, 0x3F, 0xFE, 0x1F, 0x0F, 0xC0, 0x7F, 0xFE, 0x1F, 0x0F, 0xC1, 0xFF,
  0xFE, 0x1F, 0x1F, 0x81, 0xFF, 0xFC, 0x1F, 0x1F, 0x03, 0xF0, 0xFC, 0x1F,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x3F, 0x0F, 0xC0, 0xFC, 0x1F, 0x3E, 0x0F,
  0xC0, 0xF8, 0x1F, 0x7E, 0x0F, 0x81, 0xF8, 0x3F, 0x7E, 0x1F, 0x81, 0xF8,
  0x3F, 0x7C, 0x1F, 0x81, 0xF8, 0x3E, 0x7C, 0x1F, 0x01, 0xF0, 0x3E, 0xFC,
  0x3F, 0x03, 0xF0, 0x7E, 0xFC, 0x3F, 0x03, 0xF0, 0x7E, 0xFC, 0x3F, 0x03,
  0xF0, 0x7C, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0xF8, 0x3F, 0x07, 0xE0, 0xF8,
  0xF8, 0x3F, 0x0F, 0xE1, 0xF8, 0xF8, 0x3F, 0x0F, 0xE1, 0xF0, 0xF8, 0x3F,
  0xBF, 0xF7, 0xF0, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0xF8, 0x1F, 0xF9, 0xFF,
  0xC0, 0xFC, 0x1F, 0xF9, 0xFF, 0x80, 0xFC, 0x07, 0xE0, 0xFE, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x60, 0x00, 0x1F, 0xF0, 0x03, 0xE0, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01,
  0xFB, 0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F,
  0x9F, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xFE, 0x7F, 0x00, 0x03, 0xF8,
  0xFE, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x87,
  0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x01, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x3F,
  0xC0, 0x0F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x81, 0xFE,
  0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x3F,
  0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF1, 0xFF, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0xFF, 0x7F, 0xC0,
  0x01, 0xFE, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x80, 0x7F, 0x81, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x03,
  0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xFE,
  0x03, 0xFC, 0x0F, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x3F, 0xE0, 0x1F,
  0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x81, 0xFE,
  0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF0,
  0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xF0, 0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x00,
  0xFF, 0x81, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00,
  0xFF, 0xE0, 0x78, 0x07, 0xFE, 0x00, 0x60, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x40, 0x3F, 0xF8, 0x0E, 0x00,
  0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x01,
  0xFE, 0x3F, 0xFE, 0x00, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80,
  0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xC0, 0x1F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF8,
  0x0F, 0xF0, 0x07, 0xFC, 0x0F, 0xF8, 0x03, 0xFE, 0x07, 0xF8, 0x01, 0xFF,
  0x03, 0xFC, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x3F,
  0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x07,
  0xF8, 0x1F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xF8, 0x01,
  0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x81, 0xFE, 0x00,
  0x7F, 0xC1, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0x80,
  0x3F, 0xF0, 0x3F, 0xC0, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xF0, 0x3F, 0xF8, 0x07, 0xF8, 0x7F, 0xF8, 0x03, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x7C,
  0x07, 0xFF, 0x00, 0x08, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0xFC,
  0xFF, 0x80, 0xFF, 0xF8, 0xFF, 0x80, 0xFF, 0xF8, 0xFF, 0x81, 0xFF, 0xF8,
  0xFF, 0x81, 0xFF, 0xF8, 0xFF, 0x01, 0xFF, 0xF8, 0xFF, 0x01, 0xFF, 0xF0,
  0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0,
  0xFF, 0x80, 0x1F, 0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0xC0, 0x3F, 0xC0,
  0x7F, 0xE0, 0x3F, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x0F,
  0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00,
  0x3F, 0xC0, 0x1F, 0xE0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x1F,
  0xE0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x07, 0xF8,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x03, 0xFC, 0x01, 0xFF,
  0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0xC0,
  0x1F, 0xE0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x07,
  0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xF0,
  0x07, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x07, 0xF8, 0x07,
  0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF,
  0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x07, 0xFC, 0x00,
  0x1F, 0xE0, 0xFF, 0x80, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE1, 0xFF,
  0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x03, 0xFC,
  0x7F, 0x80, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00,
  0x3F, 0xDF, 0xE0, 0x00, 0x03, 0xFB, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x00, 0xFF, 0x1F, 0xE0,
  0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03,
  0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x03, 0xFC, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x03, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0x80,
  0x7F, 0xC0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x07,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xF9, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xF8,
  0x01, 0xFD, 0xFC, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x0F, 0xFF, 0xE0,
  0x07, 0xF7, 0xF0, 0x3F, 0xBF, 0xC0, 0x0F, 0xEF, 0xE0, 0x7F, 0x7F, 0x80,
  0x3F, 0xDF, 0xC1, 0xFC, 0xFE, 0x00, 0x7F, 0xBF, 0x83, 0xF9, 0xFC, 0x00,
  0xFE, 0x7F, 0x07, 0xE7, 0xF8, 0x01, 0xFC, 0xFE, 0x1F, 0xCF, 0xF0, 0x07,
  0xF9, 0xFC, 0x3F, 0x1F, 0xE0, 0x0F, 0xF3, 0xF8, 0xFE, 0x3F, 0x80, 0x1F,
  0xC7, 0xF1, 0xF8, 0x7F, 0x00, 0x3F, 0x87, 0xE7, 0xF1, 0xFE, 0x00, 0x7F,
  0x0F, 0xCF, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xBF, 0x87, 0xF0, 0x03, 0xFC,
  0x3F, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0xFC, 0x3F, 0xC0, 0x0F, 0xE0,
  0xFF, 0xF8, 0x7F, 0x80, 0x1F, 0xC1, 0xFF, 0xE0, 0xFF, 0x00, 0x7F, 0x83,
  0xFF, 0xC1, 0xFC, 0x00, 0xFF, 0x07, 0xFF, 0x03, 0xF8, 0x01, 0xFC, 0x0F,
  0xFE, 0x0F, 0xF0, 0x03, 0xF8, 0x1F, 0xF8, 0x1F, 0xE0, 0x07, 0xF0, 0x3F,
  0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0xFF,
  0x80, 0xFE, 0x00, 0x7F, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x03, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0xF0,
  0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x0F, 0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xFE,
  0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFC,
  0x00, 0xFF, 0xF0, 0x07, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xF0, 0x07, 0xFF,
  0xE0, 0x1F, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0x80, 0x1F, 0xFF, 0x80, 0x7F,
  0x00, 0x3F, 0xFF, 0x01, 0xFE, 0x00, 0xFE, 0xFF, 0x03, 0xFC, 0x01, 0xFC,
  0xFE, 0x07, 0xF0, 0x03, 0xF9, 0xFC, 0x0F, 0xE0, 0x07, 0xF3, 0xF8, 0x3F,
  0xC0, 0x0F, 0xE7, 0xF8, 0x7F, 0x80, 0x3F, 0xCF, 0xF0, 0xFF, 0x00, 0x7F,
  0x8F, 0xE1, 0xFC, 0x00, 0xFE, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x8F,
  0xF0, 0x07, 0xF8, 0x7F, 0x9F, 0xE0, 0x0F, 0xF0, 0x7F, 0x3F, 0xC0, 0x1F,
  0xC0, 0xFE, 0x7F, 0x00, 0x3F, 0x81, 0xFC, 0xFE, 0x00, 0x7F, 0x03, 0xFD,
  0xFC, 0x01, 0xFE, 0x07, 0xFF, 0xF8, 0x03, 0xFC, 0x07, 0xFF, 0xE0, 0x07,
  0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xC0, 0x3F,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xF8, 0x01,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xF0, 0x03,
  0xFF, 0xC0, 0x1F, 0xE0, 0x03, 0xFF, 0x80, 0x3F, 0x80, 0x07, 0xFE, 0x00,
  0x7F, 0x00, 0x0F, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0xF8, 0x03, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x0F,
  0xF8, 0x01, 0xFF, 0x1F, 0xF8, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0x1F,
  0xE0, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0x7F,
  0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F,
  0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0xFF,
  0x80, 0x01, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF,
  0x00, 0x03, 0xFE, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x07, 0xFC, 0xFF,
  0x00, 0x07, 0xFC, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x0F, 0xF8, 0xFF,
  0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF,
  0x80, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x07, 0xFF, 0x00,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFF, 0x01,
  0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFF, 0x03,
  0xFE, 0x01, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x03,
  0xFC, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x07,
  0xF8, 0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x0F,
  0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0x1F, 0xF8, 0x01, 0xFF, 0x1F,
  0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0x3F,
  0xE0, 0x00, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F,
  0xC0, 0x01, 0xFF, 0x7F, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFE, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF,
  0x80, 0x03, 0xFE, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x07, 0xFC, 0xFF,
  0x00, 0x07, 0xFC, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x0F, 0xF8, 0xFF,
  0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x1F, 0xF0, 0xFF,
  0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F,
  0x83, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x07,
  0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x7F, 0xE0, 0x3F, 0xC1, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x3F, 0xC7, 0xF0, 0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x03,
  0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F,
  0xE0, 0xFF, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0xFF, 0x03, 0xFE, 0x01, 0xFE,
  0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0xE0,
  0x1F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x00,
  0x7F, 0xC3, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xF0, 0x78, 0x03,
  0xFE, 0x00, 0xC0, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x04, 0x00, 0x0F, 0xF0, 0x38, 0x00, 0xFF,
  0x81, 0xF0, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x81, 0xFE,
  0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x1F, 0xE0, 0x7F,
  0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x0F,
  0xF0, 0x03, 0xFC, 0x0F, 0xF8, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3F, 0xC0,
  0xFF, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF8,
  0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xF0, 0x03, 0xFC, 0x0F, 0xF8, 0x01, 0xFE,
  0x07, 0xF8, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x7F,
  0x81, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x1F,
  0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xF0, 0x03,
  0xFC, 0x0F, 0xF0, 0x03, 0xFE, 0x07, 0xF8, 0x01, 0xFF, 0x03, 0xFC, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0x80,
  0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x3F, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0x9F, 0xC0, 0x01, 0xFE, 0x7F,
  0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x3F, 0xC7, 0xF0, 0x01, 0xFF, 0x1F, 0xC0,
  0x07, 0xF8, 0x7F, 0x00, 0x3F, 0xE1, 0xFC, 0x00, 0xFF, 0x07, 0xF0, 0x03,
  0xFC, 0x1F, 0xC0, 0x1F, 0xE0, 0x7F, 0x00, 0x7F, 0x81, 0xFC, 0x03, 0xFC,
  0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x80, 0x7F, 0x01, 0xFE, 0x01,
  0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F,
  0x87, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x1F, 0xE3,
  0xFC, 0x00, 0x7F, 0x8F, 0xE0, 0x01, 0xFE, 0x7F, 0x80, 0x07, 0xF9, 0xFC,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x7F, 0xBF, 0xC0, 0x01, 0xFC, 0xFE, 0x00,
  0x07, 0xF7, 0xF8, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x3F, 0x7F, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xEF, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0xBF, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF3, 0xFC, 0x01, 0xFF, 0x00, 0x3F,
  0xCF, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8,
  0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xC3, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x0F,
  0xF0, 0x1F, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0xF0, 0x1F, 0xE0, 0xFF,
  0x01, 0xFF, 0xC0, 0x7F, 0x83, 0xFC, 0x0F, 0xFF, 0x01, 0xFC, 0x0F, 0xF0,
  0x3F, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0x07,
  0xEF, 0xC1, 0xFE, 0x03, 0xFC, 0x3F, 0xBF, 0x07, 0xF8, 0x0F, 0xF0, 0xFE,
  0xFC, 0x1F, 0xC0, 0x3F, 0xC3, 0xF3, 0xF0, 0xFF, 0x00, 0xFF, 0x1F, 0xCF,
  0xC3, 0xFC, 0x03, 0xFC, 0x7F, 0x3F, 0x1F, 0xE0, 0x0F, 0xE3, 0xF8, 0xFC,
  0x7F, 0x80, 0x3F, 0x8F, 0xE3, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x0F, 0xCF,
  0xF0, 0x03, 0xF9, 0xFC, 0x3F, 0x3F, 0xC0, 0x0F, 0xE7, 0xF0, 0xFD, 0xFE,
  0x00, 0x3F, 0xBF, 0x83, 0xF7, 0xF8, 0x00, 0xFE, 0xFE, 0x0F, 0xDF, 0xC0,
  0x03, 0xFB, 0xF0, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x00,
  0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x3F, 0xC0, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00,
  0x1F, 0xE1, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0xFF,
  0x00, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xDF, 0xC0, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0xC7,
  0xF8, 0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x01,
  0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xF8,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0x80,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xF7, 0xF8, 0x01, 0xFF,
  0x7F, 0x80, 0x3F, 0xE7, 0xF8, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0xC7, 0xF8,
  0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x83, 0xF8, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE,
  0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x3F,
  0xC7, 0xF8, 0x01, 0xFC, 0x7F, 0x80, 0x1F, 0xCF, 0xF0, 0x01, 0xFD, 0xFE,
  0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x3F, 0x80,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x7F, 0x3F, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0xFC, 0x3F,
  0x80, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x07,
  0xF0, 0x1F, 0xC0, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xC1, 0xFC, 0x00,
  0xFC, 0x1F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xEF,
  0xF0, 0x00, 0x7F, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0x9F, 0xF1, 0xFE, 0x3F, 0xC3, 0xFC, 0x3F, 0x87, 0xF0,
  0x7F, 0x07, 0xE0, 0x7C, 0x00, 0x7F, 0x87, 0xF0, 0x0F, 0xFC, 0x7F, 0x01,
  0xFF, 0xEF, 0xF0, 0x3F, 0xFE, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF0, 0x7F, 0xC3,
  0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x7F, 0xC0,
  0x7F, 0xC7, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x8F, 0xF8, 0x07, 0xF8,
  0xFF, 0x80, 0x7F, 0x8F, 0xF0, 0x07, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0,
  0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0x01, 0xFE,
  0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x03, 0xFE, 0x0F, 0xF0, 0x7F, 0xE0, 0xFF,
  0x8F, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xDF,
  0xC0, 0x7F, 0xF9, 0xFC, 0x03, 0xFF, 0x1F, 0x80, 0x1F, 0xE1, 0xF8, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x1F, 0x80, 0x07, 0xF3, 0xFF, 0x00, 0x7F, 0xBF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x1F,
  0xE0, 0x3F, 0xE0, 0xFF, 0x01, 0xFF, 0x07, 0xF0, 0x0F, 0xF8, 0x7F, 0x80,
  0x7F, 0x83, 0xFC, 0x03, 0xFC, 0x1F, 0xC0, 0x1F, 0xE0, 0xFE, 0x00, 0xFF,
  0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0xC3, 0xFC, 0x03, 0xFC, 0x1F,
  0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0x7F, 0x80,
  0x7F, 0x83, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x83, 0xFE,
  0x0F, 0xFE, 0x3F, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x00, 0xFC, 0xFF, 0xF0, 0x0F, 0xE7, 0xFF, 0x00, 0x7E, 0x1F,
  0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFF,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC,
  0x0F, 0xFE, 0xF8, 0x1F, 0xF8, 0x08, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x40, 0xFF, 0x80, 0xC0,
  0xFF, 0xC7, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x3F, 0xF3, 0xFC, 0x00, 0xFF,
  0xF7, 0xF8, 0x03, 0xFF, 0xEF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x80, 0x7F, 0xEF, 0xFF, 0x01, 0xFF, 0x07, 0xFE, 0x03, 0xFC, 0x0F,
  0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F,
  0xC0, 0xFF, 0x00, 0x7F, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC,
  0x0F, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xC0,
  0x7F, 0x80, 0x3F, 0x80, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x03,
  0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x7F, 0xC0, 0x3F, 0xC0, 0xFF, 0x80, 0x7F, 0xC7, 0xFE, 0x00, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xEF, 0xE0, 0x03, 0xFF, 0x9F, 0x80, 0x03, 0xFC, 0x3F, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x3F, 0xE1,
  0xFE, 0x3F, 0xE0, 0x7F, 0x1F, 0xE0, 0x3F, 0x9F, 0xE0, 0x1F, 0xCF, 0xF0,
  0x1F, 0xE7, 0xF0, 0x0F, 0xE7, 0xF8, 0x1F, 0xF3, 0xFC, 0x3F, 0xF1, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x08,
  0x3F, 0xE0, 0x1C, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0xF1, 0xFC, 0x00, 0xFF,
  0xF3, 0xF8, 0x03, 0xFF, 0xEF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0x87, 0xFE, 0x03, 0xFE, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0xC0, 0xFF, 0x80, 0xFF, 0x81, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC,
  0x0F, 0xF8, 0x07, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xC0,
  0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x1F,
  0xE0, 0x7F, 0xC0, 0x3F, 0xC1, 0xFF, 0x80, 0x7F, 0xC7, 0xFF, 0x00, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xDF, 0xE0, 0x03, 0xFF, 0x3F, 0x80, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x81,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x20, 0x00, 0xFF, 0x80, 0x70, 0x03, 0xFE,
  0x00, 0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE3, 0xF8, 0x01, 0xFC, 0xFF, 0xC0, 0x3F, 0xDF,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x07, 0xFE, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0x07, 0xFC,
  0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0xFF, 0x80, 0xFF,
  0x0F, 0xF0, 0x0F, 0xE0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFE,
  0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xE1, 0xFE, 0x01, 0xFC, 0x1F, 0xE0, 0x3F,
  0xC1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x3F,
  0xC0, 0x7F, 0x83, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x07,
  0xF8, 0x7F, 0x80, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x07,
  0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x0E,
  0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x7F, 0xC0, 0x7F, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC,
  0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xE0, 0x0F, 0xF0, 0xFF, 0x80, 0x1F, 0xC1,
  0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0xFF, 0x1F, 0xE0, 0x01, 0xFE, 0x7F,
  0x80, 0x03, 0xF9, 0xFF, 0x00, 0x07, 0xF7, 0xFC, 0x00, 0x1F, 0xEF, 0xF0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0xFF, 0x9F, 0xE0, 0x01,
  0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF0, 0x7F, 0x80, 0x0F,
  0xE0, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0xFF,
  0x03, 0xFC, 0x01, 0xFC, 0x07, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xF0,
  0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xF0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xF8, 0x7F, 0x80, 0xFE, 0x00, 0x3F, 0x1F, 0xF8,
  0x3F, 0xF0, 0x0F, 0xE7, 0xFF, 0x9F, 0xFF, 0x01, 0xFD, 0xFF, 0xF7, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFE, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xEF, 0xFF, 0xDF, 0xF8, 0x3F, 0xF0, 0xFF, 0xE1, 0xFF, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xE0, 0xFF, 0x81, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x83, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x1F, 0xE0, 0x1F, 0xC0, 0x7F, 0x83, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC1, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC1, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC1, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x80,
  0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0x01, 0xF8, 0x3F, 0x80, 0x1F, 0x8F, 0xFC, 0x01, 0xF9, 0xFF, 0xE0,
  0x3F, 0xBF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0x7F, 0xFF, 0x03, 0xFF,
  0xFF, 0xF0, 0x7F, 0xE0, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF,
  0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0xFF,
  0x00, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x01, 0xFE, 0x0F, 0xE0, 0x1F,
  0xE1, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xC1, 0xFE, 0x03, 0xFC, 0x1F,
  0xE0, 0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x03,
  0xF8, 0x3F, 0xC0, 0x7F, 0x83, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x87,
  0xF8, 0x07, 0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x00,
  0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x7F, 0xC1, 0xFE, 0x1F,
  0xE0, 0x7F, 0x8F, 0xF8, 0x0F, 0xE3, 0xFC, 0x03, 0xFD, 0xFF, 0x00, 0xFF,
  0x7F, 0x80, 0x3F, 0xDF, 0xE0, 0x0F, 0xF7, 0xF8, 0x03, 0xFB, 0xFC, 0x01,
  0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x1F, 0xEF, 0xF0, 0x07, 0xFB, 0xFC,
  0x01, 0xFE, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x3F, 0xCF, 0xF0, 0x1F, 0xF3,
  0xFC, 0x07, 0xF8, 0xFF, 0x03, 0xFE, 0x3F, 0xC1, 0xFF, 0x0F, 0xFC, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x3F, 0x07, 0xF0, 0x00, 0x3F, 0x1F, 0xF8, 0x00, 0x3F, 0x3F, 0xFC,
  0x00, 0x7F, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x7F, 0xE3, 0xFE, 0x00, 0xFF, 0xC1, 0xFE, 0x00, 0xFF, 0x81, 0xFE,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0xFE, 0x01, 0xFE,
  0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFE,
  0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC,
  0x07, 0xF8, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF8,
  0x07, 0xFC, 0x0F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xFE, 0x3F, 0xE0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xEF, 0xFF, 0x80,
  0x0F, 0xEF, 0xFF, 0x00, 0x1F, 0xE7, 0xFE, 0x00, 0x1F, 0xE3, 0xFC, 0x00,
  0x1F, 0xE0, 0x40, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC3, 0xF8,
  0x03, 0xFF, 0x1F, 0xC0, 0x3F, 0xFC, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFB, 0xFF, 0xC1, 0xFF, 0x07,
  0xFE, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x07, 0xF8, 0x07, 0xF8,
  0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x01, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF,
  0x00, 0xFF, 0x0F, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x01,
  0xFC, 0x1F, 0xE0, 0x0F, 0xE0, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xF8,
  0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x03, 0xFC, 0x1F, 0xF0, 0x1F, 0xE0, 0x7F,
  0x81, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xF1, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xF7, 0xF8,
  0x03, 0xFF, 0x3F, 0x80, 0x0F, 0xF3, 0xFC, 0x00, 0x1C, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xF8, 0x3F, 0x01, 0xF8, 0xFF, 0x03, 0xF9, 0xFE, 0x03, 0xFB, 0xFE, 0x03,
  0xFB, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xF8, 0x3C, 0x0F,
  0xF0, 0x08, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x80, 0x0F, 0xF0, 0xC0, 0x1F, 0xF0, 0xF8, 0x3F, 0xF0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0xFF, 0x0F, 0xFF, 0xE7, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF,
  0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x83, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xF0, 0x83, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0,
  0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0x00, 0x00, 0x07, 0xF0,
  0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xE0, 0xFF, 0x01, 0xFE,
  0x0F, 0xF0, 0x1F, 0xE0, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xE1, 0xFE,
  0x01, 0xFC, 0x1F, 0xE0, 0x3F, 0xC1, 0xFE, 0x03, 0xFC, 0x1F, 0xC0, 0x3F,
  0xC3, 0xFC, 0x03, 0xF8, 0x3F, 0xC0, 0x7F, 0x83, 0xFC, 0x07, 0xF8, 0x3F,
  0xC0, 0x7F, 0x83, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x07, 0xF8, 0x0F,
  0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F,
  0xF0, 0x1F, 0xE0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x03,
  0xFE, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0x8F, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xDF, 0xC0, 0x7F, 0xF9, 0xF8, 0x03, 0xFF,
  0x1F, 0x80, 0x1F, 0xE1, 0xF8, 0x00, 0x30, 0x00, 0x00, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x0F, 0xF7, 0xF0, 0x07, 0xF9, 0xFC, 0x01, 0xFE, 0x7F, 0x00,
  0xFF, 0x1F, 0xC0, 0x3F, 0xC7, 0xF0, 0x1F, 0xE1, 0xFC, 0x07, 0xF8, 0x7F,
  0x03, 0xFC, 0x1F, 0xC0, 0xFF, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0xE0,
  0x7F, 0x07, 0xF0, 0x1F, 0xC3, 0xFC, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x7F,
  0x80, 0x7F, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x07, 0xF3, 0xFC, 0x00, 0xFC,
  0xFE, 0x00, 0x3F, 0x7F, 0x80, 0x0F, 0xDF, 0xC0, 0x03, 0xF7, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFE, 0x01, 0xFF,
  0x01, 0xFF, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xF8, 0x0F, 0xF7,
  0xF0, 0x1F, 0xF0, 0x1F, 0xEF, 0xE0, 0x7F, 0xE0, 0x3F, 0x9F, 0xC0, 0xFF,
  0xC0, 0xFF, 0x3F, 0x83, 0xFF, 0x81, 0xFC, 0x7F, 0x07, 0xFF, 0x07, 0xF8,
  0xFE, 0x0F, 0xFE, 0x0F, 0xF1, 0xFC, 0x3F, 0xFC, 0x1F, 0xC3, 0xF8, 0x7F,
  0xF8, 0x7F, 0x87, 0xF1, 0xFF, 0xF0, 0xFE, 0x0F, 0xE3, 0xF7, 0xE3, 0xFC,
  0x1F, 0xC7, 0xEF, 0xC7, 0xF0, 0x3F, 0x9F, 0x9F, 0x8F, 0xE0, 0x7F, 0x3F,
  0x3F, 0x3F, 0xC0, 0xFE, 0xFE, 0x7E, 0x7F, 0x01, 0xFD, 0xF8, 0xFC, 0xFE,
  0x03, 0xFB, 0xF1, 0xFB, 0xF8, 0x07, 0xFF, 0xC3, 0xF7, 0xF0, 0x0F, 0xDF,
  0x87, 0xEF, 0xC0, 0x1F, 0xBF, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x1F, 0xFF,
  0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x01, 0xFF,
  0xC0, 0xFF, 0xE0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x07, 0xFE, 0x03, 0xFF,
  0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x3F,
  0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x00, 0xFF, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0xFF,
  0x03, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x7F,
  0x8F, 0xF8, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x3F,
  0x9F, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8,
  0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xE0,
  0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x80,
  0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x3F, 0xC0, 0x3F,
  0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x07,
  0xF0, 0x0F, 0xF0, 0x03, 0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00,
  0x1F, 0xE1, 0xFE, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x03, 0xF8, 0xFF, 0x00,
  0x01, 0xFC, 0x7F, 0x80, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x7F, 0x3F, 0xC0,
  0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xCF,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x5F, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x00, 0x7F, 0xFE,
  0x80, 0x07, 0xFE, 0x20, 0x00, 0x1E, 0x00,
};

const GFXglyph NotoSans_Condensed_BoldItalic60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 18, 44, 16, 0, -43 },
  { 100, 21, 16, 25, 6, -43 },
  { 142, 33, 43, 32, 0, -43 },
  { 320, 29, 49, 28, 0, -46 },
  { 498, 40, 44, 45, 3, -43 },
  { 718, 34, 44, 34, 0, -43 },
  { 905, 10, 16, 15, 6, -43 },
  { 925, 21, 52, 17, 1, -43 },
  { 1062, 21, 53, 18, -5, -44 },
  { 1202, 24, 26, 27, 5, -46 },
  { 1280, 26, 29, 30, 3, -36 },
  { 1375, 14, 16, 15, -3, -8 },
  { 1403, 16, 8, 18, 1, -20 },
  { 1419, 10, 10, 15, 0, -9 },
  { 1432, 31, 43, 23, -3, -43 },
  { 1599, 27, 44, 28, 1, -43 },
  { 1748, 20, 43, 28, 6, -43 },
  { 1856, 30, 43, 28, -2, -43 },
  { 2018, 28, 44, 28, 0, -43 },
  { 2172, 29, 43, 28, -1, -43 },
  { 2328, 29, 44, 28, 0, -43 },
  { 2488, 28, 45, 28, 2, -44 },
  { 2646, 29, 43, 28, 2, -43 },
  { 2802, 29, 44, 28, 0, -43 },
  { 2962, 27, 45, 28, 1, -44 },
  { 3114, 15, 34, 15, 0, -33 },
  { 3178, 18, 41, 15, -3, -33 },
  { 3271, 26, 29, 30, 3, -36 },
  { 3366, 26, 18, 30, 3, -30 },
  { 3425, 26, 29, 30, 3, -36 },
  { 3520, 23, 44, 22, 2, -43 },
  { 3647, 40, 48, 43, 2, -43 },
  { 3887, 31, 43, 31, -4, -43 },
  { 4054, 31, 43, 31, 0, -43 },
  { 4221, 30, 44, 29, 3, -43 },
  { 4386, 33, 43, 34, 0, -43 },
  { 4564, 29, 43, 27, 0, -43 },
  { 4720, 29, 43, 26, 0, -43 },
  { 4876, 32, 44, 35, 3, -43 },
  { 5052, 36, 43, 35, 0, -43 },
  { 5246, 26, 43, 20, -2, -43 },
  { 5386, 27, 56, 16, -9, -43 },
  { 5575, 36, 43, 30, 0, -43 },
  { 5769, 22, 43, 26, 0, -43 },
  { 5888, 47, 43, 45, 0, -43 },
  { 6141, 39, 43, 37, 0, -43 },
  { 6351, 32, 45, 36, 3, -44 },
  { 6531, 32, 43, 30, 0, -43 },
  { 6703, 32, 54, 36, 3, -44 },
  { 6919, 31, 43, 31, 0, -43 },
  { 7086, 29, 44, 27, 0, -43 },
  { 7246, 26, 43, 26, 5, -43 },
  { 7386, 33, 44, 34, 3, -43 },
  { 7568, 30, 43, 30, 5, -43 },
  { 7730, 46, 43, 45, 5, -43 },
  { 7978, 37, 43, 29, -3, -43 },
  { 8177, 28, 43, 28, 5, -43 },
  { 8328, 32, 43, 26, -2, -43 },
  { 8500, 24, 53, 18, -2, -43 },
  { 8659, 13, 43, 23, 6, -43 },
  { 8729, 24, 53, 18, -4, -43 },
  { 8888, 28, 26, 28, 0, -43 },
  { 8979, 22, 4, 21, -6, 5 },
  { 8990, 11, 10, 18, 9, -46 },
  { 9004, 28, 34, 30, 2, -33 },
  { 9123, 29, 47, 30, 0, -46 },
  { 9294, 24, 34, 24, 2, -33 },
  { 9396, 31, 47, 30, 2, -46 },
  { 9579, 25, 34, 28, 2, -33 },
  { 9686, 32, 60, 18, -7, -46 },
  { 9926, 31, 47, 30, -1, -33 },
  { 10109, 28, 46, 30, 0, -46 },
  { 10270, 17, 46, 15, 0, -46 },
  { 10368, 25, 60, 15, -8, -46 },
  { 10556, 31, 46, 28, 0, -46 },
  { 10735, 18, 46, 15, 0, -46 },
  { 10839, 43, 33, 44, 0, -33 },
  { 11017, 28, 33, 30, 0, -33 },
  { 11133, 26, 34, 29, 2, -33 },
  { 11244, 32, 47, 30, -3, -33 },
  { 11432, 29, 47, 30, 1, -33 },
  { 11603, 24, 33, 21, 0, -33 },
  { 11702, 24, 34, 24, 0, -33 },
  { 11804, 19, 41, 20, 2, -40 },
  { 11902, 28, 34, 30, 2, -33 },
  { 12021, 26, 33, 26, 3, -33 },
  { 12129, 39, 33, 40, 4, -33 },
  { 12290, 32, 33, 27, -3, -33 },
  { 12422, 33, 47, 26, -4, -33 },
  { 12616, 26, 33, 23, -2, -33 },
  { 12724, 25, 52, 21, 0, -43 },
  { 12887, 7, 60, 26, 9, -46 },
  { 12940, 23, 52, 21, -3, -43 },
  { 13090, 26, 10, 30, 3, -26 },
};

const GFXfont NotoSans_Condensed_BoldItalic60pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BoldItalic60pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BoldItalic60pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _NOTOSANS_CONDENSED_BOLDITALIC60PT7B_H_
