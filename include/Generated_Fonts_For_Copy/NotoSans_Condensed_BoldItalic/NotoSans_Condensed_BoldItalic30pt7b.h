#ifndef _NOTOSANS_CONDENSED_BOLDITALIC30PT7B_H_
#define _NOTOSANS_CONDENSED_BOLDITALIC30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BoldItalic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BoldItalic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0x83, 0xC1, 0xE1, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x0E,
  0x0F, 0x07, 0x83, 0xC1, 0xC0, 0x00, 0x00, 0x20, 0x3C, 0x3E, 0x1F, 0x0F,
  0x00, 0x7B, 0xEE, 0x79, 0xCF, 0x79, 0xCF, 0x39, 0xC7, 0x39, 0xE0, 0x01,
  0xC7, 0x00, 0xE7, 0x00, 0x63, 0x80, 0x71, 0x80, 0x39, 0xC1, 0xFF, 0xFC,
  0xFF, 0xFC, 0x7F, 0xFE, 0x07, 0x38, 0x07, 0x1C, 0x03, 0x9C, 0x01, 0xCE,
  0x07, 0xFF, 0xE7, 0xFF, 0xE3, 0xFF, 0xF0, 0x39, 0xC0, 0x38, 0xE0, 0x1C,
  0xE0, 0x0E, 0x70, 0x0E, 0x38, 0x07, 0x38, 0x00, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x01, 0xFF, 0x0F, 0xFC, 0x7F, 0xE1, 0xED, 0x87, 0xA0, 0x1E, 0x80,
  0x7E, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0xDE,
  0x82, 0x79, 0x0B, 0xE7, 0xFF, 0x3F, 0xFC, 0xFF, 0xC0, 0x7C, 0x00, 0x40,
  0x01, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x43, 0xF0, 0x38, 0x3F, 0x07, 0x07,
  0x38, 0x70, 0x73, 0x8E, 0x0E, 0x38, 0xE0, 0xE7, 0x9C, 0x0E, 0x73, 0x80,
  0xE7, 0x38, 0x0E, 0x77, 0x3C, 0xEE, 0xF7, 0xEF, 0xEE, 0xFE, 0xFD, 0xCE,
  0x73, 0x1D, 0xC7, 0x03, 0x9C, 0xE0, 0x79, 0xCE, 0x07, 0x1C, 0xE0, 0xE1,
  0xCE, 0x0E, 0x19, 0xC1, 0xC1, 0xFC, 0x3C, 0x1F, 0x83, 0x80, 0xF0, 0x00,
  0xE0, 0x01, 0xFC, 0x01, 0xFF, 0x00, 0xF7, 0x80, 0xF3, 0xC0, 0x79, 0xE0,
  0x3C, 0xF0, 0x1E, 0xF0, 0x0F, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x03, 0xF8,
  0xF3, 0xFC, 0xF3, 0xEF, 0x79, 0xE7, 0xF9, 0xF1, 0xFC, 0xF0, 0xFC, 0x78,
  0x3E, 0x3E, 0x7F, 0x0F, 0xFF, 0x87, 0xFF, 0xE1, 0xF8, 0xF0, 0x7B, 0xDD,
  0xEF, 0x73, 0x80, 0x03, 0xC1, 0xE0, 0xF0, 0x38, 0x1E, 0x07, 0x03, 0xC0,
  0xE0, 0x78, 0x1E, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0x03, 0xC0, 0x70, 0x1C, 0x00,
  0x07, 0x80, 0xE0, 0x38, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x81, 0xC0, 0xF0,
  0x3C, 0x0E, 0x07, 0x81, 0xC0, 0xF0, 0x78, 0x1C, 0x0E, 0x00, 0x03, 0x80,
  0x38, 0x43, 0x87, 0x70, 0x7F, 0x3F, 0xFF, 0x1F, 0xF0, 0xFF, 0x1F, 0x83,
  0xFC, 0x79, 0xC1, 0x1E, 0x11, 0x80, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x1E, 0x3C, 0xF1, 0xE3, 0xCF,
  0x1E, 0x78, 0x7F, 0x7F, 0x7F, 0xFF, 0x23, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x01, 0xC0, 0x3F, 0x83, 0xFC, 0x3F,
  0xF3, 0xE7, 0x9E, 0x3C, 0xF1, 0xEF, 0x0F, 0x78, 0x7B, 0xC3, 0xFC, 0x1F,
  0xE1, 0xEF, 0x0F, 0x78, 0x7B, 0xC3, 0xDE, 0x3C, 0xF1, 0xE7, 0x9F, 0x3D,
  0xF1, 0xFF, 0x07, 0xF8, 0x3F, 0x00, 0x03, 0xC3, 0xF1, 0xFC, 0xFE, 0x7F,
  0xBD, 0xE6, 0x79, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x00, 0x00, 0xF0, 0x07,
  0xF8, 0x1F, 0xF0, 0x7F, 0xF0, 0xE3, 0xE0, 0x83, 0xC0, 0x07, 0x80, 0x1F,
  0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF,
  0x1F, 0xFE, 0x00, 0x00, 0xE0, 0x3F, 0xE1, 0xFF, 0xC3, 0xFF, 0x0C, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x3F, 0xC0, 0xFC, 0x03, 0xF8,
  0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF2, 0x03, 0xCC, 0x3F,
  0x3F, 0xF8, 0xFF, 0xC3, 0xFC, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x0F, 0xC0,
  0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x77, 0x81, 0xDC, 0x0E, 0xF0, 0x73, 0xC3,
  0xCF, 0x0E, 0x3C, 0x70, 0xE3, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF8,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0xFC, 0x3F, 0xF0, 0xFF,
  0xC3, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xA0, 0x1F, 0xE0, 0xFF,
  0xC3, 0xFF, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x81,
  0xF3, 0x8F, 0x8F, 0xFE, 0x3F, 0xF0, 0xFF, 0x00, 0x00, 0x78, 0x0F, 0xF0,
  0x7F, 0x83, 0xFE, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x79, 0xC1,
  0xFF, 0x87, 0xFF, 0x3F, 0xFC, 0xF8, 0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x3C,
  0xF1, 0xF3, 0xC7, 0x8F, 0xBE, 0x3F, 0xF0, 0x7F, 0x80, 0xFC, 0x00, 0x3F,
  0xFE, 0x7F, 0xF8, 0xFF, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x01,
  0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x1F, 0xE0, 0xFF, 0xC3, 0xFF, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1F, 0x78, 0x3F, 0xC0, 0x7E, 0x07, 0xF8,
  0x3F, 0xF1, 0xF3, 0xC7, 0x8F, 0xBC, 0x1E, 0xF0, 0x7B, 0xC3, 0xCF, 0x8F,
  0x1F, 0xFC, 0x7F, 0xE0, 0xFE, 0x00, 0x01, 0xE0, 0x1F, 0xC0, 0xFF, 0x87,
  0xFF, 0x1E, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x7C, 0xF1, 0xF3,
  0xCF, 0x8F, 0xFE, 0x3F, 0xF8, 0x7D, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0,
  0x07, 0x88, 0x7C, 0x3F, 0xF0, 0xFF, 0x83, 0xF8, 0x00, 0x04, 0x1E, 0x1F,
  0x1E, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x78, 0xF8,
  0xF8, 0xF0, 0x01, 0x01, 0xE0, 0x7C, 0x1E, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0E,
  0x07, 0x81, 0xC0, 0xF0, 0x00, 0x00, 0x08, 0x01, 0xC0, 0x3E, 0x07, 0xF0,
  0xFE, 0x1F, 0xC3, 0xF8, 0x1F, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF0, 0x07, 0x80, 0x0C, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xC0, 0x07, 0x80,
  0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x03, 0xF8,
  0x7F, 0x0F, 0xE1, 0xFC, 0x0F, 0x80, 0x70, 0x02, 0x00, 0x00, 0x03, 0x87,
  0xF8, 0xFF, 0x9F, 0xF2, 0x1E, 0x01, 0xC0, 0x78, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0x70, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x7C, 0x0F, 0x81, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x0F, 0xF8, 0x03, 0xFF,
  0xC0, 0x78, 0x1E, 0x0F, 0x00, 0xE1, 0xC0, 0x07, 0x1C, 0x7E, 0x73, 0x8F,
  0xE7, 0x71, 0xEE, 0x77, 0x38, 0xE7, 0x73, 0x8E, 0x7E, 0x71, 0xC7, 0xE7,
  0x1C, 0x7E, 0x71, 0xCE, 0xE7, 0x1C, 0xEE, 0x73, 0x9C, 0xE7, 0xFF, 0xCE,
  0x7C, 0xF8, 0xE1, 0x86, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0xC0,
  0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xEE, 0x00, 0xEE, 0x01, 0xEE, 0x01, 0xCE, 0x03, 0xCE, 0x03, 0xCE, 0x07,
  0x8E, 0x07, 0x8E, 0x0F, 0x0E, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F,
  0xFE, 0x3C, 0x0F, 0x3C, 0x0F, 0x7C, 0x0F, 0x78, 0x0F, 0xF8, 0x0F, 0x0F,
  0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0x1F, 0x0F, 0x1F, 0x1E, 0x1F, 0x1E,
  0x1E, 0x1E, 0x3E, 0x1F, 0xFC, 0x1F, 0xF0, 0x3F, 0xF8, 0x3C, 0xF8, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x78, 0x3C, 0x78, 0x7C, 0x78, 0xF8, 0x7F,
  0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0x70, 0x07, 0xFC, 0x1F, 0xF8, 0x7F,
  0xE1, 0xF8, 0x43, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x01, 0xF3, 0x83, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x0F,
  0xF8, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0x1F, 0x0F, 0x0F, 0x1F, 0x0F, 0x1E,
  0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x3E, 0x0F, 0x3C, 0x1F, 0x3C,
  0x1F, 0x3C, 0x1E, 0x3C, 0x3E, 0x7C, 0x3C, 0x78, 0x7C, 0x7F, 0xF8, 0x7F,
  0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0x0F, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0x78,
  0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0xF0, 0x3F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x83, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xFF, 0xC1, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x1F,
  0xF8, 0x3F, 0xF0, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xE1, 0xF8, 0x20,
  0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x3F,
  0x8F, 0x1F, 0xCF, 0x8F, 0xE7, 0xC0, 0xF3, 0xE0, 0xF1, 0xF0, 0x78, 0xF8,
  0x3C, 0x3C, 0x1E, 0x1F, 0x9F, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0x80,
  0x0F, 0x83, 0xC3, 0xC0, 0xF0, 0xF0, 0x7C, 0x3C, 0x1E, 0x0F, 0x07, 0x87,
  0xC1, 0xE1, 0xE0, 0x78, 0x78, 0x3E, 0x1F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF,
  0xF0, 0xFF, 0xFC, 0x3C, 0x1F, 0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xF0, 0x78,
  0x78, 0x3E, 0x1E, 0x0F, 0x07, 0x83, 0xC3, 0xE0, 0xF0, 0xF0, 0x3C, 0x00,
  0x0F, 0xF8, 0x7F, 0xC0, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x1F, 0xC1, 0xFF, 0x0F, 0xF8, 0x00, 0x00,
  0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0,
  0x1E, 0x00, 0x78, 0x13, 0xE0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x0F,
  0x87, 0xC3, 0xC3, 0xE0, 0xF1, 0xF0, 0x3C, 0x78, 0x0F, 0x3C, 0x07, 0x9F,
  0x01, 0xE7, 0x80, 0x7B, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0x7C, 0x03, 0xCF, 0x01, 0xE3, 0xC0, 0x78,
  0xF0, 0x1E, 0x3E, 0x07, 0x87, 0x83, 0xE1, 0xE0, 0xF0, 0x7C, 0x00, 0x0F,
  0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x0F, 0xFD,
  0xFF, 0xFF, 0xEF, 0xFC, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x03,
  0xF8, 0x7E, 0x07, 0xE0, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0xFF,
  0x0F, 0xE1, 0xDE, 0x1D, 0xC3, 0xB8, 0x3B, 0x8E, 0xF0, 0xF7, 0x1D, 0xE1,
  0xEE, 0x7B, 0xC3, 0xDC, 0xE7, 0x87, 0x3F, 0xDE, 0x0E, 0x7F, 0x3C, 0x3C,
  0xFE, 0x78, 0x79, 0xF8, 0xF0, 0xF3, 0xF1, 0xC1, 0xC7, 0xC7, 0x87, 0x87,
  0x8F, 0x0F, 0x0E, 0x1E, 0x00, 0x0F, 0x81, 0xE1, 0xF8, 0x3C, 0x3F, 0x07,
  0x87, 0xE0, 0xF0, 0xFC, 0x1C, 0x3F, 0xC7, 0x87, 0xF8, 0xF0, 0xFF, 0x1E,
  0x1C, 0xE3, 0x83, 0x9C, 0xF0, 0xF3, 0xDE, 0x1E, 0x7B, 0xC3, 0xCF, 0x78,
  0x70, 0xEE, 0x0E, 0x1F, 0xC3, 0xC3, 0xF8, 0x78, 0x7F, 0x0F, 0x07, 0xE1,
  0xC0, 0xF8, 0x78, 0x1F, 0x0F, 0x03, 0xE0, 0x00, 0xF0, 0x01, 0xFE, 0x01,
  0xFF, 0x81, 0xFF, 0xE1, 0xF1, 0xF0, 0xF0, 0x78, 0xF8, 0x3E, 0x78, 0x1F,
  0x7C, 0x0F, 0xBC, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xEF, 0x80, 0xF7, 0xC0,
  0xFB, 0xE0, 0x79, 0xF0, 0x3C, 0xF8, 0x3E, 0x7C, 0x3E, 0x1F, 0x3E, 0x0F,
  0xFF, 0x03, 0xFF, 0x00, 0xFE, 0x00, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF,
  0x0F, 0x1F, 0x0F, 0x0F, 0x1F, 0x0F, 0x1E, 0x0F, 0x1E, 0x1F, 0x1E, 0x1E,
  0x1E, 0x3E, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF0, 0x3C, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x01, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xE1, 0xF1, 0xF0, 0xF0,
  0x78, 0xF8, 0x3E, 0x78, 0x1F, 0x7C, 0x0F, 0xBC, 0x07, 0x9E, 0x03, 0xCF,
  0x01, 0xEF, 0x80, 0xF7, 0xC0, 0xFB, 0xE0, 0x79, 0xF0, 0x3C, 0xF8, 0x3E,
  0x7C, 0x3E, 0x1F, 0x3E, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xFE, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xF8,
  0x1F, 0xF8, 0x3F, 0xF8, 0x78, 0xF0, 0xF1, 0xE3, 0xC3, 0xC7, 0x87, 0x8F,
  0x0F, 0x1E, 0x3E, 0x3F, 0xF8, 0xFF, 0xE1, 0xFF, 0x83, 0xFE, 0x07, 0xBC,
  0x0F, 0x3C, 0x3C, 0x78, 0x78, 0xF0, 0xF1, 0xF1, 0xE1, 0xE7, 0xC3, 0xCF,
  0x07, 0xC0, 0x00, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xE1, 0xF1, 0x83,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF1, 0x03, 0xE3,
  0xDF, 0x87, 0xFF, 0x0F, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0xFB, 0xFF, 0xFF,
  0xFE, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03,
  0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x1F, 0x07, 0x8F, 0x07, 0xC7,
  0x83, 0xC3, 0xC1, 0xE1, 0xE0, 0xF1, 0xF0, 0xF8, 0xF0, 0x78, 0x78, 0x3C,
  0x3C, 0x1E, 0x3E, 0x0F, 0x1E, 0x0F, 0x8F, 0x07, 0x87, 0x83, 0xC3, 0xC1,
  0xE3, 0xE0, 0xF1, 0xF0, 0xF0, 0xF8, 0x78, 0x7E, 0xFC, 0x1F, 0xFC, 0x0F,
  0xFC, 0x01, 0xFC, 0x00, 0xF0, 0x3F, 0xE0, 0x7B, 0xC1, 0xE7, 0x83, 0xCF,
  0x0F, 0x1E, 0x1E, 0x3C, 0x7C, 0x78, 0xF0, 0xF1, 0xE1, 0xE7, 0x83, 0xCF,
  0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0x78, 0x3C, 0x1E, 0xE0,
  0x78, 0x3D, 0xC1, 0xF0, 0xF3, 0x83, 0xE1, 0xE7, 0x0F, 0xC7, 0x8E, 0x1F,
  0x8F, 0x1C, 0x7F, 0x1E, 0x38, 0xFE, 0x78, 0x71, 0xFC, 0xF0, 0xE7, 0xFB,
  0xC1, 0xCE, 0xF7, 0x83, 0xBD, 0xEF, 0x07, 0x73, 0xFC, 0x0E, 0xE7, 0x78,
  0x3F, 0xCE, 0xE0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xF8, 0x7E, 0x03,
  0xF0, 0xFC, 0x07, 0xE1, 0xF0, 0x0F, 0x83, 0xE0, 0x00, 0x07, 0xC3, 0xE0,
  0x78, 0xF8, 0x0F, 0x1E, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0xBC, 0x00,
  0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x79, 0xE0, 0x1E,
  0x3C, 0x03, 0xC7, 0x80, 0xF0, 0xF0, 0x3E, 0x1E, 0x0F, 0x83, 0xE0, 0xF0,
  0x7F, 0xC3, 0xEF, 0x0F, 0x3C, 0x78, 0x71, 0xE1, 0xEF, 0x07, 0xBC, 0x1F,
  0xE0, 0x7F, 0x01, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x00,
  0x0F, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x70,
  0x07, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80,
  0x78, 0x07, 0x00, 0x70, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xF1, 0xE3, 0xC7,
  0x87, 0x0E, 0x1C, 0x3C, 0x78, 0xF1, 0xE1, 0xC3, 0x87, 0x0E, 0x1E, 0x3C,
  0x78, 0x70, 0xE1, 0xC3, 0xC0, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x0E, 0x01,
  0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03,
  0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0E,
  0x00, 0xE0, 0x1E, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0x00, 0xE0, 0x07, 0x80,
  0x3E, 0x00, 0xF8, 0x07, 0xF0, 0x1D, 0xC0, 0xE7, 0x07, 0x9E, 0x1C, 0x38,
  0xE0, 0xE7, 0x83, 0x9C, 0x0F, 0xF0, 0x1C, 0xFF, 0xFF, 0xFC, 0xF9, 0xE3,
  0x8F, 0x1C, 0x07, 0x00, 0x3E, 0xF1, 0xFF, 0xCF, 0xFE, 0x7C, 0x79, 0xE1,
  0xE7, 0x87, 0xBE, 0x1E, 0xF0, 0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF1,
  0xF3, 0xCF, 0x8F, 0xFE, 0x3F, 0xF8, 0x7D, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE3, 0x07, 0xBE, 0x1F, 0xFC,
  0x7F, 0xF1, 0xE3, 0xCF, 0x8F, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3, 0xCE, 0x0F,
  0x78, 0x7D, 0xE1, 0xE7, 0x87, 0x9F, 0x3C, 0x7F, 0xF3, 0xFF, 0x8E, 0x7C,
  0x00, 0x03, 0x80, 0xFF, 0x1F, 0xE3, 0xFE, 0x3C, 0x27, 0x80, 0x78, 0x0F,
  0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x98, 0xFF, 0x87,
  0xF8, 0x3F, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xC0, 0x07, 0x81, 0xCF, 0x07, 0xDE, 0x1F, 0xFC, 0x7F, 0xF0, 0xF1, 0xE3,
  0xC3, 0xC7, 0x87, 0x9F, 0x0F, 0x3C, 0x1C, 0x78, 0x78, 0xF0, 0xF1, 0xE1,
  0xE3, 0xC7, 0xC7, 0x8F, 0x0F, 0xFE, 0x0F, 0xDC, 0x1F, 0x38, 0x00, 0x03,
  0x80, 0xFE, 0x1F, 0xF3, 0xEF, 0x3C, 0x77, 0x87, 0x78, 0xFF, 0xFE, 0xFF,
  0xCF, 0xF0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x04, 0xFF, 0xC7, 0xFC, 0x3F,
  0x80, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xF2, 0x01, 0xF0, 0x01,
  0xE0, 0x01, 0xE4, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF8, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0xBE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0x03, 0x80, 0x0F, 0xBC, 0x3F, 0xF8, 0xFF, 0xE1, 0xE3, 0xC7, 0x87,
  0x8F, 0x0F, 0x3E, 0x1E, 0x78, 0x78, 0xF0, 0xF1, 0xE1, 0xE3, 0xC7, 0xC7,
  0x8F, 0x8F, 0x3E, 0x1F, 0xFC, 0x3F, 0xF8, 0x3E, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x0C, 0x3E, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0x80, 0x07, 0x80,
  0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE2, 0x07, 0xBE,
  0x1F, 0xFC, 0x7F, 0xF1, 0xE3, 0xCF, 0x8F, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3,
  0x8F, 0x1E, 0x78, 0x79, 0xE1, 0xE7, 0x87, 0x9E, 0x3C, 0x78, 0xF3, 0xC3,
  0xCF, 0x0F, 0x00, 0x03, 0x07, 0xC3, 0xE1, 0xE0, 0x20, 0x00, 0x04, 0x3C,
  0x1E, 0x0F, 0x07, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x87, 0x83, 0xC0, 0x00, 0x30, 0x07, 0xC0, 0x3E, 0x01, 0xE0,
  0x02, 0x00, 0x00, 0x00, 0x40, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07,
  0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x27,
  0x81, 0xFC, 0x0F, 0xC0, 0x7C, 0x00, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x01, 0x1E, 0x1E, 0x1E, 0x3C,
  0x1E, 0x78, 0x1C, 0xF0, 0x3D, 0xF0, 0x3D, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x7F, 0xE0, 0x79, 0xE0, 0x79, 0xE0, 0x79, 0xE0, 0x70, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0x07, 0x83, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x7C,
  0x3C, 0x1E, 0x0F, 0x07, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x87, 0x83, 0xC0, 0x02, 0x70, 0x60, 0xE7, 0xCF, 0xC7,
  0x7F, 0xFE, 0x3F, 0xFF, 0xF1, 0xE3, 0xE7, 0x9F, 0x1E, 0x3C, 0xF0, 0xF1,
  0xE7, 0x87, 0x0F, 0x3C, 0x78, 0x79, 0xC3, 0xC3, 0x9E, 0x1E, 0x3C, 0xF0,
  0xF1, 0xE7, 0x8F, 0x0F, 0x3C, 0x78, 0x79, 0xC3, 0xC7, 0x9E, 0x1E, 0x3C,
  0xF0, 0xF1, 0xE0, 0x00, 0x20, 0x73, 0xE1, 0xDF, 0xC7, 0xFF, 0x1E, 0x3C,
  0xF8, 0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x38, 0xF1, 0xE7, 0x87, 0x9E, 0x1E,
  0x78, 0x79, 0xE3, 0xC7, 0x0F, 0x3C, 0x3C, 0xF0, 0xF0, 0x03, 0x80, 0x7F,
  0x07, 0xFC, 0x7F, 0xE7, 0xC7, 0xBC, 0x3D, 0xE1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x87, 0xBC, 0x3D, 0xE1, 0xEF, 0x1F, 0x79, 0xF3, 0xFF, 0x0F, 0xF8, 0x3F,
  0x00, 0x00, 0x88, 0x07, 0x3E, 0x07, 0x7F, 0x07, 0xFF, 0x07, 0x8F, 0x0F,
  0x8F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x0F, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x3E, 0x1F, 0x3C, 0x1F, 0xFC, 0x3F, 0xF8, 0x3D, 0xF0, 0x3C,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0x07, 0x00, 0x3E, 0xF1, 0xFF, 0xCF, 0xFE, 0x3C, 0x79, 0xE1, 0xE7,
  0x87, 0xBC, 0x1E, 0xF0, 0x73, 0xC3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF1, 0xF3,
  0xC7, 0x8F, 0xFE, 0x3F, 0xF8, 0x7D, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x31, 0xEF, 0x1F, 0xE1,
  0xFE, 0x1F, 0xA3, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0x81, 0xFF,
  0x1F, 0xF3, 0xEE, 0x3C, 0x23, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xC0, 0x3C, 0x03, 0xCC, 0x7C, 0xFF, 0xCF, 0xF8, 0xFF, 0x00, 0x06,
  0x03, 0x80, 0xE0, 0x78, 0x7F, 0xDF, 0xEF, 0xF8, 0xF0, 0x3C, 0x0E, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0x8F, 0xE1, 0xF8,
  0x3C, 0x3C, 0xF0, 0xF3, 0xC7, 0x8E, 0x1E, 0x78, 0x79, 0xE1, 0xE7, 0x87,
  0x1E, 0x3C, 0x70, 0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x78, 0xF3, 0xE3, 0xFF,
  0x8F, 0xEE, 0x1F, 0x78, 0xF0, 0xFF, 0x87, 0xBC, 0x79, 0xE3, 0xCF, 0x3C,
  0x79, 0xE3, 0xCE, 0x1E, 0xF0, 0xF7, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x0F,
  0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0x00, 0xF1, 0xF1, 0xFF, 0x1F, 0x1E, 0xF3,
  0xF3, 0xCF, 0x3F, 0x3C, 0xE3, 0x73, 0x8E, 0x77, 0x78, 0xE7, 0x77, 0x8E,
  0xEF, 0x70, 0xEE, 0xEF, 0x0E, 0xEE, 0xE0, 0xFC, 0xEE, 0x0F, 0xCF, 0xE0,
  0xF8, 0xFC, 0x0F, 0x8F, 0xC0, 0xF8, 0xF8, 0x0F, 0x0F, 0x80, 0x1F, 0x1F,
  0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x78, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3D, 0xE0,
  0x78, 0xF0, 0x78, 0xF0, 0xF0, 0xF0, 0x0F, 0x0F, 0x87, 0x87, 0x83, 0xC7,
  0x81, 0xE3, 0xC0, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xE0, 0x1E, 0xF0, 0x0F,
  0x78, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0,
  0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0x0F, 0xF8, 0xFF, 0xC7, 0xFC,
  0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x07,
  0x80, 0x78, 0x07, 0x82, 0x3F, 0xE3, 0xFF, 0x1F, 0xF8, 0x01, 0xF0, 0x3F,
  0x03, 0xF0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xF0,
  0x1F, 0x07, 0xE0, 0x70, 0x0F, 0xC0, 0x7C, 0x01, 0xC0, 0x1C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x1E, 0x00, 0x60,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3F, 0x00, 0xF0, 0x3F, 0x07, 0xE0, 0xF8,
  0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0xFE, 0x0F, 0xC0,
  0xF8, 0x0E, 0x00, 0x3C, 0x0F, 0xFC, 0xFF, 0xFF, 0x8F, 0xF8, 0x0F, 0x00,
};

const GFXglyph NotoSans_Condensed_BoldItalic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 9, 21, 8, 0, -21 },
  { 25, 11, 7, 12, 3, -21 },
  { 35, 17, 21, 16, 0, -21 },
  { 80, 14, 25, 14, 0, -23 },
  { 124, 20, 22, 23, 2, -22 },
  { 179, 17, 22, 17, 0, -22 },
  { 226, 5, 7, 7, 3, -21 },
  { 231, 10, 26, 9, 1, -21 },
  { 264, 10, 27, 9, -2, -22 },
  { 298, 12, 13, 14, 2, -23 },
  { 318, 13, 15, 15, 1, -18 },
  { 343, 7, 8, 8, -2, -4 },
  { 350, 8, 4, 9, 0, -10 },
  { 354, 5, 5, 8, 0, -5 },
  { 358, 16, 22, 12, -2, -22 },
  { 402, 13, 22, 14, 1, -22 },
  { 438, 10, 21, 14, 3, -21 },
  { 465, 15, 22, 14, -1, -22 },
  { 507, 14, 22, 14, 0, -22 },
  { 546, 14, 21, 14, 0, -21 },
  { 583, 14, 21, 14, 0, -21 },
  { 620, 14, 22, 14, 1, -22 },
  { 659, 15, 21, 14, 1, -21 },
  { 699, 14, 22, 14, 0, -22 },
  { 738, 14, 22, 14, 0, -22 },
  { 777, 8, 17, 8, 0, -17 },
  { 794, 10, 21, 8, -2, -17 },
  { 821, 13, 15, 15, 1, -18 },
  { 846, 13, 9, 15, 1, -15 },
  { 861, 13, 15, 15, 1, -18 },
  { 886, 11, 22, 11, 1, -22 },
  { 917, 20, 24, 21, 1, -22 },
  { 977, 16, 21, 16, -2, -21 },
  { 1019, 16, 21, 16, 0, -21 },
  { 1061, 15, 22, 15, 1, -22 },
  { 1103, 16, 21, 17, 0, -21 },
  { 1145, 15, 21, 13, 0, -21 },
  { 1185, 15, 21, 13, 0, -21 },
  { 1225, 17, 22, 17, 1, -22 },
  { 1272, 18, 21, 17, 0, -21 },
  { 1320, 13, 21, 10, -1, -21 },
  { 1355, 14, 27, 8, -5, -21 },
  { 1403, 18, 21, 15, 0, -21 },
  { 1451, 11, 21, 13, 0, -21 },
  { 1480, 23, 21, 23, 0, -21 },
  { 1541, 19, 21, 19, 0, -21 },
  { 1591, 17, 22, 18, 1, -22 },
  { 1638, 16, 21, 15, 0, -21 },
  { 1680, 17, 27, 18, 1, -22 },
  { 1738, 15, 21, 15, 0, -21 },
  { 1778, 15, 22, 13, 0, -22 },
  { 1820, 13, 21, 13, 2, -21 },
  { 1855, 17, 21, 17, 1, -21 },
  { 1900, 15, 21, 15, 3, -21 },
  { 1940, 23, 21, 23, 2, -21 },
  { 2001, 19, 21, 15, -2, -21 },
  { 2051, 14, 21, 14, 3, -21 },
  { 2088, 16, 21, 13, -1, -21 },
  { 2130, 12, 26, 9, -1, -21 },
  { 2169, 7, 22, 12, 3, -22 },
  { 2189, 12, 26, 9, -2, -21 },
  { 2228, 14, 13, 14, 0, -21 },
  { 2251, 11, 2, 10, -3, 3 },
  { 2254, 6, 5, 9, 4, -23 },
  { 2258, 14, 17, 15, 1, -17 },
  { 2288, 14, 23, 15, 0, -23 },
  { 2329, 12, 17, 12, 1, -17 },
  { 2355, 15, 23, 15, 1, -23 },
  { 2399, 12, 17, 14, 1, -17 },
  { 2425, 16, 30, 9, -3, -23 },
  { 2485, 15, 24, 15, 0, -17 },
  { 2530, 14, 23, 15, 0, -23 },
  { 2571, 9, 23, 8, 0, -23 },
  { 2597, 13, 30, 8, -4, -23 },
  { 2646, 16, 23, 14, 0, -23 },
  { 2692, 9, 23, 7, 0, -23 },
  { 2718, 21, 17, 22, 0, -17 },
  { 2763, 14, 17, 15, 0, -17 },
  { 2793, 13, 17, 15, 1, -17 },
  { 2821, 16, 24, 15, -2, -17 },
  { 2869, 14, 24, 15, 1, -17 },
  { 2911, 12, 17, 11, 0, -17 },
  { 2937, 12, 17, 12, 0, -17 },
  { 2963, 10, 20, 10, 1, -20 },
  { 2988, 14, 16, 15, 1, -16 },
  { 3016, 13, 16, 13, 2, -16 },
  { 3042, 20, 16, 20, 2, -16 },
  { 3082, 16, 16, 13, -1, -16 },
  { 3114, 17, 23, 13, -2, -16 },
  { 3163, 13, 16, 11, -1, -16 },
  { 3189, 12, 26, 10, 0, -21 },
  { 3228, 3, 30, 13, 5, -23 },
  { 3240, 12, 26, 10, -2, -21 },
  { 3279, 13, 5, 15, 1, -13 },
};

const GFXfont NotoSans_Condensed_BoldItalic30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BoldItalic30pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BoldItalic30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_CONDENSED_BOLDITALIC30PT7B_H_
