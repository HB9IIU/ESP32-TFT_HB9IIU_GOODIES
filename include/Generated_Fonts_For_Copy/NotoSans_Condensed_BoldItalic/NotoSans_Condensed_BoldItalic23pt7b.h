#ifndef _NOTOSANS_CONDENSED_BOLDITALIC23PT7B_H_
#define _NOTOSANS_CONDENSED_BOLDITALIC23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BoldItalic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BoldItalic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x38, 0x70, 0xE3, 0xC7, 0x0E, 0x1C, 0x38, 0x61, 0xC0, 0x02,
  0x1E, 0x3C, 0x70, 0x77, 0x77, 0x67, 0xE6, 0xE6, 0xCE, 0x07, 0x30, 0x33,
  0x01, 0x98, 0x0C, 0xC3, 0xFF, 0x9F, 0xF8, 0x33, 0x03, 0xB8, 0x19, 0x87,
  0xFF, 0x3F, 0xF8, 0x66, 0x03, 0x30, 0x19, 0x81, 0x98, 0x0C, 0xC0, 0x01,
  0x00, 0xF8, 0x3F, 0x8F, 0xE3, 0xA4, 0x74, 0x0F, 0x81, 0xF0, 0x1F, 0x80,
  0xF0, 0x1F, 0x02, 0xE8, 0x5D, 0xFF, 0x3F, 0xE3, 0xF0, 0x08, 0x03, 0x00,
  0x0C, 0x04, 0x3E, 0x18, 0x76, 0x38, 0x66, 0x30, 0x66, 0x70, 0xE6, 0x60,
  0xEE, 0xC0, 0xED, 0xDE, 0xFD, 0xBE, 0x7B, 0xB7, 0x33, 0x77, 0x06, 0x66,
  0x0E, 0x66, 0x0C, 0x66, 0x1C, 0x6E, 0x18, 0x7C, 0x30, 0x78, 0x03, 0x80,
  0x3E, 0x03, 0xF8, 0x39, 0xC1, 0xCE, 0x0E, 0xE0, 0x7F, 0x01, 0xF0, 0x1E,
  0x39, 0xF9, 0xDD, 0xDC, 0xE7, 0xEE, 0x3E, 0x70, 0xE3, 0xDF, 0x8F, 0xFC,
  0x7E, 0xF0, 0x77, 0x66, 0xEE, 0x07, 0x0E, 0x0C, 0x1C, 0x18, 0x38, 0x38,
  0x70, 0x70, 0x70, 0x70, 0x60, 0x60, 0xE0, 0xE0, 0x60, 0x60, 0x70, 0x70,
  0x30, 0x06, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0xE0, 0x0A, 0x06,
  0x23, 0x1D, 0x8F, 0xF9, 0xFC, 0xF0, 0xFC, 0xE6, 0x13, 0x80, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x3F, 0xFF, 0xFC, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x3B, 0xDC, 0xEE, 0x70, 0x7D, 0xFF, 0xC0, 0x2F, 0xFE, 0x00, 0x70, 0x0E,
  0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0xE0,
  0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x00, 0x06,
  0x07, 0xE3, 0xF8, 0xE7, 0x71, 0xDC, 0x7F, 0x1F, 0x8F, 0xE3, 0xB8, 0xEE,
  0x3B, 0x8E, 0xE7, 0x39, 0xCE, 0xE3, 0xF8, 0x78, 0x00, 0x0F, 0x1F, 0x3E,
  0xFE, 0x6E, 0x4E, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x38,
  0x38, 0x03, 0x80, 0xFE, 0x1F, 0xE1, 0xCF, 0x08, 0x70, 0x0F, 0x00, 0xE0,
  0x1E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x7F, 0xC7,
  0xFC, 0xFF, 0x80, 0x07, 0x03, 0xF8, 0x7F, 0x88, 0xF0, 0x0E, 0x03, 0xC0,
  0x70, 0xFC, 0x1E, 0x03, 0xF0, 0x0E, 0x01, 0xE0, 0x39, 0x07, 0x33, 0xE7,
  0xF8, 0xFE, 0x00, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xE0, 0xFC, 0x1B, 0x86,
  0xE1, 0xDC, 0x73, 0x8C, 0x73, 0xFF, 0x7F, 0xEF, 0xFC, 0x0E, 0x01, 0xC0,
  0x70, 0x0F, 0xE3, 0xFC, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x0F, 0xE1, 0xFC,
  0x23, 0xC0, 0x78, 0x0F, 0x01, 0xC8, 0x39, 0xDF, 0x3F, 0xC7, 0xF0, 0x01,
  0xC3, 0xF1, 0xFC, 0xF0, 0x38, 0x1C, 0x07, 0x63, 0xBC, 0xFF, 0xBC, 0xEE,
  0x3B, 0x8E, 0xE3, 0xB9, 0xCF, 0xF3, 0xF8, 0x7C, 0x00, 0x3F, 0xEF, 0xFC,
  0x07, 0x01, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0x70,
  0x1C, 0x03, 0x80, 0xE0, 0x3C, 0x07, 0x00, 0x03, 0x81, 0xF8, 0x7F, 0x9C,
  0x73, 0x8E, 0x71, 0xC7, 0x70, 0xFC, 0x1F, 0x07, 0xF1, 0xCE, 0x78, 0xEE,
  0x1D, 0xC3, 0xBC, 0xE3, 0xFC, 0x3E, 0x00, 0x07, 0x01, 0xF8, 0x7F, 0x1C,
  0xF3, 0x8E, 0xF1, 0xDC, 0x7B, 0x8E, 0x7B, 0xC7, 0xF8, 0xF7, 0x01, 0xC0,
  0x38, 0x0E, 0x33, 0xC7, 0xF0, 0xFC, 0x00, 0x18, 0xF3, 0xCE, 0x00, 0x00,
  0x00, 0x00, 0x8F, 0x3C, 0xE0, 0x0C, 0x3C, 0x78, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xE3, 0x87, 0x0E, 0x38, 0x70, 0x00, 0x40, 0x70, 0x7C, 0x7C,
  0x7C, 0x3C, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0xF0, 0x0C, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x80, 0x38, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF0, 0x7C, 0x7C, 0xFC, 0x3C, 0x0C, 0x00, 0x0C, 0x3F, 0x9F, 0xC8,
  0xF0, 0x30, 0x38, 0x3C, 0x3C, 0x3C, 0x1C, 0x1C, 0x0E, 0x00, 0x00, 0x03,
  0x81, 0xC0, 0xE0, 0x00, 0x00, 0xC0, 0x0F, 0xF0, 0x3C, 0x70, 0xE0, 0x73,
  0x80, 0x6E, 0x7E, 0xD9, 0xF9, 0xB3, 0x33, 0xCC, 0x67, 0x99, 0xCF, 0x33,
  0x36, 0x66, 0x6C, 0xDD, 0x99, 0xEF, 0x30, 0x00, 0x70, 0x00, 0x70, 0x40,
  0x7F, 0x80, 0x7E, 0x00, 0x01, 0xE0, 0x7C, 0x0F, 0x83, 0xF0, 0x7E, 0x1D,
  0xC3, 0xB8, 0xE7, 0x1C, 0xE3, 0xFC, 0xFF, 0x9F, 0xF7, 0x0E, 0xE1, 0xFC,
  0x3F, 0x07, 0x1F, 0xE1, 0xFF, 0x1C, 0xF1, 0xC7, 0x1C, 0x73, 0x8E, 0x3F,
  0xE3, 0xF8, 0x3F, 0xC3, 0x9E, 0x70, 0xE7, 0x0E, 0x71, 0xC7, 0xFC, 0xFF,
  0x8F, 0xF0, 0x03, 0x80, 0xFF, 0x1F, 0xE3, 0xC4, 0x38, 0x07, 0x80, 0x70,
  0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xFF,
  0x07, 0xF0, 0x3F, 0x00, 0x1F, 0xE0, 0xFF, 0x87, 0x3C, 0x38, 0xE1, 0xC7,
  0x9E, 0x3C, 0xE1, 0xE7, 0x0E, 0x38, 0x71, 0xC3, 0x9C, 0x3C, 0xE1, 0xC7,
  0x1E, 0x3F, 0xE3, 0xFE, 0x1F, 0xC0, 0x1F, 0xE3, 0xFC, 0x70, 0x0E, 0x01,
  0xC0, 0x78, 0x0F, 0xF1, 0xFC, 0x3F, 0x87, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xFE, 0x3F, 0xC7, 0xF8, 0x1F, 0xE3, 0xFC, 0x70, 0x0E, 0x01, 0xC0, 0x78,
  0x0E, 0x01, 0xFC, 0x3F, 0x87, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x3C,
  0x07, 0x00, 0x01, 0xC0, 0x7F, 0xC7, 0xFC, 0x7C, 0x63, 0xC0, 0x3C, 0x01,
  0xC0, 0x0E, 0x02, 0xF3, 0xE7, 0x1F, 0x38, 0x39, 0xC1, 0xCE, 0x1E, 0x78,
  0xE1, 0xFF, 0x0F, 0xF8, 0x3F, 0x80, 0x1E, 0x1C, 0x70, 0xF1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0xF0, 0xE3, 0xFF, 0x8F, 0xFC, 0x3F, 0xF0, 0xE1, 0xC7,
  0x0F, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x8F, 0x0E, 0x38, 0x78, 0x1F, 0xC3,
  0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x0F, 0x0F, 0xE3, 0xF8, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0xC1, 0xF8, 0x3E, 0x0F, 0x00, 0x1E,
  0x3C, 0x71, 0xC1, 0xCF, 0x07, 0x38, 0x1D, 0xC0, 0xEE, 0x03, 0xF8, 0x0F,
  0xC0, 0x3F, 0x00, 0xEE, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0x81, 0xCF, 0x0F,
  0x1C, 0x38, 0x70, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x70, 0x70, 0x70, 0x7F, 0xFF, 0xFF, 0x1F, 0x07, 0xC7, 0xC1, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x1F, 0x8F, 0xC6, 0xE3, 0xF3, 0xF0, 0xFC,
  0xDC, 0x3B, 0x77, 0x0C, 0xDD, 0xC7, 0x36, 0x71, 0xCF, 0xB8, 0x73, 0xCE,
  0x1C, 0xF3, 0x8E, 0x38, 0xE3, 0x8E, 0x70, 0x1E, 0x0E, 0x3E, 0x18, 0x7C,
  0x70, 0xF8, 0xE1, 0xF1, 0xC7, 0x63, 0x8E, 0xEE, 0x1D, 0xDC, 0x3B, 0xB8,
  0x67, 0x71, 0xC7, 0xE3, 0x8F, 0x87, 0x1F, 0x0C, 0x3E, 0x38, 0x3C, 0x70,
  0x70, 0x03, 0x80, 0xFE, 0x1F, 0xF3, 0xC7, 0x38, 0x77, 0x87, 0x70, 0x77,
  0x07, 0xF0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xEF, 0x1E, 0xFF, 0xC7,
  0xF8, 0x3F, 0x00, 0x1F, 0xE1, 0xFF, 0x1C, 0xF1, 0xC7, 0x1C, 0x73, 0x87,
  0x38, 0xF3, 0xFE, 0x3F, 0xC3, 0xF8, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0xF0, 0x0E, 0x00, 0x03, 0x80, 0xFE, 0x1F, 0xF3, 0xC7, 0x38, 0x77, 0x87,
  0x70, 0x77, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0xFE, 0x0E, 0xE0, 0xEF, 0x1E,
  0xFF, 0xC7, 0xF8, 0x3F, 0x00, 0x70, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1F,
  0xC1, 0xFE, 0x1C, 0xF1, 0xC7, 0x1C, 0xF3, 0x8E, 0x38, 0xE3, 0xFC, 0x3F,
  0x83, 0xF8, 0x73, 0x87, 0x38, 0x73, 0x87, 0x3C, 0xF1, 0xCE, 0x1C, 0x03,
  0x81, 0xFC, 0x7F, 0x9E, 0x23, 0x80, 0x70, 0x0F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1E, 0x01, 0xC0, 0x39, 0x07, 0x3F, 0xC7, 0xF8, 0xFE, 0x00, 0xFF,
  0xFF, 0xE1, 0xC0, 0x70, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1E, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0x80, 0x3C, 0x79, 0xC3, 0x8E, 0x1C,
  0x70, 0xE7, 0x8F, 0x38, 0x71, 0xC3, 0x8E, 0x1C, 0x70, 0xE7, 0x8F, 0x38,
  0x71, 0xC3, 0x8E, 0x3C, 0x7F, 0xC1, 0xFE, 0x07, 0xC0, 0xE0, 0xFE, 0x0E,
  0xE1, 0xCE, 0x1C, 0xE3, 0x8E, 0x38, 0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0xE0,
  0xEE, 0x0F, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x00, 0xE1, 0xC3, 0xF0,
  0xE1, 0xF8, 0xF1, 0xDC, 0x78, 0xEE, 0x7C, 0xE7, 0x36, 0x73, 0x9F, 0x39,
  0xDF, 0xB8, 0xED, 0xDC, 0x7E, 0xEC, 0x3F, 0x7E, 0x1F, 0x3F, 0x0F, 0x9F,
  0x07, 0x8F, 0x83, 0xC7, 0x81, 0xC3, 0xC0, 0x1E, 0x3C, 0x39, 0xE0, 0xE7,
  0x03, 0xB8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E,
  0x01, 0xDC, 0x07, 0x70, 0x39, 0xC1, 0xE7, 0x07, 0x1C, 0x38, 0x78, 0xE1,
  0xFC, 0x79, 0xCE, 0x3B, 0x87, 0x70, 0xFC, 0x1F, 0x83, 0xE0, 0x3C, 0x07,
  0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0x0F, 0xF1, 0xFF,
  0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xE0,
  0x1C, 0x03, 0x80, 0x38, 0x07, 0xFC, 0xFF, 0x8F, 0xF8, 0x0F, 0xC3, 0xE0,
  0xE0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x80, 0xE0,
  0x30, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x1F, 0x0F, 0x83, 0xE0, 0xE7, 0x18,
  0xC7, 0x39, 0xCE, 0x71, 0x8C, 0x73, 0x9C, 0xE7, 0x18, 0x0F, 0xC3, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x38,
  0x0E, 0x03, 0x80, 0xC0, 0x70, 0x1C, 0x1F, 0x07, 0xC3, 0xE0, 0x03, 0x00,
  0xF0, 0x1E, 0x06, 0xC1, 0xD8, 0x33, 0x8E, 0x73, 0x86, 0x60, 0xDC, 0x1C,
  0xFF, 0xFF, 0xF3, 0x9C, 0x70, 0x1C, 0xE7, 0xD9, 0xFF, 0x39, 0xEF, 0x3D,
  0xC7, 0x38, 0xE7, 0x1C, 0xE3, 0x9C, 0xF3, 0xBC, 0x7F, 0x87, 0x70, 0x1E,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xD8, 0x77, 0x8F, 0xF9, 0xC7, 0x38, 0xE6,
  0x1D, 0xC3, 0xB8, 0xE7, 0x1C, 0xE3, 0x9E, 0xE7, 0xFC, 0xEF, 0x00, 0x0F,
  0x1F, 0xCF, 0xCE, 0x0F, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x3D, 0x9F,
  0xC7, 0xC0, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x1C, 0xE3, 0xFC, 0x7F,
  0xC7, 0x3C, 0xF1, 0xCE, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x78, 0xE7,
  0x0F, 0xF0, 0x7B, 0x00, 0x0E, 0x1F, 0xCF, 0xEE, 0x3E, 0x3F, 0x3F, 0xFD,
  0xF0, 0xE0, 0x70, 0x38, 0x9F, 0xC7, 0xE0, 0x00, 0x60, 0x07, 0xC0, 0x7C,
  0x03, 0x80, 0x38, 0x01, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x7C, 0x03, 0xE0, 0x04, 0x00, 0x06, 0x71,
  0xF6, 0x3F, 0xE3, 0x9E, 0x79, 0xE7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x3C, 0x77, 0x87, 0xF8, 0x3B, 0x80, 0x38, 0x07, 0x88, 0x70, 0xFF, 0x0F,
  0xE0, 0x10, 0x00, 0x0E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xD8, 0x77, 0x8F,
  0xF9, 0xE7, 0x38, 0xE7, 0x1D, 0xC7, 0x38, 0xE7, 0x1C, 0xE3, 0x9C, 0xE7,
  0x1C, 0xE3, 0x80, 0x04, 0x3C, 0x78, 0xE0, 0x03, 0x8F, 0x1C, 0x38, 0x70,
  0xE3, 0x87, 0x0E, 0x1C, 0x38, 0xE1, 0xC0, 0x00, 0x80, 0xF0, 0x3C, 0x06,
  0x00, 0x00, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x3E, 0x0F, 0x01,
  0x00, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x73, 0x8E, 0x39, 0xC3,
  0xB8, 0x3F, 0x83, 0x70, 0x7F, 0x07, 0xF0, 0x77, 0x07, 0x70, 0x63, 0x8E,
  0x38, 0xE3, 0xC0, 0x1E, 0x38, 0x70, 0xE1, 0xC7, 0x8E, 0x1C, 0x38, 0x71,
  0xC3, 0x87, 0x0E, 0x1C, 0x70, 0xE0, 0x19, 0x8E, 0x3F, 0xDF, 0x3F, 0xFF,
  0x3C, 0xE7, 0x38, 0xE7, 0x39, 0xC7, 0x71, 0xC7, 0x71, 0xC7, 0x71, 0xCE,
  0x71, 0x8E, 0x73, 0x8E, 0xE3, 0x8E, 0xE3, 0x9E, 0x19, 0x87, 0x78, 0xFF,
  0x9E, 0x73, 0x8E, 0x71, 0xDC, 0x73, 0x8E, 0x71, 0xCE, 0x39, 0xCE, 0x71,
  0xCE, 0x38, 0x0E, 0x0F, 0xE7, 0xF9, 0xCE, 0xF1, 0xF8, 0x7E, 0x3B, 0x8E,
  0xE3, 0xB9, 0xEE, 0xF3, 0xF8, 0x7C, 0x00, 0x0C, 0xC1, 0xDE, 0x1F, 0xF1,
  0xC7, 0x1C, 0x71, 0xC7, 0x38, 0x73, 0x8E, 0x38, 0xE3, 0x8E, 0x3D, 0xC7,
  0xFC, 0x77, 0x87, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x0C, 0xE7,
  0xD9, 0xFF, 0x39, 0xE7, 0x1D, 0xC7, 0x38, 0xE7, 0x1C, 0xE3, 0x9C, 0xF3,
  0x9C, 0x7F, 0x87, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x00, 0x19, 0x9D, 0xCF, 0xE7, 0xD3, 0x81, 0xC1, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x1C, 0x0E, 0x00, 0x0F, 0x1F, 0xCF, 0xEF, 0x17, 0x81, 0xE0, 0xF8,
  0x3E, 0x0F, 0x03, 0xB3, 0xDF, 0xCF, 0xC0, 0x18, 0x30, 0xFF, 0xFF, 0xEE,
  0x1C, 0x38, 0x71, 0xC3, 0x87, 0x0E, 0x9F, 0x1E, 0x00, 0x39, 0xDC, 0x77,
  0x1D, 0xC7, 0x71, 0xD8, 0xEE, 0x3B, 0x8E, 0xE3, 0xB9, 0xEE, 0xF3, 0xEC,
  0xF7, 0x00, 0xE1, 0xF8, 0x7E, 0x3B, 0x8E, 0x67, 0x19, 0xC6, 0xE1, 0xB8,
  0x6C, 0x1F, 0x07, 0x81, 0xE0, 0x70, 0x00, 0xE3, 0xC7, 0xC7, 0x9F, 0x9E,
  0x3F, 0x3C, 0xEE, 0x79, 0xDD, 0xF3, 0x3B, 0x6E, 0x7E, 0xDC, 0xF9, 0xF1,
  0xF3, 0xE3, 0xE7, 0x87, 0x8F, 0x0F, 0x1C, 0x00, 0x1C, 0x71, 0xCF, 0x1C,
  0xE1, 0xDC, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x1F, 0x03, 0xB8, 0x3B,
  0x87, 0x38, 0xE3, 0xC0, 0x1C, 0x38, 0xE1, 0xC3, 0x1C, 0x18, 0xE0, 0xCE,
  0x07, 0x70, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x78, 0x07, 0xC0, 0x10, 0x00, 0x1F,
  0xC7, 0xF1, 0xFC, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x70, 0x3C, 0x0E, 0x07,
  0x01, 0xFC, 0xFF, 0x00, 0x07, 0x83, 0xC3, 0x81, 0xC0, 0xE0, 0x60, 0x70,
  0x38, 0x78, 0x70, 0x3E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x3E,
  0x0F, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1E, 0x0F, 0x03, 0xC0, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0F, 0x81, 0x83,
  0xC3, 0x81, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x78, 0x3C, 0x18, 0x00, 0x78,
  0x7F, 0xFD, 0xFE, 0x0E,
};

const GFXglyph NotoSans_Condensed_BoldItalic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 7, 16, 6, 0, -16 },
  { 15, 8, 6, 9, 2, -16 },
  { 21, 13, 16, 12, 0, -16 },
  { 47, 11, 18, 11, 0, -17 },
  { 72, 16, 17, 17, 1, -17 },
  { 106, 13, 17, 13, 0, -17 },
  { 134, 4, 6, 6, 2, -16 },
  { 137, 8, 20, 7, 0, -16 },
  { 157, 8, 21, 7, -2, -17 },
  { 178, 9, 10, 10, 2, -18 },
  { 190, 10, 11, 11, 1, -14 },
  { 204, 5, 6, 6, -1, -3 },
  { 208, 6, 3, 7, 0, -8 },
  { 211, 4, 4, 6, 0, -4 },
  { 213, 12, 17, 9, -1, -17 },
  { 239, 10, 17, 11, 1, -17 },
  { 261, 8, 16, 11, 2, -16 },
  { 277, 12, 17, 11, -1, -17 },
  { 303, 11, 17, 11, 0, -17 },
  { 327, 11, 16, 11, 0, -16 },
  { 349, 11, 16, 11, 0, -16 },
  { 371, 10, 17, 11, 1, -17 },
  { 393, 11, 16, 11, 1, -16 },
  { 415, 11, 17, 11, 0, -17 },
  { 439, 11, 17, 11, 0, -17 },
  { 463, 6, 13, 6, 0, -13 },
  { 473, 7, 16, 6, -1, -13 },
  { 487, 10, 11, 11, 1, -14 },
  { 501, 10, 7, 11, 1, -12 },
  { 510, 10, 11, 11, 1, -14 },
  { 524, 9, 17, 9, 1, -17 },
  { 544, 15, 19, 16, 1, -17 },
  { 580, 11, 16, 12, -1, -16 },
  { 602, 12, 16, 12, 0, -16 },
  { 626, 12, 17, 11, 1, -17 },
  { 652, 13, 16, 13, 0, -16 },
  { 678, 11, 16, 10, 0, -16 },
  { 700, 11, 16, 10, 0, -16 },
  { 722, 13, 17, 13, 1, -17 },
  { 750, 14, 16, 13, 0, -16 },
  { 778, 10, 16, 8, -1, -16 },
  { 798, 11, 21, 6, -4, -16 },
  { 827, 14, 16, 12, 0, -16 },
  { 855, 8, 16, 10, 0, -16 },
  { 871, 18, 16, 17, 0, -16 },
  { 907, 15, 16, 14, 0, -16 },
  { 937, 12, 17, 14, 1, -17 },
  { 963, 12, 16, 12, 0, -16 },
  { 987, 12, 21, 14, 1, -17 },
  { 1019, 12, 16, 12, 0, -16 },
  { 1043, 11, 17, 10, 0, -17 },
  { 1067, 10, 16, 10, 2, -16 },
  { 1087, 13, 16, 13, 1, -16 },
  { 1113, 12, 16, 12, 2, -16 },
  { 1137, 17, 16, 17, 2, -16 },
  { 1171, 14, 16, 11, -1, -16 },
  { 1199, 11, 16, 11, 2, -16 },
  { 1221, 12, 16, 10, -1, -16 },
  { 1245, 10, 20, 7, -1, -16 },
  { 1270, 5, 17, 9, 2, -17 },
  { 1281, 10, 20, 7, -2, -16 },
  { 1306, 11, 10, 11, 0, -16 },
  { 1320, 8, 2, 8, -2, 2 },
  { 1322, 5, 4, 7, 3, -18 },
  { 1325, 11, 13, 12, 1, -13 },
  { 1343, 11, 17, 12, 0, -17 },
  { 1367, 9, 13, 9, 1, -13 },
  { 1382, 12, 17, 12, 1, -17 },
  { 1408, 9, 13, 11, 1, -13 },
  { 1423, 13, 24, 7, -3, -18 },
  { 1462, 12, 19, 12, 0, -13 },
  { 1491, 11, 17, 12, 0, -17 },
  { 1515, 7, 18, 6, 0, -18 },
  { 1531, 10, 24, 6, -3, -18 },
  { 1561, 12, 17, 11, 0, -17 },
  { 1587, 7, 17, 6, 0, -17 },
  { 1602, 16, 13, 17, 0, -13 },
  { 1628, 11, 13, 12, 0, -13 },
  { 1646, 10, 13, 11, 1, -13 },
  { 1663, 12, 18, 12, -1, -13 },
  { 1690, 11, 19, 12, 1, -13 },
  { 1717, 9, 13, 8, 0, -13 },
  { 1732, 9, 13, 9, 0, -13 },
  { 1747, 7, 15, 8, 1, -15 },
  { 1761, 10, 13, 11, 1, -13 },
  { 1778, 10, 13, 10, 1, -13 },
  { 1795, 15, 13, 15, 1, -13 },
  { 1820, 12, 13, 10, -1, -13 },
  { 1840, 13, 19, 10, -2, -13 },
  { 1871, 10, 13, 9, -1, -13 },
  { 1888, 9, 20, 8, 0, -16 },
  { 1911, 3, 23, 10, 3, -18 },
  { 1920, 9, 20, 8, -1, -16 },
  { 1943, 10, 4, 11, 1, -10 },
};

const GFXfont NotoSans_Condensed_BoldItalic23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BoldItalic23pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BoldItalic23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_CONDENSED_BOLDITALIC23PT7B_H_
