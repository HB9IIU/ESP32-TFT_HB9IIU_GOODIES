#ifndef _NOTOSANS_CONDENSED_BOLDITALIC46PT7B_H_
#define _NOTOSANS_CONDENSED_BOLDITALIC46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BoldItalic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BoldItalic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0,
  0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xE0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x1F, 0x80, 0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0x7C, 0x00, 0x40,
  0x00, 0x3F, 0x1F, 0x9F, 0x8F, 0x8F, 0xCF, 0xC7, 0xC7, 0xE3, 0xE3, 0xF3,
  0xF1, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0x7C, 0x7C, 0x3E, 0x3E, 0x1E, 0x1F,
  0x1F, 0x0F, 0x80, 0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0x87,
  0x80, 0x07, 0xC3, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xE1, 0xE0, 0x00, 0xF0,
  0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x78, 0x78, 0x07, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x07,
  0xC7, 0xC0, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x01, 0xF1, 0xF0, 0x00,
  0xF0, 0xF0, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x0F, 0x0F, 0x80, 0x07, 0x87, 0x80,
  0x03, 0xC3, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0,
  0x00, 0xF8, 0xF8, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x1F, 0xB9, 0xC0, 0xFC, 0xC1, 0x03, 0xF3, 0x00, 0x0F, 0xCC, 0x00, 0x3F,
  0xB0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0x7E, 0x00, 0x0D, 0xFC, 0x00, 0x77, 0xE1, 0x01, 0x9F, 0x86, 0x06,
  0x7E, 0x1F, 0x1B, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x03, 0xF0, 0x01, 0xF0,
  0x0F, 0xF0, 0x07, 0xC0, 0x3F, 0xF0, 0x0F, 0x80, 0xFF, 0xE0, 0x3E, 0x01,
  0xF3, 0xC0, 0x78, 0x07, 0xC7, 0x81, 0xF0, 0x0F, 0x0F, 0x07, 0xC0, 0x3E,
  0x1E, 0x0F, 0x80, 0x7C, 0x3C, 0x3E, 0x00, 0xF8, 0xF8, 0x78, 0x01, 0xE1,
  0xF1, 0xF0, 0x03, 0xC3, 0xE7, 0xC0, 0x0F, 0x87, 0x8F, 0x80, 0x1F, 0x1F,
  0x3E, 0x3F, 0x3E, 0x3E, 0x78, 0xFF, 0x3C, 0xF9, 0xF3, 0xFE, 0x7F, 0xF7,
  0xCF, 0xFE, 0xFF, 0xCF, 0xBE, 0x7C, 0xFF, 0x3E, 0x7C, 0xF8, 0xFC, 0x78,
  0xF1, 0xF0, 0x01, 0xF3, 0xE3, 0xE0, 0x07, 0xC7, 0xC7, 0xC0, 0x0F, 0x8F,
  0x0F, 0x80, 0x3E, 0x3E, 0x1F, 0x00, 0x78, 0x7C, 0x3C, 0x01, 0xF0, 0xF8,
  0xF8, 0x07, 0xC1, 0xF1, 0xF0, 0x0F, 0x83, 0xE3, 0xC0, 0x3E, 0x07, 0xCF,
  0x80, 0x78, 0x0F, 0xFE, 0x01, 0xF0, 0x0F, 0xFC, 0x07, 0xC0, 0x1F, 0xF0,
  0x1F, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x7E, 0x3F, 0x00,
  0x1F, 0x0F, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0xFC, 0x7E,
  0x00, 0x3F, 0x3F, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFE, 0x0F, 0xC3,
  0xFF, 0xC3, 0xE1, 0xFF, 0xF1, 0xF8, 0x7E, 0xFE, 0x7E, 0x3F, 0x1F, 0xBF,
  0x1F, 0xC7, 0xFF, 0xC7, 0xE1, 0xFF, 0xE1, 0xF8, 0x3F, 0xF0, 0xFE, 0x0F,
  0xFC, 0x3F, 0x81, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x3F, 0xE0, 0x7F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xF3, 0xF8,
  0x0F, 0xF8, 0xFF, 0x00, 0x7E, 0xFD, 0xFB, 0xE7, 0xDF, 0xBF, 0x7C, 0xF9,
  0xF3, 0xE7, 0x80, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x61,
  0xF0, 0x1E, 0x7C, 0x0F, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xF0, 0x3F, 0xFC, 0x1F, 0xC0, 0x1F, 0xF8, 0x0F, 0xDE, 0x07, 0xF7, 0xC1,
  0xF9, 0xF0, 0x3C, 0x3E, 0x07, 0x0F, 0xC0, 0x83, 0x80, 0x00, 0x80, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x0F, 0xC7, 0xF1, 0xF8, 0x7E, 0x3F,
  0x0F, 0xC3, 0xF1, 0xF8, 0x7E, 0x1F, 0x0F, 0xC3, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFE, 0xFF, 0xE0, 0x3C, 0x7E, 0x7F, 0xFF, 0xFE, 0xFE, 0x7C,
  0x10, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xE0,
  0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0x3F, 0x0F, 0xE3, 0xF0, 0xFC, 0x3F,
  0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x3F, 0x83, 0xF3, 0xF0, 0x3F, 0x3F, 0x03,
  0xF7, 0xF0, 0x3F, 0x7F, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x07, 0xF7, 0xE0,
  0x7F, 0xFE, 0x07, 0xEF, 0xE0, 0x7E, 0xFC, 0x0F, 0xEF, 0xC0, 0xFE, 0xFC,
  0x0F, 0xCF, 0xC1, 0xFC, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x3F, 0x0F,
  0xE7, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0x80,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFE, 0x03,
  0xFE, 0x0F, 0xFE, 0x1F, 0xFE, 0x3F, 0xFE, 0xFF, 0x7C, 0x7E, 0xFC, 0x3C,
  0xFC, 0x30, 0xFC, 0x10, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0,
  0x3F, 0x1F, 0xC0, 0x78, 0x1F, 0x80, 0x60, 0x3F, 0x00, 0x80, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x07,
  0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0x0F,
  0xF0, 0x10, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x88, 0x01, 0xFC, 0x38, 0x0F,
  0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7B, 0xF0, 0x01, 0xF7, 0xE0, 0x03,
  0xDF, 0x80, 0x0F, 0x3F, 0x00, 0x3E, 0x7E, 0x00, 0xF8, 0xFC, 0x01, 0xE1,
  0xF0, 0x07, 0xC7, 0xE0, 0x1F, 0x0F, 0xC0, 0x3C, 0x1F, 0x80, 0xF8, 0x3F,
  0x03, 0xE0, 0xFC, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF2, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xDE, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x08, 0x01, 0xFC, 0x38, 0x1F, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0xFD, 0xFF, 0x03,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFE, 0x3F, 0x87, 0xF0,
  0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE3, 0xF8, 0x1F, 0x8F, 0xE0, 0x7E,
  0x3F, 0x03, 0xF8, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x07, 0xE1, 0xFC, 0x1F,
  0x8F, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0x87, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0,
  0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0x7E, 0x1F, 0x81, 0xF8, 0xFE,
  0x07, 0xF7, 0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xC0, 0x03,
  0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xF3, 0xF0, 0x3F, 0x0F,
  0xE1, 0xFC, 0x1F, 0x87, 0xE0, 0x7E, 0x3F, 0x81, 0xF8, 0xFC, 0x07, 0xE3,
  0xF0, 0x1F, 0x8F, 0xE0, 0x7E, 0x3F, 0x83, 0xF8, 0x7F, 0xBF, 0xC1, 0xFF,
  0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xF1, 0xFE,
  0x7F, 0x1F, 0xC3, 0xF1, 0xF8, 0x3F, 0x3F, 0x83, 0xF3, 0xF0, 0x3F, 0x3F,
  0x03, 0xF3, 0xF0, 0x3F, 0x3F, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xF3,
  0xF0, 0xFF, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0x7E,
  0x0F, 0xEF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF0, 0x00, 0x7F, 0x08, 0x1F, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF,
  0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x7E,
  0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x07, 0xE0, 0x7F, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7C, 0x01, 0x00,
  0x00, 0x7C, 0x01, 0xF8, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E,
  0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xF0,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x00,
  0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xF8, 0x00,
  0x0E, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF,
  0xC7, 0xFF, 0xF3, 0xFF, 0xF8, 0xE0, 0xFC, 0x40, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0x10, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F,
  0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x0F, 0x01, 0xF0,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1E, 0x1F, 0x03, 0xFE, 0x3C, 0x3C, 0x1F,
  0xFC, 0x78, 0xF8, 0x7F, 0xF8, 0xF1, 0xE1, 0xF9, 0xF1, 0xE7, 0xC3, 0xC3,
  0xC3, 0xCF, 0x0F, 0x87, 0x87, 0x9E, 0x3E, 0x1F, 0x0F, 0x7C, 0x7C, 0x3E,
  0x1E, 0xF0, 0xF0, 0x78, 0x3D, 0xE3, 0xE0, 0xF0, 0xF3, 0xC7, 0xC3, 0xE1,
  0xE7, 0x8F, 0x87, 0xC3, 0xDF, 0x1E, 0x0F, 0x0F, 0x3E, 0x3E, 0x3E, 0x1E,
  0x7C, 0x7C, 0x7C, 0x78, 0xF8, 0xFF, 0xFF, 0xF1, 0xF0, 0xFF, 0x7F, 0xC3,
  0xE1, 0xFC, 0xFF, 0x03, 0xC0, 0xF0, 0x78, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x02, 0x00, 0x1F,
  0x80, 0x38, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0xBE, 0x00, 0x1F,
  0x3E, 0x00, 0x3F, 0x3E, 0x00, 0x3F, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x7E,
  0x3E, 0x00, 0x7C, 0x3E, 0x00, 0xFC, 0x3E, 0x00, 0xFC, 0x3E, 0x01, 0xF8,
  0x3E, 0x01, 0xF8, 0x3E, 0x03, 0xF0, 0x3E, 0x03, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xC0,
  0x3F, 0x1F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0x00,
  0x3F, 0x7F, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x03, 0xF0, 0xFF, 0x03, 0xF0, 0x7F, 0x03, 0xF0, 0x3F, 0x07, 0xF0,
  0x3F, 0x07, 0xE0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0x87, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x01, 0xF8, 0x3F, 0x01,
  0xF8, 0x3F, 0x03, 0xF8, 0x3F, 0x03, 0xF8, 0x7F, 0x0F, 0xF0, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0x8F, 0x03, 0xFC, 0x02, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xFC, 0x02, 0x03, 0xFC, 0x3C, 0x07, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xC1, 0xFE, 0x07, 0xE0,
  0x7F, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC,
  0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x1F,
  0x80, 0x7F, 0x0F, 0xC0, 0x3F, 0x87, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xC3,
  0xF8, 0x0F, 0xE1, 0xF8, 0x07, 0xF0, 0xFC, 0x03, 0xF0, 0xFE, 0x03, 0xF8,
  0x7F, 0x03, 0xFC, 0x3F, 0x01, 0xFC, 0x1F, 0x81, 0xFC, 0x0F, 0xC1, 0xFE,
  0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0xFF,
  0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xFC,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x3F, 0xF0, 0xF0, 0x3F, 0xE0, 0x18, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0xFC,
  0xFE, 0x0F, 0xFE, 0x7F, 0x07, 0xFE, 0x3F, 0x83, 0xFF, 0x1F, 0xC1, 0xFF,
  0x8F, 0xE0, 0x0F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xE1, 0xFC, 0x03,
  0xF0, 0xFE, 0x01, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0xC0, 0xFE, 0x0F, 0xF0,
  0x7E, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80,
  0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x07, 0xE0,
  0x3F, 0x00, 0xFE, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xF0,
  0x0F, 0xC0, 0x7F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0xC0, 0x7E, 0x01, 0xFC,
  0x07, 0xE0, 0x1F, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x01, 0xF8, 0x07, 0xF0, 0x1F, 0x80, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x3F,
  0x80, 0x7E, 0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFE, 0x03, 0xF0, 0x0F,
  0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x7F, 0x00, 0xFC, 0x07,
  0xE0, 0x1F, 0xC0, 0x7E, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x01,
  0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF,
  0xE0, 0x07, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8,
  0x0F, 0xF0, 0x1F, 0x80, 0xFE, 0x01, 0xF8, 0x1F, 0xC0, 0x1F, 0x83, 0xF8,
  0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x07, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0x3F,
  0x1F, 0xC0, 0x07, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x80, 0x07, 0xE7, 0xF0,
  0x00, 0x7E, 0x7E, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x01,
  0xF9, 0xFC, 0x00, 0x3F, 0x8F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F,
  0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xF0, 0x7E, 0x00,
  0x7E, 0x07, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0x7E, 0x07, 0xF0, 0x07, 0xE0,
  0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x17, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFC,
  0xFF, 0xFE, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xE0,
  0x03, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x03, 0xFE, 0x03,
  0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x7D, 0xF0, 0x3E, 0xF8, 0x07,
  0xDF, 0x07, 0xFF, 0x80, 0xFD, 0xF0, 0x7D, 0xF8, 0x0F, 0xDF, 0x0F, 0xDF,
  0x80, 0xFD, 0xF0, 0xF9, 0xF0, 0x0F, 0x9F, 0x0F, 0xBF, 0x00, 0xF9, 0xF1,
  0xF3, 0xF0, 0x1F, 0x9F, 0x1F, 0x3F, 0x01, 0xF9, 0xF3, 0xE3, 0xF0, 0x1F,
  0x9F, 0x3E, 0x3E, 0x01, 0xF1, 0xF7, 0xC7, 0xE0, 0x3F, 0x1F, 0x7C, 0x7E,
  0x03, 0xF1, 0xFF, 0x87, 0xE0, 0x3F, 0x1F, 0xF8, 0x7C, 0x03, 0xF1, 0xFF,
  0x8F, 0xC0, 0x3E, 0x1F, 0xF0, 0xFC, 0x07, 0xE1, 0xFF, 0x0F, 0xC0, 0x7E,
  0x1F, 0xE0, 0xFC, 0x07, 0xE1, 0xFE, 0x0F, 0x80, 0x7C, 0x0F, 0xC1, 0xF8,
  0x07, 0xC0, 0xFC, 0x1F, 0x80, 0xFC, 0x0F, 0x81, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0xFC, 0x07, 0xF0, 0x03, 0xE0, 0x1F, 0xE0, 0x1F, 0x80, 0x7F, 0x80,
  0x7E, 0x03, 0xFE, 0x01, 0xF8, 0x0F, 0xF8, 0x07, 0xE0, 0x3F, 0xF0, 0x1F,
  0x00, 0xFF, 0xC0, 0xFC, 0x07, 0xFF, 0x03, 0xF0, 0x1F, 0xFC, 0x0F, 0xC0,
  0x7D, 0xF0, 0x3E, 0x01, 0xF7, 0xE1, 0xF8, 0x07, 0xDF, 0x87, 0xE0, 0x3F,
  0x3E, 0x1F, 0x80, 0xFC, 0xF8, 0x7E, 0x03, 0xF3, 0xF1, 0xF0, 0x0F, 0x8F,
  0xCF, 0xC0, 0x3E, 0x3F, 0x3F, 0x01, 0xF8, 0x7C, 0xFC, 0x07, 0xE1, 0xF3,
  0xF0, 0x1F, 0x87, 0xEF, 0x80, 0x7C, 0x1F, 0xBE, 0x03, 0xF0, 0x7F, 0xF8,
  0x0F, 0xC0, 0xFF, 0xE0, 0x3F, 0x03, 0xFF, 0x00, 0xFC, 0x0F, 0xFC, 0x03,
  0xE0, 0x3F, 0xF0, 0x1F, 0x80, 0x7F, 0xC0, 0x7E, 0x01, 0xFF, 0x01, 0xF8,
  0x07, 0xF8, 0x07, 0xC0, 0x1F, 0xE0, 0x1F, 0x00, 0x7F, 0x80, 0xFC, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0xC7, 0xF8, 0x3F, 0xC1, 0xFC,
  0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0xCF, 0xE0, 0x0F,
  0xE7, 0xF0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xFC, 0x00,
  0xFE, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0x7F, 0x00, 0x1F, 0xBF, 0x80,
  0x1F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x07, 0xF3, 0xF8,
  0x03, 0xF9, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x3F,
  0x81, 0xFE, 0x0F, 0xF1, 0xFE, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xC1, 0xFC, 0x07, 0xE0, 0x7E, 0x07,
  0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0,
  0x7E, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x03, 0xF8, 0x1F, 0x87, 0xFC,
  0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0xC7,
  0xF8, 0x3F, 0xC1, 0xFC, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0,
  0x1F, 0xCF, 0xE0, 0x0F, 0xE7, 0xF0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF8,
  0x01, 0xFD, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0x7F,
  0x00, 0x1F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xE7,
  0xF0, 0x07, 0xF3, 0xF8, 0x03, 0xF9, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xFC,
  0x7F, 0x01, 0xFC, 0x3F, 0x81, 0xFE, 0x0F, 0xF1, 0xFE, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7E, 0x3F, 0xC0, 0xFC, 0x3F, 0x81,
  0xF8, 0x3F, 0x07, 0xF0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F,
  0x03, 0xF0, 0x7E, 0x0F, 0xE1, 0xFC, 0x3F, 0x83, 0xF0, 0xFF, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFC,
  0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF8, 0x0F, 0xE3, 0xF0, 0x1F, 0x87, 0xE0,
  0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0xC0, 0xFC, 0x1F, 0x83, 0xF8, 0x3F, 0x07,
  0xE0, 0x7F, 0x0F, 0xC0, 0xFE, 0x1F, 0x81, 0xFC, 0x3F, 0x01, 0xF8, 0xFE,
  0x03, 0xF8, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xF7, 0xC0, 0x7F, 0x03, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC2, 0x00,
  0x7F, 0x0C, 0x01, 0xFC, 0x3E, 0x1F, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0xF7,
  0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0x83,
  0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8,
  0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x3F, 0x80, 0x7E, 0x1F, 0xC0, 0x7F,
  0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC3, 0xF8, 0x0F,
  0xE1, 0xFC, 0x07, 0xF0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00,
  0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xC0, 0x3F, 0x07, 0xE0,
  0x1F, 0x87, 0xF0, 0x0F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xE0, 0xFE,
  0x03, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0xE3, 0xFC, 0x07,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x03,
  0xF7, 0xE0, 0x0F, 0xEF, 0xC0, 0x1F, 0x9F, 0x80, 0x7F, 0x3F, 0x00, 0xFC,
  0x7E, 0x01, 0xF8, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC1, 0xF0, 0x3F, 0x03,
  0xE0, 0x7E, 0x07, 0xC1, 0xFC, 0x0F, 0x83, 0xF0, 0x1F, 0x07, 0xE0, 0x3E,
  0x1F, 0x80, 0x7C, 0x3F, 0x00, 0xF8, 0xFC, 0x01, 0xF1, 0xF8, 0x03, 0xE7,
  0xE0, 0x07, 0xCF, 0xC0, 0x0F, 0x9F, 0x00, 0x1F, 0x7E, 0x00, 0x3E, 0xFC,
  0x00, 0x7D, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xFF, 0x80, 0x7E, 0x01, 0xFB,
  0xF0, 0x0F, 0xC0, 0x3F, 0x7E, 0x01, 0xF8, 0x0F, 0xEF, 0xC0, 0x7F, 0x01,
  0xF9, 0xF8, 0x0F, 0xE0, 0x3F, 0x3F, 0x03, 0xFC, 0x0F, 0xC7, 0xE0, 0x7F,
  0x81, 0xF8, 0xFC, 0x1F, 0xF0, 0x3F, 0x1F, 0x83, 0xFE, 0x0F, 0xC3, 0xF0,
  0x7F, 0xC1, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x0F, 0xC3, 0xFF, 0x0F, 0xC1,
  0xF8, 0xFB, 0xE1, 0xF8, 0x3F, 0x1F, 0x7C, 0x7E, 0x07, 0xE3, 0xEF, 0x8F,
  0xC0, 0xFC, 0xF9, 0xF3, 0xF0, 0x1F, 0x9F, 0x3E, 0x7E, 0x03, 0xF7, 0xC7,
  0xCF, 0xC0, 0x7C, 0xF8, 0xFB, 0xF0, 0x0F, 0x9F, 0x1F, 0x7E, 0x01, 0xF7,
  0xC3, 0xFF, 0x80, 0x3E, 0xF8, 0x7F, 0xF0, 0x07, 0xFE, 0x0F, 0xFE, 0x00,
  0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xF0, 0x03, 0xFE, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x0F, 0xF0, 0x1F, 0xF0, 0x01, 0xFE, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x80,
  0x3F, 0x81, 0xF8, 0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x3F,
  0x0F, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x3F, 0x7F,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0x7E, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x3F,
  0x8F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xFC, 0x1F,
  0xC0, 0x0F, 0xC0, 0xFE, 0x00, 0xFE, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80,
  0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFF, 0xF8, 0x0F, 0xE7, 0xE0, 0x3F,
  0x1F, 0x81, 0xFC, 0x7E, 0x07, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x87, 0xE0, 0x3E, 0x3F, 0x80, 0xFC, 0xFC, 0x03, 0xF7, 0xF0, 0x0F, 0xDF,
  0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x10, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xF8, 0x3E, 0x0F, 0x83, 0xF0, 0xFC,
  0x3F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF8, 0x7E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xF0, 0xFC, 0x3F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xE1, 0xF8, 0x7E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0xC0,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x7F, 0xE0, 0x3F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xBE, 0x00, 0xF8, 0xF8, 0x07,
  0xC7, 0xC0, 0x7C, 0x3E, 0x07, 0xE0, 0xF8, 0x3E, 0x07, 0xC3, 0xE0, 0x3E,
  0x3F, 0x01, 0xF1, 0xF0, 0x07, 0xDF, 0x00, 0x3F, 0xF8, 0x01, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0x1F, 0x87, 0xC3, 0xF0, 0xF8,
  0x3E, 0x00, 0x30, 0x00, 0x07, 0xF1, 0xF0, 0x3F, 0xEF, 0xC1, 0xFF, 0xBF,
  0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFC, 0x7F, 0x8F, 0xE0, 0xFE, 0x3F,
  0x83, 0xF0, 0xFC, 0x0F, 0xC7, 0xF0, 0x3F, 0x1F, 0xC0, 0xFC, 0x7E, 0x03,
  0xF1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x3F, 0x81, 0xF8, 0xFE, 0x07, 0xE3,
  0xF8, 0x3F, 0x8F, 0xE0, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x3F, 0xC3, 0xFF,
  0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFB, 0xE0, 0x3F, 0xCF, 0x80, 0x7E, 0x3E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x82, 0x00, 0x7E, 0x7E, 0x01, 0xFB, 0xFC, 0x07, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xF8, 0x7F, 0x0F, 0xC0, 0xFC,
  0x3F, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x81, 0xFC, 0x7E,
  0x07, 0xF1, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x0F,
  0xE3, 0xF0, 0x3F, 0x0F, 0xC1, 0xFC, 0x7F, 0x07, 0xE1, 0xFE, 0x3F, 0x87,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xE7, 0xFC, 0x0F, 0x8F,
  0xE0, 0x00, 0x00, 0x18, 0x00, 0x1F, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xE0,
  0xFF, 0xF8, 0x1F, 0xFF, 0x07, 0xF0, 0x20, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x01, 0x07, 0xE0, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x30, 0xFC, 0x01, 0xFC,
  0xFC, 0x03, 0xFE, 0xFC, 0x07, 0xFE, 0xF8, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF8, 0x1F, 0xC7, 0xF8, 0x1F, 0x83, 0xF8, 0x3F, 0x83, 0xF0, 0x3F, 0x03,
  0xF0, 0x7F, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x03,
  0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07,
  0xE0, 0xFC, 0x0F, 0xC0, 0xFE, 0x0F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xEF, 0x80, 0x1F, 0x8F,
  0x80, 0x00, 0x08, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F,
  0xFF, 0xE0, 0xFE, 0x7F, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x3F, 0x03, 0xE3,
  0xF0, 0x7E, 0x7E, 0x0F, 0xE7, 0xFF, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF0,
  0xFF, 0xFC, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x01, 0x07, 0xF0, 0xF0, 0x7F, 0xFF, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x9F, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x7F, 0x1F, 0x00, 0xFF, 0xBF, 0x01, 0xFF, 0xBF,
  0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xF1, 0xFE, 0x07, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0xC0, 0xFC, 0x1F, 0xC0, 0xFC,
  0x1F, 0x80, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x81, 0xF8, 0x3F, 0x81, 0xF8,
  0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF0, 0x3F, 0x87, 0xF0,
  0x3F, 0x8F, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0x0F, 0xF7, 0xE0, 0x07, 0xE7, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x80, 0x1F, 0xC0, 0xF0, 0x3F, 0x80,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x86, 0x00, 0x7E, 0x7F, 0x01, 0xFB, 0xFE,
  0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFC, 0x7F, 0x0F,
  0xE1, 0xFC, 0x3F, 0x07, 0xF0, 0xFC, 0x1F, 0x87, 0xF0, 0x7E, 0x1F, 0x81,
  0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x3F, 0x8F, 0xE0, 0xFC, 0x3F, 0x03, 0xF0,
  0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x07, 0xE1, 0xF8,
  0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x3F,
  0x0F, 0xC0, 0xFC, 0x00, 0x00, 0xF0, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F,
  0x80, 0xF8, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x81, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x9F, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7F,
  0x07, 0xE0, 0xFE, 0x07, 0xE1, 0xFC, 0x07, 0xC3, 0xF8, 0x0F, 0xC3, 0xF0,
  0x0F, 0xC7, 0xE0, 0x0F, 0xCF, 0xC0, 0x0F, 0xDF, 0xC0, 0x0F, 0xBF, 0x80,
  0x1F, 0xBF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xBF, 0x00, 0x3F, 0x3F, 0x80,
  0x3E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0xC0,
  0x7E, 0x0F, 0xC0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFC, 0x0F, 0xE0,
  0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x10, 0x03, 0xE3, 0xF0, 0x7F, 0x01, 0xF7,
  0xFC, 0x7F, 0xC0, 0xFF, 0xFF, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xC7, 0xF8, 0xFE, 0x1F, 0xC3, 0xF8, 0x3F, 0x0F,
  0xC1, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0x7E, 0x0F, 0xC3,
  0xF0, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x03, 0xF0, 0xFC, 0x1F, 0x81, 0xF8,
  0xFC, 0x0F, 0xC1, 0xF8, 0x7E, 0x07, 0xE0, 0xFC, 0x3F, 0x03, 0xE0, 0x7E,
  0x1F, 0x83, 0xF0, 0x3F, 0x0F, 0xC1, 0xF8, 0x1F, 0x0F, 0xC0, 0xFC, 0x1F,
  0x87, 0xE0, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x07, 0xE1, 0xF8, 0x3F, 0x03,
  0xF0, 0xF8, 0x1F, 0x83, 0xF0, 0xFC, 0x0F, 0xC1, 0xF8, 0x7E, 0x07, 0xE0,
  0xFC, 0x00, 0x00, 0x00, 0x80, 0x1F, 0x1F, 0xC0, 0x7C, 0xFF, 0x81, 0xF7,
  0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0x1F, 0xC3, 0xF8, 0x7F,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE1, 0xFC, 0x1F, 0x87, 0xE0, 0x7E, 0x1F,
  0x81, 0xF8, 0x7E, 0x07, 0xE3, 0xF8, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03,
  0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE1,
  0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x83, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0,
  0x3F, 0x00, 0x00, 0x18, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xC7, 0xF3, 0xF8, 0x3F, 0x3F, 0x03,
  0xF3, 0xF0, 0x3F, 0x7F, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0,
  0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC,
  0x0F, 0xEF, 0xE1, 0xFC, 0x7E, 0x1F, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x03,
  0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x60, 0x01, 0xF1, 0xF8, 0x01, 0xF3, 0xFC, 0x01, 0xF7, 0xFE, 0x01, 0xFF,
  0xFE, 0x03, 0xFE, 0xFF, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x7F, 0x07, 0xE0,
  0x7E, 0x07, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0,
  0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0xC1, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0xE3,
  0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0x7F, 0xE0, 0x3F, 0x7F,
  0xC0, 0x3F, 0x3F, 0x80, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x07, 0xF1, 0xF0, 0x3F, 0xEF, 0xC1, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFC, 0x7F, 0x87, 0xE0, 0xFE, 0x3F,
  0x83, 0xF0, 0xFC, 0x0F, 0xC7, 0xF0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x03,
  0xF1, 0xF8, 0x0F, 0x87, 0xE0, 0x7E, 0x3F, 0x81, 0xF8, 0xFC, 0x07, 0xE3,
  0xF0, 0x1F, 0x8F, 0xC0, 0xFC, 0x3F, 0x83, 0xF0, 0xFE, 0x1F, 0xC3, 0xFF,
  0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xDF, 0x80, 0x7E, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xC1, 0xF1, 0xF0,
  0x7C, 0xFC, 0x1F, 0x7F, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xE0, 0x7F,
  0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0x87, 0xF1, 0xE1, 0xF8, 0x10, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07,
  0xF2, 0x01, 0xF8, 0xC0, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xF0,
  0xFF, 0xF8, 0x1F, 0xF8, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x7F, 0xF7, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xF8,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0x00, 0x0F, 0xC0,
  0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x81, 0xF8,
  0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC,
  0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC1, 0xF8, 0x3E, 0x07, 0xE1, 0xF8, 0x1F,
  0x87, 0xE0, 0x7E, 0x1F, 0x83, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F,
  0xE1, 0xFC, 0x3F, 0x8F, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFE,
  0xF8, 0x1F, 0xF3, 0xE0, 0x1F, 0x8F, 0x80, 0xF8, 0x07, 0xFF, 0x81, 0xFF,
  0xF0, 0x3F, 0x7E, 0x07, 0xEF, 0xC1, 0xF9, 0xF8, 0x3F, 0x3F, 0x0F, 0xC7,
  0xE1, 0xF8, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xF1, 0xF0, 0x7E, 0x7E, 0x0F,
  0xCF, 0x81, 0xFB, 0xF0, 0x3F, 0x7C, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0xFF, 0xF0,
  0x7F, 0x07, 0xEF, 0xC3, 0xFC, 0x1F, 0xBE, 0x0F, 0xF0, 0x7C, 0xF8, 0x3F,
  0xC3, 0xF3, 0xE1, 0xFF, 0x0F, 0xCF, 0x87, 0xFC, 0x7E, 0x3E, 0x3F, 0xF1,
  0xF8, 0xF8, 0xFF, 0xC7, 0xC3, 0xE3, 0xDF, 0x3F, 0x0F, 0x9F, 0x7C, 0xFC,
  0x3E, 0x7D, 0xF7, 0xE0, 0xF9, 0xE7, 0xDF, 0x83, 0xEF, 0x9F, 0x7C, 0x0F,
  0xBC, 0x7F, 0xF0, 0x3F, 0xF1, 0xFF, 0x80, 0xFF, 0xC7, 0xBE, 0x03, 0xFE,
  0x1F, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0x07,
  0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x81, 0xFC,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x81, 0xF8, 0x3F, 0x00,
  0xFC, 0x3F, 0x80, 0x7E, 0x1F, 0x80, 0x1F, 0x9F, 0x80, 0x0F, 0xDF, 0xC0,
  0x07, 0xEF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x03, 0xF3, 0xF0, 0x01, 0xF9, 0xF8, 0x01, 0xF8, 0xFC, 0x01, 0xFC,
  0x7E, 0x01, 0xFC, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0,
  0xFC, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x0F,
  0xC3, 0xF0, 0x03, 0xF1, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x1F, 0x80,
  0x07, 0xCF, 0xC0, 0x01, 0xF3, 0xF0, 0x00, 0x7D, 0xF8, 0x00, 0x1F, 0x7E,
  0x00, 0x07, 0xDF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F,
  0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07,
  0xE0, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x17, 0xFE, 0x03, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0x80, 0x3F, 0xC8, 0x00, 0x30,
};

const GFXglyph NotoSans_Condensed_BoldItalic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 14, 34, 12, 0, -33 },
  { 61, 17, 12, 19, 4, -33 },
  { 87, 25, 33, 24, 0, -33 },
  { 191, 22, 38, 21, 0, -35 },
  { 296, 31, 33, 35, 2, -33 },
  { 424, 26, 33, 26, 0, -33 },
  { 532, 7, 12, 11, 5, -33 },
  { 543, 16, 40, 13, 1, -33 },
  { 623, 15, 40, 13, -3, -33 },
  { 698, 18, 20, 21, 4, -35 },
  { 743, 20, 22, 23, 2, -27 },
  { 798, 10, 12, 12, -2, -6 },
  { 813, 12, 5, 14, 1, -15 },
  { 821, 8, 8, 12, 0, -7 },
  { 829, 24, 33, 18, -2, -33 },
  { 928, 20, 33, 21, 1, -33 },
  { 1011, 16, 33, 22, 4, -33 },
  { 1077, 23, 33, 21, -2, -33 },
  { 1172, 22, 33, 21, 0, -33 },
  { 1263, 23, 33, 22, -1, -33 },
  { 1358, 22, 33, 21, 0, -33 },
  { 1449, 22, 33, 21, 1, -33 },
  { 1540, 23, 33, 21, 1, -33 },
  { 1635, 22, 33, 21, 0, -33 },
  { 1726, 20, 33, 21, 1, -33 },
  { 1809, 12, 26, 12, 0, -25 },
  { 1848, 15, 31, 12, -3, -25 },
  { 1907, 20, 23, 23, 2, -28 },
  { 1965, 20, 14, 23, 2, -23 },
  { 2000, 20, 23, 23, 2, -28 },
  { 2058, 17, 34, 17, 2, -33 },
  { 2131, 31, 37, 33, 1, -33 },
  { 2275, 24, 33, 24, -3, -33 },
  { 2374, 24, 33, 24, 0, -33 },
  { 2473, 23, 33, 23, 2, -33 },
  { 2568, 25, 33, 26, 0, -33 },
  { 2672, 22, 33, 20, 0, -33 },
  { 2763, 22, 33, 20, 0, -33 },
  { 2854, 25, 33, 26, 2, -33 },
  { 2958, 28, 33, 27, 0, -33 },
  { 3074, 21, 33, 16, -2, -33 },
  { 3161, 21, 43, 13, -7, -33 },
  { 3274, 28, 33, 23, 0, -33 },
  { 3390, 17, 33, 20, 0, -33 },
  { 3461, 36, 33, 35, 0, -33 },
  { 3610, 30, 33, 29, 0, -33 },
  { 3734, 25, 33, 28, 2, -33 },
  { 3838, 25, 33, 23, 0, -33 },
  { 3942, 25, 41, 28, 2, -33 },
  { 4071, 23, 33, 23, 0, -33 },
  { 4166, 22, 33, 21, 0, -33 },
  { 4257, 20, 33, 20, 4, -33 },
  { 4340, 25, 33, 26, 2, -33 },
  { 4444, 23, 33, 23, 4, -33 },
  { 4539, 35, 33, 35, 4, -33 },
  { 4684, 29, 33, 23, -3, -33 },
  { 4804, 22, 33, 21, 4, -33 },
  { 4895, 25, 33, 20, -2, -33 },
  { 4999, 19, 40, 14, -2, -33 },
  { 5094, 10, 33, 18, 5, -33 },
  { 5136, 18, 40, 14, -3, -33 },
  { 5226, 21, 20, 22, 0, -33 },
  { 5279, 16, 3, 16, -4, 4 },
  { 5285, 9, 7, 14, 7, -35 },
  { 5293, 22, 26, 23, 1, -26 },
  { 5365, 22, 35, 23, 0, -35 },
  { 5462, 19, 26, 18, 1, -26 },
  { 5524, 24, 35, 23, 1, -35 },
  { 5629, 20, 26, 21, 1, -26 },
  { 5694, 24, 46, 14, -5, -35 },
  { 5832, 24, 37, 23, -1, -26 },
  { 5943, 22, 35, 23, 0, -35 },
  { 6040, 13, 35, 12, 0, -35 },
  { 6097, 19, 46, 12, -6, -35 },
  { 6207, 24, 35, 22, 0, -35 },
  { 6312, 14, 35, 11, 0, -35 },
  { 6374, 33, 26, 34, 0, -26 },
  { 6482, 22, 26, 23, 0, -26 },
  { 6554, 20, 27, 22, 1, -26 },
  { 6622, 24, 37, 23, -2, -26 },
  { 6733, 22, 37, 23, 1, -26 },
  { 6835, 18, 26, 16, 0, -26 },
  { 6894, 18, 26, 18, 0, -26 },
  { 6953, 14, 30, 15, 2, -30 },
  { 7006, 22, 25, 23, 1, -25 },
  { 7075, 19, 25, 20, 3, -25 },
  { 7135, 30, 25, 31, 3, -25 },
  { 7229, 25, 25, 20, -2, -25 },
  { 7308, 26, 36, 20, -3, -25 },
  { 7425, 20, 25, 17, -1, -25 },
  { 7488, 19, 40, 16, 0, -33 },
  { 7583, 5, 45, 20, 7, -35 },
  { 7612, 18, 40, 16, -3, -33 },
  { 7702, 20, 8, 23, 2, -20 },
};

const GFXfont NotoSans_Condensed_BoldItalic46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BoldItalic46pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BoldItalic46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_CONDENSED_BOLDITALIC46PT7B_H_
