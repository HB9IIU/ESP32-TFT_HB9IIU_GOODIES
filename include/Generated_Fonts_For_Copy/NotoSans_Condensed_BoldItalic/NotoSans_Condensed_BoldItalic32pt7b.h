#ifndef _NOTOSANS_CONDENSED_BOLDITALIC32PT7B_H_
#define _NOTOSANS_CONDENSED_BOLDITALIC32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BoldItalic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BoldItalic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x03, 0xC1, 0xF0, 0x7C, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x03,
  0x01, 0xE0, 0xF8, 0x3E, 0x0F, 0x00, 0x79, 0xEF, 0x3D, 0xE7, 0xBC, 0xF7,
  0x1D, 0xE7, 0xBC, 0xF7, 0x1C, 0x00, 0xE3, 0x80, 0x39, 0xC0, 0x1C, 0x70,
  0x07, 0x1C, 0x01, 0xCE, 0x00, 0xE3, 0x81, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F,
  0xFF, 0x81, 0xC7, 0x00, 0x73, 0xC0, 0x1C, 0xE0, 0x0E, 0x38, 0x03, 0x8E,
  0x47, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFE, 0x07, 0x38, 0x03, 0x8E, 0x00,
  0xE3, 0x80, 0x39, 0xE0, 0x0E, 0x70, 0x07, 0x1C, 0x00, 0x00, 0x30, 0x00,
  0x40, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xE1, 0xFF, 0x87, 0xD3, 0x0F, 0x60,
  0x1E, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0xBE, 0x01, 0x7C, 0x86, 0xF1, 0x8D, 0xE7, 0xFF, 0xCF, 0xFF,
  0x1F, 0xFC, 0x03, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x1F, 0x01,
  0xE1, 0xFC, 0x0E, 0x0F, 0xE0, 0xE0, 0xE7, 0x07, 0x07, 0x38, 0x70, 0x79,
  0xC7, 0x83, 0x8E, 0x38, 0x1C, 0x73, 0x80, 0xE7, 0x9C, 0x07, 0x39, 0xCF,
  0x39, 0xDE, 0xFD, 0xFC, 0xEF, 0xFF, 0xEE, 0x73, 0xBE, 0x77, 0x9C, 0x07,
  0x38, 0xE0, 0x79, 0xC7, 0x03, 0x8E, 0x78, 0x38, 0xF3, 0x81, 0xC7, 0x9C,
  0x1C, 0x3D, 0xE1, 0xE1, 0xFE, 0x0E, 0x07, 0xE0, 0xE0, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x01, 0xC7,
  0x80, 0xF1, 0xE0, 0x1E, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x8F, 0x1F, 0xE7, 0xCF, 0x79, 0xE7, 0xDF, 0x79, 0xE3, 0xFC, 0xF8,
  0xFF, 0x3E, 0x1F, 0x8F, 0x87, 0xC3, 0xF7, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF,
  0xC3, 0xF9, 0xF0, 0x7D, 0xE7, 0x9E, 0x71, 0xCF, 0x3C, 0x01, 0xE0, 0x78,
  0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x81, 0xE0,
  0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xC0, 0x3C, 0x00,
  0x03, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0x80,
  0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x0F, 0x01,
  0xE0, 0x78, 0x00, 0x04, 0x00, 0x78, 0x07, 0x84, 0x70, 0xE7, 0x0F, 0xF7,
  0xFF, 0xF3, 0xFF, 0x1F, 0x73, 0xF8, 0x7B, 0x8F, 0xBC, 0x31, 0xE2, 0x18,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0x1F, 0x1E, 0x3E, 0x3C, 0x3C, 0x78, 0x78, 0xF0, 0x7F,
  0xBF, 0xDF, 0xFF, 0xE0, 0x33, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x1F,
  0xE0, 0xFF, 0x87, 0xFF, 0x1E, 0x3C, 0xF0, 0xF3, 0xC3, 0xDF, 0x0F, 0x78,
  0x3D, 0xE1, 0xFF, 0x87, 0xFE, 0x1E, 0xF0, 0x7B, 0xC1, 0xEF, 0x0F, 0xBC,
  0x3C, 0xF0, 0xF3, 0xC7, 0xCF, 0x1E, 0x3F, 0xF8, 0xFF, 0xC1, 0xFE, 0x03,
  0xF0, 0x00, 0x01, 0xE0, 0x7C, 0x3F, 0x8F, 0xE3, 0xFC, 0xFF, 0xBE, 0xF3,
  0xBC, 0x47, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x00, 0x01, 0xFC,
  0x03, 0xFE, 0x0F, 0xFE, 0x0F, 0xFF, 0x06, 0x1F, 0x04, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0x7F, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x03, 0xF8, 0x1F, 0xF8,
  0x3F, 0xF8, 0x7F, 0xF0, 0x43, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00,
  0x7C, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFF, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF2, 0x03, 0xE7, 0xBF, 0x8F, 0xFF, 0x1F,
  0xF8, 0x3F, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xE0,
  0x0F, 0xC0, 0x3F, 0x80, 0xEF, 0x01, 0xDE, 0x07, 0x78, 0x1C, 0xF0, 0x79,
  0xE0, 0xE3, 0xC3, 0x8F, 0x0F, 0x1E, 0x1C, 0x3C, 0x7F, 0xFE, 0xFF, 0xFD,
  0xFF, 0xF8, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x00,
  0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x7F, 0xF0, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3F, 0xE0, 0xFF, 0xE1, 0xFF, 0xC1, 0x0F,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF2, 0x07, 0xE7,
  0xBF, 0x8F, 0xFE, 0x1F, 0xF8, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x07, 0xFC,
  0x1F, 0xF0, 0x7F, 0xE0, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7D,
  0xE0, 0xF7, 0xE1, 0xFF, 0xC3, 0xFF, 0xCF, 0xCF, 0x9F, 0x0F, 0x3E, 0x1E,
  0x78, 0x7C, 0xF0, 0xF9, 0xE1, 0xE3, 0xC7, 0xC7, 0xDF, 0x87, 0xFE, 0x0F,
  0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0,
  0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xF8, 0x3F, 0xF8, 0x79, 0xF1, 0xE1, 0xE3,
  0xC3, 0xC7, 0x87, 0x8F, 0x9F, 0x0F, 0x7C, 0x1F, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFF, 0x07, 0xDF, 0x1F, 0x1E, 0x3C, 0x3C, 0xF8, 0x7D, 0xE0, 0xF3,
  0xE1, 0xE7, 0xC7, 0xC7, 0xFF, 0x0F, 0xFC, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0xE1, 0xE3, 0xE7, 0xC7, 0xCF, 0x0F, 0x9E,
  0x1F, 0x3C, 0x3E, 0x78, 0x7C, 0xF1, 0xF1, 0xFF, 0xE3, 0xFF, 0xC3, 0xF7,
  0x83, 0xDE, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x86, 0x3F, 0x0F,
  0xFC, 0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0x06, 0x1F, 0x1F, 0x1F, 0x1E, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x78, 0xF8, 0xF8, 0xF0,
  0x01, 0x80, 0xF0, 0x7C, 0x1F, 0x07, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x78, 0x3E, 0x0F, 0x03, 0xC1,
  0xE0, 0x78, 0x3C, 0x00, 0x00, 0x0C, 0x00, 0xF0, 0x0F, 0xC0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xE0, 0x3E, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xC0, 0x03, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0x01, 0xFC, 0x1F, 0xE1, 0xFE, 0x1F, 0xE0, 0xFC, 0x03,
  0xC0, 0x0C, 0x00, 0x00, 0x0F, 0xC3, 0xFE, 0x3F, 0xF3, 0xDF, 0x20, 0xF0,
  0x0F, 0x00, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x1E, 0x03,
  0xC0, 0x3C, 0x03, 0x80, 0x00, 0x00, 0x00, 0x30, 0x07, 0x80, 0xF8, 0x0F,
  0x80, 0x70, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01,
  0xE0, 0x1C, 0x0F, 0x00, 0x38, 0x78, 0x00, 0xE1, 0xC3, 0xFB, 0x8E, 0x1F,
  0xC7, 0x38, 0xFF, 0x1D, 0xC7, 0x1C, 0x77, 0x3C, 0x73, 0x9C, 0xE3, 0x8E,
  0xE3, 0x8E, 0x3B, 0x9E, 0x38, 0xEE, 0x70, 0xE7, 0x39, 0xC7, 0x9C, 0xE7,
  0xBE, 0xE3, 0x8F, 0xFF, 0x8E, 0x3E, 0x7C, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xC0, 0x60, 0x0F, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xBC, 0x03, 0xDE, 0x01, 0xEF, 0x01, 0xE7,
  0x80, 0xF3, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x7C, 0x78, 0x3F, 0xFC, 0x3F,
  0xFE, 0x1F, 0xFF, 0x0F, 0x07, 0x8F, 0x83, 0xC7, 0x81, 0xE7, 0xC0, 0xFB,
  0xC0, 0x7F, 0xE0, 0x3E, 0x07, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xC1, 0xFF,
  0xF0, 0xF0, 0xF8, 0x78, 0x7C, 0x3C, 0x3E, 0x3E, 0x1E, 0x1F, 0x1F, 0x0F,
  0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0xC1, 0xE1, 0xF0, 0xF0, 0x78,
  0x78, 0x3C, 0x3C, 0x3E, 0x3E, 0x1F, 0x1E, 0x1F, 0x0F, 0xFF, 0x87, 0xFF,
  0x87, 0xFF, 0x83, 0xFF, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xC1,
  0xFF, 0xC1, 0xF8, 0x20, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x04, 0x0F, 0xFE, 0x07,
  0xFF, 0x01, 0xFF, 0x80, 0x7F, 0x80, 0x07, 0xF0, 0x01, 0xFF, 0x80, 0x7F,
  0xF0, 0x3F, 0xFE, 0x0F, 0x8F, 0x83, 0xC3, 0xE0, 0xF0, 0x78, 0x7C, 0x1F,
  0x1F, 0x07, 0xC7, 0x81, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x3E, 0x0F, 0x8F,
  0x83, 0xE3, 0xC0, 0xF0, 0xF0, 0x7C, 0x3C, 0x1F, 0x1F, 0x0F, 0x87, 0xC7,
  0xC1, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xF8, 0x0F, 0xF8, 0x00, 0x07, 0xFF,
  0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8,
  0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7F, 0xF0, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x07, 0xFF, 0x07, 0xFE,
  0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x7F,
  0xF8, 0x3F, 0xFE, 0x0F, 0x81, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC7, 0xF1, 0xE1, 0xFC, 0x78, 0x7F, 0x3E,
  0x3F, 0xCF, 0x81, 0xF3, 0xE0, 0x78, 0xF8, 0x1E, 0x1E, 0x07, 0x87, 0xC3,
  0xE1, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0x80, 0x07, 0x81,
  0xE0, 0xF0, 0x3C, 0x1E, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x3E, 0x1E, 0x07,
  0x83, 0xC0, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xFF, 0xF0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7C, 0x1F, 0x0F, 0x03, 0xC1, 0xE0, 0x78,
  0x3C, 0x0F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x3C, 0x0F, 0x07, 0x81, 0xE1,
  0xF0, 0x7C, 0x3E, 0x0F, 0x80, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x80, 0xF8,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0x80, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x03, 0xFE,
  0x07, 0xF8, 0x0F, 0xE0, 0x0F, 0x00, 0x00, 0x07, 0x83, 0xE0, 0xF0, 0xF8,
  0x1E, 0x1E, 0x07, 0xC7, 0xC0, 0xF1, 0xF0, 0x1E, 0x3C, 0x03, 0xCF, 0x80,
  0xFB, 0xE0, 0x1F, 0xF8, 0x03, 0xDE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xBC, 0x01, 0xE7, 0xC0, 0x3C, 0xF8, 0x0F,
  0x8F, 0x01, 0xE1, 0xE0, 0x3C, 0x3E, 0x07, 0x87, 0xC1, 0xF0, 0xF8, 0x3E,
  0x0F, 0x00, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F,
  0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3C,
  0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x07, 0xFF, 0x7F, 0xEF, 0xFE, 0xFF,
  0xE0, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x1F, 0xC1, 0xF8, 0x0F, 0xC1, 0xFC,
  0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x07, 0xF8, 0x3F, 0x83, 0xF8, 0x3D,
  0xC3, 0xFC, 0x1E, 0xE1, 0xFE, 0x0F, 0x70, 0xEF, 0x07, 0xB8, 0xF7, 0x83,
  0xDC, 0x77, 0x83, 0xCE, 0x7B, 0xC1, 0xE7, 0x39, 0xE0, 0xF3, 0xBC, 0xF0,
  0x79, 0xDC, 0xF8, 0x3C, 0xFE, 0x78, 0x3C, 0x7E, 0x3C, 0x1E, 0x3F, 0x1E,
  0x0F, 0x1F, 0x0F, 0x07, 0x8F, 0x8F, 0x07, 0x87, 0xC7, 0x83, 0xC3, 0xC3,
  0xC0, 0x07, 0xC0, 0x78, 0x3E, 0x07, 0x81, 0xF0, 0x3C, 0x1F, 0xC1, 0xE0,
  0xFE, 0x0F, 0x07, 0xF0, 0xF0, 0x3F, 0x87, 0x83, 0xDC, 0x3C, 0x1E, 0xF1,
  0xE0, 0xF7, 0x8F, 0x07, 0xBC, 0xF0, 0x3D, 0xE7, 0x83, 0xC7, 0xBC, 0x1E,
  0x3D, 0xE0, 0xF1, 0xEF, 0x07, 0x8F, 0x70, 0x3C, 0x3F, 0x83, 0xC1, 0xFC,
  0x1E, 0x0F, 0xE0, 0xF0, 0x7F, 0x07, 0x83, 0xF0, 0x78, 0x0F, 0x83, 0xC0,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F,
  0x8F, 0x87, 0xC1, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x7C, 0x07, 0xDF, 0x01,
  0xF7, 0xC0, 0x7D, 0xE0, 0x1E, 0x78, 0x07, 0xBE, 0x03, 0xEF, 0x80, 0xFB,
  0xE0, 0x3C, 0xF8, 0x1F, 0x3E, 0x0F, 0x87, 0xC3, 0xE1, 0xFF, 0xF0, 0x7F,
  0xF8, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0x01, 0xFF,
  0xC1, 0xFF, 0xF0, 0xF0, 0xF8, 0x78, 0x7C, 0x3C, 0x1E, 0x3E, 0x1F, 0x1F,
  0x0F, 0x8F, 0x07, 0x87, 0x87, 0xC3, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xC0,
  0xFF, 0x80, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0,
  0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0x8F, 0x87, 0xC1, 0xF3, 0xE0, 0x7C, 0xF8,
  0x1F, 0x7C, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x7D, 0xE0, 0x1E, 0x78, 0x0F,
  0xBE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3C, 0xF8, 0x1F, 0x3E, 0x0F, 0x87,
  0xC3, 0xE1, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x07, 0xF8,
  0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xFF, 0x0F, 0x1F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x1F, 0x0F, 0x1F, 0x1F, 0x1E, 0x1F, 0x1E, 0x7E, 0x1F, 0xFC, 0x3F, 0xF8,
  0x3F, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF8, 0x7C, 0x78, 0x78, 0x78,
  0x78, 0x78, 0x78, 0x7C, 0xF8, 0x7C, 0xF8, 0x3C, 0x01, 0xFC, 0x0F, 0xFC,
  0x3F, 0xF8, 0x7F, 0xE1, 0xF0, 0x43, 0xE0, 0x07, 0x80, 0x0F, 0x80, 0x1F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF3, 0x07, 0xC7, 0xFF, 0x8F, 0xFE, 0x1F,
  0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xC3, 0xC1, 0xF1, 0xF0,
  0x7C, 0x7C, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0xF8, 0xF8, 0x3E,
  0x3E, 0x0F, 0x0F, 0x03, 0xC3, 0xC1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1E, 0x1E,
  0x07, 0x87, 0x81, 0xE1, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x0F, 0x87,
  0xC1, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFC, 0x01, 0xFC, 0x00, 0xF0, 0x1F,
  0xF0, 0x1E, 0xF0, 0x3E, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x78, 0xF0, 0x78,
  0xF0, 0xF8, 0xF0, 0xF0, 0xF1, 0xF0, 0xF1, 0xE0, 0xF1, 0xE0, 0xF3, 0xC0,
  0xF3, 0xC0, 0xF7, 0x80, 0xF7, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF0, 0x3C, 0x0F, 0xF0,
  0x3C, 0x1F, 0xF0, 0x7C, 0x1E, 0xF0, 0x7C, 0x3E, 0xF0, 0xFC, 0x3C, 0xF0,
  0xFC, 0x3C, 0xF0, 0xFC, 0x7C, 0xF1, 0xFC, 0x78, 0xF1, 0xFC, 0x78, 0xF3,
  0xFC, 0xF0, 0xF3, 0xBC, 0xF0, 0xF7, 0xBD, 0xF0, 0xF7, 0xBD, 0xE0, 0xF7,
  0x3D, 0xE0, 0xFF, 0x3F, 0xC0, 0xEE, 0x3B, 0xC0, 0xEE, 0x3B, 0xC0, 0xFE,
  0x3F, 0x80, 0xFC, 0x3F, 0x80, 0xFC, 0x3F, 0x00, 0xF8, 0x3F, 0x00, 0xF8,
  0x3E, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x3C, 0x1E, 0x03, 0xC3,
  0xE0, 0x3C, 0x7C, 0x03, 0xE7, 0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x7B, 0xC0, 0x0F, 0xBC, 0x00,
  0xF3, 0xC0, 0x1F, 0x3E, 0x03, 0xE3, 0xE0, 0x3C, 0x1E, 0x07, 0xC1, 0xE0,
  0xF8, 0x1F, 0x00, 0xF0, 0x3F, 0xE0, 0xFB, 0xE1, 0xE7, 0xC7, 0xC7, 0x8F,
  0x0F, 0x3E, 0x1E, 0x78, 0x3D, 0xE0, 0x7B, 0xC0, 0xFF, 0x00, 0xFE, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xE0, 0x01, 0xE0, 0x01, 0xF0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xC0,
  0x03, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x00, 0xF1, 0xE1,
  0xC3, 0x87, 0x8F, 0x1E, 0x3C, 0x78, 0x70, 0xE1, 0xE3, 0xC7, 0x8F, 0x1E,
  0x1C, 0x38, 0x78, 0xF1, 0xE3, 0xC7, 0x80, 0x03, 0xF8, 0x3F, 0x81, 0xFC,
  0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x60, 0x01, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x3F, 0x00, 0xFF, 0x01, 0xDE, 0x07, 0x9C, 0x0E, 0x38, 0x3C, 0x78,
  0xF0, 0xF1, 0xC0, 0xE7, 0x81, 0xDE, 0x03, 0xC0, 0xFF, 0xFF, 0xFE, 0xF3,
  0xE7, 0x9E, 0x3C, 0x70, 0x03, 0x80, 0x1F, 0xBC, 0x7F, 0x79, 0xFF, 0xE3,
  0xE7, 0xCF, 0x8F, 0x9E, 0x1F, 0x3C, 0x3E, 0xF8, 0x79, 0xF0, 0xF3, 0xC1,
  0xE7, 0x87, 0xCF, 0x0F, 0x9E, 0x3E, 0x3E, 0xFC, 0x7F, 0xF8, 0x7E, 0xF0,
  0xF9, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xCE, 0x0F, 0xFE, 0x1F, 0xFE, 0x3F, 0xFC, 0x7C, 0x78, 0xF0,
  0xF3, 0xE1, 0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x1F, 0x3C, 0x3E, 0xF8, 0x79,
  0xF1, 0xF3, 0xE3, 0xC7, 0xCF, 0x8F, 0xFE, 0x3F, 0xF8, 0x7B, 0xE0, 0x03,
  0xE0, 0x7F, 0xC7, 0xFC, 0x7F, 0xE3, 0xE2, 0x3E, 0x01, 0xE0, 0x0F, 0x00,
  0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x23, 0xF7, 0x1F,
  0xF8, 0x7F, 0xC1, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x07, 0x9E, 0x0F, 0xDE, 0x1F, 0xFE, 0x3F,
  0xFC, 0x3E, 0x7C, 0x7C, 0x7C, 0x78, 0x7C, 0x78, 0x7C, 0xF8, 0x78, 0xF0,
  0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0xF0, 0xF0, 0xF0, 0xF9, 0xF0, 0xFF,
  0xF0, 0x7F, 0xF0, 0x3C, 0xE0, 0x01, 0xE0, 0x7F, 0x87, 0xFE, 0x7F, 0xF3,
  0xC7, 0xBE, 0x3D, 0xE1, 0xEF, 0x3F, 0xFF, 0xF7, 0xFE, 0x3F, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xE1, 0x8F, 0xFC, 0x7F, 0xE1, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x0F, 0xF0,
  0x07, 0xF0, 0x03, 0xF0, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x07, 0xEF, 0x0F,
  0xEF, 0x1F, 0xFE, 0x1F, 0x3E, 0x3E, 0x3E, 0x3C, 0x3E, 0x3C, 0x3E, 0x7C,
  0x3C, 0x7C, 0x3C, 0x78, 0x3C, 0x78, 0x7C, 0x78, 0x7C, 0x78, 0xF8, 0x7D,
  0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x3E, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01,
  0xF0, 0x83, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0x1E, 0x00, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xCE,
  0x07, 0xFE, 0x1F, 0xFE, 0x3F, 0xFC, 0x7C, 0xF8, 0xF0, 0xF3, 0xE1, 0xE7,
  0xC7, 0xCF, 0x0F, 0x1E, 0x1E, 0x3C, 0x3C, 0xF8, 0x79, 0xE1, 0xF3, 0xC3,
  0xC7, 0x87, 0x8F, 0x0F, 0x3E, 0x1E, 0x78, 0x7C, 0x07, 0x83, 0xC3, 0xE0,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x1F, 0x0F, 0x07, 0x83, 0xC3, 0xE1, 0xF0,
  0xF0, 0x78, 0x3C, 0x3E, 0x1E, 0x0F, 0x07, 0x83, 0xC3, 0xE1, 0xE0, 0x00,
  0x78, 0x03, 0xC0, 0x3E, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x0F, 0xE0, 0x7F, 0x03,
  0xF0, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x02, 0x1E, 0x3E, 0x1E, 0x3E, 0x0F, 0x1E,
  0x07, 0x9E, 0x03, 0xDE, 0x03, 0xDF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F,
  0xC0, 0x3F, 0xE0, 0x3E, 0xF0, 0x1E, 0x7C, 0x0F, 0x1E, 0x07, 0x8F, 0x03,
  0xC7, 0x83, 0xC3, 0xE1, 0xE0, 0xF0, 0x07, 0x83, 0xC1, 0xE1, 0xF0, 0xF0,
  0x78, 0x3C, 0x3E, 0x1F, 0x0F, 0x07, 0x83, 0xC3, 0xE1, 0xF0, 0xF0, 0x78,
  0x3C, 0x3E, 0x1E, 0x0F, 0x07, 0x83, 0xC3, 0xE1, 0xE0, 0x00, 0x38, 0x38,
  0x1D, 0xF9, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF1, 0xF3, 0xF3, 0xE3,
  0xC3, 0xC7, 0xCF, 0x8F, 0x8F, 0x9E, 0x1E, 0x1E, 0x3C, 0x3C, 0x3C, 0x78,
  0x78, 0x78, 0xF0, 0xF0, 0xF3, 0xE3, 0xE3, 0xC7, 0x87, 0x87, 0x8F, 0x0F,
  0x0F, 0x1E, 0x1E, 0x1E, 0x3C, 0x3C, 0x7C, 0xF0, 0xF0, 0xF1, 0xE1, 0xE1,
  0xE0, 0x00, 0x30, 0x1D, 0xF8, 0x7F, 0xF8, 0xFF, 0xF1, 0xF1, 0xE3, 0xC3,
  0xCF, 0x87, 0x9F, 0x1F, 0x3C, 0x3C, 0x78, 0x78, 0xF0, 0xF3, 0xE1, 0xE7,
  0x87, 0xCF, 0x0F, 0x1E, 0x1E, 0x3C, 0x3C, 0xF8, 0x79, 0xE1, 0xF0, 0x03,
  0xC0, 0x3F, 0xC1, 0xFF, 0x8F, 0xFE, 0x3C, 0x7D, 0xF1, 0xF7, 0x83, 0xFE,
  0x1F, 0xF8, 0x7F, 0xC1, 0xEF, 0x07, 0xBC, 0x1E, 0xF0, 0xFB, 0xC3, 0xCF,
  0xBF, 0x1F, 0xF8, 0x7F, 0xC0, 0xFE, 0x00, 0x00, 0x0E, 0x01, 0xDF, 0x81,
  0xFF, 0xE0, 0xFF, 0xF0, 0x7C, 0x78, 0x3C, 0x3C, 0x3E, 0x1E, 0x1E, 0x0F,
  0x0F, 0x07, 0x87, 0x87, 0xC3, 0xC3, 0xE3, 0xE1, 0xE1, 0xF1, 0xF0, 0xF8,
  0xF8, 0x7C, 0xF8, 0x3F, 0xF8, 0x3D, 0xFC, 0x1E, 0x78, 0x0F, 0x00, 0x07,
  0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0x80, 0x1F, 0xBC, 0x7F, 0xF9, 0xFF, 0xE3, 0xC7,
  0xCF, 0x8F, 0x9E, 0x1F, 0x3C, 0x3E, 0xF8, 0x79, 0xE0, 0xF3, 0xC1, 0xE7,
  0x83, 0xCF, 0x0F, 0x9E, 0x1E, 0x3E, 0xFC, 0x7F, 0xF8, 0x7E, 0xF0, 0xFB,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x80, 0x00, 0x38, 0xF7, 0x87, 0xFC, 0x3F, 0xE1, 0xFF,
  0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x7F, 0xC7, 0xFC, 0x7F, 0xE3, 0xC1, 0x1E, 0x00, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x41, 0xF3, 0x9F, 0x9F, 0xF8,
  0xFF, 0x87, 0xF8, 0x00, 0x07, 0x03, 0xC0, 0xE0, 0x78, 0x3F, 0xDF, 0xF7,
  0xFC, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0xF0, 0x3E, 0x4F, 0xE1, 0xF8, 0x7E, 0x00, 0x3E, 0x1E, 0x78, 0x7C, 0xF0,
  0xF1, 0xE1, 0xE3, 0xC3, 0xCF, 0x07, 0x9E, 0x1E, 0x3C, 0x3C, 0x78, 0x78,
  0xF0, 0xF3, 0xC3, 0xE7, 0x87, 0x8F, 0x1F, 0x1F, 0x7E, 0x3F, 0xFC, 0x7F,
  0x78, 0x7C, 0xE0, 0xF0, 0x7F, 0xC3, 0xEF, 0x0F, 0x3C, 0x3C, 0xF1, 0xE3,
  0xC7, 0x8F, 0x3C, 0x3C, 0xF0, 0xF7, 0x83, 0xDE, 0x0F, 0xF0, 0x3F, 0xC0,
  0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x00, 0xF0, 0xF8, 0xFF,
  0x8F, 0xC7, 0xBC, 0x7E, 0x3D, 0xE3, 0xF3, 0xCF, 0x3F, 0x9E, 0x79, 0xFD,
  0xE3, 0xDF, 0xCF, 0x1E, 0xEE, 0x78, 0xF7, 0x77, 0x87, 0xF3, 0xBC, 0x3F,
  0x9D, 0xC1, 0xFC, 0xFE, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xE1, 0xF8,
  0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x00, 0x0F, 0x8F, 0xC1, 0xE3, 0xC0, 0x79,
  0xF0, 0x1F, 0x78, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3D, 0xE0, 0x0F, 0x78, 0x07,
  0x9E, 0x03, 0xE7, 0x81, 0xF1, 0xF0, 0xF8, 0x3C, 0x00, 0x0F, 0x07, 0xC3,
  0xC3, 0xE0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF3,
  0xC0, 0x1C, 0xF0, 0x07, 0x78, 0x01, 0xDE, 0x00, 0x77, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x3F, 0x80, 0x0F, 0xC0,
  0x03, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x3F, 0xE1, 0xFF, 0x80,
  0x3E, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0xFE, 0x3F, 0xF8, 0xFF, 0xE0,
  0x00, 0x78, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3C, 0x01, 0xE0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x07, 0xF0, 0x3E, 0x01, 0xE0,
  0x1F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0x00,
  0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3F, 0x80, 0xFC, 0x07, 0xC0, 0x7E,
  0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03,
  0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xE0, 0x00, 0x3C, 0x05, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFF, 0x81, 0xF8,
};

const GFXglyph NotoSans_Condensed_BoldItalic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 10, 23, 8, 0, -23 },
  { 30, 11, 8, 13, 3, -23 },
  { 41, 18, 23, 17, 0, -23 },
  { 93, 15, 26, 15, 0, -24 },
  { 142, 21, 23, 24, 2, -23 },
  { 203, 18, 23, 18, 0, -23 },
  { 255, 6, 8, 8, 3, -23 },
  { 261, 11, 28, 9, 1, -23 },
  { 300, 11, 28, 9, -2, -23 },
  { 339, 12, 14, 14, 3, -25 },
  { 360, 14, 15, 16, 1, -19 },
  { 387, 8, 8, 8, -2, -4 },
  { 395, 9, 4, 10, 0, -11 },
  { 400, 5, 5, 8, 0, -5 },
  { 404, 17, 23, 12, -2, -23 },
  { 453, 14, 23, 15, 1, -23 },
  { 494, 11, 23, 15, 3, -23 },
  { 526, 16, 23, 15, -1, -23 },
  { 572, 15, 23, 15, 0, -23 },
  { 616, 15, 23, 15, 0, -23 },
  { 660, 15, 23, 15, 0, -23 },
  { 704, 15, 23, 15, 1, -23 },
  { 748, 16, 23, 15, 1, -23 },
  { 794, 15, 23, 15, 0, -23 },
  { 838, 15, 23, 15, 0, -23 },
  { 882, 8, 18, 8, 0, -18 },
  { 900, 10, 22, 8, -2, -18 },
  { 928, 14, 15, 16, 1, -19 },
  { 955, 14, 10, 16, 1, -16 },
  { 973, 14, 15, 16, 1, -19 },
  { 1000, 12, 23, 12, 1, -23 },
  { 1035, 22, 26, 23, 1, -23 },
  { 1107, 17, 23, 17, -2, -23 },
  { 1156, 17, 23, 17, 0, -23 },
  { 1205, 17, 23, 16, 1, -23 },
  { 1254, 18, 23, 18, 0, -23 },
  { 1306, 16, 23, 14, 0, -23 },
  { 1352, 16, 23, 14, 0, -23 },
  { 1398, 18, 23, 18, 1, -23 },
  { 1450, 19, 23, 19, 0, -23 },
  { 1505, 14, 23, 11, -1, -23 },
  { 1546, 15, 30, 9, -5, -23 },
  { 1603, 19, 23, 16, 0, -23 },
  { 1658, 12, 23, 14, 0, -23 },
  { 1693, 25, 23, 24, 0, -23 },
  { 1765, 21, 23, 20, 0, -23 },
  { 1826, 18, 23, 19, 1, -23 },
  { 1878, 17, 23, 16, 0, -23 },
  { 1927, 18, 28, 19, 1, -23 },
  { 1990, 16, 23, 16, 0, -23 },
  { 2036, 15, 23, 14, 0, -23 },
  { 2080, 13, 23, 14, 3, -23 },
  { 2118, 18, 23, 18, 1, -23 },
  { 2170, 16, 23, 16, 3, -23 },
  { 2216, 24, 23, 24, 3, -23 },
  { 2285, 20, 23, 16, -2, -23 },
  { 2343, 15, 23, 15, 3, -23 },
  { 2387, 17, 23, 14, -1, -23 },
  { 2436, 13, 28, 10, -1, -23 },
  { 2482, 7, 23, 12, 3, -23 },
  { 2503, 13, 28, 10, -2, -23 },
  { 2549, 15, 14, 15, 0, -23 },
  { 2576, 12, 2, 11, -3, 3 },
  { 2579, 6, 6, 10, 5, -25 },
  { 2584, 15, 18, 16, 1, -18 },
  { 2618, 15, 24, 16, 0, -24 },
  { 2663, 13, 18, 13, 1, -18 },
  { 2693, 16, 24, 16, 1, -24 },
  { 2741, 13, 18, 15, 1, -18 },
  { 2771, 17, 32, 10, -4, -24 },
  { 2839, 16, 26, 16, 0, -18 },
  { 2891, 15, 24, 16, 0, -24 },
  { 2936, 9, 24, 8, 0, -24 },
  { 2963, 13, 32, 8, -4, -24 },
  { 3015, 17, 24, 15, 0, -24 },
  { 3066, 9, 24, 8, 0, -24 },
  { 3093, 23, 18, 24, 0, -18 },
  { 3145, 15, 18, 16, 0, -18 },
  { 3179, 14, 18, 16, 1, -18 },
  { 3211, 17, 26, 16, -2, -18 },
  { 3267, 15, 26, 16, 1, -18 },
  { 3316, 13, 18, 11, 0, -18 },
  { 3346, 13, 18, 13, 0, -18 },
  { 3376, 10, 21, 10, 1, -21 },
  { 3403, 15, 17, 16, 1, -17 },
  { 3435, 14, 17, 14, 2, -17 },
  { 3465, 21, 17, 21, 2, -17 },
  { 3510, 18, 17, 14, -2, -17 },
  { 3549, 18, 25, 14, -2, -17 },
  { 3606, 14, 17, 12, -1, -17 },
  { 3636, 13, 28, 11, 0, -23 },
  { 3682, 3, 31, 14, 5, -24 },
  { 3694, 13, 28, 11, -2, -23 },
  { 3740, 14, 5, 16, 1, -14 },
};

const GFXfont NotoSans_Condensed_BoldItalic32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BoldItalic32pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BoldItalic32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_CONDENSED_BOLDITALIC32PT7B_H_
