#ifndef _NOTOSANS_CONDENSED_BOLDITALIC49PT7B_H_
#define _NOTOSANS_CONDENSED_BOLDITALIC49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BoldItalic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BoldItalic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFC, 0x01, 0xF0, 0x00, 0x80, 0x00, 0x7F, 0x1F, 0xBF,
  0x9F, 0xDF, 0x8F, 0xCF, 0xC7, 0xE7, 0xE3, 0xF3, 0xE1, 0xF9, 0xF0, 0xF9,
  0xF8, 0x7C, 0xFC, 0x7E, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0x87,
  0xC0, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x3E, 0x00,
  0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x3C, 0x3E, 0x00, 0x0F, 0x87,
  0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x3C, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x3F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x84, 0x3E, 0x1E, 0x00, 0x07, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E,
  0x1E, 0x00, 0x07, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1E, 0x00,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFE, 0x00, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xC0, 0x00,
  0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0xF0, 0xF8,
  0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0x78, 0x07, 0xE7, 0x18, 0x07, 0xE6, 0x00,
  0x07, 0xE6, 0x00, 0x07, 0xE6, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3B, 0xF8, 0x00, 0x33, 0xF8, 0x40, 0x33, 0xF8, 0x60, 0x33, 0xF8,
  0x78, 0x77, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0xF8, 0x0F, 0xF8, 0x01, 0xF0, 0x1F, 0xFC, 0x03, 0xE0,
  0x1F, 0xFC, 0x03, 0xE0, 0x3E, 0x7C, 0x07, 0xC0, 0x3E, 0x3C, 0x07, 0xC0,
  0x7C, 0x3E, 0x0F, 0x80, 0x7C, 0x7C, 0x1F, 0x00, 0xF8, 0x7C, 0x1F, 0x00,
  0xF8, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x7C, 0x00,
  0xF8, 0x7C, 0xF8, 0x00, 0xF8, 0xF8, 0xF8, 0x20, 0xF0, 0xF9, 0xF1, 0xFC,
  0xF1, 0xF9, 0xF3, 0xFE, 0xF9, 0xF3, 0xE7, 0xFF, 0xFF, 0xE7, 0xCF, 0xFF,
  0xFF, 0xE7, 0xCF, 0x9F, 0x7F, 0xCF, 0x9F, 0x1F, 0x3F, 0x8F, 0x9F, 0x1F,
  0x00, 0x1F, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x1F, 0x00, 0x3E, 0x3E, 0x1F,
  0x00, 0x7C, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x1F, 0x00, 0xF8, 0x3C, 0x3E,
  0x01, 0xF0, 0x7C, 0x3E, 0x01, 0xF0, 0x7C, 0x3E, 0x03, 0xE0, 0x7C, 0x7C,
  0x03, 0xE0, 0x3E, 0xFC, 0x07, 0xC0, 0x3F, 0xF8, 0x0F, 0x80, 0x3F, 0xF8,
  0x0F, 0x80, 0x1F, 0xF0, 0x1F, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFE,
  0xFE, 0x00, 0x1F, 0xC7, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0,
  0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F,
  0x9F, 0x80, 0x01, 0xFB, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x7F, 0x07,
  0xFF, 0x87, 0xE0, 0xFF, 0xF8, 0xFE, 0x1F, 0xDF, 0xCF, 0xC3, 0xF9, 0xFD,
  0xFC, 0x3F, 0x0F, 0xFF, 0x87, 0xF0, 0xFF, 0xF8, 0x7E, 0x07, 0xFF, 0x07,
  0xE0, 0x7F, 0xF0, 0xFE, 0x03, 0xFE, 0x0F, 0xE0, 0x3F, 0xC0, 0xFE, 0x07,
  0xFC, 0x07, 0xF0, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xE7, 0xF0, 0x0F, 0xF8, 0x7F, 0x80, 0x3F,
  0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0xFC, 0xFC, 0xF8, 0xF8, 0xF8,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F,
  0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0,
  0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x00, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x40, 0xFC, 0x03, 0x0F, 0x80, 0x7C, 0xF8, 0x07,
  0xFF, 0x86, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x03, 0xFF, 0xF0, 0x7F, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0x3E,
  0x03, 0xF3, 0xF0, 0x1E, 0x3F, 0x00, 0xC1, 0xF8, 0x04, 0x1C, 0x00, 0x01,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F,
  0x83, 0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x00, 0x7F, 0xFB,
  0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0xFF, 0x7F, 0xF8, 0x3E, 0x7F, 0x7F, 0xFF,
  0xFF, 0xFE, 0x7C, 0x10, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF8,
  0x1F, 0xEF, 0xE0, 0x7F, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xC1, 0xFC, 0x7F,
  0x07, 0xF1, 0xF8, 0x1F, 0xCF, 0xE0, 0x7F, 0x3F, 0x81, 0xFC, 0xFE, 0x07,
  0xF3, 0xF0, 0x1F, 0x9F, 0xC0, 0x7E, 0x7F, 0x01, 0xF9, 0xFC, 0x0F, 0xE7,
  0xE0, 0x3F, 0x9F, 0x80, 0xFE, 0xFE, 0x03, 0xF3, 0xF8, 0x1F, 0xCF, 0xE0,
  0x7F, 0x3F, 0x81, 0xFC, 0xFE, 0x0F, 0xE3, 0xF0, 0x3F, 0x8F, 0xC0, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x3F, 0x83, 0xFD, 0xFE, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x1F,
  0xFE, 0x3F, 0xFE, 0xFF, 0xFE, 0xFE, 0xFC, 0x7C, 0xFC, 0x78, 0xFC, 0x31,
  0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03,
  0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0x0F, 0xE7, 0xFC, 0x07, 0xC0, 0xFE, 0x01, 0xC0, 0x7F, 0x00, 0x40,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0x3C, 0x3F, 0xC0, 0x60, 0x3F, 0x80, 0x80, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x88, 0x01, 0xFE, 0x1E, 0x0F,
  0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3E,
  0xFC, 0x00, 0x7C, 0xFC, 0x00, 0x7D, 0xF8, 0x00, 0xF9, 0xF8, 0x01, 0xF1,
  0xF8, 0x01, 0xF1, 0xF8, 0x03, 0xE3, 0xF8, 0x07, 0xC3, 0xF0, 0x0F, 0xC3,
  0xF0, 0x0F, 0x83, 0xF0, 0x1F, 0x07, 0xF0, 0x3F, 0x07, 0xF0, 0x3F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1E, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC4, 0x00, 0x7F, 0x0C, 0x01, 0xFE,
  0x1F, 0x0F, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x0F, 0xFC,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x7F, 0xC1, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0xE0, 0x07, 0xEF,
  0xF0, 0x1F, 0xBF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF,
  0xC3, 0xFE, 0x3F, 0x87, 0xF8, 0x3F, 0x0F, 0xE0, 0x7E, 0x1F, 0xC0, 0xFC,
  0x3F, 0x01, 0xF8, 0xFE, 0x03, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7,
  0xF0, 0x3F, 0x07, 0xE0, 0xFE, 0x0F, 0xC3, 0xFC, 0x1F, 0xCF, 0xF0, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0,
  0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x83, 0xF8, 0x3F, 0x87, 0xE0, 0x7F, 0x1F,
  0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFC, 0xFF, 0x07,
  0xF0, 0xFE, 0x1F, 0xC0, 0xFC, 0x3F, 0x81, 0xFC, 0x7E, 0x03, 0xF9, 0xFC,
  0x07, 0xF3, 0xF8, 0x0F, 0xE7, 0xF0, 0x1F, 0x8F, 0xE0, 0x7F, 0x0F, 0xE0,
  0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x04, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0x3F, 0x87,
  0xF0, 0x7E, 0x1F, 0xC1, 0xFC, 0x7E, 0x07, 0xF3, 0xF8, 0x1F, 0xCF, 0xE0,
  0x7F, 0x3F, 0x81, 0xFC, 0xFC, 0x07, 0xF3, 0xF0, 0x3F, 0x8F, 0xC0, 0xFE,
  0x3F, 0x07, 0xF8, 0xFE, 0x3F, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0x7F, 0xEF, 0xC0, 0xFF, 0x7F, 0x00, 0x71, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x08, 0x1F, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xE0, 0x7F, 0x07, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x07, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0x7C, 0x01,
  0x00, 0x00, 0x3C, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x3F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0,
  0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F,
  0x00, 0x7C, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00,
  0x1E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x80,
  0x0F, 0xE0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0x80, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x07,
  0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x03, 0xC0, 0x00,
  0x18, 0x00, 0x00, 0x03, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0xFF,
  0x1F, 0xFF, 0xC7, 0x87, 0xF1, 0x80, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xF0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x1F, 0x80, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x0F, 0x81, 0xF0, 0x1F, 0xC1, 0xE0, 0xF8, 0x1F, 0xFC, 0x78, 0x3E,
  0x1F, 0xFF, 0x1F, 0x1F, 0x07, 0xFF, 0x87, 0xC7, 0x83, 0xE3, 0xE1, 0xF3,
  0xE1, 0xF0, 0xF8, 0x78, 0xF8, 0x78, 0x3E, 0x1E, 0x3C, 0x3E, 0x0F, 0x07,
  0x9F, 0x0F, 0x07, 0xC1, 0xE7, 0xC7, 0xC1, 0xF0, 0xF9, 0xF1, 0xF0, 0x7C,
  0x3E, 0x78, 0x7C, 0x1E, 0x0F, 0x1E, 0x1E, 0x0F, 0x87, 0xC7, 0x87, 0x83,
  0xE1, 0xE1, 0xE1, 0xE0, 0xF8, 0x78, 0xF8, 0x7C, 0x7E, 0x3C, 0x3E, 0x1F,
  0x3F, 0x9F, 0x0F, 0x87, 0xFF, 0xFF, 0x81, 0xE0, 0xFF, 0x7F, 0xC0, 0x78,
  0x3F, 0x8F, 0xE0, 0x1F, 0x01, 0x00, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x80,
  0x01, 0xFC, 0x01, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xBE, 0x00,
  0x0F, 0xDF, 0x00, 0x07, 0xCF, 0x80, 0x07, 0xE7, 0xC0, 0x03, 0xF3, 0xE0,
  0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3F,
  0x00, 0xFE, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x7F, 0x07, 0xE0, 0x3F, 0x83,
  0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xF8, 0x07, 0xE3, 0xF8,
  0x03, 0xF1, 0xFC, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0xFE, 0x00, 0x7E, 0x7E,
  0x00, 0x3F, 0x7F, 0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7E, 0x3F, 0xE0, 0x3F, 0x83, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x7F, 0x01, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x01, 0xF8, 0x3F, 0xC0, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0x1F, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x3F, 0x81,
  0xF8, 0x0F, 0xE0, 0x7E, 0x03, 0xF8, 0x1F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F,
  0x83, 0xF8, 0x0F, 0xE0, 0xFC, 0x07, 0xF0, 0x3F, 0x03, 0xFC, 0x1F, 0xC7,
  0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFB,
  0xF0, 0x1F, 0xE0, 0x10, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x0C,
  0x03, 0xFF, 0x7E, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0xFE, 0x1F, 0xF0, 0x1F, 0xC0, 0xFE, 0x03,
  0xF8, 0x1F, 0xE0, 0x7E, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07,
  0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xF8, 0x03, 0xF8, 0x7F,
  0x00, 0x7F, 0x0F, 0xE0, 0x1F, 0xE1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F,
  0x07, 0xE0, 0x0F, 0xE1, 0xFC, 0x03, 0xFC, 0x3F, 0x80, 0x7F, 0x07, 0xF0,
  0x0F, 0xE0, 0xFE, 0x03, 0xFC, 0x1F, 0x80, 0x7F, 0x07, 0xF0, 0x1F, 0xE0,
  0xFE, 0x07, 0xF8, 0x1F, 0xC1, 0xFF, 0x03, 0xF0, 0x7F, 0xC0, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0x3F, 0x01, 0xFF, 0x00,
  0xE0, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x1F, 0xFC, 0x7F, 0x07, 0xFF, 0x8F, 0xE0,
  0xFF, 0xE3, 0xFC, 0x1F, 0xFC, 0x7F, 0x03, 0xFF, 0x8F, 0xE0, 0xFF, 0xF1,
  0xFC, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x00,
  0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xFC, 0x03, 0xF0, 0x3F, 0x80, 0xFE, 0x07,
  0xF8, 0x1F, 0xC0, 0xFF, 0xCF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xE0, 0x3F,
  0x80, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0,
  0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x01, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x80, 0xFE, 0x00,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7F,
  0x01, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0x00,
  0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x00,
  0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFF,
  0x80, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x03, 0xFC, 0x03, 0xF0,
  0x1F, 0xC0, 0x1F, 0x81, 0xFC, 0x00, 0xFC, 0x1F, 0xC0, 0x0F, 0xE1, 0xFE,
  0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x1F, 0x8F, 0xE0, 0x01,
  0xFC, 0xFF, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x03, 0xF7,
  0xF0, 0x00, 0x1F, 0xBF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x7E, 0x3F, 0x80, 0x03, 0xF1,
  0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC,
  0x00, 0x7E, 0x0F, 0xE0, 0x03, 0xF0, 0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x01,
  0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x7E, 0x03, 0xF8, 0x03, 0xF0,
  0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F,
  0xFF, 0xF7, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF,
  0xF8, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x1F,
  0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF,
  0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFB, 0xE0, 0x3F, 0xFC, 0x07, 0xEF,
  0x81, 0xFF, 0xE0, 0x1F, 0xBE, 0x07, 0xDF, 0x80, 0x7E, 0xF8, 0x3F, 0x7E,
  0x03, 0xF3, 0xE0, 0xFB, 0xF8, 0x0F, 0xCF, 0x87, 0xEF, 0xC0, 0x3F, 0x3E,
  0x1F, 0x3F, 0x00, 0xFC, 0xF8, 0xFC, 0xFC, 0x03, 0xF3, 0xE3, 0xE3, 0xF0,
  0x1F, 0x8F, 0x9F, 0x9F, 0xC0, 0x7E, 0x3E, 0x7C, 0x7E, 0x01, 0xF8, 0xF9,
  0xF1, 0xF8, 0x07, 0xE3, 0xEF, 0xC7, 0xE0, 0x1F, 0x8F, 0xBE, 0x1F, 0x80,
  0xFC, 0x3F, 0xF8, 0xFE, 0x03, 0xF0, 0xFF, 0xC3, 0xF0, 0x0F, 0xC3, 0xFF,
  0x0F, 0xC0, 0x3F, 0x0F, 0xF8, 0x3F, 0x01, 0xFC, 0x3F, 0xE0, 0xFC, 0x07,
  0xE0, 0xFF, 0x07, 0xE0, 0x1F, 0x83, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xE0,
  0x7E, 0x01, 0xF8, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x7E, 0x01, 0xFF, 0x00, 0x7E,
  0x01, 0xFF, 0x00, 0x7E, 0x01, 0xFF, 0x00, 0x7E, 0x01, 0xFF, 0x00, 0xFC,
  0x03, 0xFF, 0x80, 0xFC, 0x03, 0xFF, 0x80, 0xFC, 0x03, 0xFF, 0x80, 0xFC,
  0x03, 0xFF, 0x81, 0xFC, 0x07, 0xFF, 0x81, 0xF8, 0x07, 0xEF, 0xC1, 0xF8,
  0x07, 0xEF, 0xC1, 0xF8, 0x07, 0xEF, 0xC1, 0xF8, 0x07, 0xEF, 0xC3, 0xF8,
  0x0F, 0xC7, 0xE3, 0xF0, 0x0F, 0xC7, 0xE3, 0xF0, 0x0F, 0xC7, 0xE3, 0xF0,
  0x0F, 0xC7, 0xE3, 0xF0, 0x0F, 0xC7, 0xE7, 0xE0, 0x1F, 0x83, 0xF7, 0xE0,
  0x1F, 0x83, 0xF7, 0xE0, 0x1F, 0x83, 0xF7, 0xE0, 0x1F, 0x83, 0xF7, 0xE0,
  0x1F, 0x81, 0xFF, 0xC0, 0x3F, 0x01, 0xFF, 0xC0, 0x3F, 0x01, 0xFF, 0xC0,
  0x3F, 0x01, 0xFF, 0xC0, 0x3F, 0x01, 0xFF, 0xC0, 0x7F, 0x00, 0xFF, 0x80,
  0x7E, 0x00, 0xFF, 0x80, 0x7E, 0x00, 0xFF, 0x80, 0x7E, 0x00, 0xFF, 0x80,
  0x7E, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0x9F, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x1F, 0xC1, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x3F, 0x8F, 0xE0, 0x07,
  0xF3, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xFB, 0xFC,
  0x00, 0xFF, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7F,
  0x7F, 0x80, 0x0F, 0xEF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0xBF, 0x80,
  0x0F, 0xE7, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x9F, 0xC0, 0x0F, 0xE3,
  0xF8, 0x03, 0xFC, 0x7F, 0x00, 0x7F, 0x0F, 0xF0, 0x1F, 0xE0, 0xFE, 0x07,
  0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0x83, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0,
  0x7F, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF8, 0x3F,
  0x81, 0xFE, 0x0F, 0xE1, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xC0,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x00, 0xFF, 0xBF, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x1F, 0xC1, 0xFC,
  0x03, 0xFC, 0x7F, 0x80, 0x3F, 0x8F, 0xE0, 0x07, 0xF3, 0xFC, 0x00, 0xFE,
  0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xFB, 0xFC, 0x00, 0xFF, 0x7F, 0x00,
  0x1F, 0xCF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x7F, 0x80, 0x0F, 0xEF,
  0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xE7, 0xF0, 0x01,
  0xFC, 0xFE, 0x00, 0x7F, 0x9F, 0xC0, 0x0F, 0xE3, 0xF8, 0x03, 0xFC, 0x7F,
  0x00, 0x7F, 0x0F, 0xF0, 0x1F, 0xE0, 0xFE, 0x07, 0xF8, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x0F, 0xCF, 0xFC, 0x0F, 0xE1, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF0,
  0x3F, 0x81, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F,
  0x03, 0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0x83, 0xFC, 0x1F, 0xC3, 0xFC, 0x0F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xFC, 0x00, 0xFE, 0x7E, 0x00, 0x7E, 0x3F, 0x80, 0x3F, 0x1F, 0xC0,
  0x1F, 0x87, 0xE0, 0x1F, 0xC3, 0xF0, 0x0F, 0xE1, 0xFC, 0x07, 0xE0, 0xFE,
  0x03, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07,
  0xF0, 0x7E, 0x03, 0xF8, 0x3F, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xF8, 0x18, 0x07, 0xF0, 0x08, 0x0F,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0xC0, 0x0F, 0xE0, 0xF0,
  0x1F, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0xFB, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F,
  0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0xC0, 0x3F,
  0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0x83, 0xF8,
  0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8,
  0x3F, 0x00, 0x7E, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x80,
  0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x07,
  0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F,
  0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0x7F,
  0x01, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xBF, 0x80, 0x1F,
  0xCF, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F, 0xE3, 0xF0, 0x07, 0xE1, 0xF8, 0x07,
  0xF0, 0xFC, 0x03, 0xF8, 0x7E, 0x03, 0xF8, 0x3F, 0x01, 0xFC, 0x1F, 0x80,
  0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x7F, 0x01, 0xF8,
  0x3F, 0x00, 0xFC, 0x3F, 0x80, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F,
  0x8F, 0xE0, 0x0F, 0xC7, 0xE0, 0x07, 0xE7, 0xF0, 0x03, 0xF3, 0xF0, 0x01,
  0xFB, 0xF8, 0x00, 0xFD, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFF, 0xF8, 0x03,
  0xF0, 0x0F, 0xEF, 0xE0, 0x1F, 0xC0, 0x3F, 0xBF, 0x80, 0x7F, 0x00, 0xFC,
  0xFE, 0x03, 0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xF0, 0x1F, 0x8F, 0xC0, 0x7F,
  0xC0, 0xFE, 0x3F, 0x01, 0xFF, 0x03, 0xF0, 0xFC, 0x07, 0xFC, 0x0F, 0xC3,
  0xF0, 0x3F, 0xF0, 0x7F, 0x0F, 0xC0, 0xFF, 0xC1, 0xF8, 0x3F, 0x07, 0xFF,
  0x0F, 0xE0, 0xFC, 0x1F, 0xFC, 0x3F, 0x03, 0xF0, 0x7F, 0xF0, 0xFC, 0x0F,
  0xC3, 0xFF, 0xC7, 0xF0, 0x3F, 0x0F, 0xBF, 0x1F, 0x80, 0xFC, 0x7E, 0xF8,
  0xFE, 0x03, 0xF1, 0xF3, 0xE3, 0xF0, 0x0F, 0xC7, 0xCF, 0x8F, 0xC0, 0x3F,
  0x3F, 0x3E, 0x7F, 0x00, 0xFC, 0xF8, 0xF9, 0xF8, 0x03, 0xF7, 0xE3, 0xE7,
  0xE0, 0x0F, 0xDF, 0x0F, 0xBF, 0x00, 0x3F, 0x7C, 0x3E, 0xFC, 0x00, 0xFF,
  0xF0, 0xFF, 0xF0, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x0F, 0xFE, 0x0F, 0xFE,
  0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xFF,
  0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xE0,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xE0,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0xFC, 0x03, 0xF8,
  0x01, 0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00,
  0x0F, 0xE1, 0xFC, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x1F, 0x8F, 0xE0, 0x00,
  0x3F, 0x9F, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x01, 0xFD, 0xF8, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0x3F, 0x87, 0xE0, 0x00, 0xFE, 0x0F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0,
  0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0xFC,
  0x03, 0xF9, 0xF8, 0x07, 0xF3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0,
  0xFE, 0x1F, 0xC1, 0xF8, 0x1F, 0x87, 0xF0, 0x3F, 0x0F, 0xC0, 0x7E, 0x3F,
  0x80, 0xFC, 0x7E, 0x01, 0xFD, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0xFC, 0x1F, 0x83, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0x03,
  0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0x7C, 0x0F, 0x81, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F, 0x80, 0x00, 0x7F, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xF7, 0xE0, 0x07, 0xC7, 0xC0, 0x1F,
  0x8F, 0x80, 0x3E, 0x1F, 0x00, 0xFC, 0x3F, 0x03, 0xF0, 0x3E, 0x07, 0xC0,
  0x7C, 0x1F, 0x80, 0xF8, 0x3E, 0x01, 0xF8, 0xFC, 0x01, 0xF3, 0xF0, 0x03,
  0xEF, 0xC0, 0x07, 0xE0, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFE, 0x3F, 0xC7, 0xF0, 0xFC, 0x3F, 0x07, 0xE0, 0xF8, 0x3F, 0x00,
  0xFC, 0x3F, 0x01, 0xFE, 0x3E, 0x03, 0xFF, 0x7E, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x0F, 0xF7, 0xFC, 0x1F, 0xE3, 0xFC, 0x1F, 0xC1, 0xFC, 0x3F,
  0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x01, 0xF8, 0x7F, 0x01, 0xF8, 0x7F,
  0x01, 0xF8, 0x7F, 0x03, 0xF8, 0x7E, 0x03, 0xF8, 0x7E, 0x03, 0xF0, 0xFE,
  0x03, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xF0, 0xFE,
  0x0F, 0xE0, 0xFF, 0x1F, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F,
  0xF7, 0xC0, 0x3F, 0xE7, 0xC0, 0x1F, 0xC7, 0xC0, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xCF, 0xC0, 0x3F, 0xBF, 0xC0, 0x7E, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0x83, 0xFC, 0xFF, 0x0F, 0xF0, 0xFE, 0x1F, 0xC0, 0xFC,
  0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF1, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0xC7,
  0xE0, 0x3F, 0x8F, 0xC0, 0x7F, 0x1F, 0x80, 0xFE, 0x7F, 0x01, 0xF8, 0xFE,
  0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0x87, 0xF0, 0x7F, 0x1F, 0xE1,
  0xFC, 0x3F, 0xE7, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xF7, 0xFF,
  0x07, 0xEF, 0xFC, 0x0F, 0x8F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xFF,
  0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0x1C, 0x1F, 0xE0,
  0x41, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x02, 0x07,
  0xF8, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x0F, 0xC7, 0xE0, 0x07, 0xFD, 0xF8, 0x03, 0xFF, 0x7E, 0x01, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xCF, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x1F,
  0xC0, 0x7E, 0x07, 0xF0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x7E, 0x03, 0xF8,
  0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x3F, 0x03, 0xF8, 0x0F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0x7C, 0x00, 0xFF, 0x9F, 0x00,
  0x1F, 0xC7, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xF0, 0xFC, 0x7F, 0x07, 0xE3, 0xF0,
  0x3F, 0x3F, 0x81, 0xF9, 0xF8, 0x1F, 0x8F, 0xC1, 0xFC, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x1F, 0xFC, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFC, 0x40, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x8F, 0xC0, 0x1F,
  0xF3, 0xE0, 0x0F, 0xFD, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80,
  0xFF, 0x7F, 0xE0, 0x7F, 0x87, 0xF0, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x7F, 0x01, 0xF8, 0x1F, 0xC0,
  0x7E, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0,
  0x3F, 0x87, 0xF8, 0x0F, 0xF3, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0xFE, 0xFC, 0x00, 0x7F, 0x3F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x02,
  0x00, 0x3F, 0x80, 0xE0, 0x1F, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xCF, 0xC0, 0x3F, 0xBF,
  0xE0, 0x7E, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFE, 0xFF,
  0x0F, 0xF0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF0,
  0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0x87, 0xF0, 0x3F, 0x0F, 0xC0, 0xFE, 0x1F,
  0x81, 0xFC, 0x7F, 0x03, 0xF0, 0xFE, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0,
  0x3F, 0x87, 0xE0, 0x7F, 0x1F, 0xC0, 0xFC, 0x3F, 0x81, 0xF8, 0x7E, 0x03,
  0xF0, 0xFC, 0x0F, 0xE1, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x0F, 0xE0, 0x7E,
  0x00, 0x00, 0xF8, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8,
  0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7F,
  0x07, 0xF0, 0x3F, 0x07, 0xF0, 0x1F, 0x87, 0xF0, 0x0F, 0xC7, 0xF0, 0x0F,
  0xE7, 0xF0, 0x07, 0xE3, 0xF0, 0x03, 0xF3, 0xF8, 0x01, 0xFB, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xF3, 0xF0,
  0x03, 0xF1, 0xFC, 0x01, 0xF8, 0xFE, 0x01, 0xFC, 0x3F, 0x00, 0xFC, 0x1F,
  0xC0, 0x7E, 0x0F, 0xE0, 0x3F, 0x07, 0xF0, 0x1F, 0x81, 0xFC, 0x1F, 0xC0,
  0xFE, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0,
  0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x00, 0x03, 0xE3, 0xF0, 0x3F, 0x00, 0xFC, 0xFF, 0x0F, 0xF8,
  0x1F, 0x3F, 0xF3, 0xFF, 0x03, 0xEF, 0xFE, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFE, 0x0F, 0xF3, 0xFF, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xF8, 0x7F, 0x07,
  0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x0F, 0xE1, 0xF8, 0x1F, 0xC1, 0xF8, 0x3F,
  0x03, 0xF0, 0x3F, 0x0F, 0xE0, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0xC1, 0xFC,
  0x3F, 0x03, 0xF0, 0x3F, 0x87, 0xE0, 0x7E, 0x07, 0xE1, 0xFC, 0x0F, 0xC0,
  0xFC, 0x3F, 0x81, 0xF8, 0x1F, 0x87, 0xE0, 0x7F, 0x07, 0xF0, 0xFC, 0x0F,
  0xC0, 0xFE, 0x1F, 0x81, 0xF8, 0x1F, 0x87, 0xF0, 0x3F, 0x03, 0xF0, 0xFE,
  0x0F, 0xE0, 0x7E, 0x1F, 0x81, 0xFC, 0x1F, 0xC3, 0xF0, 0x3F, 0x03, 0xF8,
  0x7E, 0x07, 0xE0, 0x7E, 0x1F, 0xC0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x83,
  0xF8, 0x00, 0x03, 0xE3, 0xF0, 0x0F, 0x8F, 0xF8, 0x1F, 0x3F, 0xF0, 0x3E,
  0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xBF, 0xC3, 0xFC, 0x3F, 0x87, 0xF0,
  0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0x81, 0xFC, 0x3F, 0x03, 0xF8, 0xFE, 0x07,
  0xE1, 0xFC, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x7F, 0x1F, 0xC0, 0xFC,
  0x3F, 0x81, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x0F, 0xE1, 0xF8, 0x1F, 0xC7,
  0xF0, 0x3F, 0x0F, 0xE0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x03, 0xF8, 0x7E,
  0x07, 0xF1, 0xFC, 0x0F, 0xC3, 0xF8, 0x1F, 0x80, 0x00, 0x7F, 0x80, 0x07,
  0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xDF,
  0xE1, 0xFC, 0x1F, 0x8F, 0xE0, 0x7E, 0x3F, 0x81, 0xFC, 0xFC, 0x07, 0xF7,
  0xF0, 0x1F, 0xDF, 0xC0, 0x7E, 0x7F, 0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xE0,
  0x1F, 0xBF, 0x80, 0xFE, 0xFE, 0x03, 0xFB, 0xF8, 0x0F, 0xCF, 0xE0, 0x7F,
  0x3F, 0x81, 0xFC, 0x7E, 0x0F, 0xE1, 0xFC, 0x7F, 0x87, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x20,
  0x00, 0x00, 0xF8, 0xFC, 0x00, 0xFC, 0xFF, 0x00, 0x7E, 0xFF, 0xC0, 0x3E,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xF1, 0xFC, 0x0F, 0xF0, 0xFE, 0x07,
  0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0,
  0xFC, 0x07, 0xF0, 0x7E, 0x03, 0xF8, 0x3F, 0x01, 0xFC, 0x1F, 0x80, 0xFE,
  0x1F, 0xC0, 0x7E, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x3F,
  0x81, 0xFC, 0x1F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x9F, 0xE0, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xDF, 0xF0, 0x0F, 0xC7,
  0xF0, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x3F, 0x01, 0xFF, 0x3E, 0x03, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xE7, 0xFC, 0x1F, 0xC1, 0xFC,
  0x1F, 0xC1, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x01, 0xF8,
  0x7F, 0x01, 0xF8, 0x7F, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x03, 0xF8,
  0xFE, 0x03, 0xF0, 0xFE, 0x03, 0xF0, 0xFE, 0x03, 0xF0, 0xFE, 0x07, 0xF0,
  0xFE, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFF, 0x1F, 0xE0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xEF, 0xC0, 0x1F, 0xCF, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x03, 0xE3, 0xF0, 0x7E, 0x7E, 0x07, 0xEF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x3F,
  0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC1, 0xFC, 0x1C, 0x1F,
  0xC0, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x80, 0x7F,
  0x0E, 0x0F, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF,
  0x80, 0x7F, 0xF0, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x7E, 0x01, 0xFF, 0xCF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0xFF, 0xFE, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC,
  0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xC0, 0xFC, 0x7F, 0x03, 0xF1, 0xF8, 0x0F,
  0xC7, 0xE0, 0x7F, 0x1F, 0x81, 0xF8, 0xFE, 0x07, 0xE3, 0xF8, 0x1F, 0x8F,
  0xC0, 0x7E, 0x3F, 0x03, 0xF8, 0xFC, 0x0F, 0xC7, 0xF0, 0x3F, 0x1F, 0x80,
  0xFC, 0x7E, 0x07, 0xF1, 0xF8, 0x1F, 0xC7, 0xE0, 0x7E, 0x3F, 0x81, 0xF8,
  0xFC, 0x0F, 0xE3, 0xF0, 0x3F, 0x8F, 0xC0, 0xFC, 0x3F, 0x07, 0xF0, 0xFC,
  0x1F, 0xC3, 0xF8, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xEF,
  0x81, 0xFF, 0x3E, 0x03, 0xF8, 0xF8, 0x00, 0xFC, 0x03, 0xFF, 0xE0, 0x1F,
  0xBF, 0x01, 0xFD, 0xF8, 0x0F, 0xCF, 0xC0, 0xFE, 0x7E, 0x07, 0xE3, 0xF0,
  0x7F, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1,
  0xF8, 0xFE, 0x0F, 0xC7, 0xE0, 0x3E, 0x7F, 0x01, 0xF3, 0xF0, 0x0F, 0x9F,
  0x80, 0x7D, 0xF8, 0x03, 0xEF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x0F, 0xE0, 0x3F, 0xFC, 0x0F,
  0xE0, 0x7F, 0xFC, 0x0F, 0xE0, 0x7E, 0xFC, 0x1F, 0xE0, 0x7E, 0xFC, 0x1F,
  0xE0, 0xFC, 0xFC, 0x3F, 0xE0, 0xFC, 0xFC, 0x3F, 0xE1, 0xFC, 0xFC, 0x3F,
  0xE1, 0xF8, 0xFC, 0x7F, 0xE1, 0xF8, 0xFC, 0x7F, 0xE3, 0xF0, 0xFC, 0xFB,
  0xE3, 0xF0, 0xFC, 0xFB, 0xE7, 0xE0, 0xFC, 0xFB, 0xE7, 0xE0, 0xFD, 0xF3,
  0xE7, 0xE0, 0xFD, 0xF3, 0xEF, 0xC0, 0xFF, 0xE3, 0xEF, 0xC0, 0xFF, 0xE3,
  0xEF, 0x80, 0xFF, 0xE3, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xC3,
  0xFF, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03,
  0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x0F,
  0xE0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x01, 0xF8, 0xFE, 0x00, 0x7E,
  0x3F, 0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x0F,
  0xEF, 0xE0, 0x07, 0xF1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0xFE, 0x1F, 0xC0,
  0x7F, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xF8,
  0x07, 0xF0, 0x1F, 0x80, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0xFE,
  0x01, 0xF8, 0x1F, 0xC0, 0x1F, 0x81, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x1F,
  0x83, 0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0xFC, 0x7E,
  0x00, 0x0F, 0xCF, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0xFD, 0xF8, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80,
  0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x10, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x01, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0x00,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x00,
  0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8,
  0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xE0,
  0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x03,
  0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x0F,
  0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x03, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x0B, 0xFF, 0x80, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0x7F, 0xD0, 0x00, 0x78,
};

const GFXglyph NotoSans_Condensed_BoldItalic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 15, 36, 13, 0, -35 },
  { 69, 17, 13, 20, 5, -35 },
  { 97, 27, 35, 26, 0, -35 },
  { 216, 24, 40, 23, 0, -37 },
  { 336, 32, 35, 37, 3, -35 },
  { 476, 28, 35, 28, 0, -35 },
  { 599, 8, 13, 12, 5, -35 },
  { 612, 17, 43, 14, 1, -35 },
  { 704, 17, 44, 14, -4, -36 },
  { 798, 20, 22, 22, 4, -38 },
  { 853, 21, 23, 24, 2, -29 },
  { 914, 12, 13, 12, -3, -6 },
  { 934, 13, 6, 15, 1, -16 },
  { 944, 8, 8, 12, 0, -7 },
  { 952, 26, 35, 19, -3, -35 },
  { 1066, 22, 35, 23, 1, -35 },
  { 1163, 16, 35, 23, 5, -35 },
  { 1233, 25, 35, 23, -2, -35 },
  { 1343, 23, 35, 23, 0, -35 },
  { 1444, 24, 35, 23, -1, -35 },
  { 1549, 23, 35, 23, 0, -35 },
  { 1650, 23, 36, 23, 1, -36 },
  { 1754, 24, 35, 23, 1, -35 },
  { 1859, 23, 35, 23, 0, -35 },
  { 1960, 22, 36, 23, 1, -36 },
  { 2059, 12, 28, 13, 0, -27 },
  { 2101, 15, 34, 13, -3, -27 },
  { 2165, 21, 24, 24, 2, -30 },
  { 2228, 21, 15, 24, 2, -25 },
  { 2268, 21, 24, 24, 2, -30 },
  { 2331, 18, 36, 18, 2, -35 },
  { 2412, 34, 39, 35, 1, -35 },
  { 2578, 25, 35, 25, -3, -35 },
  { 2688, 26, 35, 25, 0, -35 },
  { 2802, 25, 35, 24, 2, -35 },
  { 2912, 27, 35, 28, 0, -35 },
  { 3031, 24, 35, 22, 0, -35 },
  { 3136, 24, 35, 21, 0, -35 },
  { 3241, 27, 35, 28, 2, -35 },
  { 3360, 30, 35, 29, 0, -35 },
  { 3492, 22, 35, 17, -2, -35 },
  { 3589, 23, 45, 13, -8, -35 },
  { 3719, 29, 35, 25, 0, -35 },
  { 3846, 18, 35, 21, 0, -35 },
  { 3925, 38, 35, 37, 0, -35 },
  { 4092, 32, 35, 30, 0, -35 },
  { 4232, 27, 36, 29, 2, -36 },
  { 4354, 26, 35, 25, 0, -35 },
  { 4468, 27, 44, 29, 2, -36 },
  { 4617, 25, 35, 25, 0, -35 },
  { 4727, 24, 35, 22, 0, -35 },
  { 4832, 21, 35, 21, 4, -35 },
  { 4924, 27, 35, 28, 2, -35 },
  { 5043, 25, 35, 25, 4, -35 },
  { 5153, 38, 35, 37, 4, -35 },
  { 5320, 31, 35, 24, -3, -35 },
  { 5456, 23, 35, 23, 4, -35 },
  { 5557, 26, 35, 21, -2, -35 },
  { 5671, 20, 43, 15, -2, -35 },
  { 5779, 11, 35, 19, 5, -35 },
  { 5828, 19, 43, 15, -3, -35 },
  { 5931, 23, 21, 23, 0, -35 },
  { 5992, 18, 4, 17, -5, 4 },
  { 6001, 10, 8, 15, 7, -38 },
  { 6011, 24, 27, 25, 1, -27 },
  { 6092, 23, 37, 25, 0, -37 },
  { 6199, 20, 27, 20, 1, -27 },
  { 6267, 26, 37, 25, 1, -37 },
  { 6388, 21, 27, 23, 1, -27 },
  { 6459, 26, 49, 15, -5, -37 },
  { 6619, 26, 39, 25, -1, -27 },
  { 6746, 23, 37, 25, 0, -37 },
  { 6853, 14, 37, 12, 0, -37 },
  { 6918, 20, 49, 12, -6, -37 },
  { 7041, 25, 37, 23, 0, -37 },
  { 7157, 15, 37, 12, 0, -37 },
  { 7227, 35, 27, 36, 0, -27 },
  { 7346, 23, 27, 25, 0, -27 },
  { 7424, 22, 28, 24, 1, -27 },
  { 7501, 25, 39, 25, -2, -27 },
  { 7623, 24, 39, 25, 1, -27 },
  { 7740, 20, 27, 17, 0, -27 },
  { 7808, 20, 27, 19, 0, -27 },
  { 7876, 15, 32, 16, 2, -32 },
  { 7936, 22, 27, 24, 2, -27 },
  { 8011, 21, 27, 21, 3, -27 },
  { 8082, 32, 27, 33, 3, -27 },
  { 8190, 26, 27, 22, -2, -27 },
  { 8278, 28, 39, 21, -4, -27 },
  { 8415, 22, 27, 19, -2, -27 },
  { 8490, 20, 43, 17, 0, -35 },
  { 8598, 6, 48, 21, 7, -37 },
  { 8634, 19, 43, 17, -3, -35 },
  { 8737, 21, 8, 24, 2, -21 },
};

const GFXfont NotoSans_Condensed_BoldItalic49pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BoldItalic49pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BoldItalic49pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _NOTOSANS_CONDENSED_BOLDITALIC49PT7B_H_
