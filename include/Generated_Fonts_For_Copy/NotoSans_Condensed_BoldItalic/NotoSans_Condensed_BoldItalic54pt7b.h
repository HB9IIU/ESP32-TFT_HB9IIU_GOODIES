#ifndef _NOTOSANS_CONDENSED_BOLDITALIC54PT7B_H_
#define _NOTOSANS_CONDENSED_BOLDITALIC54PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BoldItalic.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BoldItalic54pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03,
  0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x10, 0x00, 0x3F, 0x8F, 0xE7,
  0xF1, 0xFC, 0xFE, 0x3F, 0x9F, 0x87, 0xF3, 0xF0, 0xFC, 0xFE, 0x1F, 0x9F,
  0xC7, 0xF3, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7E, 0x3E,
  0x0F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7E, 0x00, 0x00, 0x07, 0xE1, 0xF0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x3F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xE1,
  0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xF0, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x3E, 0x00, 0x03,
  0xF0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF8,
  0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x1F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00,
  0xF8, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7E,
  0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xDB, 0xF0, 0x1F, 0xE6,
  0x18, 0x07, 0xF3, 0x82, 0x01, 0xFC, 0xE0, 0x00, 0x7F, 0x38, 0x00, 0x1F,
  0xCC, 0x00, 0x07, 0xFB, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xDF, 0xE0, 0x00, 0x73, 0xF8, 0x00, 0x1C, 0xFE, 0x10, 0x06, 0x3F, 0x86,
  0x01, 0x9F, 0xE1, 0xE0, 0xE7, 0xF0, 0x7F, 0x3F, 0xFC, 0x1F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x07, 0xFE, 0x00, 0x7E, 0x00, 0xFF,
  0xF0, 0x07, 0xC0, 0x1F, 0xFF, 0x00, 0xFC, 0x03, 0xF1, 0xF0, 0x0F, 0x80,
  0x3F, 0x1F, 0x01, 0xF8, 0x03, 0xE1, 0xF0, 0x3F, 0x00, 0x7E, 0x1F, 0x03,
  0xE0, 0x07, 0xC1, 0xF0, 0x7E, 0x00, 0x7C, 0x1F, 0x07, 0xC0, 0x0F, 0xC3,
  0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x1F, 0x80, 0x0F, 0xC3, 0xF1, 0xF0, 0x00,
  0xF8, 0x3E, 0x3F, 0x00, 0x0F, 0x87, 0xE3, 0xE0, 0xE0, 0xF8, 0x7E, 0x7E,
  0x3F, 0xCF, 0x8F, 0xCF, 0xC7, 0xFE, 0xFC, 0xFC, 0xF8, 0xFF, 0xEF, 0xFF,
  0x9F, 0x9F, 0xFE, 0xFF, 0xF1, 0xF3, 0xF3, 0xF7, 0xFF, 0x3E, 0x3E, 0x3F,
  0x3F, 0xC7, 0xE7, 0xE3, 0xF1, 0xF8, 0x7C, 0x7C, 0x3F, 0x00, 0x0F, 0xC7,
  0xC3, 0xF0, 0x00, 0xF8, 0xFC, 0x3F, 0x00, 0x1F, 0x0F, 0xC3, 0xF0, 0x03,
  0xF0, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x83, 0xE0, 0x07, 0xE0, 0xF8, 0x7E,
  0x00, 0x7C, 0x0F, 0x87, 0xE0, 0x0F, 0x80, 0xF8, 0x7C, 0x01, 0xF8, 0x0F,
  0x8F, 0xC0, 0x1F, 0x00, 0xF8, 0xF8, 0x03, 0xF0, 0x0F, 0xFF, 0x80, 0x3E,
  0x00, 0xFF, 0xF0, 0x07, 0xC0, 0x0F, 0xFF, 0x00, 0xFC, 0x00, 0x7F, 0xE0,
  0x1F, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x7F, 0x0F, 0xC0,
  0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0xFE, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x08, 0x0F, 0xFE, 0x0F, 0xE0, 0x7F,
  0xFC, 0x1F, 0xC1, 0xFF, 0xFC, 0x3F, 0x87, 0xFB, 0xF8, 0xFE, 0x0F, 0xE7,
  0xF9, 0xFC, 0x3F, 0x8F, 0xF7, 0xF0, 0x7F, 0x0F, 0xFF, 0xE1, 0xFC, 0x1F,
  0xFF, 0x83, 0xF8, 0x1F, 0xFF, 0x07, 0xF0, 0x3F, 0xFC, 0x1F, 0xE0, 0x3F,
  0xF0, 0x3F, 0xC0, 0x7F, 0xE0, 0x7F, 0x80, 0xFF, 0x80, 0x7F, 0x83, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xE3, 0xFC, 0x03, 0xFF, 0x07, 0xFC,
  0x00, 0x20, 0x00, 0x00, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF1, 0xF9, 0xFC,
  0xFE, 0x7E, 0x3F, 0x1F, 0x8F, 0x87, 0xC7, 0xE0, 0x00, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x20, 0x3E, 0x00, 0xE1, 0xF8,
  0x03, 0xE7, 0xE0, 0x1F, 0xFF, 0x07, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xF8, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xDF, 0x81, 0xFE, 0x7E, 0x03, 0xF8, 0xFC,
  0x07, 0xC3, 0xF0, 0x0E, 0x0F, 0xE0, 0x08, 0x1C, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x7F, 0x0F, 0xF0, 0xFE,
  0x0F, 0xE1, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0x07, 0xF0,
  0x7E, 0x0F, 0xC0, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xEF, 0xFF, 0x80, 0x1F, 0x3F, 0xDF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFC,
  0xFC, 0x10, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x03, 0xFC, 0xFF, 0x07, 0xF8, 0x7F, 0x07, 0xF0, 0x7F, 0x0F,
  0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0x1F, 0xE0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F,
  0xC0, 0x7F, 0x3F, 0xC0, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x3F,
  0x80, 0xFF, 0x7F, 0x80, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F,
  0x00, 0xFE, 0x7F, 0x01, 0xFE, 0x7F, 0x01, 0xFC, 0xFF, 0x01, 0xFC, 0xFE,
  0x03, 0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF8, 0xFE,
  0x07, 0xF0, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0x7F, 0x1F, 0xE0, 0x7F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x81, 0xFF,
  0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFE, 0xFE, 0x3F, 0xBF,
  0x87, 0xE7, 0xF0, 0x70, 0xFE, 0x04, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0x8F, 0xF8, 0x07, 0xC0, 0xFF, 0x00, 0xF0, 0x1F, 0xE0,
  0x0C, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0x80,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x1F, 0x0F, 0xFC, 0x03, 0x01, 0xFF, 0x00, 0x80, 0x3F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC2, 0x00, 0x1F,
  0xE0, 0xE0, 0x0F, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00,
  0x05, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0,
  0x00, 0xFB, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0x7F, 0x00, 0x0F, 0x9F,
  0xC0, 0x07, 0xE7, 0xE0, 0x01, 0xF3, 0xF8, 0x00, 0xF8, 0xFE, 0x00, 0x7E,
  0x3F, 0x80, 0x3F, 0x0F, 0xE0, 0x0F, 0x83, 0xF0, 0x07, 0xE1, 0xFC, 0x03,
  0xF0, 0x7F, 0x00, 0xF8, 0x1F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x03, 0xF8,
  0x1F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x80, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0xC3, 0x00, 0x1F, 0xE0, 0xF0, 0x1F, 0xF8, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x0A, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x07, 0xFC, 0x08, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x7F, 0x7F, 0xC0, 0x7F, 0x7F,
  0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0xFC,
  0x7F, 0x87, 0xFC, 0x1F, 0xE3, 0xFC, 0x0F, 0xF1, 0xFE, 0x07, 0xF8, 0xFE,
  0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F,
  0xE0, 0x7F, 0x87, 0xF0, 0x3F, 0xC3, 0xF8, 0x1F, 0xC1, 0xFC, 0x1F, 0xE0,
  0xFF, 0x1F, 0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xC3, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xF0,
  0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0xFE, 0x07,
  0xF8, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x3F, 0xCF, 0xF0, 0x07, 0xFF, 0xF8,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0x7F, 0x80, 0x7F,
  0x8F, 0xF0, 0x3F, 0xC1, 0xFC, 0x1F, 0xE0, 0x7F, 0x87, 0xF0, 0x0F, 0xE1,
  0xFC, 0x03, 0xF8, 0xFF, 0x00, 0xFE, 0x3F, 0xC0, 0x3F, 0x8F, 0xF0, 0x1F,
  0xE3, 0xFC, 0x07, 0xF0, 0xFF, 0x03, 0xFC, 0x1F, 0xF1, 0xFE, 0x07, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x0F, 0xF9, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xE0, 0x7F, 0x1F, 0xC0, 0x7F,
  0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x3F, 0xC0, 0x7F, 0x3F, 0x80, 0xFF,
  0x3F, 0x80, 0xFF, 0x3F, 0x80, 0xFF, 0x3F, 0x81, 0xFF, 0x3F, 0x81, 0xFE,
  0x3F, 0xC3, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFD, 0xFC, 0x07, 0xF1, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x80, 0x7F, 0xC0, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0xE0, 0x3F, 0x81,
  0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0xC0,
  0x7F, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x01, 0xF8, 0x01, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xC0, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0x0F, 0xF0, 0xC0, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x7E, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x7E,
  0x00, 0x00, 0x3E, 0x07, 0xC0, 0x1C, 0x01, 0xF0, 0xFC, 0x0F, 0xFF, 0x1F,
  0x0F, 0x81, 0xFF, 0xE1, 0xF1, 0xF0, 0x3F, 0xFE, 0x1F, 0x1F, 0x07, 0xFF,
  0xE1, 0xF3, 0xE0, 0xFC, 0x3E, 0x1F, 0x3E, 0x1F, 0x87, 0xC1, 0xF7, 0xC1,
  0xF0, 0x7C, 0x1F, 0x7C, 0x3F, 0x07, 0xC1, 0xF7, 0xC3, 0xE0, 0x7C, 0x1F,
  0x7C, 0x3E, 0x0F, 0xC3, 0xEF, 0x87, 0xC0, 0xF8, 0x3E, 0xF8, 0x7C, 0x0F,
  0x83, 0xEF, 0x87, 0xC0, 0xF8, 0x3C, 0xF8, 0x7C, 0x1F, 0x87, 0xCF, 0x87,
  0xC1, 0xF0, 0x7C, 0xF8, 0x7C, 0x3F, 0x0F, 0x8F, 0x87, 0xC3, 0xF0, 0xF8,
  0xF8, 0x7E, 0xFF, 0x3F, 0x0F, 0x87, 0xFF, 0xFF, 0xE0, 0xF8, 0x7F, 0xEF,
  0xFC, 0x0F, 0x83, 0xFC, 0x7F, 0x80, 0xF8, 0x0F, 0x83, 0xF0, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x10, 0x00, 0x1F, 0xC0, 0x0F,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x07, 0xEF, 0xE0, 0x00,
  0xFE, 0xFE, 0x00, 0x0F, 0xCF, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0x8F,
  0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF0, 0xFE, 0x00,
  0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0,
  0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE1, 0xFE, 0x00, 0xFE,
  0x1F, 0xC0, 0x0F, 0xE3, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE7, 0xF8,
  0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFC,
  0x7F, 0xF0, 0x1F, 0xC0, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x03, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x0F, 0xF0, 0x3F,
  0x80, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x03, 0xFC, 0x07, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xE0, 0x7F, 0x80, 0xFE, 0x07,
  0xF8, 0x1F, 0xE0, 0x3F, 0x81, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x81,
  0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF8, 0x3F, 0x80,
  0x7F, 0x83, 0xF8, 0x0F, 0xF0, 0x3F, 0x83, 0xFF, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xCF, 0x80, 0x3F, 0xE0, 0x18, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x01, 0x00, 0x7F, 0xE0,
  0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0x07, 0xFE, 0x01, 0xFC, 0x0F, 0xF8,
  0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0xFF, 0x03,
  0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC1, 0xFE,
  0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00,
  0x7F, 0x83, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x1F,
  0xE0, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0,
  0x7F, 0x80, 0x7F, 0xC1, 0xFC, 0x01, 0xFE, 0x07, 0xF0, 0x0F, 0xF8, 0x1F,
  0xC0, 0x3F, 0xC0, 0xFF, 0x01, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x0F, 0xE0,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFE, 0x7F, 0x00, 0xFF, 0xC0,
  0x18, 0x07, 0xFC, 0x00, 0x20, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x07, 0xFF, 0x87, 0xF8, 0x1F, 0xFE, 0x1F, 0xE0, 0x7F, 0xF8, 0x7F, 0x81,
  0xFF, 0xE1, 0xFC, 0x0F, 0xFF, 0x8F, 0xF0, 0x3F, 0xFC, 0x3F, 0xC0, 0xFF,
  0xF0, 0xFF, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC,
  0x3F, 0xC0, 0x0F, 0xE0, 0xFF, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0xFE, 0x07,
  0xF8, 0x07, 0xF8, 0x1F, 0xF0, 0x1F, 0xC0, 0x7F, 0xE0, 0x7F, 0x00, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0x80, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFE,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x83, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x03,
  0xFC, 0x00, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFC, 0x0F,
  0xF0, 0x01, 0xFC, 0x1F, 0xE0, 0x01, 0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x3F,
  0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xF8, 0xFF, 0x00, 0x03, 0xF8, 0xFF,
  0x00, 0x03, 0xF9, 0xFE, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x07, 0xF7, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xE7, 0xF8,
  0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x3F, 0x81, 0xFC,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x7F, 0x81, 0xFE,
  0x00, 0x7F, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x17, 0xFF, 0xFE, 0x7F, 0xFF,
  0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0xF8,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0x7F, 0xFC, 0x03, 0xF7, 0xC0, 0x3F, 0x7E, 0x00, 0xFD, 0xF0, 0x0F, 0xFF,
  0x80, 0x7F, 0x7E, 0x07, 0xEF, 0xE0, 0x1F, 0xDF, 0x81, 0xFB, 0xF8, 0x07,
  0xF7, 0xE0, 0xFE, 0xFC, 0x01, 0xFD, 0xF8, 0x3F, 0x7F, 0x00, 0x7E, 0x7E,
  0x1F, 0xDF, 0xC0, 0x3F, 0x9F, 0x87, 0xE7, 0xF0, 0x0F, 0xE7, 0xE1, 0xF9,
  0xFC, 0x03, 0xF9, 0xF8, 0xFC, 0x7E, 0x00, 0xFE, 0x7E, 0x3F, 0x3F, 0x80,
  0x3F, 0x1F, 0x9F, 0x8F, 0xE0, 0x1F, 0xC7, 0xE7, 0xE3, 0xF8, 0x07, 0xF1,
  0xFB, 0xF0, 0xFE, 0x01, 0xFC, 0x7E, 0xFC, 0x7F, 0x00, 0x7E, 0x1F, 0xFE,
  0x1F, 0xC0, 0x1F, 0x87, 0xFF, 0x87, 0xF0, 0x0F, 0xE1, 0xFF, 0xC1, 0xFC,
  0x03, 0xF8, 0x7F, 0xF0, 0x7E, 0x00, 0xFE, 0x1F, 0xFC, 0x3F, 0x80, 0x3F,
  0x07, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFF, 0x83, 0xF8, 0x07, 0xF0, 0x7F,
  0xC0, 0xFE, 0x01, 0xFC, 0x1F, 0xF0, 0x3F, 0x00, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0x1F, 0x80, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x1F, 0xF0, 0x01, 0xFC, 0x03, 0xFE, 0x00,
  0x3F, 0x00, 0x7F, 0xC0, 0x0F, 0xE0, 0x0F, 0xFC, 0x01, 0xFC, 0x03, 0xFF,
  0x80, 0x3F, 0x80, 0x7F, 0xF0, 0x07, 0xF0, 0x0F, 0xFE, 0x00, 0xFC, 0x01,
  0xFF, 0xC0, 0x3F, 0x80, 0x3F, 0xFC, 0x07, 0xF0, 0x0F, 0xFF, 0x80, 0xFE,
  0x01, 0xFF, 0xF0, 0x1F, 0x80, 0x3F, 0x7E, 0x07, 0xF0, 0x07, 0xEF, 0xE0,
  0xFE, 0x01, 0xFD, 0xFC, 0x1F, 0xC0, 0x3F, 0xBF, 0x83, 0xF8, 0x07, 0xF3,
  0xF0, 0x7E, 0x00, 0xFC, 0x7E, 0x1F, 0xC0, 0x1F, 0x8F, 0xE3, 0xF8, 0x07,
  0xF1, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x8F, 0xE0, 0x1F, 0xC3, 0xF1, 0xF8,
  0x03, 0xF0, 0x7F, 0x7F, 0x00, 0x7E, 0x0F, 0xEF, 0xE0, 0x1F, 0xC1, 0xFD,
  0xFC, 0x03, 0xF8, 0x1F, 0xBF, 0x00, 0x7F, 0x03, 0xF7, 0xE0, 0x0F, 0xC0,
  0x7F, 0xFC, 0x01, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0x01, 0xFF, 0xF0, 0x0F,
  0xE0, 0x1F, 0xFC, 0x01, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0x00, 0x7F, 0xF0,
  0x0F, 0xE0, 0x0F, 0xFE, 0x01, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0x80, 0x1F,
  0xF0, 0x07, 0xF0, 0x03, 0xFE, 0x00, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0x80,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0x3F, 0xF9, 0xFF, 0x80, 0xFF, 0x81, 0xFE, 0x07, 0xFC, 0x07,
  0xF8, 0x3F, 0xE0, 0x0F, 0xE0, 0xFF, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0xFF,
  0x1F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xF3, 0xFC, 0x00, 0x3F, 0xCF,
  0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xF9, 0xFE, 0x00, 0x0F, 0xE7, 0xF8,
  0x00, 0x7F, 0x9F, 0xE0, 0x01, 0xFE, 0x7F, 0x80, 0x07, 0xF9, 0xFC, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0x7F, 0x3F, 0xC0, 0x03, 0xFC, 0xFF, 0x00, 0x0F,
  0xF3, 0xFC, 0x00, 0x3F, 0xCF, 0xF0, 0x01, 0xFE, 0x3F, 0xC0, 0x07, 0xF8,
  0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x01, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x1F,
  0xE0, 0x3F, 0xE0, 0x7F, 0xC3, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0x81, 0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x01,
  0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0x80, 0x7F, 0x81, 0xFC, 0x03, 0xF8,
  0x1F, 0xE0, 0x1F, 0xC0, 0xFF, 0x01, 0xFE, 0x07, 0xF0, 0x0F, 0xF0, 0x3F,
  0x80, 0xFF, 0x01, 0xFC, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFB, 0xFF, 0x80, 0xFF, 0x83,
  0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x3F, 0xE0, 0x0F, 0xE0, 0xFF, 0x00, 0x3F,
  0xC7, 0xFC, 0x00, 0xFF, 0x1F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xF3,
  0xFC, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xF9, 0xFE,
  0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x7F, 0x9F, 0xE0, 0x01, 0xFE, 0x7F, 0x80,
  0x07, 0xF9, 0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x03,
  0xFC, 0xFF, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x7F, 0xCF, 0xF0, 0x01, 0xFE,
  0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x01, 0xFF, 0x07,
  0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC3, 0xFF, 0x01, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0x3F, 0xF8, 0x0F, 0xE0, 0xFF, 0x01, 0xFC,
  0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xF0,
  0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xC1, 0xFE, 0x07, 0xF8, 0x3F, 0x80,
  0xFF, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x0F, 0xF8, 0x1F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xE7, 0xF0, 0x03, 0xF8, 0xFF, 0x00, 0x7F,
  0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x87, 0xF8,
  0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFE, 0x0F, 0xF0,
  0x3F, 0xC1, 0xFC, 0x07, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xF0,
  0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xF0, 0x1C, 0x07, 0xF8, 0x02,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x08, 0x00, 0x7F, 0x83,
  0x80, 0x3F, 0xE0, 0xFC, 0x1F, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFC, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x07, 0xF0, 0x3F, 0x80,
  0x3F, 0xC0, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xF8, 0x1F, 0xE0, 0x0F,
  0xE0, 0x7F, 0x00, 0x7F, 0x81, 0xFC, 0x01, 0xFE, 0x07, 0xF0, 0x07, 0xF8,
  0x3F, 0xC0, 0x1F, 0xC0, 0xFF, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xFC, 0x0F,
  0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0x81, 0xFE, 0x00, 0xFE, 0x07, 0xF8,
  0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xE0, 0x7F, 0x00, 0x7F, 0x83, 0xFC, 0x01,
  0xFC, 0x0F, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0xC0, 0xFE, 0x00, 0xFF,
  0x03, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xE0, 0x7F, 0x80, 0x3F, 0x81,
  0xFC, 0x01, 0xFE, 0x07, 0xF0, 0x07, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFF,
  0x00, 0x7F, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0,
  0x7F, 0x80, 0x7F, 0xC3, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFF,
  0xC0, 0x03, 0xFB, 0xF8, 0x00, 0xFF, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x03,
  0xF9, 0xFC, 0x00, 0xFF, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x07, 0xF8, 0xFE,
  0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0xC3, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFE,
  0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xF0,
  0x3F, 0x80, 0xFE, 0x0F, 0xF0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x80,
  0x3F, 0x0F, 0xE0, 0x07, 0xE1, 0xFC, 0x00, 0xFC, 0x7F, 0x00, 0x1F, 0x8F,
  0xE0, 0x03, 0xF3, 0xF8, 0x00, 0x7E, 0x7F, 0x00, 0x0F, 0xCF, 0xC0, 0x01,
  0xFB, 0xF8, 0x00, 0x3F, 0x7F, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x3F, 0xDF, 0xC0, 0x0F, 0xC0, 0x0F, 0xE7, 0xF0, 0x07, 0xF0, 0x03, 0xF9,
  0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x7F, 0x00, 0xFF, 0x00, 0x7F, 0x1F, 0xC0,
  0x3F, 0xC0, 0x1F, 0xC7, 0xF0, 0x0F, 0xF0, 0x0F, 0xE1, 0xFC, 0x07, 0xFC,
  0x03, 0xF8, 0x7F, 0x01, 0xFF, 0x01, 0xFC, 0x1F, 0xC0, 0xFF, 0xC0, 0x7F,
  0x07, 0xE0, 0x3F, 0xF0, 0x1F, 0xC1, 0xF8, 0x0F, 0xFC, 0x0F, 0xE0, 0x7E,
  0x07, 0xFF, 0x03, 0xF8, 0x1F, 0x81, 0xFF, 0xC1, 0xFC, 0x07, 0xE0, 0xFF,
  0xF0, 0x7F, 0x01, 0xF8, 0x3F, 0xFC, 0x1F, 0xC0, 0x7E, 0x0F, 0xBF, 0x0F,
  0xE0, 0x1F, 0x87, 0xEF, 0xC3, 0xF8, 0x07, 0xE1, 0xFB, 0xF1, 0xFC, 0x01,
  0xF8, 0xFC, 0xFC, 0x7F, 0x00, 0x7E, 0x3F, 0x3F, 0x1F, 0xC0, 0x1F, 0x9F,
  0xCF, 0xCF, 0xE0, 0x07, 0xE7, 0xE3, 0xF3, 0xF8, 0x01, 0xF9, 0xF8, 0xFD,
  0xFC, 0x00, 0x7E, 0xFC, 0x3F, 0x7F, 0x00, 0x1F, 0xBF, 0x0F, 0xDF, 0xC0,
  0x07, 0xEF, 0xC3, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0xFF,
  0xF8, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0,
  0x1F, 0xE0, 0x03, 0xF8, 0x1F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFE,
  0x0F, 0xF0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x0F,
  0xE7, 0xF8, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x01,
  0xFD, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xBF, 0x80,
  0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x1F, 0xE3, 0xF8,
  0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF8, 0x07,
  0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xBF, 0x80, 0x3F, 0xDF,
  0xE0, 0x1F, 0xC7, 0xF0, 0x1F, 0xE3, 0xF8, 0x0F, 0xE1, 0xFC, 0x0F, 0xF0,
  0xFE, 0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x3F, 0x87, 0xF8, 0x0F, 0xC3, 0xF8,
  0x07, 0xF3, 0xFC, 0x03, 0xF9, 0xFC, 0x01, 0xFD, 0xFC, 0x00, 0xFE, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xFC, 0x3F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFE, 0x1F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF8, 0x7F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xE1, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x87, 0xF0, 0xFE, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xBE, 0x00, 0x1F, 0x9F, 0x80, 0x1F, 0x8F,
  0xC0, 0x0F, 0xC7, 0xE0, 0x0F, 0xC1, 0xF0, 0x0F, 0xE0, 0xFC, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xE3, 0xF0,
  0x03, 0xF1, 0xF8, 0x01, 0xF9, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x3F, 0xC7, 0xF8, 0xFE,
  0x3F, 0x87, 0xE0, 0xFC, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0xE3, 0xF0,
  0x1F, 0xFD, 0xFC, 0x0F, 0xFF, 0x7E, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xE0, 0xFF, 0x9F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xE0, 0xFF, 0x07, 0xF0,
  0x1F, 0xC3, 0xFC, 0x07, 0xF0, 0xFF, 0x01, 0xFC, 0x3F, 0x80, 0xFF, 0x1F,
  0xE0, 0x3F, 0x87, 0xF8, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFE,
  0x1F, 0xC0, 0x7F, 0x87, 0xF0, 0x1F, 0xC3, 0xFC, 0x07, 0xF0, 0xFF, 0x03,
  0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x7F, 0x81, 0xFC, 0x3F, 0xE0, 0x7F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xEF, 0xC0,
  0x3F, 0xF3, 0xF0, 0x03, 0xF8, 0xFC, 0x00, 0x10, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE3,
  0xE0, 0x03, 0xF9, 0xFE, 0x00, 0xFE, 0xFF, 0xC0, 0x3F, 0x7F, 0xF8, 0x1F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0x1F, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC3, 0xF8, 0x0F, 0xF0, 0xFE, 0x03,
  0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC,
  0x03, 0xF8, 0x7F, 0x01, 0xFE, 0x1F, 0xC0, 0x7F, 0x8F, 0xF0, 0x1F, 0xC3,
  0xF8, 0x0F, 0xF0, 0xFE, 0x03, 0xFC, 0x3F, 0x80, 0xFE, 0x0F, 0xF0, 0x7F,
  0x87, 0xFC, 0x3F, 0xC1, 0xFF, 0xDF, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFC, 0x07, 0xEF, 0xFE, 0x03, 0xF3, 0xFF, 0x00, 0xFC, 0x7F, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0x80, 0x7F, 0xFE, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xC3, 0x83, 0xFC, 0x04,
  0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x04, 0x1F, 0xE0, 0x60, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x03, 0xE1, 0xFC, 0x00, 0xFF, 0x9F, 0xC0, 0x1F,
  0xFD, 0xFC, 0x03, 0xFF, 0xDF, 0x80, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x80, 0xFF, 0x1F, 0xF8, 0x0F, 0xE0, 0xFF, 0x81, 0xFE, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x03, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x0F,
  0xF0, 0x7F, 0x80, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07,
  0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x01,
  0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80,
  0x7F, 0x07, 0xF8, 0x07, 0xFD, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xBF, 0x00, 0x0F, 0xE3, 0xF0,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x80, 0x1F, 0xFF,
  0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xEF, 0xF1, 0xFE, 0x1F, 0xC7,
  0xF0, 0x3F, 0x3F, 0x80, 0xFC, 0xFE, 0x07, 0xF7, 0xF0, 0x1F, 0xDF, 0xC0,
  0xFE, 0x7F, 0x1F, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x03, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x10, 0xFF, 0x03,
  0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x3F, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x04, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x11, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xFE, 0x3F, 0x00, 0x7F, 0xF7, 0xF0, 0x0F, 0xFF, 0x7E,
  0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFE, 0x7F, 0xE0, 0x3F,
  0xC3, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x1F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0xC1, 0xFE, 0x03, 0xF8, 0x1F,
  0xE0, 0x3F, 0x81, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x07,
  0xF8, 0x3F, 0xC0, 0x7F, 0x03, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x03, 0xFC, 0x3F, 0xE0, 0x1F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFD, 0xFC, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8,
  0x0C, 0x00, 0xFF, 0x00, 0xF8, 0x1F, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x3F, 0x9F, 0xE0, 0x1F, 0xDF,
  0xF8, 0x0F, 0xDF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF,
  0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0xFF, 0x07, 0xF0, 0xFF, 0x03, 0xF8, 0x7F,
  0x81, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F,
  0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF1,
  0xFE, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFE,
  0x1F, 0xC0, 0xFF, 0x1F, 0xE0, 0x7F, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F,
  0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x0F, 0xF1, 0xFC, 0x07, 0xF0, 0xFE, 0x03,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFE,
  0x01, 0xFE, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x80,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFE, 0x00, 0x47, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x01, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x81,
  0xFC, 0x03, 0xF8, 0x3F, 0xC0, 0x7F, 0x07, 0xF8, 0x07, 0xF0, 0xFF, 0x00,
  0x7F, 0x1F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0x7E, 0x3F, 0x80, 0x0F, 0xE7,
  0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFD, 0xFC, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xCF, 0xE0,
  0x03, 0xF8, 0xFF, 0x00, 0x3F, 0x8F, 0xF0, 0x03, 0xF0, 0x7F, 0x00, 0x7F,
  0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x80, 0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x3F,
  0x80, 0x7E, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0xC0, 0xFE, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x01, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC,
  0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0,
  0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFC, 0x03, 0xE0, 0x0F, 0xCF, 0xF8, 0x3F, 0xE0, 0x3F, 0x7F, 0xF1, 0xFF,
  0x80, 0xFB, 0xFF, 0xCF, 0xFF, 0x07, 0xEF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xC7, 0xFF, 0x3F, 0xC1, 0xFE, 0x0F, 0xF8, 0x7F,
  0x07, 0xF0, 0x3F, 0xC1, 0xFC, 0x3F, 0xC0, 0xFE, 0x07, 0xF0, 0xFE, 0x03,
  0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x01, 0xFC,
  0x7F, 0x81, 0xFC, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0x3F, 0x87, 0xF0, 0x1F,
  0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x0F, 0xE3,
  0xF8, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x3F, 0x80, 0xFE,
  0x07, 0xF0, 0xFE, 0x07, 0xF0, 0x1F, 0xC3, 0xF8, 0x1F, 0xC0, 0x7F, 0x1F,
  0xC0, 0x7F, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x0F, 0xE1, 0xFC, 0x0F, 0xE0,
  0x3F, 0x87, 0xF0, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0xFE,
  0x03, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x00, 0x7C,
  0x01, 0xF8, 0xFF, 0x00, 0xF8, 0xFF, 0xC0, 0x7C, 0xFF, 0xF0, 0x7E, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xF9, 0xFE, 0x0F, 0xF0, 0x7F, 0x07, 0xF8,
  0x3F, 0x87, 0xF8, 0x1F, 0xC3, 0xFC, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE,
  0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x1F,
  0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x8F, 0xF0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3,
  0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0xFF, 0x03, 0xF8,
  0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x7F,
  0x8F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x01, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0x87, 0xFC, 0xFF, 0x1F, 0xE0, 0xFF, 0x3F, 0xC0, 0xFE, 0xFF, 0x01, 0xFD,
  0xFE, 0x03, 0xFB, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFF, 0x00, 0xFE, 0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xF8,
  0x07, 0xF7, 0xF0, 0x1F, 0xEF, 0xE0, 0x3F, 0x9F, 0xC0, 0xFF, 0x3F, 0x81,
  0xFC, 0x7F, 0x07, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xF1, 0xFE, 0x00, 0x1F, 0xBF, 0xF8,
  0x00, 0xFD, 0xFF, 0xE0, 0x0F, 0xDF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03,
  0xFE, 0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0xFE, 0x07, 0xF8, 0x0F, 0xF0,
  0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F,
  0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x03,
  0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x81, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xE0, 0xFF,
  0x01, 0xFF, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x80, 0x1F, 0xBF, 0xFC, 0x01, 0xFC, 0xFF, 0x80, 0x0F, 0xE3,
  0xF8, 0x00, 0x7F, 0x02, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xE3, 0xF0, 0x1F, 0xFD, 0xFC, 0x0F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0x1F, 0xF8,
  0x3F, 0x83, 0xFE, 0x1F, 0xE0, 0x7F, 0x07, 0xF0, 0x1F, 0xC3, 0xFC, 0x07,
  0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x1F, 0xE0, 0x3F, 0x87, 0xF0,
  0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x0F,
  0xF0, 0x1F, 0xC3, 0xFC, 0x07, 0xF0, 0xFF, 0x01, 0xFC, 0x3F, 0xC0, 0xFF,
  0x0F, 0xF0, 0x3F, 0x83, 0xFC, 0x1F, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xF7, 0xF0, 0x07,
  0xF9, 0xFC, 0x00, 0x20, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x1F, 0x8F, 0xC0, 0xFC, 0xFE, 0x07, 0xEF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xE6, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x80, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0x81, 0x83, 0xFC,
  0x04, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE2, 0x00, 0x7F, 0x18, 0x07, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x04,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xFF, 0x3F, 0xFF, 0xBF, 0xFF, 0xDF,
  0xFF, 0xCF, 0xFF, 0xE0, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xFE, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0,
  0x3F, 0xF8, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x20, 0x00, 0x0F, 0xE0, 0x3F,
  0x87, 0xF0, 0x3F, 0x83, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x07,
  0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x80,
  0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x3F, 0x87, 0xF0,
  0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE,
  0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0xFF, 0x0F,
  0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x7F, 0xC1, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFD, 0xF8, 0x0F, 0xFC, 0xFC,
  0x03, 0xFC, 0x7E, 0x00, 0x10, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xFC, 0x03,
  0xFB, 0xF8, 0x07, 0xF7, 0xF0, 0x1F, 0xCF, 0xE0, 0x3F, 0x9F, 0xC0, 0xFE,
  0x3F, 0x81, 0xFC, 0x3F, 0x07, 0xF8, 0x7E, 0x0F, 0xE0, 0xFC, 0x1F, 0xC1,
  0xF8, 0x7F, 0x03, 0xF0, 0xFE, 0x07, 0xE3, 0xF8, 0x0F, 0xC7, 0xF0, 0x1F,
  0x9F, 0xC0, 0x3F, 0x3F, 0x80, 0x7E, 0x7E, 0x00, 0xFD, 0xFC, 0x01, 0xFB,
  0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x0F, 0xFF,
  0xE0, 0x7F, 0xC0, 0xFE, 0xFE, 0x07, 0xFC, 0x0F, 0xCF, 0xE0, 0xFF, 0xC1,
  0xFC, 0xFE, 0x0F, 0xFC, 0x1F, 0xCF, 0xE0, 0xFF, 0xC3, 0xF8, 0xFE, 0x1F,
  0xFC, 0x3F, 0x8F, 0xE1, 0xFF, 0xC3, 0xF0, 0xFE, 0x3F, 0xFC, 0x7F, 0x0F,
  0xE3, 0xFF, 0x87, 0xF0, 0xFE, 0x3E, 0xF8, 0xFE, 0x0F, 0xE7, 0xEF, 0x8F,
  0xE0, 0xFE, 0x7C, 0xF8, 0xFC, 0x0F, 0xEF, 0xCF, 0x9F, 0xC0, 0xFE, 0xFC,
  0xF9, 0xF8, 0x0F, 0xEF, 0x8F, 0x9F, 0x80, 0xFF, 0xF8, 0xFB, 0xF8, 0x0F,
  0xDF, 0x0F, 0xBF, 0x00, 0xFD, 0xF0, 0xFB, 0xF0, 0x0F, 0xFF, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xE0,
  0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x0F,
  0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xF0,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0,
  0x7F, 0x80, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x3F, 0xC0, 0x0F, 0xE3, 0xFC,
  0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFD, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFD,
  0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFE, 0x3F, 0x80, 0x1F, 0xE1, 0xFC,
  0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x0F,
  0xF0, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x3F, 0xC0, 0x0F, 0xC0, 0x7F, 0x00,
  0x1F, 0x81, 0xFE, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x7E, 0x07, 0xF0, 0x00,
  0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x3F,
  0x9F, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x04, 0x3F, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x02, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x60, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x1F, 0xE0, 0x01, 0x7F, 0xFC, 0x07, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE0, 0x1F, 0xFE,
  0x80, 0x07, 0xF8,
};

const GFXglyph NotoSans_Condensed_BoldItalic54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 16, 40, 14, 0, -39 },
  { 81, 19, 14, 22, 5, -39 },
  { 115, 30, 39, 29, 0, -39 },
  { 262, 26, 44, 25, 0, -41 },
  { 405, 36, 39, 41, 3, -39 },
  { 581, 31, 40, 31, 0, -39 },
  { 736, 9, 14, 13, 5, -39 },
  { 752, 19, 48, 16, 1, -39 },
  { 866, 19, 48, 16, -4, -39 },
  { 980, 22, 23, 24, 4, -41 },
  { 1044, 24, 26, 27, 2, -32 },
  { 1122, 12, 14, 14, -3, -7 },
  { 1143, 14, 7, 16, 1, -18 },
  { 1156, 9, 9, 14, 0, -8 },
  { 1167, 28, 39, 21, -3, -39 },
  { 1304, 24, 40, 25, 1, -39 },
  { 1424, 19, 39, 25, 5, -39 },
  { 1517, 27, 39, 25, -2, -39 },
  { 1649, 26, 40, 25, 0, -39 },
  { 1779, 26, 39, 25, -1, -39 },
  { 1906, 26, 40, 25, 0, -39 },
  { 2036, 25, 40, 25, 2, -39 },
  { 2161, 26, 39, 25, 2, -39 },
  { 2288, 26, 40, 25, 0, -39 },
  { 2418, 24, 40, 25, 1, -39 },
  { 2538, 14, 31, 14, 0, -30 },
  { 2593, 17, 37, 14, -3, -30 },
  { 2672, 24, 27, 27, 2, -33 },
  { 2753, 24, 16, 27, 2, -27 },
  { 2801, 24, 27, 27, 2, -33 },
  { 2882, 20, 40, 20, 2, -39 },
  { 2982, 36, 43, 38, 2, -39 },
  { 3176, 28, 39, 28, -3, -39 },
  { 3313, 28, 39, 28, 0, -39 },
  { 3450, 28, 40, 26, 2, -39 },
  { 3590, 30, 39, 30, 0, -39 },
  { 3737, 26, 39, 24, 0, -39 },
  { 3864, 26, 39, 23, 0, -39 },
  { 3991, 30, 40, 31, 2, -39 },
  { 4141, 33, 39, 31, 0, -39 },
  { 4302, 24, 39, 18, -2, -39 },
  { 4419, 24, 50, 15, -8, -39 },
  { 4569, 32, 39, 27, 0, -39 },
  { 4725, 20, 39, 23, 0, -39 },
  { 4823, 42, 39, 41, 0, -39 },
  { 5028, 35, 39, 33, 0, -39 },
  { 5199, 30, 40, 32, 2, -39 },
  { 5349, 29, 39, 27, 0, -39 },
  { 5491, 30, 48, 32, 2, -39 },
  { 5671, 27, 39, 28, 0, -39 },
  { 5803, 26, 40, 24, 0, -39 },
  { 5933, 24, 39, 24, 4, -39 },
  { 6050, 30, 40, 31, 2, -39 },
  { 6200, 27, 39, 27, 5, -39 },
  { 6332, 42, 39, 41, 4, -39 },
  { 6537, 33, 39, 26, -3, -39 },
  { 6698, 25, 39, 25, 5, -39 },
  { 6820, 29, 39, 23, -2, -39 },
  { 6962, 22, 48, 16, -2, -39 },
  { 7094, 11, 39, 21, 6, -39 },
  { 7148, 22, 48, 16, -4, -39 },
  { 7280, 25, 24, 25, 0, -39 },
  { 7355, 19, 3, 19, -5, 5 },
  { 7363, 10, 8, 17, 8, -41 },
  { 7373, 26, 31, 27, 1, -30 },
  { 7474, 26, 42, 27, 0, -41 },
  { 7611, 21, 31, 22, 2, -30 },
  { 7693, 28, 42, 27, 1, -41 },
  { 7840, 22, 31, 25, 2, -30 },
  { 7926, 29, 54, 17, -6, -41 },
  { 8122, 28, 43, 27, -1, -30 },
  { 8273, 25, 41, 27, 0, -41 },
  { 8402, 16, 41, 14, 0, -41 },
  { 8484, 23, 54, 14, -7, -41 },
  { 8640, 28, 41, 25, 0, -41 },
  { 8784, 16, 41, 13, 0, -41 },
  { 8866, 38, 30, 40, 0, -30 },
  { 9009, 25, 30, 27, 0, -30 },
  { 9103, 23, 31, 26, 2, -30 },
  { 9193, 29, 43, 27, -3, -30 },
  { 9349, 26, 43, 27, 1, -30 },
  { 9489, 21, 30, 19, 0, -30 },
  { 9568, 21, 31, 21, 0, -30 },
  { 9650, 17, 37, 18, 2, -36 },
  { 9729, 25, 30, 27, 2, -29 },
  { 9823, 23, 29, 23, 3, -29 },
  { 9907, 36, 29, 36, 3, -29 },
  { 10038, 29, 29, 24, -3, -29 },
  { 10144, 31, 42, 24, -4, -29 },
  { 10307, 24, 29, 20, -2, -29 },
  { 10394, 22, 48, 19, 0, -39 },
  { 10526, 6, 53, 23, 8, -41 },
  { 10566, 21, 48, 19, -3, -39 },
  { 10692, 24, 9, 27, 2, -24 },
};

const GFXfont NotoSans_Condensed_BoldItalic54pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BoldItalic54pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BoldItalic54pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _NOTOSANS_CONDENSED_BOLDITALIC54PT7B_H_
