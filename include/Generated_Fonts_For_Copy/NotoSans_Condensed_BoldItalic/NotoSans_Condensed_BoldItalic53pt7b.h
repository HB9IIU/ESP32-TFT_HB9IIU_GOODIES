#ifndef _NOTOSANS_CONDENSED_BOLDITALIC53PT7B_H_
#define _NOTOSANS_CONDENSED_BOLDITALIC53PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BoldItalic.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BoldItalic53pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x00, 0xFF, 0x00, 0x7E, 0x00, 0x10, 0x00, 0x3F, 0x8F, 0xE7, 0xF1, 0xFC,
  0xFC, 0x3F, 0x1F, 0x8F, 0xE7, 0xF1, 0xFC, 0xFE, 0x3F, 0x1F, 0x87, 0xE3,
  0xF0, 0xFC, 0x7E, 0x1F, 0x8F, 0x83, 0xE1, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F,
  0xC3, 0xE1, 0xF0, 0x7C, 0x00, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x1F,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x7C, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F,
  0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x1F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E,
  0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x7C,
  0x01, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0x87, 0xC0, 0x00, 0x7C,
  0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x7E, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x3E, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xB9, 0xE0, 0x1F,
  0xCE, 0x18, 0x07, 0xF3, 0x80, 0x01, 0xFC, 0xC0, 0x00, 0x7F, 0x30, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xDF, 0xE0, 0x00, 0x67, 0xF8, 0x40, 0x19, 0xFC, 0x18, 0x0E, 0x7F,
  0x07, 0x83, 0x9F, 0xC1, 0xF8, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0xFF, 0x80, 0x0F, 0xC0, 0x3F, 0xF8, 0x01, 0xF0, 0x0F, 0xFF, 0x00, 0x7E,
  0x01, 0xFB, 0xF0, 0x0F, 0x80, 0x7E, 0x7E, 0x03, 0xE0, 0x0F, 0x87, 0xC0,
  0xFC, 0x03, 0xF0, 0xF8, 0x1F, 0x00, 0x7C, 0x1F, 0x07, 0xC0, 0x0F, 0x87,
  0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x3E, 0x00, 0x7E, 0x1F, 0x0F, 0xC0, 0x0F,
  0x83, 0xE1, 0xF0, 0x01, 0xF0, 0x7C, 0x7C, 0x00, 0x3E, 0x1F, 0x9F, 0x80,
  0x07, 0xC3, 0xE3, 0xE1, 0xF8, 0xF8, 0xFC, 0xFC, 0xFF, 0xDF, 0x1F, 0x9F,
  0x3F, 0xFB, 0xF7, 0xE7, 0xC7, 0xFF, 0xFF, 0xF9, 0xF9, 0xFF, 0xF7, 0xFF,
  0x3E, 0x7E, 0x3E, 0xFF, 0xCF, 0xCF, 0x87, 0xCF, 0xE1, 0xF1, 0xF0, 0xF8,
  0x00, 0x7C, 0x7E, 0x1F, 0x00, 0x1F, 0x8F, 0x83, 0xE0, 0x03, 0xE1, 0xF0,
  0x7C, 0x00, 0xFC, 0x3E, 0x1F, 0x80, 0x1F, 0x0F, 0xC3, 0xF0, 0x07, 0xC1,
  0xF8, 0x7C, 0x01, 0xF8, 0x3E, 0x0F, 0x80, 0x3E, 0x07, 0xC3, 0xF0, 0x0F,
  0xC0, 0xF8, 0x7C, 0x01, 0xF0, 0x1F, 0x1F, 0x80, 0x7C, 0x03, 0xF7, 0xE0,
  0x1F, 0x80, 0x3F, 0xFC, 0x03, 0xE0, 0x07, 0xFF, 0x00, 0xFC, 0x00, 0x7F,
  0xC0, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x80, 0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF0, 0x00,
  0x7F, 0x1F, 0xC0, 0x00, 0xFC, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x1F, 0xC0, 0xFF, 0xF0, 0x7F, 0x07, 0xFF, 0xC3,
  0xF8, 0x3F, 0xFF, 0x8F, 0xE1, 0xFC, 0xFE, 0x7F, 0x0F, 0xF3, 0xFD, 0xFC,
  0x3F, 0x87, 0xFF, 0xE1, 0xFC, 0x1F, 0xFF, 0x87, 0xF0, 0x3F, 0xFC, 0x1F,
  0xC0, 0xFF, 0xF0, 0xFF, 0x03, 0xFF, 0x83, 0xFC, 0x07, 0xFC, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0xC0, 0x7F, 0xDF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0x3F,
  0xE0, 0x3F, 0xF0, 0x7F, 0x80, 0x04, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0xCF,
  0xE7, 0xE3, 0xF3, 0xF9, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x0F, 0x8F, 0xC7,
  0xE0, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0xC1, 0xF8, 0x03,
  0xC7, 0xC0, 0x1F, 0xDF, 0x00, 0x7F, 0xFC, 0x79, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xE0,
  0x03, 0xFF, 0x80, 0x1F, 0xDF, 0x00, 0xFE, 0x7E, 0x07, 0xF9, 0xF8, 0x07,
  0xC3, 0xF0, 0x0E, 0x0F, 0xC0, 0x18, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x7F, 0x0F, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F,
  0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x7F, 0xFD, 0xFF, 0xEF,
  0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xE0, 0x1E, 0x1F, 0x9F, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFC, 0xFC, 0x10, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF0, 0x7F, 0x0F, 0xF0, 0x7F, 0x0F, 0xE0,
  0x7F, 0x0F, 0xE0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x3F, 0xC0,
  0x7F, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x7F, 0x80,
  0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x01, 0xFE, 0x7F, 0x01,
  0xFC, 0x7F, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x03,
  0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF8, 0xFE, 0x07, 0xF0, 0xFE, 0x0F,
  0xF0, 0xFE, 0x0F, 0xE0, 0xFF, 0x1F, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF,
  0x1F, 0xFF, 0xCF, 0xF7, 0xF1, 0xF9, 0xFC, 0x3C, 0x7F, 0x0C, 0x3F, 0x81,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x80, 0x7F, 0x0F, 0xF8, 0x07, 0xC0, 0xFF, 0x00, 0x60, 0x1F,
  0xE0, 0x08, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0x81,
  0xFE, 0x01, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xC2, 0x00, 0x1F, 0xE1, 0x80, 0x1F, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xEF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7D, 0xFC, 0x00, 0x3F, 0x7E, 0x00,
  0x1F, 0xBF, 0x80, 0x07, 0xCF, 0xE0, 0x03, 0xE3, 0xF8, 0x01, 0xF8, 0xFE,
  0x00, 0x7C, 0x3F, 0x00, 0x3E, 0x1F, 0xC0, 0x1F, 0x87, 0xF0, 0x0F, 0xC1,
  0xFC, 0x03, 0xE0, 0x7E, 0x01, 0xF8, 0x3F, 0x80, 0xFC, 0x0F, 0xE0, 0x3F,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x60, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC2, 0x00, 0x3F, 0xE1, 0xC0, 0x3F,
  0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x87, 0x00, 0x3F, 0x9F, 0xC0, 0x3F, 0x7F, 0xE0, 0x7F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0xFF, 0xEF, 0xF8, 0xFF,
  0x83, 0xF8, 0xFF, 0x03, 0xF8, 0xFF, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE,
  0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF8, 0xFE, 0x07, 0xF0, 0xFC,
  0x07, 0xF0, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F, 0xF0, 0xFE, 0x1F, 0xE0, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x1F,
  0xE3, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x83,
  0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x87, 0xF0,
  0x1F, 0xC7, 0xF8, 0x0F, 0xF7, 0xF8, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0x9F, 0xE0, 0x7F, 0x87, 0xF8, 0x7F, 0x81,
  0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x1F, 0xE0, 0x3F, 0x8F, 0xE0,
  0x1F, 0xC7, 0xF0, 0x0F, 0xE3, 0xFC, 0x07, 0xF1, 0xFE, 0x07, 0xF8, 0x7F,
  0x87, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xE0, 0xFE,
  0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFF, 0x3F, 0x80, 0xFF, 0x3F, 0x80, 0xFE,
  0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x81, 0xFE, 0x3F, 0x81, 0xFE,
  0x3F, 0x83, 0xFE, 0x3F, 0xC7, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFD, 0xFC, 0x07, 0xFB, 0xF8, 0x00, 0xC3, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x01, 0xFC, 0x0F, 0xF0, 0xFF, 0x87, 0xFC,
  0x3F, 0xC1, 0xFE, 0x07, 0xE0, 0x08, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x04, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xC0, 0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x7F, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x1E, 0x07, 0xF0, 0x80, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFC, 0x0F, 0xF8, 0x01,
  0xFE, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x3E,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7C, 0x3F, 0x01, 0xFE,
  0x0F, 0x87, 0xC0, 0xFF, 0xF1, 0xF1, 0xF0, 0x3F, 0xFE, 0x3E, 0x3E, 0x0F,
  0xFF, 0xC7, 0xCF, 0x83, 0xF1, 0xF0, 0x79, 0xF0, 0xFC, 0x3E, 0x1F, 0x7C,
  0x1F, 0x07, 0xC3, 0xEF, 0x87, 0xC0, 0xF8, 0x7D, 0xF0, 0xF8, 0x3E, 0x0F,
  0xBC, 0x3F, 0x07, 0xC1, 0xFF, 0x87, 0xC0, 0xF8, 0x3D, 0xF0, 0xF8, 0x3F,
  0x0F, 0xBE, 0x1F, 0x07, 0xC1, 0xF7, 0xC3, 0xE0, 0xF8, 0x3E, 0xF8, 0xFC,
  0x1F, 0x0F, 0x9E, 0x1F, 0x87, 0xE1, 0xF3, 0xC3, 0xF1, 0xFC, 0x7C, 0x78,
  0x3E, 0x3F, 0x9F, 0x8F, 0x07, 0xFE, 0xFF, 0xE1, 0xF0, 0xFF, 0xDF, 0xF8,
  0x3E, 0x0F, 0xF3, 0xFE, 0x07, 0xC0, 0xFC, 0x3F, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x30, 0x00, 0x7F, 0x80, 0x3E, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0xFD, 0xF8, 0x00, 0x3F, 0xBF, 0x00, 0x07, 0xE7, 0xE0, 0x01, 0xFC,
  0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xE3, 0xF0, 0x01, 0xFC, 0x7E, 0x00,
  0x3F, 0x0F, 0xC0, 0x0F, 0xE1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x7F, 0x07,
  0xF0, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xC0, 0x1F, 0xC7, 0xF8,
  0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x3F, 0xC0, 0x0F, 0xE7, 0xF0, 0x01, 0xFD,
  0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01,
  0xFC, 0x1F, 0xF0, 0x1F, 0xC0, 0xFF, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0x80,
  0xFF, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0x00, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0x7F, 0x01, 0xFC,
  0x07, 0xF8, 0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x3F,
  0x81, 0xFC, 0x07, 0xF8, 0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x0F, 0xF0, 0x3F,
  0x80, 0xFF, 0x03, 0xF8, 0x3F, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xC1, 0xE0, 0x3F, 0xE0, 0x08, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x04, 0x03,
  0xFE, 0x07, 0x80, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0x83, 0xFE, 0x01, 0xFC, 0x0F, 0xF8,
  0x1F, 0xE0, 0x3F, 0xC0, 0xFE, 0x01, 0xFE, 0x07, 0xF0, 0x0F, 0xF0, 0x3F,
  0x80, 0x7F, 0x83, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFE, 0x00,
  0xFF, 0x07, 0xF0, 0x07, 0xF8, 0x3F, 0x80, 0x3F, 0xC3, 0xFC, 0x01, 0xFE,
  0x1F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFF, 0x07, 0xF0, 0x07, 0xF8, 0x3F,
  0x80, 0x3F, 0xC3, 0xFC, 0x01, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFE, 0x00,
  0xFF, 0x07, 0xF0, 0x0F, 0xF0, 0x3F, 0x80, 0x7F, 0x83, 0xFC, 0x07, 0xF8,
  0x1F, 0xC0, 0x7F, 0xC0, 0xFE, 0x0F, 0xFC, 0x07, 0xF3, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x04, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFE, 0x07, 0x80, 0xFF, 0xC0, 0x0C, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x0F, 0xFF, 0x1F, 0xE0,
  0x7F, 0xF8, 0xFE, 0x07, 0xFF, 0x87, 0xF0, 0x3F, 0xFC, 0x7F, 0x81, 0xFF,
  0xE3, 0xFC, 0x0F, 0xFF, 0x1F, 0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0x87,
  0xF8, 0x01, 0xFC, 0x3F, 0xC0, 0x0F, 0xE1, 0xFE, 0x00, 0xFF, 0x0F, 0xF0,
  0x07, 0xF0, 0x3F, 0xC0, 0x3F, 0x81, 0xFE, 0x01, 0xFC, 0x0F, 0xFC, 0x0F,
  0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x01,
  0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFC, 0x01, 0xFE, 0x01,
  0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x01, 0xFC, 0x03,
  0xF8, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xFC, 0x07, 0xF8, 0x03, 0xF8, 0x07,
  0xF8, 0x03, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F,
  0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F,
  0xC0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x3F,
  0x80, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0xC0, 0x7F,
  0x80, 0x3F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x80, 0x7F,
  0x00, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFC,
  0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x43, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFE,
  0x00, 0xFE, 0x03, 0xFC, 0x00, 0xFE, 0x07, 0xF8, 0x01, 0xFC, 0x07, 0xF8,
  0x01, 0xFC, 0x0F, 0xF0, 0x01, 0xFC, 0x1F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0,
  0x01, 0xFC, 0x3F, 0xC0, 0x03, 0xF8, 0x7F, 0x80, 0x03, 0xF8, 0xFF, 0x00,
  0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x07, 0xFB, 0xFC, 0x00,
  0x07, 0xF3, 0xF8, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x1F, 0xE7, 0xF0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x1F, 0xC7, 0xF8, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x3F, 0x83, 0xFC, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0x7F, 0x81, 0xFE, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x7F, 0x01, 0xFE, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF,
  0xFF, 0xE7, 0xFF, 0xFD, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xFE,
  0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xF7, 0xE0, 0x1F, 0xDF, 0x01, 0xFF, 0xF0,
  0x0F, 0xEF, 0x81, 0xFB, 0xF8, 0x07, 0xE7, 0xC0, 0xFD, 0xFC, 0x03, 0xF3,
  0xE0, 0xFC, 0xFC, 0x03, 0xF9, 0xF0, 0x7E, 0xFE, 0x01, 0xFC, 0xF8, 0x7E,
  0x7F, 0x00, 0xFE, 0x7C, 0x3F, 0x3F, 0x80, 0x7E, 0x3E, 0x3F, 0x1F, 0xC0,
  0x3F, 0x1F, 0x9F, 0x8F, 0xC0, 0x3F, 0x8F, 0xDF, 0x8F, 0xE0, 0x1F, 0xC7,
  0xEF, 0xC7, 0xF0, 0x0F, 0xE3, 0xF7, 0xC3, 0xF8, 0x07, 0xE1, 0xFF, 0xE1,
  0xF8, 0x03, 0xF0, 0xFF, 0xF0, 0xFC, 0x03, 0xF8, 0x7F, 0xF0, 0xFE, 0x01,
  0xFC, 0x3F, 0xF8, 0x7F, 0x00, 0xFC, 0x1F, 0xF8, 0x3F, 0x80, 0x7E, 0x0F,
  0xFC, 0x1F, 0x80, 0x7F, 0x07, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xFE, 0x0F,
  0xE0, 0x1F, 0xC1, 0xFE, 0x07, 0xF0, 0x0F, 0xC0, 0xFF, 0x03, 0xF8, 0x07,
  0xE0, 0x7F, 0x01, 0xF8, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x1F, 0xC0, 0x3F, 0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x01, 0xFC, 0x03,
  0xFE, 0x00, 0x7E, 0x01, 0xFF, 0x80, 0x1F, 0x80, 0x7F, 0xF0, 0x0F, 0xE0,
  0x1F, 0xFC, 0x03, 0xF8, 0x07, 0xFF, 0x00, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0x00, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0xFE, 0x07, 0xF0, 0x0F, 0xFF, 0x81,
  0xFC, 0x03, 0xF7, 0xE0, 0x7F, 0x01, 0xFD, 0xF8, 0x1F, 0x80, 0x7F, 0x7F,
  0x0F, 0xE0, 0x1F, 0x9F, 0xC3, 0xF8, 0x07, 0xE7, 0xF0, 0xFE, 0x01, 0xF8,
  0xFC, 0x3F, 0x00, 0xFE, 0x3F, 0x0F, 0xC0, 0x3F, 0x8F, 0xE7, 0xF0, 0x0F,
  0xE3, 0xF9, 0xFC, 0x03, 0xF0, 0x7E, 0x7F, 0x00, 0xFC, 0x1F, 0x9F, 0x80,
  0x7F, 0x07, 0xF7, 0xE0, 0x1F, 0xC1, 0xFD, 0xF8, 0x07, 0xF0, 0x7F, 0xFE,
  0x01, 0xF8, 0x0F, 0xFF, 0x80, 0x7E, 0x03, 0xFF, 0xC0, 0x3F, 0x80, 0xFF,
  0xF0, 0x0F, 0xE0, 0x3F, 0xFC, 0x03, 0xF0, 0x07, 0xFF, 0x00, 0xFC, 0x01,
  0xFF, 0xC0, 0x7F, 0x00, 0x7F, 0xE0, 0x1F, 0xC0, 0x1F, 0xF8, 0x07, 0xF0,
  0x07, 0xFE, 0x01, 0xF8, 0x00, 0xFF, 0x80, 0x7E, 0x00, 0x3F, 0xC0, 0x3F,
  0x80, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x07, 0xF8, 0x07,
  0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xF1,
  0xFE, 0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xE7, 0xF0,
  0x00, 0xFF, 0x7F, 0x80, 0x07, 0xFB, 0xFC, 0x00, 0x3F, 0xDF, 0xE0, 0x01,
  0xFE, 0xFF, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x07, 0xFB,
  0xFC, 0x00, 0x3F, 0xDF, 0xE0, 0x01, 0xFC, 0xFF, 0x00, 0x1F, 0xE7, 0xF8,
  0x00, 0xFF, 0x3F, 0xC0, 0x0F, 0xF1, 0xFE, 0x00, 0x7F, 0x8F, 0xF0, 0x07,
  0xF8, 0x3F, 0x80, 0x3F, 0xC1, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x7F, 0xE0,
  0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01,
  0xFC, 0x3F, 0xF0, 0x1F, 0xC0, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC0,
  0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x07, 0xF0,
  0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x01, 0xFE, 0x07, 0xF0,
  0x1F, 0xE0, 0x7F, 0x07, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x07, 0xF8, 0x07, 0xF8,
  0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xF1, 0xFE,
  0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xE7, 0xF0, 0x00,
  0xFF, 0x7F, 0x80, 0x07, 0xFB, 0xFC, 0x00, 0x3F, 0xDF, 0xE0, 0x01, 0xFE,
  0xFF, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x07, 0xFB, 0xFC,
  0x00, 0x3F, 0xDF, 0xE0, 0x01, 0xFC, 0xFF, 0x00, 0x1F, 0xE7, 0xF8, 0x00,
  0xFF, 0x3F, 0xC0, 0x0F, 0xF1, 0xFE, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF8,
  0x3F, 0x80, 0x7F, 0xC1, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x7F, 0xE0, 0x7F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x80, 0x7F, 0x0F, 0xF8, 0x0F, 0xE0, 0xFF, 0x01, 0xFC, 0x1F,
  0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x3F,
  0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x81, 0xFE,
  0x07, 0xF0, 0x7F, 0x80, 0xFE, 0x7F, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x0F,
  0xE0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xF8, 0x0F,
  0xE0, 0xFF, 0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xFC, 0x0F, 0xE0, 0x3F,
  0xC1, 0xFC, 0x07, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xF1, 0xFC,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F,
  0xE3, 0xE0, 0x1F, 0xF0, 0x18, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x20, 0x01, 0xFE, 0x0E, 0x00, 0xFF, 0x03, 0xE0, 0x7F, 0xC0, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x81,
  0xFE, 0x00, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xC0, 0x1F, 0xE0, 0x7F,
  0x00, 0x7F, 0x01, 0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x07, 0xF0, 0x3F, 0x80,
  0x3F, 0xC0, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xE0, 0x0F,
  0xE0, 0x7F, 0x80, 0x7F, 0x81, 0xFC, 0x01, 0xFE, 0x07, 0xF0, 0x07, 0xF0,
  0x1F, 0xC0, 0x1F, 0xC0, 0xFF, 0x00, 0x7F, 0x03, 0xFC, 0x03, 0xFC, 0x0F,
  0xE0, 0x0F, 0xF0, 0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x07, 0xF8,
  0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xE0, 0x7F, 0x00, 0x7F, 0x01, 0xFC, 0x01,
  0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE1, 0xFF, 0x00,
  0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03,
  0xFB, 0xF8, 0x01, 0xFE, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xE0,
  0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F,
  0xE0, 0x3F, 0xC3, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x87,
  0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x1F,
  0x8F, 0xE0, 0x07, 0xE7, 0xF0, 0x01, 0xF9, 0xFC, 0x00, 0x7E, 0xFE, 0x00,
  0x1F, 0xBF, 0x80, 0x07, 0xEF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F,
  0xBF, 0x00, 0x3F, 0x80, 0x3F, 0x9F, 0x80, 0x1F, 0xC0, 0x1F, 0xCF, 0xC0,
  0x1F, 0xE0, 0x1F, 0xE7, 0xE0, 0x0F, 0xF0, 0x0F, 0xE3, 0xF0, 0x07, 0xF8,
  0x07, 0xF1, 0xF8, 0x07, 0xFC, 0x07, 0xF0, 0xFC, 0x03, 0xFE, 0x03, 0xF8,
  0x7E, 0x03, 0xFF, 0x01, 0xFC, 0x3F, 0x01, 0xFF, 0x81, 0xFC, 0x1F, 0x81,
  0xFF, 0xC0, 0xFE, 0x0F, 0xC0, 0xFF, 0xE0, 0xFE, 0x07, 0xE0, 0x7F, 0xF0,
  0x7F, 0x03, 0xF0, 0x7F, 0xF8, 0x3F, 0x81, 0xF8, 0x3F, 0xFC, 0x3F, 0x80,
  0xFC, 0x3F, 0x7E, 0x1F, 0xC0, 0x7E, 0x1F, 0xBF, 0x1F, 0xC0, 0x3F, 0x0F,
  0xDF, 0x8F, 0xE0, 0x1F, 0x8F, 0xCF, 0xC7, 0xE0, 0x0F, 0xC7, 0xE7, 0xE7,
  0xF0, 0x0F, 0xE7, 0xE3, 0xE3, 0xF8, 0x07, 0xF3, 0xF1, 0xF3, 0xF8, 0x03,
  0xF9, 0xF8, 0xF9, 0xFC, 0x01, 0xFD, 0xF8, 0x7C, 0xFC, 0x00, 0xFE, 0xFC,
  0x3E, 0xFE, 0x00, 0x7F, 0xFC, 0x1F, 0x7F, 0x00, 0x3F, 0xFE, 0x0F, 0xBF,
  0x00, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xF0,
  0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x7F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x1F, 0xC0, 0x3F, 0x80, 0x0F,
  0xF0, 0x3F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xE0, 0x00,
  0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0x8F, 0xF0, 0x00,
  0x0F, 0xE7, 0xF0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0xBF,
  0x80, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x3F, 0xC7,
  0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x1F, 0xE0,
  0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xBF, 0x80, 0x3F, 0x9F, 0xC0, 0x3F, 0xCF,
  0xF0, 0x1F, 0xC3, 0xF8, 0x1F, 0xC1, 0xFC, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0,
  0x7F, 0x0F, 0xF0, 0x3F, 0x87, 0xF0, 0x1F, 0xC7, 0xF0, 0x07, 0xE3, 0xF8,
  0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F,
  0xF8, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xFC, 0x1F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xF0, 0x3F, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFD, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF8,
  0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xE0, 0x7C, 0x0F, 0xC0,
  0x7E, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0x7E, 0x3F, 0x80, 0x3E, 0x3F, 0x00,
  0x3F, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFE, 0x3F, 0xCF, 0xF1, 0xFC, 0x3F, 0x8F, 0xE1, 0xF8,
  0x3F, 0x07, 0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x7F, 0xE7, 0xE0, 0x3F, 0xFD,
  0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC3,
  0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x7F, 0x80, 0xFE, 0x1F, 0xE0, 0x3F,
  0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0,
  0x7F, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xE0, 0xFF, 0x03, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFE, 0xFC, 0x03, 0xFF, 0xBF, 0x00, 0xFF, 0xCF, 0xC0, 0x1F, 0xC3,
  0xF0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0xBF, 0xE0, 0x1F, 0xBF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xFE, 0xFF, 0x83, 0xFC,
  0x1F, 0xC1, 0xFC, 0x0F, 0xE1, 0xFE, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x7F,
  0x01, 0xFC, 0x3F, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F,
  0xE0, 0x3F, 0xC7, 0xF0, 0x1F, 0xC3, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xF1,
  0xFC, 0x07, 0xF8, 0xFE, 0x03, 0xF8, 0x7F, 0x03, 0xFC, 0x3F, 0x81, 0xFC,
  0x3F, 0xE1, 0xFE, 0x1F, 0xF9, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x03, 0xF3, 0xFF, 0x01, 0xF8, 0xFF, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0x02, 0x07, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x02, 0x07, 0xF8, 0x18, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF,
  0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x07, 0xF1, 0xF8, 0x01, 0xFF, 0xBF, 0x80, 0x3F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xFB, 0xFF,
  0x00, 0xFF, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x01, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x07, 0xF8, 0x0F,
  0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xC0, 0x7F, 0x00, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0xFE, 0x03,
  0xF8, 0x0F, 0xF0, 0x3F, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80,
  0x7F, 0x9F, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF,
  0xBF, 0x00, 0x3F, 0xF3, 0xF0, 0x00, 0xFE, 0x3F, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC1, 0xFE, 0x1F, 0xC3, 0xF8, 0x3F, 0x8F, 0xE0, 0x7F,
  0x1F, 0xC0, 0xFE, 0x7F, 0x01, 0xF8, 0xFE, 0x07, 0xF1, 0xF8, 0x3F, 0xE7,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0x7F,
  0xF8, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x08, 0x3F, 0xC0, 0xE0, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xF0,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFE, 0x40, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x09, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x07, 0xFE, 0x7E, 0x00, 0xFF, 0xF7, 0xE0,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFC,
  0x3F, 0xC0, 0x7F, 0x83, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x3F, 0x81, 0xFE,
  0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x03, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x3F,
  0xC1, 0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xC3, 0xFE, 0x01, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xDF, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0xC0, 0x0F, 0xF0, 0x0F, 0x83, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0xBF, 0xE0, 0x1F, 0xBF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFC, 0x3F,
  0xC1, 0xFE, 0x0F, 0xE1, 0xFE, 0x07, 0xF0, 0xFF, 0x03, 0xF8, 0x7F, 0x01,
  0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0,
  0x3F, 0x87, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC,
  0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x3F,
  0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x3F, 0x83,
  0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0x00, 0x7E, 0x01,
  0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x01,
  0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x0D, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xE0,
  0x7F, 0x01, 0xFC, 0x1F, 0xE0, 0x3F, 0x87, 0xF8, 0x07, 0xF0, 0xFE, 0x00,
  0xFE, 0x3F, 0x80, 0x1F, 0x8F, 0xE0, 0x07, 0xF3, 0xF8, 0x00, 0xFE, 0xFF,
  0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xF7, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFE, 0x00, 0x7F, 0x9F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC,
  0x7F, 0x00, 0x3F, 0x0F, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0,
  0x3F, 0x83, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x3F, 0x80,
  0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03,
  0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F,
  0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x03, 0xF1, 0xFC, 0x0F, 0xE0, 0x0F, 0x8F, 0xF8, 0x7F, 0xC0, 0x3E,
  0x7F, 0xF3, 0xFF, 0x81, 0xFB, 0xFF, 0xDF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0x87, 0xFC, 0x3F, 0xC1, 0xFC,
  0x1F, 0xF0, 0x7F, 0x0F, 0xF0, 0x7F, 0x81, 0xFC, 0x3F, 0x81, 0xFE, 0x07,
  0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0,
  0x7F, 0x03, 0xF8, 0x7F, 0x01, 0xF8, 0x0F, 0xE1, 0xFC, 0x0F, 0xE0, 0x7F,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0xFE, 0x03,
  0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xC0, 0x7F, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0xFC, 0x07, 0xF0, 0x3F, 0x87, 0xF0, 0x1F,
  0x80, 0xFE, 0x1F, 0xC0, 0xFE, 0x03, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xC1,
  0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x3F, 0x80, 0xFC,
  0x07, 0xF0, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xE1, 0xFC, 0x01, 0xF1,
  0xFF, 0x00, 0xF9, 0xFF, 0xC0, 0xFD, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0x7F, 0x0F, 0xF0, 0x3F, 0x87,
  0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0,
  0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFC, 0x1F, 0xC0, 0xFE,
  0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F,
  0xC1, 0xFC, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x01,
  0xFC, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0,
  0x3F, 0x80, 0x00, 0x02, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xF0,
  0x7F, 0x1F, 0xE0, 0xFE, 0x3F, 0x81, 0xFC, 0xFE, 0x03, 0xF9, 0xFC, 0x07,
  0xF3, 0xF8, 0x0F, 0xEF, 0xE0, 0x1F, 0xDF, 0xC0, 0x3F, 0xBF, 0x80, 0x7F,
  0x7F, 0x00, 0xFE, 0xFE, 0x01, 0xFD, 0xFC, 0x07, 0xF7, 0xF0, 0x0F, 0xEF,
  0xE0, 0x1F, 0xCF, 0xC0, 0x7F, 0x1F, 0xC1, 0xFE, 0x3F, 0x87, 0xFC, 0x7F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x7E, 0x3F, 0x80,
  0x07, 0xC7, 0xFC, 0x00, 0x7C, 0xFF, 0xE0, 0x0F, 0xDF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFD, 0xFF, 0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xE0, 0x7F,
  0x01, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0x80, 0x7F, 0x01, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x0F,
  0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07,
  0xF0, 0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0x7F, 0x03,
  0xF8, 0x0F, 0xF8, 0x7F, 0x80, 0xFF, 0xDF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xDF, 0xFC, 0x01, 0xFC, 0xFF, 0x80, 0x1F, 0xC7,
  0xF0, 0x01, 0xFC, 0x08, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x0F, 0xC0, 0x3F, 0xE7, 0xE0, 0x1F, 0xFD, 0xF8, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x83, 0xFE, 0xFF, 0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0x83,
  0xFC, 0x1F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC3, 0xF8, 0x0F, 0xE0, 0xFE,
  0x03, 0xF8, 0x7F, 0x80, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xC1,
  0xFC, 0x03, 0xF0, 0x7F, 0x01, 0xFC, 0x3F, 0xC0, 0x7F, 0x0F, 0xF0, 0x1F,
  0xC3, 0xF8, 0x07, 0xE0, 0xFF, 0x03, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x81, 0xFF, 0x7F, 0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xDF, 0xC0, 0x1F, 0xC7, 0xF0, 0x00, 0xC3, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF1, 0xF8, 0x1F, 0x9F, 0xC0, 0xFD, 0xFC,
  0x0F, 0xFF, 0xE0, 0x7E, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xF8,
  0xF0, 0x7F, 0x80, 0x83, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x01, 0xFC, 0x40, 0x1F, 0xE3, 0x00, 0xFF, 0x1F, 0xBF, 0xF0,
  0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x07, 0xFF,
  0x80, 0x00, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xFE, 0x3F, 0xFF, 0x7F, 0xFF, 0x3F,
  0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE1, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF9, 0x83, 0xFF, 0xC1, 0xFF, 0xE0,
  0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0x40, 0x00, 0x0F, 0xE0, 0x7F,
  0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7E,
  0x1F, 0xC0, 0xFE, 0x1F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE,
  0x3F, 0x80, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x01, 0xFC, 0x7F, 0x01, 0xFC,
  0x7F, 0x01, 0xFC, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0xFE, 0x03, 0xF8,
  0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0,
  0xFE, 0x0F, 0xF0, 0xFE, 0x1F, 0xF0, 0xFF, 0x7F, 0xE0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xF7, 0xE0, 0x7F, 0xE7, 0xE0, 0x3F, 0xC7, 0xC0,
  0x06, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xF7,
  0xF0, 0x1F, 0xCF, 0xE0, 0x3F, 0x9F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F,
  0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0xFC, 0x3F, 0x81, 0xF8, 0x7F, 0x03, 0xF0,
  0xFC, 0x07, 0xE3, 0xF8, 0x0F, 0xC7, 0xE0, 0x1F, 0x9F, 0xC0, 0x3F, 0x3F,
  0x00, 0x7E, 0xFE, 0x00, 0xFD, 0xFC, 0x01, 0xFB, 0xF0, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0x01, 0xFB,
  0xF8, 0x1F, 0xE0, 0x7F, 0x7F, 0x07, 0xFC, 0x0F, 0xEF, 0xE0, 0xFF, 0x83,
  0xF9, 0xFC, 0x1F, 0xF0, 0x7F, 0x3F, 0x87, 0xFE, 0x0F, 0xC7, 0xF0, 0xFF,
  0xC3, 0xF8, 0xFE, 0x3F, 0xF8, 0x7E, 0x1F, 0xC7, 0xDF, 0x1F, 0xC3, 0xF8,
  0xFB, 0xE3, 0xF8, 0x7F, 0x3F, 0x7C, 0x7E, 0x0F, 0xE7, 0xCF, 0x9F, 0xC1,
  0xFD, 0xF9, 0xF3, 0xF0, 0x3F, 0x3E, 0x3E, 0xFE, 0x07, 0xE7, 0xCF, 0xDF,
  0x80, 0xFD, 0xF9, 0xFB, 0xF0, 0x1F, 0xBE, 0x3F, 0xFE, 0x03, 0xF7, 0xC7,
  0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0xF0, 0x0F, 0xFE, 0x1F, 0xFC, 0x01, 0xFF,
  0xC3, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xF0, 0x07, 0xFE, 0x0F, 0xFC, 0x00,
  0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x03, 0xFE, 0x07, 0xFC,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x01, 0xFC,
  0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x80, 0x7F, 0x83, 0xF8, 0x01, 0xFC, 0x3F,
  0xC0, 0x0F, 0xE3, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xF9, 0xFC, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F,
  0xBF, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFC, 0x3F,
  0x80, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0x7F, 0x00,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x01, 0xFC,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x00,
  0xFC, 0x07, 0xF0, 0x03, 0xF0, 0x3F, 0x80, 0x0F, 0xC0, 0xFE, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0xFC, 0x1F, 0xC0, 0x03, 0xF0, 0x7F, 0x00, 0x0F, 0xC3,
  0xF8, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0xFC, 0x7F, 0x00, 0x03, 0xF1, 0xFC,
  0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0xFC, 0xFC, 0x00,
  0x01, 0xF7, 0xF0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x1F, 0x7E, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x11, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x02,
  0x7F, 0xE0, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x07, 0xFC, 0x80, 0x00, 0xE0,
};

const GFXglyph NotoSans_Condensed_BoldItalic53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 16, 39, 14, 0, -38 },
  { 79, 19, 14, 22, 5, -38 },
  { 113, 29, 38, 28, 0, -38 },
  { 251, 26, 43, 24, 0, -40 },
  { 391, 35, 38, 40, 3, -38 },
  { 558, 30, 39, 30, 0, -38 },
  { 705, 9, 14, 13, 5, -38 },
  { 721, 18, 46, 15, 1, -38 },
  { 825, 18, 47, 16, -4, -39 },
  { 931, 22, 23, 24, 4, -41 },
  { 995, 23, 25, 26, 2, -31 },
  { 1067, 12, 14, 13, -3, -7 },
  { 1088, 14, 6, 16, 1, -17 },
  { 1099, 9, 9, 13, 0, -8 },
  { 1110, 28, 38, 21, -3, -38 },
  { 1243, 24, 39, 24, 1, -38 },
  { 1360, 18, 38, 25, 5, -38 },
  { 1446, 27, 38, 24, -2, -38 },
  { 1575, 25, 39, 24, 0, -38 },
  { 1697, 26, 38, 25, -1, -38 },
  { 1821, 25, 39, 24, 0, -38 },
  { 1943, 24, 39, 24, 2, -38 },
  { 2060, 25, 38, 24, 2, -38 },
  { 2179, 25, 39, 24, 0, -38 },
  { 2301, 24, 39, 24, 1, -38 },
  { 2418, 13, 30, 14, 0, -29 },
  { 2467, 16, 36, 14, -3, -29 },
  { 2539, 23, 26, 26, 2, -32 },
  { 2614, 23, 16, 26, 2, -27 },
  { 2660, 23, 26, 26, 2, -32 },
  { 2735, 20, 39, 20, 2, -38 },
  { 2833, 35, 42, 38, 2, -38 },
  { 3017, 27, 38, 27, -3, -38 },
  { 3146, 28, 38, 28, 0, -38 },
  { 3279, 27, 39, 26, 2, -38 },
  { 3411, 29, 38, 30, 0, -38 },
  { 3549, 26, 38, 23, 0, -38 },
  { 3673, 26, 38, 23, 0, -38 },
  { 3797, 29, 39, 30, 2, -38 },
  { 3939, 32, 38, 31, 0, -38 },
  { 4091, 23, 38, 18, -2, -38 },
  { 4201, 24, 49, 14, -8, -38 },
  { 4348, 32, 38, 27, 0, -38 },
  { 4500, 19, 38, 23, 0, -38 },
  { 4591, 41, 38, 40, 0, -38 },
  { 4786, 34, 38, 33, 0, -38 },
  { 4948, 29, 39, 32, 2, -38 },
  { 5090, 28, 38, 27, 0, -38 },
  { 5223, 29, 47, 32, 2, -38 },
  { 5394, 27, 38, 27, 0, -38 },
  { 5523, 26, 39, 24, 0, -38 },
  { 5650, 23, 38, 23, 4, -38 },
  { 5760, 30, 39, 30, 2, -38 },
  { 5907, 26, 38, 27, 5, -38 },
  { 6031, 41, 38, 40, 4, -38 },
  { 6226, 33, 38, 26, -3, -38 },
  { 6383, 25, 38, 25, 5, -38 },
  { 6502, 28, 38, 23, -2, -38 },
  { 6635, 22, 46, 16, -2, -38 },
  { 6762, 12, 38, 21, 5, -38 },
  { 6819, 22, 46, 16, -4, -38 },
  { 6946, 24, 23, 25, 0, -38 },
  { 7015, 19, 3, 18, -5, 5 },
  { 7023, 10, 9, 16, 8, -41 },
  { 7035, 26, 30, 27, 1, -29 },
  { 7133, 25, 41, 27, 0, -40 },
  { 7262, 22, 30, 21, 1, -29 },
  { 7345, 28, 41, 27, 1, -40 },
  { 7489, 23, 30, 25, 1, -29 },
  { 7576, 28, 54, 16, -6, -41 },
  { 7765, 28, 42, 27, -1, -29 },
  { 7912, 25, 40, 27, 0, -40 },
  { 8037, 15, 40, 13, 0, -40 },
  { 8112, 22, 53, 13, -7, -40 },
  { 8258, 27, 40, 25, 0, -40 },
  { 8393, 16, 40, 13, 0, -40 },
  { 8473, 38, 29, 39, 0, -29 },
  { 8611, 25, 29, 27, 0, -29 },
  { 8702, 23, 31, 26, 1, -30 },
  { 8792, 28, 42, 27, -3, -29 },
  { 8939, 26, 42, 27, 1, -29 },
  { 9076, 21, 29, 19, 0, -29 },
  { 9153, 21, 30, 21, 0, -29 },
  { 9232, 17, 36, 17, 2, -35 },
  { 9309, 24, 30, 26, 2, -29 },
  { 9399, 23, 29, 23, 3, -29 },
  { 9483, 35, 29, 35, 3, -29 },
  { 9610, 29, 29, 23, -3, -29 },
  { 9716, 30, 42, 23, -4, -29 },
  { 9874, 23, 29, 20, -2, -29 },
  { 9958, 22, 46, 18, 0, -38 },
  { 10085, 6, 52, 23, 8, -40 },
  { 10124, 21, 46, 18, -3, -38 },
  { 10245, 23, 9, 26, 2, -23 },
};

const GFXfont NotoSans_Condensed_BoldItalic53pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BoldItalic53pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BoldItalic53pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _NOTOSANS_CONDENSED_BOLDITALIC53PT7B_H_
