#ifndef _NOTOSANS_CONDENSED_BOLDITALIC33PT7B_H_
#define _NOTOSANS_CONDENSED_BOLDITALIC33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BoldItalic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BoldItalic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x1F,
  0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x0F, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x78, 0x3E, 0x0F, 0x83, 0xC0, 0x7C, 0xF7, 0x9F, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x1C, 0x71, 0xCF, 0x1C, 0xF3, 0xC0, 0x00, 0xE3, 0x80,
  0x38, 0xE0, 0x0E, 0x78, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x3C,
  0xE0, 0x7F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xF0, 0x71, 0xC0, 0x1C, 0x70,
  0x07, 0x3C, 0x03, 0x8E, 0x07, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x07,
  0x1C, 0x01, 0xC7, 0x00, 0xF3, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x9E,
  0x01, 0xC7, 0x00, 0x00, 0x30, 0x00, 0x30, 0x00, 0x78, 0x03, 0xFE, 0x07,
  0xFF, 0x0F, 0xFE, 0x1F, 0x6C, 0x1E, 0x44, 0x1E, 0x40, 0x1F, 0xC0, 0x1F,
  0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x01,
  0xFC, 0x01, 0x3C, 0x43, 0x7C, 0x73, 0x7C, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F,
  0xE0, 0x0F, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0F, 0x00, 0xE0,
  0x7E, 0x07, 0x83, 0xF8, 0x1C, 0x1E, 0xF0, 0xF0, 0x73, 0xC3, 0x81, 0xCF,
  0x1C, 0x0F, 0x3C, 0xF0, 0x38, 0xF3, 0x80, 0xE3, 0x9E, 0x03, 0x8E, 0x70,
  0x0E, 0x7B, 0x9F, 0xB9, 0xDE, 0xFE, 0xFF, 0x73, 0xFD, 0xFB, 0xDC, 0xF3,
  0x8E, 0x73, 0xC0, 0x73, 0xCF, 0x03, 0xCE, 0x3C, 0x0E, 0x38, 0xE0, 0x78,
  0xE3, 0x81, 0xC3, 0x9E, 0x0E, 0x0E, 0x70, 0x78, 0x3F, 0xC1, 0xC0, 0xFE,
  0x0F, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xEF,
  0x00, 0x78, 0xF0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0xBC,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x10, 0xFE, 0x3C, 0x7F, 0xE7,
  0x8F, 0x7D, 0xF3, 0xE7, 0xBC, 0x78, 0xFF, 0x9F, 0x0F, 0xE3, 0xE1, 0xF8,
  0x7C, 0x3F, 0x0F, 0xDF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC1, 0xFC, 0x7C,
  0x7D, 0xF7, 0x9E, 0x79, 0xC7, 0x3C, 0xF0, 0x01, 0xE0, 0x78, 0x0F, 0x03,
  0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x81, 0xF0, 0x3C, 0x07,
  0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x03,
  0xC0, 0x78, 0x0F, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x1E, 0x03, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x81, 0xE0,
  0x3C, 0x0F, 0x00, 0x07, 0x80, 0x3C, 0x11, 0xE0, 0xCF, 0x0F, 0xF1, 0xFF,
  0xFD, 0xFF, 0xE1, 0xFF, 0x1F, 0x81, 0xFC, 0x3E, 0xF0, 0xF3, 0xC3, 0x1E,
  0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x1F, 0x1E, 0x3E, 0x3C,
  0x3C, 0x78, 0x78, 0xF0, 0x7F, 0xBF, 0xDF, 0xFF, 0xF0, 0x7B, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x1F, 0xE0, 0xFF,
  0xC3, 0xFF, 0x1F, 0x3C, 0xF8, 0xF3, 0xC3, 0xCF, 0x0F, 0x7C, 0x3D, 0xE0,
  0xF7, 0x83, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x07, 0xBC, 0x3E, 0xF0,
  0xFB, 0xC3, 0xCF, 0x1F, 0x3C, 0x78, 0xFF, 0xE3, 0xFF, 0x07, 0xF8, 0x0F,
  0xC0, 0x00, 0xE0, 0x7C, 0x1F, 0x87, 0xF1, 0xFE, 0xFF, 0xBF, 0xF3, 0x9E,
  0x67, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x00, 0xF8,
  0x03, 0xFE, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0x1F, 0x06, 0x0F, 0x04, 0x0F,
  0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3C, 0x00, 0x7F, 0xFC, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x01, 0xF0,
  0x07, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x06, 0x3F, 0x08, 0x1F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x07, 0xF8, 0x07, 0xE0, 0x0F, 0xF0,
  0x0F, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78,
  0x80, 0xF8, 0xF7, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC,
  0x03, 0xBC, 0x07, 0xBC, 0x07, 0x7C, 0x0E, 0x78, 0x1E, 0x78, 0x1C, 0x78,
  0x38, 0x78, 0x78, 0xF8, 0xF0, 0xF2, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC,
  0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xFF,
  0x07, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8,
  0x80, 0xF8, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0x80, 0x00, 0x7E,
  0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F,
  0x00, 0x3C, 0x00, 0xFB, 0xE1, 0xEF, 0xE3, 0xFF, 0xC7, 0xEF, 0x9F, 0x0F,
  0x3E, 0x1E, 0x7C, 0x3C, 0xF0, 0x79, 0xE1, 0xF3, 0xC3, 0xE7, 0xC7, 0x8F,
  0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0x1F, 0xC0, 0x1F, 0xFF, 0x1F, 0xFF, 0x3F,
  0xFF, 0x3F, 0xFE, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07,
  0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x03, 0xFC, 0x07,
  0xFE, 0x0F, 0xFF, 0x0F, 0x1F, 0x1F, 0x1F, 0x1E, 0x1F, 0x1F, 0x1E, 0x1F,
  0x3E, 0x0F, 0xFC, 0x0F, 0xF8, 0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3E,
  0xF8, 0x7C, 0x7C, 0x78, 0x3C, 0xF8, 0x3C, 0xF8, 0x7C, 0xF8, 0x7C, 0xFC,
  0xF8, 0x7F, 0xF8, 0x7F, 0xF0, 0x1F, 0xC0, 0x01, 0xF0, 0x0F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xF1, 0xF3, 0xE3, 0xC3, 0xCF, 0x87, 0x9F, 0x0F, 0x3C, 0x1E,
  0x78, 0x7C, 0xF0, 0xF9, 0xF3, 0xF3, 0xFF, 0xE7, 0xFF, 0x87, 0xEF, 0x03,
  0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x8E, 0x7E, 0x1F, 0xF8,
  0x3F, 0xE0, 0x7F, 0x80, 0x0F, 0x1F, 0x1F, 0x1F, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x78, 0xF8, 0xF8, 0xF0, 0x03, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x78, 0x3E, 0x0F, 0x03, 0xC1, 0xE0, 0x78,
  0x3C, 0x00, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xF8, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xC0, 0x07, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7E, 0x03, 0xFC, 0x1F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x1F, 0x80, 0x3C, 0x00, 0x60, 0x00, 0x07, 0xC0, 0xFF,
  0x0F, 0xFC, 0x7F, 0xE3, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x0E, 0x00,
  0x00, 0x1F, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xF8, 0x3E, 0x07,
  0x80, 0x38, 0x3C, 0x00, 0x71, 0xE0, 0xC1, 0xC7, 0x0F, 0xE7, 0x38, 0xFF,
  0x9C, 0xE3, 0x9E, 0x77, 0x1C, 0x71, 0xDC, 0xF1, 0xC7, 0x73, 0x87, 0x1F,
  0x8E, 0x3C, 0x7E, 0x38, 0xE3, 0xB8, 0xE3, 0x8E, 0xE7, 0x9E, 0x73, 0x8E,
  0xFB, 0xCE, 0x3F, 0x7E, 0x38, 0x79, 0xF0, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x01, 0x80, 0x3F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0,
  0x07, 0x70, 0x07, 0xB8, 0x03, 0xDC, 0x03, 0xCE, 0x01, 0xE7, 0x00, 0xF3,
  0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x3F, 0xFE, 0x1F,
  0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xCF, 0x81, 0xE7, 0xC0, 0xF3, 0xC0, 0x7B,
  0xE0, 0x3D, 0xE0, 0x1F, 0xF0, 0x0F, 0x07, 0xF0, 0x03, 0xFF, 0x01, 0xFF,
  0xC0, 0xFF, 0xF0, 0xF8, 0xF8, 0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x1F, 0x1F,
  0x0F, 0x8F, 0x8F, 0x87, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xF0,
  0xF8, 0x78, 0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x0F, 0x1F, 0x0F, 0x8F, 0x87,
  0xC7, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0x80, 0x00, 0x7E, 0x00,
  0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFC, 0x30, 0xFC, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x0F, 0x81, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xE0,
  0x07, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x0F, 0x9F, 0x83,
  0xE1, 0xF0, 0xF0, 0x7C, 0x3C, 0x1F, 0x1F, 0x07, 0xC7, 0xC1, 0xF1, 0xF0,
  0x7C, 0x78, 0x1F, 0x1E, 0x07, 0xCF, 0x81, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E,
  0x3C, 0x1F, 0x8F, 0x07, 0xC7, 0xC3, 0xE1, 0xF1, 0xF8, 0x7F, 0xFC, 0x1F,
  0xFE, 0x07, 0xFF, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF,
  0x07, 0xFE, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x3E, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7F, 0xF0,
  0x7F, 0xF0, 0x7F, 0xE0, 0xFF, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF,
  0x07, 0xFE, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xE0, 0xFC, 0x18, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x3F, 0xC7, 0xC7,
  0xF8, 0xF0, 0xFE, 0x3E, 0x1F, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03,
  0xE1, 0xF0, 0x78, 0x3E, 0x0F, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF,
  0x80, 0x7F, 0xC0, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xF0, 0x78,
  0x1E, 0x0F, 0x81, 0xE0, 0xF8, 0x3E, 0x0F, 0x03, 0xE0, 0xF0, 0x3E, 0x1F,
  0x03, 0xC1, 0xF0, 0x3C, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0x83,
  0xFF, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x0F, 0x83, 0xC0, 0xF0,
  0x7C, 0x0F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xF0, 0x78, 0x1E,
  0x0F, 0x83, 0xE0, 0x07, 0xFC, 0x3F, 0xF0, 0xFF, 0xC0, 0xFC, 0x03, 0xE0,
  0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x07, 0xC0, 0x1E, 0x01, 0xFF, 0x0F, 0xFC, 0x3F, 0xE0, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x07,
  0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0x00, 0x07, 0xC1, 0xF0, 0x78,
  0x3E, 0x07, 0x87, 0xC0, 0x78, 0x7C, 0x0F, 0x8F, 0x80, 0xF1, 0xF0, 0x0F,
  0x3E, 0x00, 0xF3, 0xE0, 0x1F, 0x7C, 0x01, 0xFF, 0x80, 0x1E, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xCF, 0x80,
  0x3C, 0xF8, 0x03, 0xC7, 0x80, 0x7C, 0x78, 0x07, 0xC7, 0xC0, 0x78, 0x7C,
  0x07, 0x83, 0xC0, 0x78, 0x3E, 0x0F, 0x83, 0xE0, 0x07, 0xC0, 0x78, 0x07,
  0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C,
  0x07, 0xC0, 0x7F, 0xF7, 0xFF, 0x7F, 0xEF, 0xFE, 0x07, 0xE0, 0x1F, 0xC1,
  0xF8, 0x07, 0xE0, 0x7E, 0x03, 0xF8, 0x1F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F,
  0x83, 0xF8, 0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xFC, 0x1E, 0xE0,
  0xEF, 0x07, 0xB8, 0x7F, 0xC1, 0xEE, 0x1F, 0xE0, 0x7B, 0x8F, 0x78, 0x1E,
  0xE3, 0xDE, 0x0F, 0xBD, 0xE7, 0x83, 0xCF, 0x7B, 0xE0, 0xF3, 0xDC, 0xF0,
  0x3C, 0xFF, 0x3C, 0x0F, 0x3F, 0x8F, 0x07, 0x8F, 0xE3, 0xC1, 0xE3, 0xF1,
  0xF0, 0x78, 0xFC, 0x78, 0x1E, 0x3E, 0x1E, 0x07, 0x8F, 0x87, 0x83, 0xC3,
  0xC3, 0xE0, 0x07, 0xC0, 0x78, 0x3E, 0x03, 0xC1, 0xF8, 0x1E, 0x0F, 0xC1,
  0xF0, 0xFE, 0x0F, 0x07, 0xF0, 0x78, 0x3F, 0xC3, 0xC1, 0xFE, 0x1E, 0x1E,
  0xF1, 0xF0, 0xF7, 0x8F, 0x07, 0xBC, 0x78, 0x3C, 0xF3, 0xC1, 0xE7, 0x9E,
  0x1E, 0x3D, 0xE0, 0xF1, 0xEF, 0x07, 0x8F, 0xF8, 0x3C, 0x3F, 0xC1, 0xE1,
  0xFE, 0x1E, 0x0F, 0xE0, 0xF0, 0x7F, 0x07, 0x81, 0xF8, 0x3C, 0x0F, 0xC1,
  0xE0, 0x7E, 0x1E, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x7F, 0xF8,
  0x1F, 0xFE, 0x0F, 0xCF, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0xF8, 0x0F, 0x3E,
  0x03, 0xDF, 0x00, 0xF7, 0xC0, 0x7D, 0xF0, 0x1F, 0x7C, 0x07, 0xDE, 0x01,
  0xFF, 0x80, 0x7B, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x07, 0xC7, 0x81, 0xF1,
  0xF0, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0x80, 0x07,
  0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x0F, 0x8F, 0x83, 0xE1,
  0xF0, 0xF0, 0x7C, 0x3C, 0x1F, 0x1F, 0x07, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x78, 0xFC, 0x1F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x3F, 0xF8,
  0x1F, 0xFE, 0x0F, 0xCF, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0xF8, 0x0F, 0x3E,
  0x03, 0xDF, 0x00, 0xF7, 0xC0, 0x7D, 0xF0, 0x1F, 0x7C, 0x07, 0xDE, 0x01,
  0xFF, 0x80, 0x7B, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x07, 0xC7, 0x81, 0xF1,
  0xF0, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0xF9, 0xF8,
  0x7C, 0x7C, 0x3C, 0x3E, 0x1E, 0x1F, 0x1F, 0x0F, 0x8F, 0x8F, 0x87, 0x87,
  0xC3, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xC0, 0x79, 0xF0, 0x3C,
  0xF8, 0x1E, 0x3C, 0x1F, 0x1E, 0x0F, 0x8F, 0x87, 0x87, 0xC3, 0xC1, 0xE1,
  0xE0, 0xF9, 0xF0, 0x7C, 0x00, 0xF8, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFE,
  0x1F, 0x8E, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x80, 0xF8, 0xC1, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0,
  0xFF, 0xC0, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFE, 0x0F,
  0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x0F, 0x83,
  0xE1, 0xE0, 0x78, 0x3C, 0x0F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F,
  0x87, 0x81, 0xE0, 0xF0, 0x3C, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x3E,
  0x1E, 0x07, 0x87, 0xC0, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xC0, 0xF0,
  0x78, 0x1E, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x3E, 0x07, 0xFF, 0xC0,
  0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1E, 0xF0, 0x3E, 0xF0, 0x3C, 0xF0, 0x7C, 0xF0, 0x78, 0xF0,
  0xF8, 0xF0, 0xF0, 0xF1, 0xF0, 0xF1, 0xE0, 0xF1, 0xE0, 0xF3, 0xE0, 0xF3,
  0xC0, 0x77, 0xC0, 0x77, 0x80, 0x77, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF0, 0x1C, 0x0F, 0xF8, 0x1E,
  0x07, 0xFC, 0x0F, 0x03, 0xDE, 0x0F, 0x83, 0xEF, 0x07, 0xC1, 0xE7, 0x87,
  0xE0, 0xF3, 0xC3, 0xF0, 0xF9, 0xE1, 0xF8, 0x78, 0xF1, 0xFC, 0x7C, 0x78,
  0xEE, 0x3C, 0x3C, 0xF7, 0x1E, 0x1E, 0x7B, 0x9E, 0x0F, 0x39, 0xCF, 0x07,
  0xBC, 0xEF, 0x83, 0xDC, 0x77, 0x81, 0xFE, 0x3B, 0xC0, 0xFF, 0x1F, 0xC0,
  0x7F, 0x1F, 0xE0, 0x3F, 0x8F, 0xF0, 0x1F, 0x87, 0xF0, 0x0F, 0xC3, 0xF8,
  0x07, 0xE1, 0xF8, 0x03, 0xE0, 0xFC, 0x01, 0xF0, 0x7E, 0x00, 0x07, 0xC0,
  0xF8, 0x1E, 0x0F, 0x80, 0xF0, 0x78, 0x07, 0xC7, 0xC0, 0x3E, 0x7C, 0x00,
  0xF3, 0xC0, 0x07, 0xBE, 0x00, 0x3D, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x7D, 0xF0, 0x03, 0xCF, 0x80,
  0x3E, 0x3C, 0x03, 0xE1, 0xE0, 0x1E, 0x0F, 0x81, 0xF0, 0x7C, 0x1F, 0x03,
  0xE0, 0xF0, 0x1F, 0xF0, 0x7F, 0xE0, 0xF7, 0xC3, 0xE7, 0x8F, 0x8F, 0x1E,
  0x1E, 0x7C, 0x3C, 0xF0, 0x7B, 0xE0, 0xFF, 0x80, 0xFE, 0x01, 0xFC, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x07, 0xFF,
  0x83, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x07, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF,
  0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0,
  0x00, 0xF0, 0x70, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x38, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x0F, 0x03, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x00, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x7F,
  0x01, 0xEE, 0x03, 0x9C, 0x0F, 0x3C, 0x3C, 0x78, 0x78, 0x71, 0xE0, 0xE3,
  0x81, 0xEF, 0x03, 0xFC, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xF9, 0xE7, 0x8F,
  0x1C, 0x07, 0xCF, 0x0F, 0xFE, 0x1F, 0xFE, 0x3F, 0x7E, 0x3E, 0x3E, 0x7C,
  0x3C, 0x7C, 0x3C, 0x78, 0x3C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x78, 0xF0,
  0x78, 0xF0, 0xF8, 0xF8, 0xF8, 0xFB, 0xF0, 0xFF, 0xF0, 0x7E, 0xF0, 0x3C,
  0xF0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x00, 0x0F, 0x7C, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xBF, 0x1F,
  0x1F, 0x1E, 0x1F, 0x3E, 0x1F, 0x3C, 0x1F, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C,
  0x3E, 0x7C, 0x3E, 0x7C, 0x3C, 0x7C, 0x7C, 0x7E, 0xF8, 0x7F, 0xF8, 0xF7,
  0xF0, 0xF7, 0xE0, 0x07, 0xF8, 0x7F, 0xC7, 0xFC, 0x7E, 0xE3, 0xE0, 0x3E,
  0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00,
  0x7C, 0x23, 0xF7, 0x0F, 0xF8, 0x7F, 0xC1, 0xFC, 0x00, 0x00, 0x07, 0x80,
  0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x0F, 0xBC, 0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0x9F, 0x87, 0x87, 0xC7, 0xC3,
  0xC3, 0xC1, 0xE1, 0xE0, 0xF1, 0xF0, 0x78, 0xF8, 0x7C, 0x78, 0x3C, 0x3C,
  0x1E, 0x1E, 0x1F, 0x0F, 0x0F, 0x87, 0xCF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0,
  0x3E, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0xE1, 0xFF, 0xCF, 0x8F, 0x3C, 0x3D,
  0xF0, 0xF7, 0x87, 0x9F, 0xFE, 0xFF, 0xF3, 0xFF, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x86, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0x00, 0x00,
  0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xE0,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE7, 0x83, 0xFF, 0x83, 0xFF, 0xC3, 0xF7, 0xE1, 0xF1,
  0xF1, 0xF0, 0xF0, 0xF8, 0x78, 0x78, 0x3C, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F,
  0x0F, 0x0F, 0x07, 0x87, 0x87, 0xC3, 0xE7, 0xE1, 0xFF, 0xF0, 0xFF, 0xF0,
  0x3F, 0x78, 0x1F, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x04, 0x0F,
  0x83, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0x80, 0x00, 0x07, 0xC0,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x7C, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFF, 0x1F, 0x1F, 0x1E, 0x1E,
  0x3E, 0x1E, 0x3E, 0x1E, 0x3C, 0x3E, 0x3C, 0x3E, 0x3C, 0x3C, 0x7C, 0x3C,
  0x7C, 0x3C, 0x78, 0x7C, 0x78, 0x7C, 0x78, 0x78, 0xF8, 0x78, 0xF0, 0x78,
  0x03, 0x81, 0xF0, 0x78, 0x1E, 0x03, 0x00, 0x00, 0x00, 0x3C, 0x1F, 0x07,
  0xC1, 0xF0, 0x78, 0x1E, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x07, 0xC1,
  0xF0, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0xF8, 0x00, 0x00, 0x38, 0x01, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x1F, 0x0F,
  0x1F, 0x0F, 0x9F, 0x07, 0x8F, 0x03, 0xCF, 0x01, 0xEF, 0x81, 0xFF, 0x80,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0x7C, 0x0F, 0x1E,
  0x07, 0x8F, 0x03, 0xC7, 0xC1, 0xE3, 0xE1, 0xF0, 0xF0, 0xF0, 0x7C, 0x00,
  0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x1F, 0x07,
  0xC1, 0xF0, 0x78, 0x1E, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x07, 0xC1,
  0xF0, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0xF8, 0x00, 0x0E, 0x7C, 0x7C, 0x3D,
  0xFD, 0xFC, 0x7F, 0xFF, 0xF8, 0xFD, 0xFD, 0xF1, 0xF1, 0xF1, 0xE3, 0xC3,
  0xC3, 0xCF, 0x87, 0x87, 0x9F, 0x1F, 0x0F, 0x3C, 0x3E, 0x3E, 0x78, 0x78,
  0x7C, 0xF0, 0xF0, 0xF3, 0xE1, 0xE1, 0xE7, 0x87, 0xC3, 0xCF, 0x0F, 0x0F,
  0x9E, 0x1E, 0x1E, 0x3C, 0x3C, 0x3C, 0xF8, 0x78, 0x79, 0xE1, 0xF1, 0xF0,
  0x0E, 0x7C, 0x0E, 0xFE, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0x1F, 0x1E, 0x1E,
  0x3E, 0x1E, 0x3E, 0x1E, 0x3C, 0x1E, 0x3C, 0x3E, 0x3C, 0x3C, 0x7C, 0x3C,
  0x7C, 0x3C, 0x78, 0x7C, 0x78, 0x7C, 0x78, 0x78, 0xF8, 0x78, 0xF0, 0x78,
  0x07, 0xF0, 0x3F, 0xE1, 0xFF, 0x8F, 0xFF, 0x3C, 0x3D, 0xF0, 0xF7, 0x83,
  0xFE, 0x0F, 0xF8, 0x3F, 0xC1, 0xFF, 0x07, 0xFC, 0x1E, 0xF0, 0xFB, 0xC3,
  0xEF, 0xFF, 0x1F, 0xF8, 0x7F, 0xC0, 0x7E, 0x00, 0x03, 0x9F, 0x00, 0xEF,
  0xE0, 0x7F, 0xF8, 0x1F, 0xBF, 0x07, 0xC7, 0xC1, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3C, 0x1F, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x07, 0xC7, 0xC1, 0xFB, 0xE0, 0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0x3E,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xCF, 0x0F, 0xFE, 0x1F,
  0xFE, 0x3E, 0x7E, 0x3C, 0x3E, 0x7C, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0xF8,
  0x3C, 0xF8, 0x7C, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0xF8, 0xF0, 0xF8, 0xF9,
  0xF0, 0xFF, 0xF0, 0x7E, 0xF0, 0x7C, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x0E,
  0x78, 0xF7, 0xC7, 0xFC, 0x3F, 0xE1, 0xF9, 0x0F, 0x80, 0xF8, 0x07, 0xC0,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0xF0, 0xFF, 0xC7, 0xFC, 0x7C, 0x63,
  0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07,
  0xC0, 0x1E, 0x41, 0xF3, 0x9F, 0x9F, 0xF8, 0xFF, 0xC7, 0xF8, 0x00, 0x07,
  0x00, 0xE0, 0x3C, 0x07, 0x81, 0xFE, 0xFF, 0x9F, 0xF1, 0xF0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03,
  0xE4, 0x7F, 0x87, 0xF0, 0xFE, 0x00, 0x1E, 0x1E, 0x7C, 0x3C, 0xF0, 0x79,
  0xE1, 0xF3, 0xC3, 0xC7, 0x87, 0x9F, 0x0F, 0x3C, 0x1E, 0x78, 0x7C, 0xF0,
  0xF1, 0xE1, 0xE7, 0xC3, 0xCF, 0x0F, 0x9E, 0x1F, 0x3E, 0x7C, 0x7F, 0xF8,
  0x7F, 0xF0, 0xF9, 0xE0, 0xF0, 0x7F, 0xC1, 0xEF, 0x0F, 0xBC, 0x3C, 0xF0,
  0xF3, 0xC7, 0x8F, 0x1E, 0x3C, 0xF8, 0xF3, 0xC3, 0xDF, 0x0F, 0x78, 0x1D,
  0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x00,
  0xF0, 0xF8, 0x7F, 0xC3, 0xE1, 0xEF, 0x1F, 0x8F, 0xBC, 0x7E, 0x3C, 0xF1,
  0xF8, 0xF3, 0xCF, 0xE7, 0x8F, 0x3B, 0x9E, 0x3D, 0xEE, 0xF8, 0xF7, 0x3B,
  0xC3, 0xDC, 0xEF, 0x0F, 0xF7, 0xF8, 0x3F, 0x9F, 0xE0, 0xFE, 0x7F, 0x03,
  0xF1, 0xFC, 0x0F, 0xC7, 0xF0, 0x3F, 0x1F, 0x80, 0xF8, 0x7E, 0x03, 0xE1,
  0xF0, 0x00, 0x0F, 0x87, 0xC1, 0xE3, 0xE0, 0x78, 0xF0, 0x1F, 0x7C, 0x03,
  0xDE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xDE, 0x01, 0xE7, 0xC0,
  0xF9, 0xF0, 0x7C, 0x3C, 0x3E, 0x0F, 0x80, 0x0F, 0x07, 0xC3, 0xC1, 0xF0,
  0xF0, 0x78, 0x3C, 0x3E, 0x0F, 0x0F, 0x03, 0xC7, 0xC0, 0xF1, 0xE0, 0x1C,
  0xF8, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0x7F, 0x80, 0x1D, 0xE0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFC, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC4,
  0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0xFF, 0x3F, 0xF8, 0xFF, 0xE3,
  0xFF, 0x80, 0x00, 0x04, 0x03, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xE0, 0x0F,
  0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x1F,
  0x01, 0xF8, 0x07, 0x80, 0x3F, 0x00, 0xFE, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xFC, 0x03,
  0xF0, 0x07, 0xC0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x02, 0x00, 0x3E,
  0x01, 0xF8, 0x0F, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xFC, 0x03, 0xE0, 0x3F, 0x07,
  0xF0, 0x3E, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0,
  0x1E, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0x80, 0x00, 0x7F, 0x03, 0xFF,
  0xDF, 0xFF, 0xFF, 0x1F, 0xF8, 0x0F, 0x80,
};

const GFXglyph NotoSans_Condensed_BoldItalic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 10, 24, 9, 0, -24 },
  { 31, 12, 9, 14, 3, -24 },
  { 45, 18, 24, 17, 0, -24 },
  { 99, 16, 27, 15, 0, -25 },
  { 153, 22, 24, 25, 2, -24 },
  { 219, 19, 24, 19, 0, -24 },
  { 276, 6, 9, 8, 3, -24 },
  { 283, 11, 29, 10, 1, -24 },
  { 323, 11, 29, 10, -2, -24 },
  { 363, 13, 14, 15, 3, -25 },
  { 386, 15, 16, 16, 1, -20 },
  { 416, 8, 8, 8, -2, -4 },
  { 424, 9, 4, 10, 0, -11 },
  { 429, 5, 5, 8, 0, -5 },
  { 433, 18, 24, 13, -2, -24 },
  { 487, 14, 24, 15, 1, -24 },
  { 529, 11, 24, 15, 3, -24 },
  { 562, 16, 24, 15, -1, -24 },
  { 610, 16, 24, 15, 0, -24 },
  { 658, 16, 24, 15, 0, -24 },
  { 706, 16, 24, 15, 0, -24 },
  { 754, 15, 24, 15, 1, -24 },
  { 799, 16, 24, 15, 1, -24 },
  { 847, 16, 24, 15, 0, -24 },
  { 895, 15, 24, 15, 0, -24 },
  { 940, 8, 18, 8, 0, -18 },
  { 958, 10, 22, 8, -2, -18 },
  { 986, 15, 16, 16, 1, -20 },
  { 1016, 15, 10, 16, 1, -17 },
  { 1035, 15, 16, 16, 1, -20 },
  { 1065, 13, 24, 12, 1, -24 },
  { 1104, 22, 27, 23, 1, -24 },
  { 1179, 17, 24, 17, -2, -24 },
  { 1230, 17, 24, 17, 0, -24 },
  { 1281, 17, 24, 16, 1, -24 },
  { 1332, 18, 24, 19, 0, -24 },
  { 1386, 16, 24, 15, 0, -24 },
  { 1434, 16, 24, 14, 0, -24 },
  { 1482, 19, 24, 19, 1, -24 },
  { 1539, 20, 24, 19, 0, -24 },
  { 1599, 14, 24, 11, -1, -24 },
  { 1641, 15, 31, 9, -5, -24 },
  { 1700, 20, 24, 17, 0, -24 },
  { 1760, 12, 24, 14, 0, -24 },
  { 1796, 26, 24, 25, 0, -24 },
  { 1874, 21, 24, 20, 0, -24 },
  { 1937, 18, 24, 20, 1, -24 },
  { 1991, 18, 24, 17, 0, -24 },
  { 2045, 18, 30, 20, 1, -24 },
  { 2113, 17, 24, 17, 0, -24 },
  { 2164, 16, 24, 15, 0, -24 },
  { 2212, 14, 24, 14, 3, -24 },
  { 2254, 19, 24, 19, 1, -24 },
  { 2311, 16, 24, 17, 3, -24 },
  { 2359, 25, 24, 25, 3, -24 },
  { 2434, 21, 24, 16, -2, -24 },
  { 2497, 15, 24, 15, 3, -24 },
  { 2542, 17, 24, 14, -1, -24 },
  { 2593, 13, 29, 10, -1, -24 },
  { 2641, 8, 24, 13, 3, -24 },
  { 2665, 13, 29, 10, -2, -24 },
  { 2713, 15, 15, 15, 0, -24 },
  { 2742, 12, 2, 11, -3, 3 },
  { 2745, 6, 5, 10, 5, -25 },
  { 2749, 16, 18, 17, 1, -18 },
  { 2785, 16, 25, 17, 0, -25 },
  { 2835, 13, 18, 13, 1, -18 },
  { 2865, 17, 25, 17, 1, -25 },
  { 2919, 14, 18, 15, 1, -18 },
  { 2951, 18, 33, 10, -4, -25 },
  { 3026, 17, 26, 17, 0, -18 },
  { 3082, 16, 25, 17, 0, -25 },
  { 3132, 10, 25, 8, 0, -25 },
  { 3164, 14, 33, 8, -4, -25 },
  { 3222, 17, 25, 15, 0, -25 },
  { 3276, 10, 25, 8, 0, -25 },
  { 3308, 23, 18, 24, 0, -18 },
  { 3360, 16, 18, 17, 0, -18 },
  { 3396, 14, 18, 16, 1, -18 },
  { 3428, 18, 26, 17, -2, -18 },
  { 3487, 16, 26, 17, 1, -18 },
  { 3539, 13, 18, 12, 0, -18 },
  { 3569, 13, 18, 13, 0, -18 },
  { 3599, 11, 22, 11, 1, -22 },
  { 3630, 15, 18, 16, 1, -18 },
  { 3664, 14, 18, 14, 2, -18 },
  { 3696, 22, 18, 22, 2, -18 },
  { 3746, 18, 18, 15, -2, -18 },
  { 3787, 18, 26, 14, -2, -18 },
  { 3846, 14, 18, 12, -1, -18 },
  { 3878, 14, 29, 11, 0, -24 },
  { 3929, 4, 32, 14, 5, -25 },
  { 3945, 13, 29, 11, -2, -24 },
  { 3993, 15, 5, 16, 1, -14 },
};

const GFXfont NotoSans_Condensed_BoldItalic33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BoldItalic33pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BoldItalic33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_CONDENSED_BOLDITALIC33PT7B_H_
