#ifndef _NOTOSANS_CONDENSED_BOLDITALIC70PT7B_H_
#define _NOTOSANS_CONDENSED_BOLDITALIC70PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BoldItalic.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BoldItalic70pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0xC0,
  0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00,
  0x07, 0x80, 0x00, 0x3F, 0xF1, 0xFF, 0x9F, 0xF0, 0xFF, 0x8F, 0xF8, 0x7F,
  0xC7, 0xFC, 0x3F, 0xE3, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF1, 0xFF, 0x0F,
  0xF8, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0,
  0xFF, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x87, 0xF8, 0x3F, 0xC3, 0xFC,
  0x1F, 0xE1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x7E,
  0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00,
  0x3F, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x40, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00,
  0x07, 0xE0, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00,
  0x03, 0xF8, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x81, 0xF8, 0x00,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x01, 0xF8,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x00, 0x1F, 0x81, 0xFC, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x3F, 0x00,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x00, 0x7F,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFD,
  0xEF, 0xE0, 0x0F, 0xFC, 0xE1, 0xE0, 0x07, 0xFC, 0x70, 0x30, 0x03, 0xFC,
  0x38, 0x00, 0x01, 0xFE, 0x3C, 0x00, 0x00, 0xFF, 0x1C, 0x00, 0x00, 0x7F,
  0xCE, 0x00, 0x00, 0x3F, 0xE7, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xDF, 0xFC,
  0x00, 0x00, 0xE7, 0xFE, 0x00, 0x00, 0x73, 0xFF, 0x00, 0x00, 0x79, 0xFF,
  0x80, 0x00, 0x3C, 0xFF, 0xC1, 0x00, 0x1C, 0x7F, 0xE0, 0xC0, 0x0E, 0x3F,
  0xE0, 0xF8, 0x0F, 0x3F, 0xF0, 0x7F, 0x87, 0xBF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x07,
  0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xC0, 0x07, 0xF8, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC3,
  0xF8, 0x03, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x3F,
  0x80, 0x7F, 0x00, 0x1F, 0xE0, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8,
  0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x83,
  0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x7F,
  0x00, 0x03, 0xF8, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0,
  0x00, 0x3F, 0x83, 0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xE1, 0xFC, 0x07,
  0x83, 0xF8, 0x3F, 0x8F, 0xE0, 0xFF, 0x8F, 0xE1, 0xFC, 0x3F, 0x8F, 0xFF,
  0x3F, 0x87, 0xF1, 0xFC, 0x7F, 0xFE, 0xFE, 0x3F, 0xCF, 0xE3, 0xFF, 0xFB,
  0xFF, 0xFE, 0x3F, 0x8F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFC, 0x7F, 0xFF, 0xDF,
  0xFF, 0xCF, 0xF1, 0xFC, 0x7F, 0x7F, 0xFE, 0x3F, 0x8F, 0xE1, 0xFC, 0xFF,
  0xF1, 0xFC, 0x3F, 0x87, 0xF1, 0xFF, 0x07, 0xF1, 0xFC, 0x1F, 0xC0, 0xE0,
  0x3F, 0x87, 0xF0, 0x7F, 0x00, 0x01, 0xFE, 0x1F, 0xC1, 0xFC, 0x00, 0x07,
  0xF0, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x1F, 0xC0, 0x00, 0xFE,
  0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x00, 0x3F, 0xC1,
  0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x1F,
  0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x07, 0xF8, 0x00, 0xFE, 0x01, 0xFC,
  0x1F, 0xC0, 0x07, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC0, 0x1F, 0xC3,
  0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x03, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xF9,
  0xFF, 0x80, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0x01, 0xFF, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x07, 0xF8,
  0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0xFF, 0x80,
  0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x00, 0xFF,
  0x9F, 0xF0, 0x00, 0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xF0, 0x3F,
  0xFF, 0xF0, 0x3F, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0x81, 0xFF, 0xFF, 0xE1,
  0xFF, 0x07, 0xFE, 0xFF, 0xC7, 0xFC, 0x1F, 0xF8, 0xFF, 0xCF, 0xF8, 0x3F,
  0xE1, 0xFF, 0xBF, 0xE0, 0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xFF, 0x03, 0xFF,
  0xFF, 0x07, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xF8, 0x07, 0xFF, 0xF8, 0x1F,
  0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0xE0, 0x0F, 0xFF, 0xC0, 0x7F, 0xC0, 0x0F,
  0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF9, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC1, 0xFF, 0x80, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xF3, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3, 0xFC, 0x3F, 0xC7,
  0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFE, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x20, 0x0F, 0xE0, 0x03, 0x81, 0xFE,
  0x00, 0x3E, 0x1F, 0xC0, 0x07, 0xF9, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0xE7,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x00, 0x3F, 0xF7, 0xF8, 0x07, 0xFE, 0x3F, 0xC0, 0x3F, 0xE3, 0xFC,
  0x01, 0xFC, 0x3F, 0xE0, 0x0F, 0x81, 0xFE, 0x00, 0x78, 0x1F, 0xF0, 0x03,
  0x01, 0xF8, 0x00, 0x10, 0x0E, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8,
  0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0,
  0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF,
  0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7, 0xFF,
  0xFC, 0xFF, 0xFF, 0x80, 0x03, 0x03, 0xF8, 0xFF, 0xBF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xF9, 0xFE, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0x0F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xE0, 0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0xC3, 0xFF, 0x01, 0xFF, 0x87,
  0xFC, 0x03, 0xFF, 0x1F, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F,
  0xC0, 0x1F, 0xF1, 0xFF, 0x80, 0x3F, 0xE3, 0xFF, 0x00, 0x7F, 0xC7, 0xFC,
  0x00, 0xFF, 0x9F, 0xF8, 0x01, 0xFF, 0x3F, 0xF0, 0x07, 0xFE, 0x7F, 0xE0,
  0x0F, 0xFC, 0xFF, 0x80, 0x1F, 0xF9, 0xFF, 0x00, 0x3F, 0xE7, 0xFE, 0x00,
  0x7F, 0xCF, 0xFC, 0x01, 0xFF, 0x9F, 0xF8, 0x03, 0xFF, 0x3F, 0xE0, 0x07,
  0xFE, 0x7F, 0xC0, 0x0F, 0xF8, 0xFF, 0x80, 0x3F, 0xF1, 0xFF, 0x00, 0x7F,
  0xE3, 0xFE, 0x00, 0xFF, 0x87, 0xFC, 0x03, 0xFF, 0x0F, 0xF8, 0x07, 0xFE,
  0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC0,
  0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x0F, 0xFC, 0x07,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF8, 0xFF, 0xEF, 0xF8, 0x7F, 0x8F, 0xF8, 0x7F, 0x1F, 0xF0, 0x3E,
  0x1F, 0xF0, 0x1C, 0x1F, 0xF0, 0x10, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x1F,
  0xFC, 0x00, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0x00, 0x3F, 0xF0, 0x01, 0xC0,
  0x07, 0xFE, 0x00, 0x20, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x7F, 0xF0, 0x01, 0xC0, 0x0F, 0xFC,
  0x00, 0x40, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x80, 0x00, 0x1F, 0xF8, 0x30, 0x00, 0x0F, 0xFE, 0x0F,
  0x80, 0x0F, 0xFF, 0x03, 0xFE, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFD,
  0xFE, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x3F, 0xBF, 0xE0, 0x00, 0x0F,
  0xEF, 0xF8, 0x00, 0x07, 0xF3, 0xFE, 0x00, 0x03, 0xF9, 0xFF, 0x00, 0x00,
  0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0x1F, 0xF0, 0x00, 0x3F, 0x87, 0xFC, 0x00,
  0x1F, 0xE1, 0xFE, 0x00, 0x07, 0xF0, 0xFF, 0x80, 0x03, 0xF8, 0x3F, 0xE0,
  0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0x03, 0xFE, 0x00, 0x3F, 0x81, 0xFF,
  0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF0, 0x1F, 0xF0, 0x03, 0xF8, 0x07,
  0xFC, 0x01, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x8C, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x7C, 0x7F, 0xFE, 0x00, 0x20, 0x07, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC1, 0x00, 0x00, 0xFF, 0xE0,
  0xE0, 0x00, 0xFF, 0xE0, 0x7C, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x0E, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x1F, 0xE0, 0x01, 0xFF, 0x3F, 0xF8,
  0x00, 0xFF, 0xBF, 0xFE, 0x00, 0xFF, 0xBF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0x9F,
  0xFC, 0x0F, 0xFF, 0x07, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0x00,
  0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xC0,
  0x1F, 0xF0, 0x7F, 0xE0, 0x0F, 0xF8, 0x3F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0,
  0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x83, 0xFE,
  0x00, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F,
  0xE0, 0x7F, 0xE0, 0x1F, 0xF8, 0x7F, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0,
  0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xE1, 0xFF,
  0x80, 0x1F, 0xF9, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x3F, 0xF0,
  0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF0,
  0x07, 0xFC, 0x1F, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x87, 0xFC,
  0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x3F, 0xF1, 0xFF,
  0x80, 0x1F, 0xF0, 0xFF, 0xC0, 0x0F, 0xF8, 0x7F, 0xE0, 0x0F, 0xFC, 0x1F,
  0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF8,
  0x3F, 0xF0, 0x1F, 0xF0, 0xFF, 0xC0, 0x3F, 0xE1, 0xFF, 0x80, 0x7F, 0xC3,
  0xFE, 0x00, 0xFF, 0x87, 0xFC, 0x01, 0xFF, 0x1F, 0xF8, 0x03, 0xFE, 0x3F,
  0xF0, 0x07, 0xFC, 0x7F, 0xC0, 0x1F, 0xF8, 0xFF, 0x80, 0x3F, 0xF1, 0xFF,
  0x00, 0x7F, 0xE3, 0xFE, 0x01, 0xFF, 0xC7, 0xFC, 0x03, 0xFF, 0x8F, 0xFC,
  0x0F, 0xFF, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFD, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFB, 0xFE, 0x01, 0xFF, 0xCF, 0xF8, 0x00, 0xFF, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x07, 0xC3, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80,
  0x7F, 0xC0, 0x1F, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x07, 0xF0, 0x03, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80,
  0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xF8, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xC0, 0x01, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0xE1,
  0xFF, 0xC3, 0xC0, 0x3F, 0xF0, 0xC0, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0xC0, 0xFE, 0x01, 0xFF, 0xFC,
  0x1F, 0x83, 0xF8, 0x07, 0xFF, 0xF8, 0x3F, 0x07, 0xF0, 0x1F, 0xFF, 0xF0,
  0x7E, 0x1F, 0xC0, 0x7F, 0xFF, 0xE0, 0xFC, 0x3F, 0x81, 0xFF, 0x3F, 0xC1,
  0xF8, 0xFE, 0x07, 0xF8, 0x3F, 0x03, 0xF1, 0xFC, 0x1F, 0xE0, 0xFE, 0x07,
  0xE3, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xCF, 0xE0, 0xFE, 0x03, 0xF8, 0x1F,
  0x9F, 0x81, 0xFC, 0x07, 0xE0, 0x7F, 0x3F, 0x03, 0xF0, 0x1F, 0xC0, 0xFE,
  0xFE, 0x0F, 0xE0, 0x3F, 0x81, 0xF9, 0xFC, 0x1F, 0xC0, 0x7F, 0x03, 0xF3,
  0xF0, 0x3F, 0x00, 0xFC, 0x07, 0xE7, 0xE0, 0xFE, 0x03, 0xF8, 0x1F, 0xCF,
  0xC1, 0xFC, 0x07, 0xF0, 0x3F, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0x7E, 0x7F,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF1, 0xFC,
  0x1F, 0xC1, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x83, 0xFC, 0x1F, 0x87, 0xE0,
  0x7F, 0x0F, 0xF8, 0x7F, 0x0F, 0xE0, 0xFF, 0x3F, 0xF1, 0xFC, 0x1F, 0x81,
  0xFF, 0xFB, 0xFF, 0xF0, 0x3F, 0x81, 0xFF, 0xF7, 0xFF, 0xC0, 0x7F, 0x03,
  0xFF, 0xCF, 0xFF, 0x00, 0xFE, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0xFC, 0x03,
  0xF8, 0x0F, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x00, 0x7F, 0xBF,
  0xE0, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x1F,
  0xF3, 0xFE, 0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x3F, 0xE3, 0xFE, 0x00,
  0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x07, 0xFC, 0x3F,
  0xE0, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0xFF,
  0x83, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x03, 0xFE, 0x00,
  0x3F, 0xF0, 0x3F, 0xE0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x3F,
  0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0xC0,
  0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x03, 0xFF, 0x1F,
  0xF8, 0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x3F,
  0xF3, 0xFF, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x3F, 0xF7, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F,
  0xC0, 0x3F, 0xF0, 0x03, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x7F,
  0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xFC,
  0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xFC, 0x03,
  0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xE0, 0x07,
  0xFF, 0x80, 0x0C, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x10, 0x01, 0xFF, 0xE0, 0x1E, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xE3, 0xFF, 0xF8, 0x01, 0xFF,
  0x81, 0xFF, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xFF,
  0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFC,
  0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xE0,
  0x03, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xFF, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0x81,
  0xFF, 0x80, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00,
  0xFF, 0xE0, 0x7F, 0xC0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x0F,
  0xFC, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x0F,
  0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x7F,
  0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xF0, 0x3F, 0xFE, 0x00, 0xFF, 0xCF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0x80, 0x1F, 0xFF, 0x00, 0x0E, 0x00,
  0xFF, 0xF0, 0x00, 0x08, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x07, 0xFF,
  0xF8, 0x7F, 0xE0, 0x1F, 0xFF, 0xE1, 0xFF, 0x80, 0x7F, 0xFF, 0x87, 0xFE,
  0x01, 0xFF, 0xFC, 0x3F, 0xF8, 0x0F, 0xFF, 0xF0, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC3, 0xFF, 0x00, 0xFF, 0xFF, 0x0F, 0xFC, 0x03, 0xFF, 0xFC, 0x3F, 0xF0,
  0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x07, 0xFE,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0xFF, 0xC0,
  0x01, 0xFF, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xFE, 0x00, 0x3F, 0xF0,
  0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0xC0,
  0x0F, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x0F,
  0xFE, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x00, 0x1F,
  0xF0, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0xFF, 0xC0,
  0x00, 0x0F, 0xF8, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0x8F, 0xFC, 0x00, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x00, 0x1F, 0xF3,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x83,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x3F, 0xF0,
  0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x3F,
  0xF0, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x01, 0xFE, 0xFF,
  0x80, 0x1F, 0xF7, 0xF0, 0x07, 0xFB, 0xFC, 0x00, 0x7F, 0x9F, 0xC0, 0x3F,
  0xDF, 0xF0, 0x01, 0xFE, 0x7F, 0x00, 0xFF, 0x7F, 0xC0, 0x0F, 0xF9, 0xFC,
  0x07, 0xF9, 0xFF, 0x00, 0x3F, 0xE7, 0xF0, 0x1F, 0xE7, 0xF8, 0x00, 0xFF,
  0x9F, 0xC0, 0xFF, 0x3F, 0xE0, 0x03, 0xFC, 0x7F, 0x03, 0xFC, 0xFF, 0x80,
  0x0F, 0xF1, 0xFC, 0x0F, 0xE3, 0xFE, 0x00, 0x7F, 0xC7, 0xF0, 0x7F, 0x8F,
  0xF8, 0x01, 0xFF, 0x1F, 0xC1, 0xFC, 0x3F, 0xC0, 0x07, 0xFC, 0x7F, 0x0F,
  0xF1, 0xFF, 0x00, 0x1F, 0xE1, 0xFC, 0x3F, 0xC7, 0xFC, 0x00, 0x7F, 0x87,
  0xF9, 0xFE, 0x1F, 0xF0, 0x03, 0xFE, 0x1F, 0xE7, 0xF8, 0x7F, 0xC0, 0x0F,
  0xF8, 0x7F, 0xBF, 0xC3, 0xFE, 0x00, 0x3F, 0xE1, 0xFE, 0xFF, 0x0F, 0xF8,
  0x00, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xFF, 0xE0,
  0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0xC1, 0xFF,
  0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xC0, 0x07, 0xF8,
  0x1F, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xFC, 0x07, 0xFC, 0x00,
  0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xE0, 0x03, 0xFE, 0x07, 0xFF, 0x80, 0xFF,
  0x80, 0x0F, 0xF0, 0x1F, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0xF0,
  0x0F, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x7F,
  0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xC0, 0x0F, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xE0,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xFF,
  0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xF0,
  0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xE0, 0x03, 0xFF, 0xFE, 0x01,
  0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xF8, 0x01, 0xFF, 0x7F, 0x80, 0x7F,
  0xC0, 0x0F, 0xFB, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x9F, 0xF0, 0x3F, 0xE0,
  0x03, 0xFC, 0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x0F, 0xF8, 0x01,
  0xFF, 0x1F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF8, 0xFF, 0x83, 0xFC, 0x00, 0x7F,
  0xC7, 0xFC, 0x3F, 0xE0, 0x03, 0xFC, 0x3F, 0xE1, 0xFF, 0x00, 0x1F, 0xE0,
  0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF8, 0x3F,
  0xE3, 0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x3F, 0xE0, 0x03, 0xFC, 0x07, 0xF9,
  0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xCF, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x7F,
  0x80, 0x0F, 0xF8, 0x0F, 0xFB, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xDF, 0xE0,
  0x03, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0x80, 0x1F, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xE0,
  0x03, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xE0,
  0x07, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00,
  0x3F, 0xF0, 0xFF, 0xE0, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x03, 0xFF, 0x1F,
  0xFC, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x00,
  0xFF, 0xCF, 0xFE, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0xFF,
  0xC0, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x00, 0xFF, 0xDF, 0xFC, 0x00, 0x07,
  0xFF, 0x7F, 0xE0, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x7F, 0xE7, 0xFE,
  0x00, 0x01, 0xFF, 0xBF, 0xF8, 0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x00, 0x3F,
  0xFB, 0xFF, 0x00, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x03, 0xFF, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x7F, 0xF3, 0xFF, 0x00, 0x01, 0xFF,
  0x8F, 0xFC, 0x00, 0x0F, 0xFE, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0xFF, 0xC0,
  0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x07, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xF8,
  0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0x3F, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xF8, 0x03, 0xFF, 0x01, 0xFF,
  0xC0, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x1F, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x1F,
  0xF0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xE0, 0x7F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x3F,
  0xF0, 0xFF, 0xE0, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x03, 0xFF, 0x1F, 0xFC,
  0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x00, 0xFF,
  0xCF, 0xFE, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0xFF, 0xC0,
  0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x00, 0xFF, 0xDF, 0xFC, 0x00, 0x07, 0xFF,
  0x7F, 0xE0, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x7F, 0xE7, 0xFE, 0x00,
  0x01, 0xFF, 0xBF, 0xF8, 0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x00, 0x3F, 0xFB,
  0xFF, 0x00, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x7F, 0xF3, 0xFF, 0x00, 0x01, 0xFF, 0x8F,
  0xFC, 0x00, 0x0F, 0xFE, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0xFF, 0xC0, 0x00,
  0xFF, 0xC3, 0xFF, 0x00, 0x07, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x3F,
  0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0xE0, 0x07,
  0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC,
  0x01, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x07,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFC, 0x7F,
  0xC0, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xE0, 0x00, 0xFF,
  0x83, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0x83, 0xFF, 0x00,
  0x1F, 0xF8, 0x3F, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x1F,
  0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xF8, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0xC0,
  0x3F, 0xE0, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x07,
  0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x07, 0xFE, 0x0F, 0xFC,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x07, 0xE0, 0x03,
  0xFF, 0x80, 0x18, 0x00, 0x7F, 0xE0, 0x01, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x02, 0x00, 0x01, 0xFF, 0x80, 0x30, 0x00,
  0x3F, 0xF0, 0x0F, 0x80, 0x0F, 0xFE, 0x01, 0xFC, 0x07, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xFE, 0x00,
  0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0xC0,
  0x3F, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x80,
  0x07, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xF0,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xFC,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0xFF,
  0xC0, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x7F,
  0xC0, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x0F,
  0xF8, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00,
  0x7F, 0xEF, 0xFC, 0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x03, 0xFF, 0x1F, 0xF0,
  0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x03, 0xFE, 0x0F,
  0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x03, 0xFE,
  0x07, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xF0, 0x07,
  0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xE0, 0x07,
  0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xE0,
  0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x0F, 0xF8, 0x7F,
  0xE0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x07, 0xFC,
  0x7F, 0xC0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x03,
  0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x0F, 0xFB, 0xFE, 0x00,
  0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFD, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xEF, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x7F, 0xC0, 0x07, 0xFF,
  0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x9F, 0xF0, 0x01,
  0xFF, 0xC0, 0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xC7, 0xFC,
  0x00, 0xFF, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xE1,
  0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0x0F, 0xF8, 0x03, 0xFF, 0xE0, 0x1F,
  0xF0, 0x7F, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0xF8,
  0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF,
  0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0,
  0x7F, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x03, 0xFB, 0xF8, 0x1F, 0xF0, 0x0F,
  0xF8, 0x3F, 0xDF, 0xC0, 0xFF, 0x80, 0x7F, 0xC1, 0xFE, 0xFE, 0x07, 0xFC,
  0x03, 0xFE, 0x1F, 0xE7, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0xFF, 0x3F, 0x83,
  0xFE, 0x00, 0xFF, 0x87, 0xF1, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x7F, 0x8F,
  0xE1, 0xFF, 0x00, 0x3F, 0xE3, 0xFC, 0x7F, 0x0F, 0xF8, 0x01, 0xFF, 0x3F,
  0xC3, 0xF8, 0xFF, 0x80, 0x0F, 0xF1, 0xFE, 0x1F, 0xC7, 0xFC, 0x00, 0x7F,
  0x8F, 0xE0, 0xFE, 0x7F, 0xC0, 0x03, 0xFC, 0xFF, 0x07, 0xF3, 0xFE, 0x00,
  0x1F, 0xE7, 0xF8, 0x3F, 0x9F, 0xF0, 0x00, 0xFF, 0x7F, 0x81, 0xFD, 0xFF,
  0x00, 0x07, 0xFB, 0xFC, 0x0F, 0xEF, 0xF8, 0x00, 0x3F, 0xDF, 0xC0, 0x7F,
  0x7F, 0x80, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x0F,
  0xF8, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC1, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xDF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xDF, 0xF0, 0x00, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0xBF, 0xE0, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0xFF,
  0xCF, 0xF8, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x7F,
  0xE1, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xC0, 0x3F, 0xF0, 0x3F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x07, 0xFC, 0x0F,
  0xF8, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xC7,
  0xFC, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x0F, 0xFB,
  0xFF, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0x01, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xEF, 0xF0, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x3F, 0xC7, 0xF0, 0x00,
  0x7F, 0x87, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x03, 0xF8, 0x01,
  0xFE, 0x03, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07,
  0xF8, 0x01, 0xFC, 0x07, 0xF8, 0x01, 0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x1F,
  0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x7F,
  0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x7F,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xC1, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x1F, 0xFE,
  0x1F, 0xE0, 0x1F, 0xFF, 0x9F, 0xF0, 0x1F, 0xFF, 0xEF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0x1F, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x83, 0xFF,
  0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0x80, 0x3F, 0xE0, 0xFF,
  0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x7F, 0xE0, 0x07, 0xFC, 0x3F,
  0xF0, 0x07, 0xFE, 0x1F, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x0F,
  0xFC, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x7F, 0xE1,
  0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0xC0, 0x1F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF8,
  0x3F, 0xE0, 0x0F, 0xFC, 0x1F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE,
  0x07, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xC7, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xEF,
  0xF0, 0x0F, 0xFF, 0xE7, 0xF8, 0x03, 0xFF, 0xE3, 0xFC, 0x00, 0xFF, 0xE3,
  0xFC, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x0F, 0x80,
  0x01, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0xBF, 0xFC, 0x00, 0x7F, 0x9F, 0xFF,
  0x00, 0x7F, 0xDF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0x80,
  0x3F, 0xE0, 0xFF, 0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0,
  0x07, 0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xF0, 0x03, 0xFF, 0x0F, 0xF8,
  0x01, 0xFF, 0x87, 0xFC, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x7F, 0xC1, 0xFF,
  0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0x80, 0x1F, 0xF8, 0x7F,
  0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F, 0xFC, 0x1F, 0xF0, 0x07, 0xFE, 0x1F,
  0xF8, 0x07, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xE3, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xDF, 0xFF, 0xC0,
  0x1F, 0xCF, 0xFF, 0xC0, 0x1F, 0xE3, 0xFF, 0xC0, 0x0F, 0xE0, 0xFF, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0x03,
  0x80, 0xFF, 0xE0, 0x08, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x80, 0xFF, 0xE0, 0x38, 0x0F, 0xFF, 0x0F, 0x80, 0x7F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xC0, 0xFF, 0x80, 0x01, 0xFF, 0x0F,
  0xF8, 0x00, 0x7F, 0xFC, 0xFF, 0x80, 0x0F, 0xFF, 0xCF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0xFF,
  0xE0, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0,
  0x07, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x7F,
  0xC0, 0x7F, 0xC0, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xC0,
  0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xF0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x7F, 0xE0, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F,
  0xFE, 0x1F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFB, 0xFC, 0x00, 0x3F, 0xFF,
  0x3F, 0x80, 0x01, 0xFF, 0xE3, 0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xE1, 0xFF, 0x07, 0xFE, 0x07,
  0xF8, 0x7F, 0xE0, 0x3F, 0xC3, 0xFE, 0x01, 0xFE, 0x3F, 0xE0, 0x0F, 0xF1,
  0xFF, 0x00, 0xFF, 0x9F, 0xF0, 0x07, 0xFC, 0xFF, 0x80, 0x7F, 0xC7, 0xFC,
  0x0F, 0xFE, 0x7F, 0xC3, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x04, 0x0F, 0xFC, 0x01, 0xE0,
  0x7F, 0xFD, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x60, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0xFF, 0x00, 0x0F, 0xFF, 0x8F, 0xF0,
  0x01, 0xFF, 0xF9, 0xFF, 0x00, 0x3F, 0xFF, 0xDF, 0xE0, 0x07, 0xFF, 0xFD,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xE3, 0xFF, 0xE0, 0x1F, 0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F,
  0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xF8, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x1F, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF8,
  0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x07, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x81, 0xFF,
  0xC0, 0x1F, 0xF8, 0x3F, 0xFC, 0x01, 0xFF, 0xC7, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0xFF, 0x80, 0x07, 0xFF, 0xDF, 0xF8, 0x00, 0x3F, 0xF9, 0xFF,
  0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x03, 0x81, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x08, 0x00, 0x0F, 0xFC,
  0x00, 0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xC0, 0x3F, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x0F, 0xC0,
  0x01, 0xFF, 0x1F, 0xF8, 0x00, 0xFF, 0xBF, 0xFE, 0x00, 0x7F, 0xBF, 0xFF,
  0x80, 0x7F, 0xDF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x8F, 0xFE, 0x07, 0xFF, 0x83,
  0xFF, 0x03, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0,
  0x7F, 0xE0, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF0, 0x3F, 0xE0,
  0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xFC,
  0x03, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x81, 0xFF,
  0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0xC0, 0x3F, 0xE0, 0x7F,
  0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x1F,
  0xF8, 0x07, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x03,
  0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x7F, 0xE0,
  0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF8,
  0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xF8, 0x07, 0xFE, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xC0,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x63, 0xFF, 0x80, 0x03, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x0F,
  0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xF0, 0x01, 0xFF,
  0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x03, 0xFE, 0x0F, 0xFC, 0x00,
  0x3F, 0xE1, 0xFF, 0x80, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x3F, 0xE3, 0xFE,
  0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x07, 0xFD,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0x8F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xFC,
  0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x7F, 0xC0, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x07,
  0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x03, 0xFF,
  0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x3F, 0x83, 0xFE, 0x01, 0xFF, 0x80,
  0x0F, 0xE3, 0xFF, 0xC1, 0xFF, 0xF0, 0x03, 0xF9, 0xFF, 0xF8, 0xFF, 0xFE,
  0x01, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF8,
  0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07,
  0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x3F, 0xE0,
  0x0F, 0xF8, 0x07, 0xFC, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F,
  0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x07,
  0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC,
  0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x0F, 0xF8, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x07, 0xFE, 0x00,
  0x3F, 0x87, 0xFF, 0x80, 0x1F, 0xC7, 0xFF, 0xC0, 0x1F, 0xE7, 0xFF, 0xF0,
  0x0F, 0xF7, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xE3, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xE0, 0x7F, 0xE0, 0x1F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0, 0x0F,
  0xF8, 0x1F, 0xF8, 0x07, 0xFC, 0x0F, 0xF8, 0x03, 0xFE, 0x07, 0xFC, 0x01,
  0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x00,
  0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0,
  0x0F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x0F, 0xF8,
  0x03, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0x7F,
  0xC0, 0x1F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F,
  0xF0, 0x07, 0xFC, 0x0F, 0xF8, 0x03, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x07,
  0xFE, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0x1F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF1, 0xFF, 0x80,
  0x7F, 0xC7, 0xFE, 0x01, 0xFF, 0x3F, 0xF0, 0x07, 0xFC, 0xFF, 0xC0, 0x1F,
  0xF3, 0xFE, 0x00, 0x7F, 0xDF, 0xF8, 0x01, 0xFF, 0x7F, 0xE0, 0x07, 0xFD,
  0xFF, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x7F, 0xDF, 0xF0, 0x01, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0xFF, 0xBF, 0xE0,
  0x03, 0xFE, 0xFF, 0x80, 0x1F, 0xFB, 0xFE, 0x00, 0x7F, 0xCF, 0xF8, 0x03,
  0xFF, 0x3F, 0xE0, 0x0F, 0xFC, 0xFF, 0x80, 0x7F, 0xE3, 0xFF, 0x01, 0xFF,
  0x8F, 0xFC, 0x0F, 0xFC, 0x1F, 0xFC, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0x07, 0xFC, 0x00,
  0x03, 0xF8, 0xFF, 0xF0, 0x00, 0x1F, 0xCF, 0xFF, 0xC0, 0x01, 0xFE, 0xFF,
  0xFF, 0x00, 0x0F, 0xF7, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0xFF,
  0xC0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFC, 0x00,
  0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0xC0, 0x3F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xFE, 0x0F,
  0xFE, 0x00, 0x7F, 0xF8, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xDF, 0xFF, 0x80, 0x07, 0xFC, 0x7F, 0xF0, 0x00, 0x3F, 0xE1,
  0xFF, 0x00, 0x01, 0xFF, 0x03, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xFC, 0x3F, 0xC0, 0x0F, 0xFF, 0x1F, 0xE0, 0x1F, 0xFF,
  0xDF, 0xE0, 0x1F, 0xFF, 0xEF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x1F, 0xFE, 0x07, 0xFE,
  0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xC1, 0xFF,
  0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0xC0, 0x1F, 0xF0, 0x7F,
  0xC0, 0x0F, 0xF8, 0x7F, 0xE0, 0x07, 0xFC, 0x3F, 0xF0, 0x03, 0xFE, 0x1F,
  0xF0, 0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x87,
  0xFE, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x3F, 0xE0,
  0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F, 0xFC,
  0x1F, 0xF0, 0x07, 0xFC, 0x0F, 0xF8, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xEF,
  0xF8, 0x03, 0xFF, 0xE7, 0xF8, 0x00, 0xFF, 0xE7, 0xFC, 0x00, 0x3F, 0xE3,
  0xFE, 0x00, 0x03, 0x81, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFE, 0x3F, 0xE0, 0x0F,
  0xE3, 0xFE, 0x01, 0xFE, 0x7F, 0xE0, 0x1F, 0xEF, 0xFE, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFB, 0xFC, 0x0F, 0xFE, 0x03,
  0x80, 0xFF, 0xC0, 0x08, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x08, 0x00,
  0x3F, 0xF0, 0xE0, 0x07, 0xFE, 0x0F, 0xC1, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x07,
  0xFF, 0xFC, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xF9, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x83, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x20,
  0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xC0,
  0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF8,
  0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x0F, 0xF8, 0x03, 0xFE,
  0x07, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0xFF,
  0x81, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F,
  0xF0, 0x3F, 0xE0, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07,
  0xFC, 0x0F, 0xF8, 0x03, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x01,
  0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80,
  0x7F, 0xE0, 0x7F, 0xC0, 0x3F, 0xF0, 0x3F, 0xE0, 0x1F, 0xF0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFE, 0x07, 0xFE,
  0x0F, 0xFE, 0x03, 0xFF, 0x8F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xDF, 0xE0, 0x1F, 0xFF, 0xCF, 0xE0, 0x07,
  0xFF, 0xE7, 0xF0, 0x03, 0xFF, 0xC3, 0xF8, 0x00, 0x7F, 0xC1, 0xFC, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xEF,
  0xF8, 0x01, 0xFF, 0xBF, 0xE0, 0x07, 0xFC, 0xFF, 0x80, 0x1F, 0xF3, 0xFE,
  0x00, 0xFF, 0x8F, 0xF8, 0x03, 0xFE, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0x80,
  0x7F, 0xC1, 0xFE, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F,
  0xE0, 0x7F, 0x81, 0xFF, 0x01, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x3F, 0xE0,
  0x1F, 0xE0, 0xFF, 0x80, 0x7F, 0x87, 0xFC, 0x01, 0xFE, 0x1F, 0xF0, 0x07,
  0xF8, 0xFF, 0x80, 0x1F, 0xE3, 0xFE, 0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFE,
  0x7F, 0xC0, 0x07, 0xF9, 0xFE, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x7F, 0xBF,
  0xC0, 0x01, 0xFE, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xC0, 0x3F, 0xEF, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xBF, 0xE0, 0x1F, 0xFC,
  0x03, 0xFE, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xF3, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xCF, 0xF8, 0x1F, 0xFF, 0x01, 0xFE, 0x3F, 0xE0, 0x7F, 0xFC, 0x0F,
  0xF8, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xE3, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF,
  0x0F, 0xF8, 0x3F, 0xFF, 0x07, 0xFC, 0x3F, 0xE1, 0xFD, 0xFC, 0x1F, 0xE0,
  0xFF, 0x87, 0xF7, 0xF0, 0xFF, 0x83, 0xFE, 0x1F, 0xDF, 0xC3, 0xFC, 0x0F,
  0xF8, 0xFE, 0x7F, 0x1F, 0xF0, 0x3F, 0xE3, 0xF9, 0xFC, 0x7F, 0xC0, 0xFF,
  0x9F, 0xE7, 0xF1, 0xFE, 0x03, 0xFE, 0x7F, 0x1F, 0xCF, 0xF8, 0x0F, 0xF9,
  0xFC, 0xFF, 0x3F, 0xC0, 0x3F, 0xCF, 0xE3, 0xFD, 0xFF, 0x00, 0xFF, 0x3F,
  0x8F, 0xE7, 0xF8, 0x03, 0xFC, 0xFE, 0x3F, 0x9F, 0xE0, 0x0F, 0xF7, 0xF0,
  0xFE, 0xFF, 0x80, 0x3F, 0xDF, 0xC3, 0xFB, 0xFC, 0x00, 0xFF, 0x7E, 0x0F,
  0xEF, 0xF0, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xF8,
  0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF,
  0x87, 0xFE, 0x00, 0x07, 0xFC, 0x7F, 0xE0, 0x00, 0x3F, 0xF3, 0xFE, 0x00,
  0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03,
  0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x03, 0xFF, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x1F, 0xF8,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xFC,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0x07, 0xF8, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xFC,
  0x00, 0x1F, 0xE0, 0x1F, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x01, 0xFF, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x3F, 0xE3, 0xFE,
  0x00, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x00,
  0xFF, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x03, 0xFD, 0xFF,
  0x00, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x20, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x3F,
  0xE0, 0x00, 0x13, 0xFF, 0xF0, 0x00, 0xDF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xEC, 0x00, 0x1F, 0xFF,
  0x20, 0x00, 0x0F, 0xF0,
};

const GFXglyph NotoSans_Condensed_BoldItalic70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 21, 51, 18, 0, -50 },
  { 135, 25, 18, 29, 7, -50 },
  { 192, 39, 50, 37, 0, -50 },
  { 436, 33, 57, 32, 1, -53 },
  { 672, 46, 52, 53, 4, -51 },
  { 971, 39, 52, 40, 1, -51 },
  { 1225, 12, 18, 17, 7, -50 },
  { 1252, 25, 61, 20, 1, -50 },
  { 1443, 24, 62, 21, -5, -51 },
  { 1629, 28, 31, 32, 6, -54 },
  { 1738, 30, 34, 35, 3, -42 },
  { 1866, 16, 18, 18, -4, -9 },
  { 1902, 19, 9, 21, 1, -23 },
  { 1924, 11, 12, 18, 0, -11 },
  { 1941, 37, 50, 27, -4, -50 },
  { 2173, 31, 52, 32, 2, -51 },
  { 2375, 24, 50, 33, 7, -50 },
  { 2525, 35, 51, 32, -2, -51 },
  { 2749, 34, 52, 32, -1, -51 },
  { 2970, 34, 50, 33, -1, -50 },
  { 3183, 33, 51, 32, 0, -50 },
  { 3394, 33, 52, 32, 2, -51 },
  { 3609, 34, 50, 32, 2, -50 },
  { 3822, 33, 52, 32, 0, -51 },
  { 4037, 31, 52, 32, 1, -51 },
  { 4239, 18, 40, 18, 0, -39 },
  { 4329, 22, 48, 18, -4, -39 },
  { 4461, 30, 34, 35, 3, -42 },
  { 4589, 30, 21, 35, 3, -35 },
  { 4668, 30, 34, 35, 3, -42 },
  { 4796, 26, 52, 26, 3, -51 },
  { 4965, 47, 56, 50, 2, -50 },
  { 5294, 36, 50, 36, -4, -50 },
  { 5519, 37, 50, 36, 0, -50 },
  { 5751, 35, 52, 34, 3, -51 },
  { 5979, 38, 50, 39, 0, -50 },
  { 6217, 34, 50, 31, 0, -50 },
  { 6430, 34, 50, 30, 0, -50 },
  { 6643, 38, 52, 40, 3, -51 },
  { 6890, 42, 50, 41, 0, -50 },
  { 7153, 31, 50, 24, -3, -50 },
  { 7347, 32, 65, 19, -11, -50 },
  { 7607, 42, 50, 35, 0, -50 },
  { 7870, 25, 50, 30, 0, -50 },
  { 8027, 54, 50, 53, 0, -50 },
  { 8365, 45, 50, 43, 0, -50 },
  { 8647, 38, 52, 42, 3, -51 },
  { 8894, 37, 50, 35, 0, -50 },
  { 9126, 38, 63, 42, 3, -51 },
  { 9426, 36, 50, 36, 0, -50 },
  { 9651, 35, 52, 31, -1, -51 },
  { 9879, 30, 50, 31, 6, -50 },
  { 10067, 39, 51, 40, 3, -50 },
  { 10316, 35, 50, 35, 6, -50 },
  { 10535, 53, 50, 53, 6, -50 },
  { 10867, 43, 50, 34, -4, -50 },
  { 11136, 33, 50, 33, 6, -50 },
  { 11343, 38, 50, 30, -3, -50 },
  { 11581, 28, 61, 21, -2, -50 },
  { 11795, 15, 50, 27, 7, -50 },
  { 11889, 28, 61, 21, -5, -50 },
  { 12103, 32, 31, 33, 0, -50 },
  { 12227, 26, 5, 24, -7, 6 },
  { 12244, 14, 12, 21, 10, -54 },
  { 12265, 33, 40, 35, 2, -39 },
  { 12430, 33, 54, 35, 0, -53 },
  { 12653, 28, 40, 28, 2, -39 },
  { 12793, 36, 54, 35, 2, -53 },
  { 13036, 29, 40, 32, 2, -39 },
  { 13181, 37, 71, 21, -8, -54 },
  { 13510, 36, 56, 35, -1, -39 },
  { 13762, 33, 53, 35, 0, -53 },
  { 13981, 20, 53, 18, 0, -53 },
  { 14114, 29, 70, 18, -9, -53 },
  { 14368, 36, 53, 33, 0, -53 },
  { 14607, 21, 53, 17, 0, -53 },
  { 14747, 50, 39, 52, 0, -39 },
  { 14991, 33, 39, 35, 0, -39 },
  { 15152, 30, 40, 34, 2, -39 },
  { 15302, 37, 56, 35, -4, -39 },
  { 15561, 33, 56, 35, 2, -39 },
  { 15792, 28, 39, 25, 0, -39 },
  { 15929, 28, 40, 28, 0, -39 },
  { 16069, 22, 47, 23, 3, -46 },
  { 16199, 33, 39, 35, 2, -38 },
  { 16360, 30, 38, 30, 4, -38 },
  { 16503, 46, 38, 47, 4, -38 },
  { 16722, 37, 38, 31, -3, -38 },
  { 16898, 39, 55, 31, -5, -38 },
  { 17167, 30, 38, 26, -2, -38 },
  { 17310, 28, 61, 24, 1, -50 },
  { 17524, 7, 69, 30, 11, -53 },
  { 17585, 27, 61, 24, -4, -50 },
  { 17791, 30, 12, 35, 3, -31 },
};

const GFXfont NotoSans_Condensed_BoldItalic70pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BoldItalic70pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BoldItalic70pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _NOTOSANS_CONDENSED_BOLDITALIC70PT7B_H_
