#ifndef _NOTOSANS_CONDENSED_BOLDITALIC9PT7B_H_
#define _NOTOSANS_CONDENSED_BOLDITALIC9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BoldItalic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BoldItalic9pt7bBitmaps[] PROGMEM = {
  0x00, 0x69, 0x21, 0x00, 0xB4, 0x3B, 0xD5, 0xE6, 0x50, 0x27, 0x66, 0x3B,
  0x64, 0x25, 0xA6, 0xAD, 0x5C, 0xB4, 0xC0, 0x23, 0x94, 0xCE, 0xCB, 0xE0,
  0xC0, 0x29, 0x49, 0x30, 0x24, 0x92, 0x5E, 0x5D, 0x50, 0x2F, 0x22, 0xE0,
  0xE0, 0x80, 0x12, 0x64, 0xC8, 0x27, 0x5D, 0x9B, 0xE0, 0x7D, 0x25, 0x80,
  0x27, 0x13, 0x6C, 0xE0, 0x27, 0x16, 0x33, 0xE0, 0x33, 0x7A, 0xF2, 0x74,
  0x71, 0x3E, 0x13, 0x47, 0xDB, 0x60, 0x78, 0x88, 0x44, 0x60, 0x25, 0x56,
  0xF9, 0xE0, 0x27, 0x5D, 0x72, 0xE0, 0x40, 0x80, 0x20, 0x15, 0x80, 0x3C,
  0x61, 0xF0, 0xF0, 0xC3, 0x68, 0x27, 0x36, 0x40, 0xC0, 0x3D, 0x7A, 0xED,
  0xBA, 0x07, 0x00, 0x19, 0xCA, 0x74, 0xE4, 0x7A, 0xDC, 0xAD, 0x70, 0x13,
  0xD0, 0x8C, 0x61, 0xC0, 0x7A, 0x52, 0xBD, 0x70, 0x74, 0x74, 0xCE, 0x74,
  0x74, 0xC8, 0x11, 0xD0, 0xBD, 0xE9, 0xC0, 0x6A, 0x5E, 0xBD, 0x48, 0x76,
  0x44, 0x4C, 0x32, 0x22, 0x64, 0x4C, 0x7A, 0x98, 0xCF, 0x48, 0x69, 0x2D,
  0xC0, 0x66, 0xDD, 0xB3, 0xAB, 0x57, 0x80, 0x6D, 0xA6, 0x96, 0x9A, 0x60,
  0x13, 0xD2, 0x9C, 0xED, 0xC0, 0x7A, 0x54, 0xCC, 0x40, 0x13, 0xD2, 0x9C,
  0xED, 0xC6, 0x10, 0x72, 0xD4, 0xCF, 0x48, 0x27, 0x46, 0x3B, 0xE0, 0xF4,
  0x4C, 0x88, 0x6A, 0x52, 0xBD, 0x38, 0x9A, 0xAE, 0xCC, 0xB7, 0x6B, 0x66,
  0xCD, 0x92, 0x00, 0x2C, 0xE1, 0x0C, 0x73, 0x60, 0xBA, 0xCC, 0x88, 0x73,
  0x24, 0xCE, 0x69, 0x29, 0x30, 0xAB, 0x50, 0x31, 0x22, 0x22, 0xE0, 0x25,
  0x59, 0xE0, 0xD0, 0x7A, 0xB5, 0x2F, 0x00, 0x64, 0x75, 0x5D, 0xE0, 0x74,
  0xC8, 0x60, 0x08, 0xDC, 0xAD, 0x4B, 0xC0, 0x75, 0xE8, 0x60, 0x19, 0x9C,
  0x42, 0x31, 0x08, 0xC0, 0x7A, 0xB5, 0x6F, 0x13, 0x80, 0x64, 0x75, 0x5D,
  0xB0, 0x61, 0x25, 0xA0, 0x30, 0x22, 0x26, 0x44, 0xC0, 0x62, 0x16, 0xC6,
  0x52, 0xC0, 0x69, 0x25, 0xA0, 0x7D, 0x55, 0x65, 0xBC, 0x75, 0x5D, 0xB0,
  0x75, 0xD9, 0x60, 0x75, 0x5D, 0xE8, 0x80, 0x7A, 0xB5, 0x2F, 0x10, 0x80,
  0x74, 0x4C, 0x80, 0x74, 0x62, 0xE0, 0x7D, 0x2D, 0x80, 0x55, 0x5B, 0xD0,
  0xB7, 0x68, 0xAF, 0x7D, 0x6B, 0x00, 0x56, 0x66, 0xA0, 0x29, 0x4C, 0x62,
  0x13, 0x00, 0x72, 0x4C, 0xE0, 0x36, 0x48, 0x44, 0xC0, 0xFF, 0x80, 0x32,
  0x21, 0x26, 0xC0, 0xF9,
};

const GFXglyph NotoSans_Condensed_BoldItalic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 6, 2, 0, -6 },
  { 4, 3, 2, 4, 1, -6 },
  { 5, 5, 6, 5, 0, -6 },
  { 9, 4, 8, 4, 0, -7 },
  { 13, 6, 7, 7, 0, -7 },
  { 19, 5, 7, 5, 0, -7 },
  { 24, 1, 2, 2, 1, -6 },
  { 25, 3, 7, 3, 0, -6 },
  { 28, 3, 8, 3, -1, -7 },
  { 31, 3, 4, 4, 1, -7 },
  { 33, 4, 4, 4, 0, -5 },
  { 35, 2, 2, 2, 0, -1 },
  { 36, 3, 1, 3, 0, -3 },
  { 37, 1, 1, 2, 0, -1 },
  { 38, 4, 6, 3, 0, -6 },
  { 41, 4, 7, 4, 0, -7 },
  { 45, 3, 6, 4, 1, -6 },
  { 48, 4, 7, 4, 0, -7 },
  { 52, 4, 7, 4, 0, -7 },
  { 56, 4, 6, 4, 0, -6 },
  { 59, 4, 6, 4, 0, -6 },
  { 62, 4, 7, 4, 0, -7 },
  { 66, 5, 6, 4, 0, -6 },
  { 70, 4, 7, 4, 0, -7 },
  { 74, 4, 7, 4, 0, -7 },
  { 78, 2, 5, 2, 0, -5 },
  { 80, 3, 6, 2, -1, -5 },
  { 83, 4, 4, 4, 0, -5 },
  { 85, 4, 3, 4, 0, -5 },
  { 87, 4, 4, 4, 0, -5 },
  { 89, 4, 7, 3, 0, -7 },
  { 93, 6, 7, 6, 0, -6 },
  { 99, 5, 6, 5, -1, -6 },
  { 103, 5, 6, 5, 0, -6 },
  { 107, 5, 7, 4, 0, -7 },
  { 112, 5, 6, 5, 0, -6 },
  { 116, 4, 6, 4, 0, -6 },
  { 119, 4, 6, 4, 0, -6 },
  { 122, 5, 7, 5, 0, -7 },
  { 127, 5, 6, 5, 0, -6 },
  { 131, 4, 6, 3, 0, -6 },
  { 134, 4, 8, 2, -1, -6 },
  { 138, 5, 6, 5, 0, -6 },
  { 142, 3, 6, 4, 0, -6 },
  { 145, 7, 6, 7, 0, -6 },
  { 151, 6, 6, 6, 0, -6 },
  { 156, 5, 7, 5, 0, -7 },
  { 161, 5, 6, 5, 0, -6 },
  { 165, 5, 9, 5, 0, -7 },
  { 171, 5, 6, 5, 0, -6 },
  { 175, 4, 7, 4, 0, -7 },
  { 179, 4, 6, 4, 1, -6 },
  { 182, 5, 6, 5, 0, -6 },
  { 186, 4, 6, 5, 1, -6 },
  { 189, 7, 6, 7, 1, -6 },
  { 195, 6, 6, 4, -1, -6 },
  { 200, 4, 6, 4, 1, -6 },
  { 203, 4, 6, 4, 0, -6 },
  { 206, 3, 7, 3, 0, -6 },
  { 209, 2, 6, 4, 1, -6 },
  { 211, 4, 7, 3, -1, -6 },
  { 215, 4, 4, 4, 0, -6 },
  { 217, 3, 1, 3, -1, 1 },
  { 218, 2, 2, 3, 1, -7 },
  { 219, 5, 5, 5, 0, -5 },
  { 223, 4, 7, 5, 0, -7 },
  { 227, 4, 5, 4, 0, -5 },
  { 230, 5, 7, 5, 0, -7 },
  { 235, 4, 5, 4, 0, -5 },
  { 238, 5, 9, 3, -1, -7 },
  { 244, 5, 7, 5, 0, -5 },
  { 249, 4, 7, 5, 0, -7 },
  { 253, 3, 7, 2, 0, -7 },
  { 256, 4, 9, 2, -1, -7 },
  { 261, 5, 7, 4, 0, -7 },
  { 266, 3, 7, 2, 0, -7 },
  { 269, 6, 5, 7, 0, -5 },
  { 273, 4, 5, 5, 0, -5 },
  { 276, 4, 5, 4, 0, -5 },
  { 279, 4, 7, 5, 0, -5 },
  { 283, 5, 7, 5, 0, -5 },
  { 288, 4, 5, 3, 0, -5 },
  { 291, 4, 5, 4, 0, -5 },
  { 294, 3, 6, 3, 0, -6 },
  { 297, 4, 5, 4, 0, -5 },
  { 300, 3, 5, 4, 1, -5 },
  { 302, 5, 5, 6, 1, -5 },
  { 306, 4, 5, 4, 0, -5 },
  { 309, 5, 7, 4, -1, -5 },
  { 314, 4, 5, 3, 0, -5 },
  { 317, 4, 7, 3, 0, -6 },
  { 321, 1, 9, 4, 1, -7 },
  { 323, 4, 7, 3, -1, -6 },
  { 327, 4, 2, 4, 0, -4 },
};

const GFXfont NotoSans_Condensed_BoldItalic9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BoldItalic9pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BoldItalic9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_CONDENSED_BOLDITALIC9PT7B_H_
