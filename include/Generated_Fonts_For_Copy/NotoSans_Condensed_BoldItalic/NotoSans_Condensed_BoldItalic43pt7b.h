#ifndef _NOTOSANS_CONDENSED_BOLDITALIC43PT7B_H_
#define _NOTOSANS_CONDENSED_BOLDITALIC43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BoldItalic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BoldItalic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7E, 0x01, 0xF0, 0x00, 0x3E, 0x3E, 0x7C, 0x7D, 0xF9, 0xFB, 0xF3, 0xF7,
  0xC7, 0xCF, 0x8F, 0x9F, 0x1F, 0x3C, 0x3C, 0x78, 0x79, 0xF1, 0xF3, 0xE3,
  0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x3E, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C,
  0x78, 0x00, 0x7C, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0xF8, 0x00, 0x78,
  0xF0, 0x00, 0xF0, 0xF0, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFE, 0x01, 0xE3, 0xC0, 0x03, 0xE3, 0xC0, 0x03, 0xC3,
  0xC0, 0x03, 0xC7, 0xC0, 0x03, 0xC7, 0x80, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x0F, 0x0F, 0x00, 0x0F, 0x1E,
  0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x3E, 0x3C,
  0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x7C, 0x00, 0x7C, 0x78, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x07, 0xFE, 0x00,
  0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x7E, 0x62,
  0x03, 0xF6, 0x00, 0x1F, 0x30, 0x00, 0xFD, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x37, 0xE0, 0x01, 0xBF, 0x00, 0x0D,
  0xF8, 0x40, 0xEF, 0xC3, 0x86, 0x7E, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x03, 0xE0, 0x03,
  0xC0, 0x7F, 0x80, 0x3C, 0x07, 0xFE, 0x03, 0xE0, 0x3F, 0xF0, 0x1E, 0x03,
  0xE7, 0x81, 0xE0, 0x1E, 0x3C, 0x1F, 0x01, 0xF1, 0xE0, 0xF0, 0x0F, 0x0F,
  0x0F, 0x80, 0x78, 0x78, 0x78, 0x03, 0xC3, 0xC7, 0x80, 0x3E, 0x3E, 0x7C,
  0x01, 0xF1, 0xF3, 0xC0, 0x0F, 0x8F, 0x3E, 0x3C, 0x7C, 0xF9, 0xE7, 0xFB,
  0xE7, 0x9E, 0x7F, 0xCF, 0xFD, 0xF3, 0xFF, 0x7F, 0xCF, 0x3E, 0xFB, 0xFC,
  0xF9, 0xE3, 0xC7, 0xC7, 0x9F, 0x1E, 0x00, 0x78, 0xF0, 0xF0, 0x07, 0xC7,
  0x8F, 0x80, 0x3C, 0x7C, 0x7C, 0x03, 0xE3, 0xC3, 0xC0, 0x1E, 0x1E, 0x1E,
  0x01, 0xE0, 0xF1, 0xF0, 0x1F, 0x07, 0x8F, 0x80, 0xF0, 0x3C, 0x78, 0x0F,
  0x81, 0xFF, 0xC0, 0x78, 0x0F, 0xFC, 0x07, 0x80, 0x3F, 0xC0, 0x7C, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xF0, 0x01, 0xF1, 0xF0, 0x03, 0xF1, 0xF0, 0x03, 0xE1, 0xF0, 0x03,
  0xE1, 0xF0, 0x03, 0xE3, 0xF0, 0x03, 0xE3, 0xE0, 0x03, 0xF7, 0xE0, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07,
  0xFC, 0x1F, 0x0F, 0xFE, 0x3F, 0x1F, 0xFE, 0x3E, 0x3F, 0x7F, 0x7E, 0x3F,
  0x3F, 0x7C, 0x7E, 0x3F, 0xFC, 0x7E, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0xFC,
  0x0F, 0xF0, 0xFC, 0x0F, 0xE0, 0xFE, 0x1F, 0xE0, 0x7F, 0x7F, 0xF0, 0x7F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFD, 0xF8, 0x1F, 0xF1, 0xFC, 0x3F,
  0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0xF8, 0xF8, 0x00, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x03,
  0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x30, 0xF0, 0x0F, 0x3C, 0x07,
  0xFF, 0x3D, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xF0, 0x3F, 0xFC, 0x3F,
  0xC0, 0x1F, 0xF8, 0x0F, 0xDE, 0x07, 0xF7, 0xC0, 0xF8, 0xF8, 0x0C, 0x3E,
  0x01, 0x0E, 0x00, 0x02, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x0F, 0xC7, 0xE1, 0xF8, 0x7E, 0x3F, 0x0F,
  0xC3, 0xE1, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFC, 0x08, 0xFD, 0xFF, 0xFF, 0xFF, 0x9F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xFE,
  0x1F, 0xCF, 0xC3, 0xF1, 0xF8, 0xFC, 0x3F, 0x1F, 0x87, 0xE7, 0xE0, 0xFC,
  0xFC, 0x1F, 0x9F, 0x83, 0xF7, 0xE0, 0x7E, 0xFC, 0x0F, 0xDF, 0x81, 0xFB,
  0xF0, 0x7E, 0x7C, 0x0F, 0xDF, 0x81, 0xFB, 0xF0, 0x3F, 0x7E, 0x07, 0xCF,
  0xC1, 0xF9, 0xF8, 0x3F, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0xFC, 0x7F, 0x1F,
  0x8F, 0xC3, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x07,
  0xF0, 0x00, 0x00, 0x3E, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0xC3,
  0xFF, 0x8F, 0xFF, 0x3F, 0xFC, 0xFE, 0xF8, 0xFB, 0xF0, 0xC7, 0xE1, 0x0F,
  0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xE0,
  0x7F, 0xFF, 0x83, 0xF1, 0xFC, 0x0E, 0x07, 0xE0, 0x20, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0,
  0x38, 0x3F, 0x02, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x3F, 0xF8, 0x03, 0xFE,
  0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x80,
  0x1F, 0x8C, 0x03, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F,
  0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xEF,
  0xC0, 0x1E, 0x7E, 0x01, 0xF3, 0xE0, 0x1F, 0x1F, 0x00, 0xF0, 0xF8, 0x0F,
  0x8F, 0xC0, 0xF8, 0x7E, 0x07, 0x83, 0xE0, 0x78, 0x1F, 0x07, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0x7F, 0xC0,
  0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x80, 0x3F, 0x86, 0x03, 0xFC, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFC, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF3, 0xE0, 0x3F, 0x7F, 0x03, 0xEF, 0xF8,
  0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0x1F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F,
  0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1,
  0xF8, 0xFC, 0x1F, 0x87, 0xE3, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x3F,
  0xFC, 0x03, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x00, 0x7F,
  0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0x7F, 0x03, 0xE0, 0xFC, 0x3F, 0x07, 0xE1,
  0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0xF8, 0x0F, 0xDF,
  0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x0F,
  0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xE7, 0xE0, 0xFE, 0x1F, 0x87, 0xE0, 0xFC,
  0x3E, 0x07, 0xE3, 0xF0, 0x1F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0,
  0x7E, 0x1F, 0x8F, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x07, 0xFF,
  0xE0, 0xFF, 0xFC, 0x3F, 0x9F, 0xC7, 0xE1, 0xF9, 0xF8, 0x3F, 0x3F, 0x07,
  0xE7, 0xE0, 0xFC, 0xF8, 0x1F, 0xBF, 0x03, 0xF7, 0xE0, 0xFE, 0xFC, 0x1F,
  0x9F, 0xC7, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0x7F, 0xBE,
  0x07, 0xEF, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x3F, 0x83, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x01,
  0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x03, 0xC0, 0xF8, 0x3F, 0x87, 0xF0, 0xFE,
  0x1F, 0x81, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x01, 0xF8, 0x3F, 0x0F, 0xE1, 0xFC, 0x3F,
  0x03, 0xE0, 0x00, 0xF0, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF0, 0x0F,
  0x80, 0x78, 0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x7F,
  0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F,
  0xE0, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x07,
  0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x1C,
  0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0x80,
  0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0xFF,
  0xC0, 0x1F, 0xC0, 0x03, 0xE0, 0x00, 0x70, 0x00, 0x08, 0x00, 0x00, 0x07,
  0xF8, 0x1F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFF, 0x38, 0x3F, 0x20,
  0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x00, 0xF8, 0x0F,
  0x80, 0x03, 0xC0, 0xF8, 0x00, 0x0F, 0x0F, 0x81, 0xF0, 0x78, 0x78, 0x3F,
  0xF3, 0xC7, 0x83, 0xFF, 0x1E, 0x3C, 0x3F, 0xF8, 0xF3, 0xC3, 0xC3, 0xC7,
  0x9E, 0x3E, 0x3E, 0x3D, 0xF1, 0xE1, 0xE1, 0xEF, 0x1F, 0x0F, 0x0F, 0x78,
  0xF0, 0x78, 0x7B, 0xC7, 0x87, 0xC7, 0x9E, 0x3C, 0x3C, 0x3D, 0xE1, 0xE1,
  0xE1, 0xEF, 0x1F, 0x1F, 0x1E, 0x78, 0xF8, 0xF8, 0xF3, 0xC3, 0xCF, 0xCF,
  0x1E, 0x1F, 0xEF, 0xF0, 0xF0, 0xFF, 0x7F, 0x83, 0xC3, 0xE1, 0xF0, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x08, 0x00, 0x7E, 0x01, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x05, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x7C,
  0xF8, 0x00, 0xF9, 0xF0, 0x03, 0xF3, 0xE0, 0x07, 0xC7, 0xC0, 0x1F, 0x8F,
  0x80, 0x3E, 0x1F, 0x00, 0xFC, 0x3E, 0x01, 0xF8, 0x7C, 0x07, 0xE0, 0xF8,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x07, 0xE0, 0x3E, 0x1F, 0x80, 0x7C, 0x3F, 0x00, 0xF8, 0xFC,
  0x01, 0xF1, 0xF8, 0x03, 0xE3, 0xF0, 0x07, 0xEF, 0xC0, 0x0F, 0xFF, 0x80,
  0x1F, 0x80, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0x87, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0xC3, 0xF0, 0x7E, 0x0F,
  0xC7, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x7E, 0x3F, 0x81, 0xF8, 0x3F, 0x07, 0xC0, 0xFC, 0x3F, 0x03, 0xF0,
  0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3E, 0x07, 0xF1, 0xF8,
  0x3F, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xF8,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xC1, 0xC0, 0xFE, 0x02, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xFC, 0x0C, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xF7, 0xFE,
  0x07, 0xE0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F,
  0x07, 0xE0, 0x7F, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x7E,
  0x0F, 0xC0, 0x7E, 0x0F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0xFE,
  0x1F, 0x80, 0xFE, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0x01, 0xF8,
  0x3F, 0x03, 0xF8, 0x3F, 0x07, 0xF0, 0x3F, 0x0F, 0xF0, 0x7E, 0x3F, 0xE0,
  0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0xFF, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC,
  0x07, 0xFF, 0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC0, 0xFF, 0x07, 0x83, 0xF8, 0x02, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xFE, 0x7F, 0x0F, 0xFC, 0xFC, 0x1F, 0xF9,
  0xF8, 0x3F, 0xF3, 0xF0, 0x7F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F,
  0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF0, 0xFE, 0x07, 0xE1, 0xFE,
  0x0F, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x03, 0xFF,
  0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0xFC, 0x03, 0xF0,
  0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x00,
  0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x3F, 0x00, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFE, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x47, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x0F, 0xF0, 0x00, 0x01, 0xF0, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x3F,
  0x03, 0xF0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0xFE, 0x00, 0xF8, 0x3F, 0x00,
  0x7E, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x07, 0xE7, 0xF0, 0x01, 0xF9, 0xF8,
  0x00, 0x7C, 0xFC, 0x00, 0x3F, 0x7F, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7E, 0x7C, 0x00, 0x3F, 0x1F, 0x80,
  0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3E, 0x0F,
  0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E,
  0x07, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0x01,
  0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0xE0,
  0x7F, 0x80, 0x1F, 0xF0, 0x3F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xC1, 0xF7,
  0xC0, 0xFB, 0xE0, 0xFF, 0xE0, 0x7D, 0xF0, 0xFB, 0xF0, 0x3E, 0xF8, 0x7D,
  0xF0, 0x1F, 0x7C, 0x7C, 0xF8, 0x1F, 0xBE, 0x3E, 0xFC, 0x0F, 0x9F, 0x3E,
  0x7E, 0x07, 0xCF, 0x9F, 0x3E, 0x03, 0xE7, 0xDF, 0x1F, 0x03, 0xF3, 0xEF,
  0x8F, 0x81, 0xF8, 0xF7, 0x8F, 0xC0, 0xF8, 0x7F, 0xC7, 0xE0, 0x7C, 0x3F,
  0xC3, 0xE0, 0x3E, 0x1F, 0xE1, 0xF0, 0x3F, 0x0F, 0xE0, 0xF8, 0x1F, 0x87,
  0xF0, 0xFC, 0x0F, 0x83, 0xF8, 0x7E, 0x07, 0xC1, 0xF8, 0x3E, 0x03, 0xE0,
  0xFC, 0x1F, 0x03, 0xF0, 0x7C, 0x1F, 0x80, 0x01, 0xF8, 0x03, 0xF0, 0x3F,
  0xC0, 0x3E, 0x03, 0xFC, 0x03, 0xE0, 0x3F, 0xC0, 0x3E, 0x03, 0xFC, 0x07,
  0xE0, 0x3F, 0xC0, 0x7E, 0x07, 0xFE, 0x07, 0xC0, 0x7F, 0xE0, 0x7C, 0x07,
  0xFE, 0x07, 0xC0, 0x7F, 0xE0, 0xFC, 0x07, 0xFF, 0x0F, 0xC0, 0xFF, 0xF0,
  0xF8, 0x0F, 0x9F, 0x0F, 0x80, 0xF9, 0xF0, 0xF8, 0x0F, 0x9F, 0x1F, 0x80,
  0xF9, 0xF9, 0xF0, 0x1F, 0x8F, 0x9F, 0x01, 0xF0, 0xF9, 0xF0, 0x1F, 0x0F,
  0x9F, 0x01, 0xF0, 0xFF, 0xF0, 0x3F, 0x0F, 0xFE, 0x03, 0xF0, 0x7F, 0xE0,
  0x3E, 0x07, 0xFE, 0x03, 0xE0, 0x7F, 0xE0, 0x3E, 0x07, 0xFE, 0x07, 0xE0,
  0x3F, 0xC0, 0x7E, 0x03, 0xFC, 0x07, 0xC0, 0x3F, 0xC0, 0x7C, 0x03, 0xFC,
  0x07, 0xC0, 0x3F, 0xC0, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFE,
  0x3F, 0xC3, 0xF8, 0x3F, 0x8F, 0xE0, 0x3F, 0x1F, 0x80, 0x7E, 0x7F, 0x00,
  0xFC, 0xFC, 0x01, 0xFB, 0xF8, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F,
  0xDF, 0x80, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFB,
  0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xEF, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x3F,
  0x00, 0xFE, 0x7E, 0x03, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x1F, 0xC1, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7E, 0x3F, 0xC1, 0xF8, 0x3F, 0x83, 0xF0,
  0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x01, 0xF8, 0x7E, 0x07,
  0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x3F, 0x83, 0xF0, 0xFE, 0x07, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0xFF, 0xF0, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFE,
  0x3F, 0xC3, 0xF8, 0x3F, 0x8F, 0xE0, 0x3F, 0x1F, 0x80, 0x7E, 0x7F, 0x00,
  0xFC, 0xFC, 0x01, 0xFB, 0xF8, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F,
  0xDF, 0x80, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFB,
  0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xEF, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x3F,
  0x00, 0xFE, 0x7E, 0x03, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x3F, 0xC1, 0xFF,
  0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xF8,
  0x0F, 0x87, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7C, 0x0F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F,
  0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01,
  0xFF, 0xF0, 0x07, 0xCF, 0xC0, 0x3F, 0x1F, 0x00, 0xFC, 0x7E, 0x03, 0xF1,
  0xF8, 0x0F, 0xC7, 0xE0, 0x3E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x07, 0xE1, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x00,
  0x00, 0x3F, 0xC0, 0x07, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFF, 0x07, 0xF8, 0xF0, 0x3F, 0x80, 0x81, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0xC0, 0x3F, 0x87, 0x83, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7, 0xFF, 0xFD, 0xFF, 0xFF,
  0x80, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E,
  0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC,
  0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x01, 0xF8,
  0x3F, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0,
  0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0xFC, 0x03, 0xF0,
  0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x0F, 0xE0,
  0xFC, 0x0F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80,
  0x7F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x3E, 0x7E, 0x03,
  0xF3, 0xF0, 0x1F, 0x9F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0xFC, 0x3F,
  0x07, 0xE1, 0xF8, 0x3E, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x03, 0xF1, 0xF8,
  0x1F, 0x8F, 0x80, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x1F, 0x7E, 0x00, 0xFB,
  0xF0, 0x07, 0xDF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0x7C, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xBE,
  0x01, 0xF8, 0x0F, 0xDF, 0x00, 0xFC, 0x07, 0xEF, 0x80, 0xFE, 0x07, 0xE7,
  0xC0, 0x7F, 0x03, 0xF3, 0xE0, 0x3F, 0x81, 0xF1, 0xF0, 0x3F, 0x81, 0xF8,
  0xF8, 0x1F, 0xC0, 0xFC, 0x7C, 0x1F, 0xE0, 0xFC, 0x3E, 0x0F, 0xF0, 0x7E,
  0x1F, 0x0F, 0xF8, 0x3E, 0x0F, 0x87, 0xFC, 0x3F, 0x07, 0xC3, 0xDE, 0x1F,
  0x83, 0xE3, 0xEF, 0x1F, 0x81, 0xF1, 0xF7, 0x8F, 0xC0, 0xF9, 0xF3, 0xC7,
  0xC0, 0x7C, 0xF9, 0xE7, 0xE0, 0x3E, 0x78, 0xF3, 0xE0, 0x1F, 0x7C, 0x79,
  0xF0, 0x0F, 0xBE, 0x3D, 0xF8, 0x07, 0xFE, 0x1E, 0xF8, 0x03, 0xFF, 0x0F,
  0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xC1,
  0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xE0,
  0x3F, 0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xF8,
  0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x81, 0xFC, 0x03, 0xF0,
  0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x00, 0xF8, 0x7E, 0x00,
  0x1F, 0x9F, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xDF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFC, 0xF8, 0x00, 0x3F, 0x1F, 0x80,
  0x07, 0xE3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xC0,
  0xFC, 0x03, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x3F, 0x80, 0x7E, 0x00,
  0xFC, 0x03, 0xFF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0xFC, 0x7C, 0x1F,
  0x87, 0xC1, 0xF8, 0x7C, 0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x7E, 0x07, 0xE7,
  0xE0, 0x3E, 0xFC, 0x03, 0xEF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F,
  0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0xF8, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x7C,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07,
  0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3E, 0x78, 0x07, 0xC7,
  0xC0, 0x7C, 0x7C, 0x0F, 0x87, 0xC0, 0xF0, 0x3C, 0x1F, 0x03, 0xE3, 0xE0,
  0x3E, 0x3E, 0x01, 0xE7, 0xC0, 0x1E, 0xF8, 0x01, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFE, 0x7E, 0x7E, 0x3E, 0x1F, 0x1F, 0x0F, 0x00, 0xF0,
  0x08, 0x1F, 0xCF, 0x81, 0xFF, 0x7C, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F,
  0xE7, 0xF8, 0xFE, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xE3, 0xF0, 0x3F,
  0x1F, 0x81, 0xF0, 0xFC, 0x0F, 0x87, 0xC0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0,
  0x3F, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x0F, 0xE1,
  0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xEF, 0x80, 0xFF, 0x7C, 0x07, 0xE3,
  0xE0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x78, 0x07, 0xDF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x0F, 0xE3, 0xF0, 0xFC, 0x3F, 0x1F, 0x81, 0xF1, 0xF8, 0x1F, 0x1F, 0x81,
  0xF1, 0xF0, 0x3F, 0x1F, 0x03, 0xF3, 0xF0, 0x3F, 0x3F, 0x03, 0xF3, 0xF0,
  0x3E, 0x3F, 0x07, 0xE3, 0xE0, 0x7E, 0x7F, 0x0F, 0xC7, 0xF0, 0xFC, 0x7F,
  0x9F, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xBF, 0xE0, 0xF9, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xF0, 0xFE,
  0x10, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x82, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0xFF,
  0xE0, 0x3F, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x03, 0xC7, 0xE0, 0x3F, 0x9F, 0x01, 0xFF, 0x7C,
  0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xF8, 0xFE, 0x0F, 0xE1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x81, 0xF0, 0x7E, 0x07,
  0xC1, 0xF0, 0x1F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xE0, 0xFE, 0x7F, 0x81, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xF7, 0xC0, 0x1F, 0x9F, 0x00, 0x00, 0x7C,
  0x00, 0x7F, 0xC0, 0x7F, 0xF8, 0x3F, 0xFF, 0x0F, 0xEF, 0xC7, 0xE1, 0xF3,
  0xF0, 0x7C, 0xFC, 0x1F, 0x3E, 0x0F, 0xDF, 0x87, 0xE7, 0xFF, 0xF9, 0xFF,
  0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x21, 0xF8, 0x38, 0x7F, 0xFE, 0x0F, 0xFF, 0x83,
  0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0x80, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x02, 0x01,
  0xFC, 0xF8, 0x07, 0xFD, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFE,
  0x7F, 0x83, 0xF8, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x3F, 0x03,
  0xF0, 0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0x81, 0xF8, 0x3F, 0x07, 0xE0, 0x7E,
  0x0F, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x1F, 0xC0,
  0xFC, 0x3F, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x03, 0xFE, 0xF8, 0x07,
  0xFF, 0xF0, 0x07, 0xE7, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x0C, 0x03, 0xF0, 0x1F, 0xBF, 0xE0, 0x3F, 0xFF,
  0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x78, 0x07,
  0xDF, 0xE0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xE3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF1, 0xF8, 0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0x3F,
  0x1F, 0x03, 0xE3, 0xF0, 0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x3E, 0x07,
  0xE3, 0xE0, 0x7C, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xC0,
  0xF8, 0x7C, 0x0F, 0x8F, 0xC1, 0xF8, 0xFC, 0x1F, 0x80, 0x00, 0xE0, 0x1F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xFC, 0x00, 0x00,
  0x07, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x07,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x1F, 0xC1, 0xF0, 0x7E, 0x0F, 0xC3, 0xF0, 0x3F, 0x1F, 0x80, 0xF8, 0xFC,
  0x03, 0xE7, 0xE0, 0x0F, 0x9F, 0x80, 0x7E, 0xFC, 0x01, 0xF7, 0xE0, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x3F, 0x7E, 0x00, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0,
  0x7C, 0x1F, 0x01, 0xF0, 0x7E, 0x07, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x07, 0x80, 0xF0,
  0x0F, 0x3F, 0xC7, 0xF0, 0x1E, 0xFF, 0x9F, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xE1, 0xFC, 0x7F, 0x9F, 0xC3, 0xF0, 0xFE, 0x1F, 0x8F,
  0xE1, 0xF8, 0x3E, 0x1F, 0x83, 0xF0, 0x7C, 0x3F, 0x07, 0xC0, 0xF8, 0x7C,
  0x0F, 0x83, 0xF0, 0xF8, 0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x0F, 0x87, 0xE0,
  0xFC, 0x1F, 0x0F, 0xC1, 0xF0, 0x7E, 0x1F, 0x03, 0xE0, 0xFC, 0x3E, 0x0F,
  0xC1, 0xF8, 0xFC, 0x1F, 0x83, 0xE1, 0xF8, 0x3E, 0x07, 0xC3, 0xF0, 0x7C,
  0x1F, 0x87, 0xC0, 0xF8, 0x3F, 0x0F, 0x83, 0xF0, 0x7E, 0x3F, 0x07, 0xE0,
  0xF8, 0x7E, 0x0F, 0x83, 0xF0, 0x00, 0x07, 0x80, 0x78, 0xFE, 0x07, 0xBF,
  0xE0, 0xFB, 0xFF, 0x0F, 0xFF, 0xF0, 0xFE, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x1F, 0x83, 0xF1, 0xF0, 0x3E, 0x3F,
  0x03, 0xE3, 0xF0, 0x7E, 0x3F, 0x07, 0xE3, 0xE0, 0x7E, 0x3E, 0x07, 0xC7,
  0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7C, 0x0F, 0x87, 0xC0, 0xF8,
  0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE,
  0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0x1F, 0x8F, 0xC1, 0xF9, 0xF8, 0x3F,
  0x7E, 0x07, 0xEF, 0xC0, 0xFD, 0xF8, 0x1F, 0xBE, 0x03, 0xFF, 0xC0, 0x7D,
  0xF8, 0x0F, 0xBF, 0x03, 0xF7, 0xE0, 0x7E, 0xFC, 0x1F, 0x9F, 0x83, 0xF3,
  0xF0, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFE, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xE0, 0x07, 0x9F, 0xE0, 0x1E, 0xFF, 0x80, 0xFB,
  0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xE3, 0xF0, 0x3F, 0x07, 0xC0, 0xF8, 0x1F,
  0x07, 0xE0, 0x7C, 0x1F, 0x81, 0xF0, 0x7C, 0x0F, 0xC1, 0xF0, 0x3F, 0x0F,
  0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0x81,
  0xF8, 0x7F, 0x0F, 0xC1, 0xFC, 0x7F, 0x07, 0xFB, 0xF8, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x03, 0xF7, 0xF8, 0x0F, 0xCF, 0xC0, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x08, 0x1F, 0xE7, 0x81, 0xFF, 0x7C, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x0F, 0xC7, 0xF8, 0xFE, 0x1F, 0x87, 0xE0, 0xFC, 0x3E, 0x07, 0xE3,
  0xF0, 0x3F, 0x1F, 0x81, 0xF0, 0xFC, 0x0F, 0x87, 0xC0, 0x7C, 0x7E, 0x07,
  0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x3F,
  0x0F, 0xE1, 0xFE, 0xFF, 0x0F, 0xFF, 0xF0, 0x3F, 0xEF, 0x81, 0xFF, 0xFC,
  0x07, 0xE7, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x47, 0x83, 0xCF, 0xC1, 0xE7,
  0xE1, 0xF7, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xC0, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x03,
  0xFF, 0x83, 0xFF, 0xE3, 0xFF, 0xE1, 0xFF, 0xF0, 0xFC, 0x10, 0x7C, 0x00,
  0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x20,
  0x3F, 0x1F, 0x7F, 0x8F, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0x80,
  0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x1F, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF1, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03,
  0xE0, 0x1F, 0x90, 0xFF, 0x87, 0xFC, 0x3F, 0xE0, 0xFF, 0x00, 0x0F, 0x81,
  0xF1, 0xF8, 0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x1F, 0x03, 0xE1, 0xF0,
  0x3E, 0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x3F, 0x07, 0xC3, 0xE0, 0x7C, 0x3E,
  0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xC0, 0xF8, 0x7C, 0x1F, 0x87,
  0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC3, 0xF8, 0xFE, 0xFF, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x07, 0xFD, 0xF0, 0x3F, 0x9F, 0x00, 0xFC, 0x07, 0xEF, 0x81,
  0xF9, 0xF0, 0x3F, 0x3E, 0x0F, 0xC7, 0xC1, 0xF8, 0xF8, 0x3E, 0x1F, 0x0F,
  0xC3, 0xE1, 0xF0, 0x7C, 0x7E, 0x0F, 0x8F, 0x81, 0xF3, 0xF0, 0x3E, 0x7C,
  0x07, 0xDF, 0x80, 0xFB, 0xE0, 0x1F, 0x7C, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x3F, 0x83, 0xFF, 0x83, 0xF8, 0x7E, 0xF8, 0x7F,
  0x87, 0xEF, 0x87, 0xF8, 0x7C, 0xF8, 0x7F, 0x8F, 0xCF, 0x8F, 0xF8, 0xF8,
  0xF8, 0xFF, 0x8F, 0x8F, 0x9F, 0xF1, 0xF0, 0xF9, 0xEF, 0x1F, 0x0F, 0x9E,
  0xF3, 0xF0, 0xFB, 0xEF, 0x3E, 0x0F, 0xBC, 0xF3, 0xE0, 0xFF, 0xCF, 0x7C,
  0x0F, 0xF8, 0xF7, 0xC0, 0xF7, 0x8F, 0x7C, 0x0F, 0xF8, 0xFF, 0x80, 0xFF,
  0x0F, 0xF8, 0x0F, 0xF0, 0xFF, 0x00, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0xFE,
  0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xC0, 0xFE, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0xFE, 0x07, 0xC1, 0xF8, 0x0F, 0xC7, 0xE0, 0x1F, 0x9F, 0x80,
  0x3F, 0x3F, 0x00, 0x3E, 0xFC, 0x00, 0x7D, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xDF,
  0x00, 0x1F, 0x3F, 0x00, 0x7E, 0x7E, 0x01, 0xF8, 0x7C, 0x03, 0xF0, 0xFC,
  0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x3F, 0x03, 0xE0,
  0x7E, 0x03, 0xE0, 0x7E, 0x03, 0xE0, 0xFC, 0x03, 0xE0, 0xFC, 0x03, 0xE0,
  0xF8, 0x03, 0xE1, 0xF8, 0x03, 0xE1, 0xF0, 0x03, 0xE3, 0xF0, 0x03, 0xE3,
  0xE0, 0x03, 0xE7, 0xE0, 0x03, 0xE7, 0xC0, 0x01, 0xE7, 0xC0, 0x01, 0xEF,
  0x80, 0x01, 0xEF, 0x80, 0x01, 0xEF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xC1, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFE, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x07, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F,
  0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFF,
  0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xC0, 0x01, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x03, 0xFC,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0x00, 0x7F, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0xFF, 0x00, 0xFF, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x2F, 0xF8, 0x0F, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xA0, 0x0F, 0xE0,
};

const GFXglyph NotoSans_Condensed_BoldItalic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 13, 31, 11, 0, -31 },
  { 52, 15, 11, 18, 4, -31 },
  { 73, 24, 31, 23, 0, -31 },
  { 166, 21, 36, 20, 0, -33 },
  { 261, 29, 31, 32, 2, -31 },
  { 374, 24, 31, 25, 0, -31 },
  { 467, 8, 11, 11, 4, -31 },
  { 478, 15, 38, 13, 1, -31 },
  { 550, 15, 38, 13, -3, -31 },
  { 622, 18, 19, 19, 3, -33 },
  { 665, 18, 21, 21, 2, -26 },
  { 713, 10, 12, 11, -2, -6 },
  { 728, 11, 5, 13, 1, -14 },
  { 735, 7, 7, 11, 0, -7 },
  { 742, 22, 31, 17, -2, -31 },
  { 828, 19, 31, 20, 1, -31 },
  { 902, 15, 31, 20, 4, -31 },
  { 961, 21, 31, 20, -1, -31 },
  { 1043, 20, 31, 20, 0, -31 },
  { 1121, 21, 31, 20, -1, -31 },
  { 1203, 21, 31, 20, 0, -31 },
  { 1285, 20, 31, 20, 1, -31 },
  { 1363, 21, 31, 20, 1, -31 },
  { 1445, 21, 31, 20, 0, -31 },
  { 1527, 19, 31, 20, 1, -31 },
  { 1601, 11, 24, 11, 0, -24 },
  { 1634, 13, 30, 11, -2, -24 },
  { 1683, 18, 21, 21, 2, -26 },
  { 1731, 18, 13, 21, 2, -22 },
  { 1761, 19, 21, 21, 2, -26 },
  { 1811, 16, 31, 16, 2, -31 },
  { 1873, 29, 35, 31, 1, -31 },
  { 2000, 23, 31, 22, -3, -31 },
  { 2090, 22, 31, 22, 0, -31 },
  { 2176, 22, 31, 21, 2, -31 },
  { 2262, 24, 31, 24, 0, -31 },
  { 2355, 21, 31, 19, 0, -31 },
  { 2437, 21, 31, 18, 0, -31 },
  { 2519, 23, 31, 25, 2, -31 },
  { 2609, 26, 31, 25, 0, -31 },
  { 2710, 19, 31, 14, -2, -31 },
  { 2784, 20, 40, 12, -7, -31 },
  { 2884, 26, 31, 22, 0, -31 },
  { 2985, 16, 31, 18, 0, -31 },
  { 3047, 33, 31, 32, 0, -31 },
  { 3175, 28, 31, 27, 0, -31 },
  { 3284, 23, 31, 26, 2, -31 },
  { 3374, 23, 31, 22, 0, -31 },
  { 3464, 23, 38, 26, 2, -31 },
  { 3574, 22, 31, 22, 0, -31 },
  { 3660, 21, 31, 19, 0, -31 },
  { 3742, 19, 31, 19, 3, -31 },
  { 3816, 24, 31, 24, 2, -31 },
  { 3909, 21, 31, 22, 4, -31 },
  { 3991, 33, 31, 33, 3, -31 },
  { 4119, 27, 31, 21, -3, -31 },
  { 4224, 20, 31, 20, 4, -31 },
  { 4302, 23, 31, 19, -2, -31 },
  { 4392, 17, 38, 13, -1, -31 },
  { 4473, 10, 31, 17, 4, -31 },
  { 4512, 17, 38, 13, -3, -31 },
  { 4593, 20, 19, 20, 0, -31 },
  { 4641, 15, 3, 15, -4, 4 },
  { 4647, 8, 7, 13, 6, -33 },
  { 4654, 21, 24, 22, 1, -24 },
  { 4717, 20, 33, 22, 0, -33 },
  { 4800, 17, 24, 17, 1, -24 },
  { 4851, 22, 33, 22, 1, -33 },
  { 4942, 18, 24, 20, 1, -24 },
  { 4996, 23, 43, 13, -5, -33 },
  { 5120, 23, 34, 22, -1, -24 },
  { 5218, 20, 33, 22, 0, -33 },
  { 5301, 12, 33, 11, 0, -33 },
  { 5351, 17, 43, 11, -5, -33 },
  { 5443, 22, 33, 20, 0, -33 },
  { 5534, 13, 33, 11, 0, -33 },
  { 5588, 31, 24, 32, 0, -24 },
  { 5681, 20, 24, 22, 0, -24 },
  { 5741, 19, 24, 21, 1, -24 },
  { 5798, 22, 34, 22, -2, -24 },
  { 5892, 21, 34, 22, 1, -24 },
  { 5982, 17, 24, 15, 0, -24 },
  { 6033, 17, 24, 17, 0, -24 },
  { 6084, 13, 28, 14, 2, -28 },
  { 6130, 20, 23, 21, 1, -23 },
  { 6188, 19, 23, 19, 2, -23 },
  { 6243, 28, 23, 29, 3, -23 },
  { 6324, 23, 23, 19, -2, -23 },
  { 6391, 24, 33, 19, -3, -23 },
  { 6490, 18, 23, 16, -1, -23 },
  { 6542, 18, 38, 15, 0, -31 },
  { 6628, 4, 43, 18, 7, -33 },
  { 6650, 16, 38, 15, -2, -31 },
  { 6726, 19, 7, 21, 2, -19 },
};

const GFXfont NotoSans_Condensed_BoldItalic43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BoldItalic43pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BoldItalic43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_CONDENSED_BOLDITALIC43PT7B_H_
