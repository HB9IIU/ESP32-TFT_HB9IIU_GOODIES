#ifndef _NOTOSANS_CONDENSED_BOLDITALIC57PT7B_H_
#define _NOTOSANS_CONDENSED_BOLDITALIC57PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BoldItalic.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BoldItalic57pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x1F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFE, 0x00, 0x7E, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xC7, 0xF9, 0xFE, 0x3F,
  0x8F, 0xF1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC7, 0xF0, 0xFC,
  0x3F, 0x87, 0xE1, 0xFC, 0x7F, 0x0F, 0xC3, 0xF8, 0x7E, 0x1F, 0x83, 0xF0,
  0xFC, 0x1F, 0x87, 0xE1, 0xF8, 0x3E, 0x0F, 0xC3, 0xF0, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3F,
  0x07, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x7E, 0x0F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFE, 0x10, 0xFC, 0x3F, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3E, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFE, 0x01, 0xFE, 0xE3, 0xC0, 0x3F, 0x9C, 0x10, 0x0F, 0xF3,
  0x80, 0x01, 0xFC, 0x70, 0x00, 0x3F, 0xCC, 0x00, 0x07, 0xFB, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0x7F,
  0x80, 0x00, 0xEF, 0xF0, 0x00, 0x18, 0xFE, 0x00, 0x07, 0x1F, 0xC3, 0x00,
  0xE7, 0xF8, 0x70, 0x1C, 0xFF, 0x0F, 0xC3, 0xBF, 0xC1, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x0F, 0xF8, 0x00, 0x3E, 0x00,
  0x7F, 0xF0, 0x01, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xC0, 0x1F, 0xFF, 0x80,
  0x3F, 0x00, 0x7E, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0xF8, 0x07, 0xC0, 0x0F,
  0xC3, 0xE0, 0x3F, 0x00, 0x3E, 0x0F, 0x81, 0xF8, 0x01, 0xF8, 0x3E, 0x07,
  0xE0, 0x07, 0xE1, 0xF8, 0x3F, 0x00, 0x1F, 0x07, 0xE0, 0xF8, 0x00, 0x7C,
  0x1F, 0x87, 0xE0, 0x03, 0xF0, 0x7E, 0x3F, 0x00, 0x0F, 0xC1, 0xF0, 0xFC,
  0x00, 0x3F, 0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0x3F, 0x1F, 0x07, 0xC3, 0xF1,
  0xF8, 0xFC, 0x7F, 0xCF, 0xC7, 0xE7, 0xE3, 0xFF, 0xBF, 0x3F, 0x1F, 0x9F,
  0xFE, 0xFF, 0xFC, 0xFC, 0xFF, 0xFD, 0xFF, 0xE3, 0xE3, 0xF3, 0xF7, 0xFF,
  0x1F, 0x9F, 0x8F, 0xCF, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0xC3, 0xF3, 0xF0,
  0xFC, 0x00, 0x1F, 0x8F, 0xC3, 0xF0, 0x00, 0x7C, 0x3F, 0x0F, 0xC0, 0x03,
  0xF1, 0xF8, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0xFC, 0x00, 0x7E, 0x1F, 0x83,
  0xE0, 0x03, 0xF0, 0x7E, 0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x7E, 0x00, 0x7E,
  0x07, 0xC1, 0xF8, 0x03, 0xF0, 0x1F, 0x0F, 0xC0, 0x0F, 0xC0, 0x7C, 0x3F,
  0x00, 0x7E, 0x01, 0xF9, 0xF8, 0x03, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xC0,
  0x1F, 0xFF, 0x00, 0x7E, 0x00, 0x3F, 0xF8, 0x01, 0xF8, 0x00, 0xFF, 0xC0,
  0x0F, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE,
  0x3F, 0x80, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x7F, 0x03, 0xFF,
  0xE0, 0xFF, 0x07, 0xFF, 0xF0, 0xFE, 0x0F, 0xFF, 0xF0, 0xFE, 0x1F, 0xE7,
  0xF9, 0xFC, 0x3F, 0xC7, 0xF9, 0xFC, 0x3F, 0x83, 0xFF, 0xF8, 0x7F, 0x83,
  0xFF, 0xF8, 0x7F, 0x83, 0xFF, 0xF0, 0x7F, 0x01, 0xFF, 0xF0, 0x7F, 0x01,
  0xFF, 0xE0, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0x80,
  0xFF, 0x80, 0x7F, 0x83, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0x8F, 0xF8, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x60, 0x00, 0x00, 0x3F, 0x9F,
  0xDF, 0xEF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFC, 0x7E, 0x7F, 0x3F, 0x9F, 0x8F,
  0xC7, 0xE3, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x04, 0x0F, 0xC0, 0x1E, 0x1F, 0x80, 0x3F, 0x3F, 0x00, 0x7F, 0x7C, 0x0D,
  0xFF, 0xFB, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F,
  0xBE, 0x00, 0xFF, 0x7E, 0x03, 0xFC, 0xFE, 0x03, 0xF0, 0xFC, 0x03, 0xE1,
  0xFC, 0x03, 0x83, 0xF0, 0x02, 0x03, 0x80, 0x00, 0x04, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xF8,
  0x3F, 0xC3, 0xFC, 0x1F, 0xE0, 0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x3F,
  0xC1, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x00, 0x7F,
  0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF,
  0x00, 0x06, 0x1F, 0xDF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xF0,
  0xFE, 0x07, 0xF8, 0x3F, 0x81, 0xFE, 0x0F, 0xE0, 0xFF, 0x03, 0xF8, 0x3F,
  0xC0, 0xFF, 0x1F, 0xE0, 0x3F, 0x87, 0xF8, 0x0F, 0xE1, 0xFC, 0x03, 0xF8,
  0xFF, 0x00, 0xFE, 0x3F, 0xC0, 0x3F, 0x8F, 0xF0, 0x1F, 0xE3, 0xF8, 0x07,
  0xF9, 0xFE, 0x01, 0xFE, 0x7F, 0x80, 0x7F, 0x9F, 0xE0, 0x1F, 0xC7, 0xF8,
  0x0F, 0xF1, 0xFC, 0x03, 0xFC, 0x7F, 0x00, 0xFF, 0x1F, 0xC0, 0x3F, 0xCF,
  0xF0, 0x1F, 0xE3, 0xFC, 0x07, 0xF8, 0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0xFF,
  0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0xC3,
  0xFC, 0x07, 0xF9, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFC,
  0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0xFF, 0xDF, 0xC7, 0xFB, 0xFC, 0x7F, 0x3F,
  0x83, 0xE3, 0xF8, 0x18, 0x3F, 0x81, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFE, 0xFF,
  0xC0, 0x1F, 0x81, 0xFF, 0x00, 0x78, 0x0F, 0xF8, 0x03, 0x80, 0x3F, 0xC0,
  0x08, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xC0, 0x3F, 0xBF, 0xF8, 0x07, 0x01, 0xFF, 0x00, 0x80, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x80, 0x03, 0xFE, 0x10, 0x00, 0xFF, 0x83, 0xC0,
  0x7F, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xDF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xBF, 0x80,
  0x01, 0xFB, 0xF8, 0x00, 0x3F, 0x3F, 0x80, 0x03, 0xE7, 0xF8, 0x00, 0x7E,
  0x7F, 0x00, 0x0F, 0xC7, 0xF0, 0x01, 0xF8, 0x7F, 0x00, 0x1F, 0x87, 0xF0,
  0x03, 0xF0, 0xFF, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0xFC,
  0x0F, 0xE0, 0x1F, 0x81, 0xFE, 0x03, 0xF0, 0x1F, 0xE0, 0x3F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x9E, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x80, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x80, 0x03, 0xFE, 0x1C, 0x00, 0xFF, 0x83, 0xE0, 0x7F, 0xF0,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x14, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFC, 0x18, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0x3F, 0xC0, 0x3F, 0x9F, 0xF8, 0x0F, 0xEF, 0xFE, 0x07, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x1F, 0xF8, 0xFF, 0x8F,
  0xF8, 0x1F, 0xE3, 0xFE, 0x07, 0xF8, 0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0x7F,
  0x8F, 0xF0, 0x1F, 0xE3, 0xF8, 0x07, 0xF8, 0xFE, 0x01, 0xFC, 0x3F, 0x80,
  0xFF, 0x0F, 0xE0, 0x3F, 0xC3, 0xF8, 0x0F, 0xF0, 0xFE, 0x07, 0xF8, 0x3F,
  0xC3, 0xFE, 0x0F, 0xF9, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0,
  0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x81,
  0xFC, 0x07, 0xF0, 0x7F, 0x80, 0xFF, 0x1F, 0xE0, 0x0F, 0xF7, 0xFC, 0x01,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x7F,
  0xDF, 0xE0, 0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFE, 0x03, 0xFC,
  0x3F, 0xC0, 0x7F, 0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x3F, 0xC0,
  0x1F, 0xC7, 0xF8, 0x07, 0xF8, 0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x1F, 0xC1,
  0xFE, 0x07, 0xF8, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0A, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFB,
  0xFE, 0x1F, 0xF0, 0xFF, 0x0F, 0xF0, 0x3F, 0x8F, 0xF0, 0x1F, 0xC7, 0xF8,
  0x0F, 0xE3, 0xFC, 0x07, 0xF1, 0xFC, 0x03, 0xF9, 0xFE, 0x03, 0xFC, 0xFF,
  0x01, 0xFE, 0x7F, 0x80, 0xFF, 0x3F, 0xC0, 0x7F, 0x9F, 0xE0, 0x7F, 0xCF,
  0xF0, 0x3F, 0xE7, 0xFC, 0x3F, 0xF3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFE, 0xFE, 0x03, 0xFC, 0x7F,
  0x00, 0x30, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x20, 0x1F, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF,
  0xF8, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x30, 0x07, 0xE0, 0x3F, 0xC0, 0xFF, 0x07, 0xFC,
  0x1F, 0xF0, 0x7F, 0xC1, 0xFE, 0x03, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x3F, 0x81, 0xFE,
  0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF0, 0x1F, 0x80, 0x18,
  0x00, 0x00, 0x04, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x01, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F,
  0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xF8, 0x7F, 0x83, 0x80, 0xFF, 0x08, 0x03,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xC0, 0x00, 0x7E, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0x0F,
  0xC1, 0xF8, 0x0F, 0xF8, 0x1F, 0x0F, 0xC0, 0xFF, 0xF8, 0x7C, 0x3E, 0x07,
  0xFF, 0xE1, 0xF1, 0xF8, 0x3F, 0xFF, 0x87, 0xC7, 0xC1, 0xFC, 0x7E, 0x1F,
  0x3F, 0x0F, 0xC1, 0xF0, 0x7C, 0xF8, 0x3F, 0x07, 0xC1, 0xF7, 0xE1, 0xF8,
  0x3F, 0x07, 0xDF, 0x87, 0xC0, 0xFC, 0x1F, 0x7C, 0x1F, 0x03, 0xE0, 0xFD,
  0xF0, 0xFC, 0x0F, 0x83, 0xEF, 0xC3, 0xE0, 0x7E, 0x0F, 0xBF, 0x0F, 0x81,
  0xF8, 0x3E, 0xF8, 0x7E, 0x07, 0xC1, 0xFB, 0xE1, 0xF8, 0x3F, 0x07, 0xCF,
  0x87, 0xE0, 0xFC, 0x1F, 0x3E, 0x1F, 0x83, 0xF0, 0xF8, 0xF8, 0x7E, 0x1F,
  0xC7, 0xE3, 0xE1, 0xF8, 0xFF, 0x1F, 0x0F, 0x83, 0xFF, 0xFF, 0xF8, 0x3E,
  0x0F, 0xFF, 0xFF, 0xE0, 0xF8, 0x3F, 0xF3, 0xFF, 0x03, 0xE0, 0x7F, 0x87,
  0xF0, 0x0F, 0xC0, 0x38, 0x0F, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x30, 0x00, 0x1F, 0xE0, 0x07, 0xC0, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xBF, 0x80,
  0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xC7,
  0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0xFF, 0x0F, 0xE0,
  0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x83, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x3F,
  0xC0, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xE1, 0xFE, 0x00, 0xFF, 0x1F, 0xE0, 0x07, 0xF8, 0xFF,
  0x00, 0x3F, 0xCF, 0xF0, 0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xF3, 0xFC, 0x00,
  0x7F, 0xBF, 0xC0, 0x03, 0xFD, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0x81, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0x00,
  0xFF, 0x03, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F,
  0x80, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x3F, 0xE0, 0x1F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFC, 0x1F, 0xF0, 0x0F, 0xE0,
  0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x07,
  0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0x00, 0x7F, 0x81, 0xFC, 0x03, 0xFC,
  0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0xC0, 0xFE, 0x03, 0xFE, 0x03,
  0xF8, 0x7F, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xE0, 0x18, 0x03, 0xFE, 0x00, 0x40, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0xC0, 0x1F, 0xFE, 0x3E, 0x00, 0x7F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0xFF, 0x0F, 0xFE, 0x01, 0xFE, 0x07, 0xFE, 0x03, 0xFC,
  0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0,
  0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0xFF, 0x03, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x07,
  0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xE1, 0xFE, 0x00, 0x7F,
  0xC3, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xFC,
  0x1F, 0xE0, 0x0F, 0xF8, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0xC1,
  0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xFE, 0x07, 0xF0, 0x0F, 0xF8, 0x1F,
  0xE0, 0x3F, 0xF0, 0x3F, 0xC0, 0xFF, 0xC0, 0x7F, 0x87, 0xFF, 0x00, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x38, 0x03, 0xFF,
  0x00, 0x08, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0xFF, 0xF8, 0x7F, 0xC0, 0xFF, 0xF8, 0x7F, 0x80,
  0xFF, 0xF8, 0x7F, 0x81, 0xFF, 0xF0, 0x7F, 0x81, 0xFF, 0xF0, 0x7F, 0x81,
  0xFF, 0xF0, 0x7F, 0x81, 0xFF, 0xF0, 0xFF, 0x80, 0x0F, 0xF0, 0xFF, 0x80,
  0x0F, 0xE0, 0xFF, 0x80, 0x1F, 0xE0, 0xFF, 0x80, 0x1F, 0xE0, 0x7F, 0x80,
  0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xC0, 0x7F, 0xC0,
  0x3F, 0xC0, 0x7F, 0xE0, 0x3F, 0xC0, 0x3F, 0xF8, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F,
  0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x0F, 0xE0, 0x7F, 0xC0, 0x07, 0xF8,
  0x3F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x1F,
  0xC3, 0xFE, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00,
  0xFF, 0x3F, 0xC0, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x0F, 0xE7, 0xF8, 0x00,
  0x03, 0xFB, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x7F,
  0x8F, 0xF0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x01,
  0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC1, 0xFF, 0x00,
  0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0xFF, 0x80, 0x1F, 0xE0, 0x1F, 0xE0, 0x07, 0xF0, 0x07,
  0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xDF, 0xC0, 0x3F,
  0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF,
  0x01, 0xFB, 0xF8, 0x03, 0xF7, 0xF0, 0x3F, 0xBF, 0x80, 0x7F, 0x3F, 0x03,
  0xF7, 0xF8, 0x07, 0xF3, 0xF0, 0x7F, 0x7F, 0x00, 0x7F, 0x3F, 0x07, 0xE7,
  0xF0, 0x07, 0xF3, 0xF0, 0xFE, 0x7F, 0x00, 0xFF, 0x3F, 0x0F, 0xCF, 0xF0,
  0x0F, 0xE3, 0xF1, 0xFC, 0xFE, 0x00, 0xFE, 0x3F, 0x1F, 0x8F, 0xE0, 0x0F,
  0xE3, 0xF3, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x3F, 0x0F, 0xE0, 0x1F, 0xC3,
  0xF3, 0xF1, 0xFE, 0x01, 0xFC, 0x3F, 0x7E, 0x1F, 0xC0, 0x1F, 0xC3, 0xF7,
  0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0xFC, 0x1F, 0xC0, 0x1F, 0xC3, 0xFF, 0xC1,
  0xFC, 0x03, 0xF8, 0x3F, 0xFC, 0x3F, 0xC0, 0x3F, 0x83, 0xFF, 0x83, 0xF8,
  0x03, 0xF8, 0x3F, 0xF8, 0x3F, 0x80, 0x3F, 0x83, 0xFF, 0x03, 0xF8, 0x07,
  0xF8, 0x3F, 0xF0, 0x7F, 0x80, 0x7F, 0x03, 0xFE, 0x07, 0xF0, 0x07, 0xF0,
  0x3F, 0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x3F,
  0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x03, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0xF0, 0x01, 0xFC, 0x01,
  0xFF, 0x80, 0x0F, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0xF0, 0x03,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0x80, 0x3F, 0xFC, 0x01, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0x00, 0x7F, 0xFC, 0x07, 0xF8,
  0x03, 0xFF, 0xE0, 0x3F, 0x80, 0x3F, 0xFF, 0x01, 0xFC, 0x01, 0xFD, 0xF8,
  0x0F, 0xE0, 0x0F, 0xEF, 0xE0, 0x7F, 0x00, 0x7F, 0x7F, 0x07, 0xF0, 0x03,
  0xF3, 0xF8, 0x3F, 0x80, 0x3F, 0x9F, 0xC1, 0xFC, 0x01, 0xFC, 0x7F, 0x0F,
  0xE0, 0x0F, 0xE3, 0xF8, 0xFF, 0x00, 0x7F, 0x1F, 0xC7, 0xF0, 0x07, 0xF8,
  0xFE, 0x3F, 0x80, 0x3F, 0x83, 0xF1, 0xFC, 0x01, 0xFC, 0x1F, 0xCF, 0xE0,
  0x0F, 0xE0, 0xFE, 0x7F, 0x00, 0x7F, 0x07, 0xF7, 0xF0, 0x07, 0xF0, 0x3F,
  0xBF, 0x80, 0x3F, 0x80, 0xFF, 0xFC, 0x01, 0xFC, 0x07, 0xFF, 0xE0, 0x0F,
  0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0x01, 0xFF, 0xF0, 0x07, 0xF0, 0x0F, 0xFF,
  0x80, 0x3F, 0x80, 0x3F, 0xFC, 0x01, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xF0, 0x01, 0xFF, 0x80,
  0x3F, 0x80, 0x0F, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xE0, 0x03,
  0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x01, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFC, 0x3F, 0xE0,
  0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF1, 0xFF, 0x00, 0x1F, 0xE3, 0xFE, 0x00,
  0x3F, 0xC7, 0xF8, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x01,
  0xFE, 0x7F, 0x80, 0x03, 0xFD, 0xFF, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x0F,
  0xF7, 0xF8, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0xFF,
  0x3F, 0xC0, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFD, 0xFF, 0x00, 0x0F, 0xFB,
  0xFE, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0xFF, 0x9F,
  0xF0, 0x03, 0xFE, 0x1F, 0xE0, 0x07, 0xFC, 0x3F, 0xC0, 0x1F, 0xF0, 0x7F,
  0x80, 0x7F, 0xE0, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xCF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0x81, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFF, 0x03,
  0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF,
  0x00, 0xFF, 0x03, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0x81,
  0xFF, 0x81, 0xFE, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x0F,
  0xF8, 0x03, 0xFC, 0x3F, 0xE0, 0x07, 0xF8, 0x7F, 0xC0, 0x0F, 0xF1, 0xFF,
  0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x7F, 0x9F, 0xF0,
  0x00, 0xFF, 0x3F, 0xC0, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFD, 0xFF, 0x00,
  0x07, 0xFB, 0xFE, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x3F, 0xEF, 0xF0, 0x00,
  0x7F, 0xDF, 0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x01, 0xFE, 0x7F, 0x80, 0x07,
  0xFD, 0xFF, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x7F,
  0xCF, 0xF8, 0x00, 0xFF, 0x9F, 0xF0, 0x03, 0xFE, 0x1F, 0xE0, 0x07, 0xFC,
  0x3F, 0xC0, 0x1F, 0xF0, 0x7F, 0x80, 0x7F, 0xE0, 0xFF, 0x81, 0xFF, 0x81,
  0xFF, 0xCF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xC1, 0xFF, 0x01,
  0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x03, 0xF8,
  0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x81, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x1F,
  0xE0, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x01,
  0xFE, 0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xC7, 0xF8, 0x01,
  0xFE, 0x1F, 0xC0, 0x0F, 0xE0, 0xFF, 0x00, 0x7F, 0x07, 0xF8, 0x07, 0xF8,
  0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x3F,
  0xC0, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1,
  0xFC, 0x01, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x3F, 0xF0, 0x78, 0x07, 0xFC, 0x01, 0x80, 0x7F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x08,
  0x00, 0x3F, 0xC0, 0xC0, 0x03, 0xFC, 0x0F, 0x00, 0x7F, 0xC0, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFD,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x3F,
  0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x83, 0xFC,
  0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0,
  0x0F, 0xF0, 0x3F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC1, 0xFE, 0x00,
  0x7F, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x07,
  0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x7F,
  0x81, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC,
  0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x0F,
  0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F,
  0x80, 0x7F, 0x80, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x07, 0xFC, 0x03, 0xFF,
  0x3F, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x01, 0x40, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x7F, 0xBF, 0xC0, 0x03, 0xFD, 0xFE, 0x00, 0x3F, 0xCF, 0xF0, 0x01, 0xFE,
  0x7F, 0x80, 0x1F, 0xE3, 0xFC, 0x00, 0xFF, 0x1F, 0xE0, 0x07, 0xF0, 0xFF,
  0x00, 0x7F, 0x87, 0xF8, 0x03, 0xF8, 0x3F, 0xC0, 0x3F, 0xC0, 0xFE, 0x01,
  0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0xFF, 0x01, 0xFC, 0x07, 0xF0,
  0x0F, 0xE0, 0x7F, 0x80, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x3F, 0xC0, 0x1F,
  0xC1, 0xFC, 0x00, 0xFE, 0x1F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x8F,
  0xF0, 0x01, 0xFC, 0x7F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x3F, 0xC0,
  0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xF0, 0x03, 0xFF, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xEF, 0xE0, 0x07, 0xF8,
  0x03, 0xFD, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0xE0, 0x1F,
  0xE7, 0xF0, 0x0F, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0x1F,
  0xC0, 0x3F, 0xF0, 0x1F, 0xE3, 0xF8, 0x0F, 0xFE, 0x03, 0xF8, 0x7F, 0x01,
  0xFF, 0xC0, 0xFF, 0x0F, 0xE0, 0x7F, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xFF,
  0x07, 0xF8, 0x3F, 0x81, 0xFF, 0xE0, 0xFF, 0x07, 0xF0, 0x7E, 0xFC, 0x1F,
  0xC0, 0xFE, 0x0F, 0xDF, 0x87, 0xF8, 0x1F, 0xC3, 0xFF, 0xF0, 0xFE, 0x03,
  0xF8, 0x7E, 0xFE, 0x1F, 0xC0, 0x7F, 0x1F, 0xDF, 0xC7, 0xF8, 0x0F, 0xE3,
  0xF3, 0xF8, 0xFE, 0x01, 0xFC, 0x7E, 0x7F, 0x3F, 0xC0, 0x3F, 0x9F, 0xCF,
  0xE7, 0xF0, 0x07, 0xF3, 0xF1, 0xFC, 0xFE, 0x00, 0xFE, 0xFE, 0x3F, 0x3F,
  0xC0, 0x1F, 0xDF, 0x87, 0xE7, 0xF0, 0x03, 0xFB, 0xF0, 0xFD, 0xFE, 0x00,
  0x7F, 0xFE, 0x1F, 0xBF, 0x80, 0x0F, 0xDF, 0x83, 0xF7, 0xF0, 0x01, 0xFB,
  0xF0, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x81,
  0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x00,
  0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x3F,
  0xE0, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC,
  0x0F, 0xF0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00,
  0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x03, 0xFC, 0xFF, 0x00,
  0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x00, 0xFE, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x03,
  0xFC, 0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x1F, 0xE3, 0xFC, 0x00,
  0x07, 0xF8, 0x3F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFB, 0xFC,
  0x01, 0xFE, 0x3F, 0x80, 0x3F, 0xC7, 0xF0, 0x0F, 0xF0, 0xFF, 0x01, 0xFE,
  0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xE0, 0x7F, 0x83, 0xFC, 0x07, 0xF0,
  0x7F, 0x00, 0xFE, 0x1F, 0xE0, 0x1F, 0xC7, 0xF8, 0x03, 0xF8, 0xFF, 0x00,
  0x7F, 0xBF, 0xC0, 0x07, 0xF7, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF8, 0x3F, 0x83, 0xF8,
  0x3F, 0x83, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC,
  0x1F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01,
  0xF9, 0xF8, 0x00, 0xFE, 0x7E, 0x00, 0x7F, 0x1F, 0x80, 0x1F, 0x87, 0xF0,
  0x0F, 0xE0, 0xFC, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x03,
  0xF8, 0x3F, 0x00, 0x7E, 0x1F, 0xC0, 0x1F, 0x8F, 0xE0, 0x07, 0xE3, 0xF0,
  0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xF1, 0xFE, 0x1F,
  0xC3, 0xFC, 0x3F, 0x83, 0xF0, 0x7F, 0x07, 0xE0, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0xF8, 0x7F, 0x00, 0xFF, 0xC7, 0xE0, 0x1F, 0xFE, 0xFE, 0x03, 0xFF,
  0xEF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0x87, 0xFC,
  0x0F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0x3F, 0xC3, 0xFC,
  0x03, 0xF8, 0x3F, 0xC0, 0x7F, 0x83, 0xFC, 0x07, 0xF8, 0x3F, 0x80, 0x7F,
  0x87, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x07, 0xF8, 0x07, 0xF0, 0x7F,
  0x80, 0xFF, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xF0, 0x1F,
  0xE0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0x83, 0xFE, 0x07,
  0xF8, 0x7F, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFD,
  0xFC, 0x03, 0xFF, 0xDF, 0xC0, 0x1F, 0xF9, 0xF8, 0x00, 0xFE, 0x1F, 0x80,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x0C, 0x00, 0x3F, 0xCF, 0xF0,
  0x07, 0xFB, 0xFF, 0x00, 0xFE, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xF0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0,
  0x7F, 0x81, 0xFE, 0x0F, 0xE0, 0x3F, 0xC3, 0xFC, 0x07, 0xF8, 0x7F, 0x00,
  0xFF, 0x0F, 0xE0, 0x1F, 0xE1, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x8F,
  0xE0, 0x0F, 0xE1, 0xFC, 0x03, 0xFC, 0x3F, 0x80, 0x7F, 0x87, 0xF0, 0x0F,
  0xF1, 0xFE, 0x01, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0xFF,
  0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x87, 0xFE, 0x1F, 0xE0, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x03, 0xF7, 0xFF, 0xC0, 0x7E, 0xFF, 0xF0, 0x1F, 0xCF,
  0xFC, 0x03, 0xF0, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFC, 0x0C, 0x1F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x83, 0xFE, 0x0E, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0x80, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x03, 0x03,
  0xFC, 0x00, 0x7F, 0x8F, 0xE0, 0x03, 0xFF, 0x3F, 0x80, 0x1F, 0xFE, 0xFE,
  0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00,
  0xFF, 0x87, 0xFC, 0x03, 0xFC, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x03, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x1F,
  0xC0, 0x7F, 0x80, 0x7F, 0x01, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xF0,
  0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0xFF, 0x80, 0x7F, 0x87, 0xFC, 0x01, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFD,
  0xF8, 0x00, 0x7F, 0xE7, 0xE0, 0x00, 0xFF, 0x1F, 0x80, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xF0, 0xFE, 0x1F, 0xE0,
  0x7F, 0x1F, 0xC0, 0x7F, 0x3F, 0xC0, 0x7E, 0x3F, 0x80, 0xFE, 0x7F, 0x80,
  0xFE, 0x7F, 0x03, 0xFE, 0x7F, 0x0F, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x60, 0xFF, 0xC7, 0xE0, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7F,
  0xC7, 0xF0, 0x03, 0xFF, 0x1F, 0x80, 0x1F, 0xFE, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0x87, 0xFC,
  0x03, 0xFC, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x03,
  0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE,
  0x01, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80,
  0x7F, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0,
  0x3F, 0xE1, 0xFF, 0x80, 0x7F, 0x8F, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFB, 0xFC, 0x00, 0x7F,
  0xCF, 0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x41, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x02, 0x00, 0x1F, 0xF0, 0x0F, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x0E, 0x00, 0x3F, 0xCF, 0xF0, 0x07, 0xF3, 0xFF, 0x00, 0xFE,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC,
  0x1F, 0xF8, 0xFF, 0x83, 0xFE, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0,
  0x3F, 0xC3, 0xFC, 0x07, 0xF0, 0x7F, 0x80, 0xFE, 0x0F, 0xF0, 0x1F, 0xC1,
  0xFC, 0x07, 0xF8, 0x3F, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xC1, 0xFE, 0x03,
  0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F,
  0xC0, 0x7F, 0x07, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xFC, 0x1F, 0xC0, 0x7F,
  0x87, 0xF8, 0x0F, 0xF0, 0xFF, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8,
  0x0F, 0xF0, 0x7F, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0xC3, 0xFC, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x07,
  0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F,
  0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x01, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0x81, 0xFE, 0x00, 0xFE, 0x07, 0xF8, 0x03,
  0xF8, 0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFC,
  0x7F, 0x80, 0x07, 0xF3, 0xFC, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0xFF, 0x7F,
  0x80, 0x03, 0xFB, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xF9, 0xFC, 0x00, 0x3F,
  0xC7, 0xF0, 0x00, 0xFE, 0x1F, 0xE0, 0x03, 0xF8, 0x7F, 0x80, 0x0F, 0xE0,
  0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x07, 0xF0, 0x3F,
  0xC0, 0x1F, 0xC0, 0x7F, 0x80, 0x7F, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xE0, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x60, 0x01, 0xF8, 0x7F, 0x81, 0xFE, 0x00,
  0xFC, 0xFF, 0xE1, 0xFF, 0x80, 0x7E, 0x7F, 0xFB, 0xFF, 0xE0, 0x3F, 0x7F,
  0xFD, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFC, 0x7F, 0xF1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0x83,
  0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xC1, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xFE, 0x07,
  0xF8, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x1F,
  0xE0, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x07, 0xF0, 0x1F,
  0xE0, 0x7F, 0x83, 0xF8, 0x0F, 0xE0, 0x3F, 0x83, 0xFC, 0x07, 0xF0, 0x1F,
  0xC1, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x7F,
  0x01, 0xFC, 0x07, 0xF8, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x3F, 0xC0, 0x7F,
  0x01, 0xFC, 0x1F, 0xE0, 0x7F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x83, 0xF8, 0x0F, 0xE0, 0x3F, 0x83, 0xFC,
  0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x3E, 0x1F, 0xE0, 0x0F, 0xC7, 0xFE, 0x01, 0xF9, 0xFF, 0xE0, 0x3F,
  0x7F, 0xFC, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xF0, 0xFF,
  0x07, 0xFC, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x87, 0xF8,
  0x0F, 0xE0, 0xFF, 0x01, 0xFC, 0x1F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xF0,
  0x7F, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0x83, 0xFC, 0x07, 0xF0, 0x7F, 0x00,
  0xFE, 0x0F, 0xE0, 0x3F, 0xC3, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0xFE, 0x0F,
  0xF0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0xFF, 0x0F, 0xF0, 0x1F,
  0xE1, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x1F, 0xE0, 0xFE,
  0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xF0, 0xFF, 0x3F, 0xE0, 0xFF,
  0x3F, 0xC0, 0x7F, 0x3F, 0x80, 0x7F, 0x7F, 0x80, 0x7F, 0x7F, 0x80, 0x7F,
  0x7F, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFE,
  0xFE, 0x01, 0xFE, 0xFE, 0x03, 0xFC, 0xFE, 0x03, 0xFC, 0xFF, 0x07, 0xF8,
  0xFF, 0x0F, 0xF8, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x7F, 0x80, 0x07, 0xE3, 0xFF, 0x00,
  0x1F, 0x9F, 0xFE, 0x00, 0x7E, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xE0, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xFC,
  0x0F, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x03,
  0xFC, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0x00, 0xFF,
  0x03, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x80,
  0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xE0, 0x3F, 0xF1,
  0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xBF, 0xFC, 0x01, 0xFE, 0xFF, 0xC0, 0x07, 0xF9, 0xFE, 0x00,
  0x1F, 0xC0, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xFC, 0x7F,
  0x00, 0xFF, 0xE7, 0xE0, 0x1F, 0xFE, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0x87, 0xFC, 0x0F, 0xF0, 0x7F,
  0xC1, 0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F,
  0xC0, 0x3F, 0x83, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x87, 0xF8, 0x07,
  0xF0, 0x7F, 0x80, 0x7F, 0x07, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07,
  0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0xFF, 0x01,
  0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x83, 0xFE, 0x07, 0xF8, 0x7F, 0xC0,
  0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFD, 0xFC, 0x03, 0xFF,
  0xFF, 0x80, 0x1F, 0xFB, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3E, 0x07, 0xF1, 0xF8, 0x0F, 0xE7, 0xF0, 0x1F, 0x9F, 0xE0, 0x3F, 0x7F,
  0xC0, 0x7E, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0x08,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x03,
  0xFE, 0x3E, 0x07, 0xF8, 0x18, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x80, 0x1F, 0xE1, 0xC0, 0x7F, 0xC3, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0x01, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0x1F,
  0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFE, 0x7F, 0xFF, 0x83, 0xF8,
  0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x81,
  0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x20, 0x00, 0x0F, 0xF0, 0x1F,
  0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x03, 0xFC, 0x3F, 0x80, 0xFF, 0x1F, 0xE0,
  0x3F, 0x87, 0xF8, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x01, 0xFE, 0x1F,
  0xC0, 0x7F, 0x8F, 0xF0, 0x1F, 0xC3, 0xFC, 0x07, 0xF0, 0xFE, 0x01, 0xFC,
  0x3F, 0x80, 0xFF, 0x0F, 0xE0, 0x3F, 0x87, 0xF8, 0x0F, 0xE1, 0xFE, 0x03,
  0xF8, 0x7F, 0x01, 0xFE, 0x1F, 0xC0, 0x7F, 0x8F, 0xF0, 0x1F, 0xC3, 0xFC,
  0x07, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0x80, 0xFF, 0x0F, 0xE0, 0x7F, 0xC3,
  0xF8, 0x1F, 0xE0, 0xFF, 0x0F, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xC0, 0x7F, 0xFB, 0xF0, 0x1F, 0xFC, 0xFC, 0x01, 0xFC,
  0x3F, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xBF,
  0xC0, 0x3F, 0xDF, 0xE0, 0x3F, 0xC7, 0xF0, 0x1F, 0xE3, 0xF8, 0x0F, 0xE1,
  0xFC, 0x0F, 0xF0, 0xFE, 0x07, 0xF0, 0x7F, 0x07, 0xF8, 0x3F, 0x83, 0xF8,
  0x1F, 0xC3, 0xFC, 0x0F, 0xE1, 0xFC, 0x07, 0xF1, 0xFE, 0x03, 0xF8, 0xFE,
  0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0xBF,
  0x80, 0x1F, 0xDF, 0xC0, 0x0F, 0xEF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xFF, 0xF0,
  0x3F, 0xE0, 0x3F, 0xBF, 0x81, 0xFF, 0x03, 0xFD, 0xFC, 0x0F, 0xF8, 0x1F,
  0xCF, 0xE0, 0xFF, 0xC0, 0xFE, 0x7E, 0x07, 0xFE, 0x0F, 0xF3, 0xF0, 0x7F,
  0xF0, 0x7F, 0x1F, 0x83, 0xFF, 0x87, 0xF8, 0xFC, 0x1F, 0xFC, 0x3F, 0x87,
  0xE1, 0xFF, 0xE1, 0xFC, 0x3F, 0x0F, 0xFF, 0x1F, 0xC1, 0xF8, 0xFD, 0xF8,
  0xFE, 0x0F, 0xC7, 0xEF, 0xC7, 0xF0, 0x7E, 0x3E, 0x7E, 0x7F, 0x03, 0xF3,
  0xF3, 0xF3, 0xF8, 0x1F, 0x9F, 0x9F, 0xBF, 0x80, 0xFD, 0xF8, 0xFD, 0xFC,
  0x07, 0xEF, 0xC7, 0xEF, 0xC0, 0x3F, 0x7C, 0x3F, 0xFE, 0x01, 0xFF, 0xE1,
  0xF7, 0xF0, 0x0F, 0xFF, 0x0F, 0xBF, 0x00, 0x7F, 0xF0, 0x7F, 0xF8, 0x03,
  0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x01, 0xFF,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x80,
  0x03, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x03, 0xFE, 0x01, 0xFC,
  0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF0,
  0xFF, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0xDF,
  0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFF, 0x7F, 0x00, 0x03,
  0xFC, 0xFF, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x7F,
  0x83, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0xFE, 0x03, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF8, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00,
  0xFE, 0x3F, 0xC0, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x7E, 0x7F, 0x80, 0x00,
  0x7E, 0x7F, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00,
  0x7E, 0xFE, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x03, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x09, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x78, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x03,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x9F, 0xFC, 0x00, 0x5F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC0, 0x3F, 0xFE, 0xC0, 0x03,
  0xFE, 0x40, 0x00, 0x30, 0x00,
};

const GFXglyph NotoSans_Condensed_BoldItalic57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 17, 42, 15, 0, -41 },
  { 91, 21, 15, 23, 5, -41 },
  { 131, 31, 41, 30, 0, -41 },
  { 290, 27, 46, 26, 0, -43 },
  { 446, 38, 42, 43, 3, -41 },
  { 646, 32, 42, 33, 0, -41 },
  { 814, 9, 15, 14, 6, -41 },
  { 831, 20, 50, 17, 1, -41 },
  { 956, 19, 51, 17, -4, -42 },
  { 1078, 23, 25, 26, 5, -44 },
  { 1150, 24, 28, 28, 3, -34 },
  { 1234, 13, 15, 14, -3, -7 },
  { 1259, 15, 7, 17, 1, -19 },
  { 1273, 9, 10, 14, 0, -9 },
  { 1285, 30, 41, 22, -3, -41 },
  { 1439, 26, 42, 26, 1, -41 },
  { 1576, 20, 41, 27, 5, -41 },
  { 1679, 29, 41, 26, -2, -41 },
  { 1828, 27, 42, 26, 0, -41 },
  { 1970, 28, 41, 27, -1, -41 },
  { 2114, 27, 42, 26, 0, -41 },
  { 2256, 26, 42, 26, 2, -41 },
  { 2393, 28, 41, 26, 2, -41 },
  { 2537, 27, 42, 26, 0, -41 },
  { 2679, 25, 42, 26, 1, -41 },
  { 2811, 14, 33, 15, 0, -32 },
  { 2869, 17, 40, 15, -3, -32 },
  { 2954, 25, 28, 28, 2, -34 },
  { 3042, 25, 17, 28, 2, -29 },
  { 3096, 24, 28, 28, 3, -34 },
  { 3180, 22, 42, 21, 2, -41 },
  { 3296, 38, 46, 40, 2, -41 },
  { 3515, 29, 41, 29, -3, -41 },
  { 3664, 30, 41, 30, 0, -41 },
  { 3818, 29, 42, 28, 2, -41 },
  { 3971, 31, 41, 32, 0, -41 },
  { 4130, 28, 41, 25, 0, -41 },
  { 4274, 28, 41, 24, 0, -41 },
  { 4418, 32, 42, 33, 2, -41 },
  { 4586, 35, 41, 33, 0, -41 },
  { 4766, 25, 41, 19, -2, -41 },
  { 4895, 26, 53, 16, -9, -41 },
  { 5068, 34, 41, 29, 0, -41 },
  { 5243, 21, 41, 24, 0, -41 },
  { 5351, 44, 41, 43, 0, -41 },
  { 5577, 37, 41, 35, 0, -41 },
  { 5767, 31, 42, 34, 2, -41 },
  { 5930, 30, 41, 29, 0, -41 },
  { 6084, 31, 51, 34, 2, -41 },
  { 6282, 29, 41, 29, 0, -41 },
  { 6431, 28, 42, 25, 0, -41 },
  { 6578, 25, 41, 25, 4, -41 },
  { 6707, 31, 42, 32, 3, -41 },
  { 6870, 29, 41, 29, 5, -41 },
  { 7019, 43, 41, 43, 5, -41 },
  { 7240, 35, 41, 28, -3, -41 },
  { 7420, 27, 41, 27, 5, -41 },
  { 7559, 30, 41, 25, -2, -41 },
  { 7713, 23, 50, 17, -2, -41 },
  { 7857, 12, 41, 22, 6, -41 },
  { 7919, 23, 50, 17, -4, -41 },
  { 8063, 26, 25, 27, 0, -41 },
  { 8145, 20, 4, 20, -5, 5 },
  { 8155, 11, 9, 17, 8, -44 },
  { 8168, 28, 33, 29, 1, -32 },
  { 8284, 27, 44, 29, 0, -43 },
  { 8433, 22, 33, 23, 2, -32 },
  { 8524, 30, 44, 29, 1, -43 },
  { 8689, 24, 33, 26, 2, -32 },
  { 8788, 30, 58, 18, -6, -44 },
  { 9006, 30, 46, 29, -1, -32 },
  { 9179, 27, 43, 29, 0, -43 },
  { 9325, 16, 43, 14, 0, -43 },
  { 9411, 23, 57, 14, -7, -43 },
  { 9575, 30, 43, 27, 0, -43 },
  { 9737, 17, 43, 14, 0, -43 },
  { 9829, 41, 32, 42, 0, -32 },
  { 9993, 27, 32, 29, 0, -32 },
  { 10101, 24, 33, 28, 2, -32 },
  { 10200, 30, 46, 29, -3, -32 },
  { 10373, 28, 46, 29, 1, -32 },
  { 10534, 23, 32, 20, 0, -32 },
  { 10626, 23, 33, 22, 0, -32 },
  { 10721, 18, 39, 19, 2, -38 },
  { 10809, 26, 32, 28, 2, -31 },
  { 10913, 25, 31, 25, 3, -31 },
  { 11010, 37, 31, 38, 4, -31 },
  { 11154, 31, 31, 25, -3, -31 },
  { 11275, 32, 45, 25, -4, -31 },
  { 11455, 25, 31, 22, -2, -31 },
  { 11552, 23, 50, 20, 0, -41 },
  { 11696, 6, 57, 24, 9, -44 },
  { 11739, 22, 50, 20, -3, -41 },
  { 11877, 25, 10, 28, 2, -25 },
};

const GFXfont NotoSans_Condensed_BoldItalic57pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BoldItalic57pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BoldItalic57pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _NOTOSANS_CONDENSED_BOLDITALIC57PT7B_H_
