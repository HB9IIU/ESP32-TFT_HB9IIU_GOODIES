#ifndef _NOTOSANS_CONDENSED_BOLDITALIC37PT7B_H_
#define _NOTOSANS_CONDENSED_BOLDITALIC37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BoldItalic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BoldItalic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C,
  0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x00, 0x7C, 0xFB, 0xC7, 0x9E, 0x7D, 0xF3, 0xEF, 0x1E, 0x78, 0xF3, 0xC7,
  0x9E, 0x38, 0xE3, 0xC0, 0x00, 0x79, 0xE0, 0x07, 0x1E, 0x00, 0xF1, 0xC0,
  0x0F, 0x1C, 0x00, 0xE3, 0xC0, 0x1E, 0x38, 0x01, 0xE3, 0x81, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x03, 0x8F, 0x00, 0x38, 0xF0, 0x07, 0x8E,
  0x00, 0x78, 0xE0, 0x07, 0x1E, 0x07, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xC1, 0xE3, 0x80, 0x1C, 0x78, 0x01, 0xC7, 0x80, 0x3C,
  0x70, 0x03, 0xCF, 0x00, 0x38, 0xF0, 0x07, 0x8E, 0x00, 0x00, 0x08, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x03, 0xFC, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF,
  0xF8, 0x3E, 0xCC, 0x0F, 0x31, 0x07, 0xC8, 0x01, 0xF6, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0xC0, 0x0D, 0xF0, 0x02, 0x7C, 0x41, 0x9F, 0x18, 0x6F, 0x87, 0xFF,
  0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xFC, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xE0, 0x1E, 0x07,
  0xF8, 0x1E, 0x07, 0xFC, 0x0E, 0x03, 0x9E, 0x0F, 0x03, 0xCF, 0x0F, 0x01,
  0xE7, 0x87, 0x81, 0xE3, 0xC7, 0x80, 0xF1, 0xE3, 0x80, 0x78, 0xF3, 0xC0,
  0x3C, 0x73, 0xC0, 0x1E, 0x79, 0xE7, 0xCF, 0x3D, 0xE7, 0xF7, 0xFC, 0xE7,
  0xFB, 0xFC, 0xF7, 0x9E, 0xFE, 0xF3, 0xCF, 0x1C, 0x7B, 0xC7, 0x80, 0x79,
  0xE3, 0xC0, 0x38, 0xF1, 0xC0, 0x3C, 0x71, 0xE0, 0x3C, 0x78, 0xF0, 0x1C,
  0x3C, 0x78, 0x1E, 0x1E, 0x78, 0x1E, 0x0F, 0x3C, 0x0F, 0x03, 0xFC, 0x0F,
  0x01, 0xFC, 0x0F, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xF8, 0x00,
  0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x3C, 0x78, 0x03, 0xE3, 0xC0, 0x1F, 0x1E,
  0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0xF8, 0x01, 0xFF, 0x80, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x7C, 0x7F, 0xE3, 0xC3, 0xFF, 0x3E,
  0x3E, 0xFD, 0xF3, 0xE3, 0xFF, 0x1F, 0x1F, 0xF9, 0xF0, 0x7F, 0x8F, 0x83,
  0xF8, 0x7C, 0x0F, 0xC3, 0xF0, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1,
  0xFF, 0xBE, 0x07, 0xF1, 0xF8, 0x7D, 0xE7, 0xBE, 0xFB, 0xCF, 0x3C, 0xF0,
  0x01, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03,
  0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xE0,
  0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03,
  0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xE0,
  0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x03, 0x1E, 0x07, 0xBC, 0x1F, 0xF7, 0xFF, 0xFF, 0x9F,
  0xFF, 0x07, 0xFE, 0x3F, 0x80, 0xFF, 0x83, 0xEF, 0x07, 0xCF, 0x07, 0x1F,
  0x04, 0x38, 0x00, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x1F, 0x1F, 0x1F, 0x3E, 0x3E, 0x3C, 0x7C, 0x78,
  0x78, 0xF0, 0x7F, 0xDF, 0xF7, 0xFF, 0xFF, 0x19, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x01, 0xFC, 0x07, 0xFE, 0x07,
  0xFF, 0x0F, 0xFF, 0x1F, 0x1F, 0x1F, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E,
  0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF8,
  0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8,
  0xF8, 0xF9, 0xF8, 0xFF, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0x3F, 0x80, 0x00,
  0xF8, 0x0F, 0xC1, 0xFE, 0x1F, 0xE1, 0xFF, 0x1F, 0xFB, 0xFF, 0xCF, 0x3E,
  0x33, 0xE1, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x7F, 0xC0, 0x3F,
  0xF8, 0x1F, 0xFF, 0x0F, 0xFF, 0xC1, 0xE1, 0xF0, 0x20, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xFF, 0xF8,
  0xFF, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0xFF, 0xC0,
  0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x81, 0x83, 0xF0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xF8, 0x07, 0xF8,
  0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x20, 0x1F, 0x8C, 0x0F, 0xC3, 0xFF,
  0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x0F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x03,
  0xFE, 0x03, 0xDF, 0x03, 0xCF, 0x01, 0xEF, 0x81, 0xE7, 0xC1, 0xE3, 0xE0,
  0xF1, 0xF0, 0xF0, 0xF0, 0xF0, 0xF8, 0xF0, 0x7C, 0x7F, 0xFF, 0xBF, 0xFF,
  0xDF, 0xFF, 0xEF, 0xFF, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F,
  0xFE, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x07, 0xDC, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x80,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x80, 0x7E, 0x38, 0x3F, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0,
  0x7F, 0xB0, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x0F, 0xBE, 0x0F, 0xBF, 0x87, 0xFF, 0xE3, 0xFF, 0xF1, 0xF8, 0xF9, 0xF8,
  0x7C, 0xFC, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x87, 0xC7,
  0xC3, 0xE3, 0xF3, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x1F, 0xF8, 0x07, 0xF0,
  0x00, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFE, 0x20, 0x0F,
  0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x1F, 0xFE, 0x0F, 0xCF, 0xC3,
  0xE1, 0xF0, 0xF0, 0x7C, 0x3C, 0x1F, 0x0F, 0x0F, 0x83, 0xE3, 0xE0, 0xFF,
  0xF0, 0x1F, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF0,
  0x3E, 0x3E, 0x1F, 0x0F, 0x87, 0xC1, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E,
  0x0F, 0x8F, 0xC3, 0xE1, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xFE, 0x01, 0xFE,
  0x00, 0x00, 0x78, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF8,
  0xFC, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x83,
  0xE7, 0xC3, 0xF3, 0xE1, 0xF9, 0xFB, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F,
  0xDF, 0x03, 0x9F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xE1, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x00, 0x02,
  0x07, 0xC3, 0xE3, 0xF1, 0xF8, 0x78, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x7C, 0x7E, 0x3F, 0x1F, 0x8F, 0x80, 0x00,
  0x80, 0x7C, 0x0F, 0x83, 0xF0, 0x7E, 0x07, 0x80, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x03, 0xE0,
  0x7C, 0x1F, 0x03, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0x78, 0x1E, 0x00, 0x00,
  0x03, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0xE0, 0x00, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x3F,
  0xE0, 0xFF, 0x80, 0xFE, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x03,
  0xE0, 0x3F, 0xE3, 0xFF, 0xCF, 0xFF, 0x1C, 0xFC, 0x41, 0xF0, 0x03, 0xC0,
  0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x07, 0xE0, 0x3E, 0x00,
  0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0x8F, 0xC0,
  0x3E, 0x01, 0xF0, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x1C, 0x0F, 0x0F,
  0x1E, 0x1F, 0xE3, 0x9E, 0x1F, 0xF1, 0xCF, 0x1E, 0x78, 0xE7, 0x1E, 0x3C,
  0x77, 0x8E, 0x1C, 0x3B, 0x8F, 0x0E, 0x3D, 0xC7, 0x0F, 0x1F, 0xE3, 0x87,
  0x8E, 0xF3, 0xC3, 0x87, 0x79, 0xE3, 0xC7, 0xBC, 0xF1, 0xE3, 0x9C, 0x79,
  0xF3, 0xCF, 0x1F, 0xFF, 0xC7, 0x8F, 0xDF, 0xC3, 0xC3, 0xC7, 0x80, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0xE0, 0x03,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xF7, 0x80,
  0x1E, 0xF0, 0x07, 0xDE, 0x00, 0xF3, 0xC0, 0x3E, 0x78, 0x07, 0x8F, 0x01,
  0xF1, 0xE0, 0x3E, 0x3C, 0x0F, 0x87, 0x81, 0xF0, 0xF0, 0x3F, 0xFE, 0x0F,
  0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0x81, 0xF3, 0xE0, 0x3E, 0x7C,
  0x07, 0xDF, 0x80, 0xFB, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7C, 0x03,
  0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7C, 0x3E, 0x0F,
  0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0xF8, 0x7F,
  0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xC7, 0xE1, 0xF0,
  0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xC7, 0xC1,
  0xF8, 0xF8, 0x7E, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFC,
  0x00, 0x00, 0x3C, 0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x87, 0xF0, 0x41, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xE1, 0x81, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFE, 0x01,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xC7, 0xF0, 0x7C, 0x3F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81,
  0xF0, 0xF8, 0x1F, 0x1F, 0x81, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0,
  0x3F, 0x1F, 0x03, 0xF3, 0xF0, 0x3E, 0x3E, 0x07, 0xE3, 0xE0, 0x7E, 0x3E,
  0x0F, 0xC3, 0xE0, 0xFC, 0x7E, 0x3F, 0x87, 0xDF, 0xF0, 0x7F, 0xFE, 0x07,
  0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xC1, 0xFF, 0xF0,
  0x7F, 0xF8, 0x1F, 0xFE, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFE,
  0x07, 0xFF, 0x81, 0xFF, 0xC0, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0x81, 0xFF,
  0xE0, 0x7F, 0xF8, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F,
  0xF8, 0x1F, 0xFE, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x07,
  0xFF, 0x81, 0xFF, 0xC0, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0xFE, 0x03, 0xFF,
  0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFC, 0x0C, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x3F, 0xCF, 0x87, 0xFC, 0xF8, 0x7F, 0xCF, 0x87, 0xFC, 0xF8, 0x0F, 0x8F,
  0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x1F, 0x0F, 0xC1, 0xF0,
  0xFE, 0x1F, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x0F, 0xFC,
  0x00, 0x03, 0xE0, 0x7C, 0x1F, 0x81, 0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x1F,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x0F,
  0x81, 0xF8, 0x3E, 0x07, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xC0, 0xF8, 0x3E, 0x03, 0xE0,
  0xF8, 0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x7E, 0x07, 0xC1, 0xF0,
  0x1F, 0x07, 0xC0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0x3E,
  0x00, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x80, 0xFF,
  0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0xFC, 0x1F, 0x07, 0xE0,
  0x7C, 0x1F, 0x01, 0xF0, 0xF8, 0x07, 0xC7, 0xE0, 0x1E, 0x3F, 0x00, 0xF8,
  0xF8, 0x03, 0xE7, 0xC0, 0x0F, 0xBF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F,
  0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xFC, 0x07, 0xC3, 0xF0, 0x1F, 0x07, 0xC0,
  0x78, 0x1F, 0x03, 0xE0, 0x7E, 0x00, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x01, 0xFF, 0xEF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xC0, 0x03, 0xF0, 0x07, 0xF8, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x03, 0xFC,
  0x0F, 0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xE0, 0x7F, 0x81, 0xFF, 0x07, 0xFC, 0x0F, 0x78, 0x3F, 0xE0, 0x7B, 0xC3,
  0xDF, 0x07, 0xDE, 0x1E, 0xF0, 0x3E, 0xF1, 0xEF, 0x81, 0xF7, 0x8F, 0x7C,
  0x0F, 0x3C, 0xFB, 0xE0, 0x79, 0xE7, 0x9F, 0x07, 0xCF, 0x7C, 0xF0, 0x3E,
  0x7B, 0xCF, 0x81, 0xF3, 0xDE, 0x7C, 0x0F, 0x1F, 0xE3, 0xE0, 0x78, 0xFF,
  0x1E, 0x07, 0xC7, 0xF0, 0xF0, 0x3E, 0x3F, 0x8F, 0x81, 0xF1, 0xF8, 0x7C,
  0x0F, 0x0F, 0xC3, 0xE0, 0x78, 0x7C, 0x1E, 0x07, 0xC3, 0xE1, 0xF0, 0x00,
  0x03, 0xF0, 0x1F, 0x07, 0xF0, 0x1E, 0x07, 0xF0, 0x1E, 0x07, 0xF0, 0x3E,
  0x07, 0xF0, 0x3E, 0x07, 0xF8, 0x3E, 0x0F, 0xF8, 0x3C, 0x0F, 0x78, 0x3C,
  0x0F, 0x78, 0x7C, 0x0F, 0x7C, 0x7C, 0x1F, 0x7C, 0x7C, 0x1F, 0x3C, 0x78,
  0x1F, 0x3C, 0xF8, 0x1E, 0x3C, 0xF8, 0x1E, 0x3E, 0xF8, 0x3E, 0x3E, 0xF0,
  0x3E, 0x1E, 0xF0, 0x3E, 0x1E, 0xF0, 0x3C, 0x1F, 0xF0, 0x3C, 0x1F, 0xF0,
  0x7C, 0x1F, 0xE0, 0x7C, 0x0F, 0xE0, 0x7C, 0x0F, 0xE0, 0x78, 0x0F, 0xE0,
  0x78, 0x0F, 0xE0, 0xF8, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x1F, 0xF8, 0x03,
  0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xE1, 0xF8, 0x7E, 0x3F, 0x03, 0xE3,
  0xF0, 0x3F, 0x3E, 0x03, 0xF7, 0xE0, 0x3F, 0x7C, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x7E, 0xF8, 0x07,
  0xEF, 0x80, 0x7C, 0xF8, 0x0F, 0xCF, 0x80, 0xFC, 0xF8, 0x1F, 0x8F, 0x81,
  0xF8, 0xFC, 0x7F, 0x0F, 0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x1F,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xC3, 0xF0, 0x7C, 0x3F, 0x0F, 0x81, 0xF0, 0xF8, 0x3F, 0x0F, 0x83,
  0xF0, 0xF8, 0x3E, 0x1F, 0x87, 0xE1, 0xF0, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xF0, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0xF8,
  0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xE1, 0xF8, 0x7E, 0x3F, 0x03,
  0xE3, 0xF0, 0x3F, 0x3E, 0x03, 0xF7, 0xE0, 0x3F, 0x7C, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x7E, 0xF8,
  0x07, 0xEF, 0x80, 0x7C, 0xF8, 0x0F, 0xCF, 0x80, 0xFC, 0xF8, 0x1F, 0x8F,
  0x81, 0xF8, 0xFE, 0x7F, 0x0F, 0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0x80,
  0x1F, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x1F,
  0xFF, 0x03, 0xFF, 0xE0, 0x7C, 0x7E, 0x0F, 0x07, 0xC3, 0xE0, 0xF8, 0x7C,
  0x1F, 0x0F, 0x87, 0xE1, 0xF0, 0xF8, 0x7C, 0x3F, 0x0F, 0x9F, 0xC1, 0xFF,
  0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x3E, 0x7C, 0x07, 0xCF,
  0x80, 0xF8, 0xF8, 0x1F, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x07,
  0xC3, 0xE0, 0xF8, 0x78, 0x1F, 0x1F, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x7F,
  0xE0, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x83, 0xF0, 0xC1, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x20, 0x1F, 0x0F, 0x1F, 0xC3,
  0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0x1F, 0x81, 0xF1, 0xF0, 0x1F, 0x1F, 0x03, 0xE1, 0xF0, 0x3E, 0x1F,
  0x03, 0xE3, 0xF0, 0x3E, 0x3E, 0x07, 0xE3, 0xE0, 0x7C, 0x3E, 0x07, 0xC3,
  0xE0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0xFC, 0x7C, 0x0F, 0x87, 0xC0, 0xF8,
  0xFC, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F,
  0x0F, 0x83, 0xF0, 0xF8, 0x3E, 0x0F, 0xC7, 0xE0, 0xFF, 0xFC, 0x07, 0xFF,
  0xC0, 0x7F, 0xF8, 0x01, 0xFE, 0x00, 0xF8, 0x07, 0xFF, 0x00, 0xFB, 0xE0,
  0x3F, 0x7C, 0x07, 0xCF, 0x80, 0xF8, 0xF0, 0x3E, 0x1E, 0x07, 0xC3, 0xC1,
  0xF0, 0x78, 0x3E, 0x0F, 0x0F, 0x81, 0xE1, 0xF0, 0x3C, 0x7C, 0x07, 0x8F,
  0x80, 0xF1, 0xF0, 0x1E, 0x7C, 0x03, 0xCF, 0x80, 0x7B, 0xE0, 0x0F, 0x7C,
  0x01, 0xEF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x0F, 0x01, 0xFF,
  0x81, 0xF0, 0x1F, 0xF8, 0x1F, 0x03, 0xEF, 0x81, 0xF0, 0x3E, 0xF8, 0x3F,
  0x07, 0xCF, 0x83, 0xF0, 0x7C, 0xF8, 0x7F, 0x07, 0xCF, 0x87, 0xF0, 0xF8,
  0xF8, 0x7F, 0x0F, 0x8F, 0x8F, 0xF1, 0xF0, 0xF8, 0xFF, 0x1F, 0x0F, 0x9E,
  0xF1, 0xF0, 0xF9, 0xEF, 0x3E, 0x0F, 0xBE, 0xF3, 0xE0, 0xFB, 0xCF, 0x3C,
  0x0F, 0xBC, 0xF7, 0xC0, 0xFF, 0x8F, 0x7C, 0x0F, 0x78, 0xFF, 0x80, 0xF7,
  0x8F, 0xF8, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xE0, 0xFE,
  0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFC, 0x0F, 0xC0, 0x0F,
  0xC0, 0xFC, 0x00, 0x03, 0xE0, 0x7E, 0x07, 0xC1, 0xF8, 0x07, 0xC3, 0xE0,
  0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x7C, 0x00, 0x7D, 0xF0, 0x00,
  0x7B, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x7C, 0xF8,
  0x01, 0xF8, 0xF8, 0x03, 0xE1, 0xF0, 0x0F, 0x83, 0xE0, 0x3F, 0x07, 0xC0,
  0x7C, 0x0F, 0x81, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0xDF, 0x07, 0xC7, 0xC1,
  0xF1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x1F, 0x07, 0xC7, 0xC0, 0xF3, 0xE0,
  0x3D, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF,
  0x83, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0x87,
  0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x03, 0xFE, 0x07, 0xF8, 0x0F,
  0xF0, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xF0, 0xF0, 0xF0, 0xF8, 0xF8,
  0xF8, 0x78, 0x78, 0x78, 0x78, 0x78, 0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3E, 0x3E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1F, 0x1F, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x11, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E,
  0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3C, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F,
  0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x07, 0x8F, 0x07, 0xC3, 0xC3, 0xC1, 0xE3,
  0xC0, 0xF3, 0xE0, 0x7D, 0xE0, 0x1F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFC, 0xF8, 0xF9, 0xF1, 0xE1, 0xC0, 0x01, 0x80, 0x41, 0xF9, 0xE0,
  0xFF, 0x78, 0x7F, 0xFE, 0x1F, 0xFF, 0x8F, 0xC7, 0xE3, 0xE1, 0xF1, 0xF8,
  0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xCF, 0xC1, 0xF3, 0xE0, 0xF8, 0xF8, 0x3E,
  0x3E, 0x0F, 0x8F, 0x87, 0xE3, 0xE1, 0xF0, 0xF8, 0xFC, 0x3F, 0xFF, 0x07,
  0xFF, 0xC1, 0xFD, 0xF0, 0x3E, 0x78, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E,
  0x10, 0x0F, 0xBF, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0x8F,
  0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0x78, 0x1F, 0x3E, 0x0F, 0x8F, 0x83, 0xE3,
  0xE0, 0xF8, 0xF8, 0x3E, 0x3C, 0x1F, 0x1F, 0x07, 0xC7, 0xE3, 0xF1, 0xF8,
  0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x0F, 0x7F, 0x83, 0xCF, 0xC0, 0x00, 0x40,
  0x07, 0xFC, 0x3F, 0xF0, 0xFF, 0xE1, 0xFF, 0x87, 0xE1, 0x0F, 0x80, 0x3F,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x21, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x04, 0x3E, 0x07, 0xE7, 0x81,
  0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC3, 0xF1, 0xF8, 0x7C, 0x3E, 0x1F,
  0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x1F, 0x03, 0xC3, 0xE0, 0x78, 0x7C,
  0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x3E, 0x1F, 0x07, 0xC3, 0xE0, 0xFF,
  0xFC, 0x0F, 0xFF, 0x81, 0xFE, 0xF0, 0x1F, 0x9C, 0x00, 0x00, 0x60, 0x03,
  0xFC, 0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x7C,
  0x1E, 0x7C, 0x7E, 0x7F, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0xFC, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x08, 0x7E, 0xF8, 0x7F, 0xF8, 0x3F,
  0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0xBF,
  0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x40, 0x20, 0x7E, 0x78, 0x1F, 0xEF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC,
  0x3F, 0x1F, 0x87, 0xC3, 0xE1, 0xF8, 0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xF1,
  0xF8, 0x3E, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x3E, 0x1F, 0x0F, 0xC3,
  0xE1, 0xF0, 0x7C, 0x7E, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x1F, 0xDF, 0x01,
  0xF7, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x80, 0xF8, 0x1C,
  0x3F, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x1F, 0x08, 0x0F, 0xBF, 0x07, 0xFF, 0xC3, 0xFF, 0xE1,
  0xFF, 0xF1, 0xF8, 0xF8, 0xFC, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x3E, 0x0F,
  0x9F, 0x07, 0xCF, 0x83, 0xC7, 0xC3, 0xE3, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0,
  0x7C, 0xF8, 0x7C, 0x7C, 0x3E, 0x3C, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xC0,
  0x03, 0xC0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x81, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x03,
  0xE0, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x9F, 0x80, 0xFF, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x87, 0xE1, 0xF0, 0xF8, 0x3C, 0x3E, 0x07, 0x8F, 0x81, 0xF3, 0xE0,
  0x3E, 0xF8, 0x07, 0xFF, 0x00, 0xF7, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xEF, 0x80, 0xF9, 0xF0, 0x1F, 0x1F, 0x03,
  0xE3, 0xE0, 0x78, 0x7C, 0x0F, 0x0F, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x00,
  0x03, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x03,
  0xE0, 0x7C, 0x00, 0x00, 0x0C, 0x02, 0x03, 0xCF, 0xC7, 0xE0, 0xF7, 0xFB,
  0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7, 0xE3, 0xF1, 0xF1, 0xF0,
  0xFC, 0x7C, 0x7C, 0x3E, 0x1F, 0x1F, 0x0F, 0x87, 0xCF, 0x83, 0xC1, 0xF3,
  0xE1, 0xF0, 0x78, 0xF8, 0x7C, 0x3E, 0x3E, 0x1F, 0x0F, 0x8F, 0x07, 0xC3,
  0xE7, 0xC1, 0xE0, 0xF9, 0xF0, 0xF8, 0x3C, 0x7C, 0x3E, 0x1F, 0x1F, 0x0F,
  0x87, 0xC7, 0x83, 0xE1, 0xF3, 0xE0, 0xF0, 0x7C, 0xF8, 0x7C, 0x3E, 0x00,
  0x00, 0x0C, 0x07, 0x9F, 0x83, 0xDF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0xFC,
  0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xE7,
  0xC1, 0xE3, 0xE1, 0xF1, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1E,
  0x3E, 0x1F, 0x1E, 0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xE0, 0x00, 0x60, 0x03,
  0xF8, 0x0F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFF, 0x3F, 0x1F, 0x3E, 0x1F, 0x7C,
  0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3E, 0xF8,
  0x3E, 0xF8, 0x3E, 0xF8, 0x7E, 0xF8, 0xFC, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F,
  0xF0, 0x1F, 0xC0, 0x00, 0x01, 0x00, 0x3C, 0xFC, 0x03, 0xDF, 0xE0, 0x3F,
  0xFE, 0x03, 0xFF, 0xE0, 0x7E, 0x3F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0x81, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0x81, 0xFF, 0xF8,
  0x1F, 0xFF, 0x03, 0xEF, 0xE0, 0x3E, 0x7C, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xC0, 0x41, 0xF9, 0xE0, 0xFF,
  0x78, 0x7F, 0xFE, 0x1F, 0xFF, 0x8F, 0xC7, 0xE3, 0xE1, 0xF1, 0xF0, 0x7C,
  0x7C, 0x1F, 0x1F, 0x07, 0xCF, 0x81, 0xE3, 0xE0, 0x78, 0xF8, 0x3E, 0x3E,
  0x0F, 0x8F, 0x83, 0xE3, 0xE1, 0xF0, 0xF8, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF,
  0xC1, 0xFD, 0xF0, 0x3E, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x00, 0x04, 0x1E, 0x7C, 0x3D, 0xF0, 0x7F, 0xE1, 0xFF, 0xC3,
  0xFF, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0xC0, 0x0F, 0xF8, 0x3F, 0xF8,
  0xFF, 0xE3, 0xFB, 0xC7, 0xC1, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F,
  0x80, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC,
  0xC1, 0xF1, 0xFF, 0xE3, 0xFF, 0x87, 0xFF, 0x0F, 0xF8, 0x00, 0x03, 0x80,
  0x78, 0x07, 0x80, 0xF8, 0x1F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFE, 0x1E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x78, 0x0F, 0x80, 0xFF, 0x87, 0xF8, 0x7F, 0x83, 0xF8, 0x1F, 0x0F,
  0x8F, 0x87, 0xC7, 0x83, 0xE7, 0xC1, 0xF3, 0xE0, 0xF1, 0xF0, 0xF8, 0xF8,
  0x7C, 0x78, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0x1F, 0x0F, 0x8F, 0x87, 0xCF,
  0x83, 0xE7, 0xC3, 0xE3, 0xE1, 0xF1, 0xF1, 0xF8, 0xFF, 0xFC, 0x7F, 0xDE,
  0x1F, 0xDE, 0x07, 0xCF, 0x00, 0xF8, 0x1F, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8,
  0x7C, 0xF8, 0x7C, 0xF8, 0x78, 0xF8, 0xF8, 0x78, 0xF0, 0x79, 0xF0, 0x79,
  0xE0, 0x7B, 0xE0, 0x7B, 0xC0, 0x7B, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F,
  0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xF8, 0x7E, 0x1F,
  0xFC, 0x3F, 0x0F, 0xBE, 0x1F, 0x87, 0x9F, 0x1F, 0xC7, 0xCF, 0x8F, 0xE3,
  0xE7, 0xCF, 0xF3, 0xE3, 0xE7, 0xF9, 0xF1, 0xF3, 0xBC, 0xF0, 0xFB, 0xDE,
  0xF8, 0x7D, 0xEF, 0x78, 0x3F, 0xE7, 0xBC, 0x1F, 0xF3, 0xFE, 0x0F, 0x71,
  0xFE, 0x07, 0xF8, 0xEF, 0x03, 0xFC, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFE,
  0x1F, 0x80, 0x7F, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xE0, 0x00,
  0x07, 0xC3, 0xF0, 0x7C, 0x3E, 0x07, 0xC7, 0xC0, 0x3E, 0xFC, 0x03, 0xEF,
  0x80, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F,
  0xBC, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x03, 0xE3, 0xE0, 0x7C, 0x1F, 0x0F,
  0xC1, 0xF0, 0x07, 0xC0, 0xF8, 0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x87,
  0xC0, 0x3C, 0x3E, 0x01, 0xE1, 0xE0, 0x0F, 0x1F, 0x00, 0x78, 0xF8, 0x03,
  0xCF, 0x80, 0x1E, 0x7C, 0x00, 0xF7, 0xC0, 0x07, 0xBE, 0x00, 0x3D, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x8F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F,
  0xFE, 0x0F, 0xFE, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x00,
  0x7E, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x0F,
  0xF0, 0x1F, 0xC0, 0x3E, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x03, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x01, 0xFE,
  0x01, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x01, 0xFC, 0x0F,
  0xF0, 0x7E, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x38,
  0x00, 0x7E, 0x01, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFE, 0x80,
  0x7C,
};

const GFXglyph NotoSans_Condensed_BoldItalic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 11, 26, 10, 0, -26 },
  { 37, 13, 9, 15, 4, -26 },
  { 52, 20, 26, 20, 0, -26 },
  { 117, 18, 30, 17, 0, -28 },
  { 185, 25, 27, 28, 2, -27 },
  { 270, 21, 27, 21, 0, -27 },
  { 341, 6, 9, 9, 4, -26 },
  { 348, 13, 32, 11, 1, -26 },
  { 400, 13, 33, 11, -3, -27 },
  { 454, 15, 16, 17, 3, -28 },
  { 484, 16, 18, 18, 2, -22 },
  { 520, 8, 10, 9, -2, -5 },
  { 530, 10, 4, 11, 0, -12 },
  { 535, 6, 6, 9, 0, -6 },
  { 540, 19, 27, 14, -2, -27 },
  { 605, 16, 27, 17, 1, -27 },
  { 659, 13, 26, 17, 3, -26 },
  { 702, 18, 27, 17, -1, -27 },
  { 763, 18, 27, 17, 0, -27 },
  { 824, 17, 26, 17, 0, -26 },
  { 880, 18, 26, 17, 0, -26 },
  { 939, 17, 27, 17, 1, -27 },
  { 997, 18, 26, 17, 1, -26 },
  { 1056, 18, 27, 17, 0, -27 },
  { 1117, 17, 27, 17, 0, -27 },
  { 1175, 9, 21, 9, 0, -21 },
  { 1199, 11, 26, 9, -2, -21 },
  { 1235, 16, 18, 18, 2, -22 },
  { 1271, 16, 12, 18, 2, -19 },
  { 1295, 16, 18, 18, 2, -22 },
  { 1331, 14, 27, 14, 1, -27 },
  { 1379, 25, 30, 26, 1, -27 },
  { 1473, 19, 26, 19, -2, -26 },
  { 1535, 19, 26, 19, 0, -26 },
  { 1597, 18, 27, 18, 2, -27 },
  { 1658, 20, 26, 21, 0, -26 },
  { 1723, 18, 26, 16, 0, -26 },
  { 1782, 18, 26, 16, 0, -26 },
  { 1841, 20, 27, 21, 2, -27 },
  { 1909, 22, 26, 22, 0, -26 },
  { 1981, 16, 26, 12, -1, -26 },
  { 2033, 17, 34, 10, -6, -26 },
  { 2106, 22, 26, 19, 0, -26 },
  { 2178, 13, 26, 16, 0, -26 },
  { 2221, 29, 26, 28, 0, -26 },
  { 2316, 24, 26, 23, 0, -26 },
  { 2394, 20, 27, 22, 2, -27 },
  { 2462, 20, 26, 19, 0, -26 },
  { 2527, 20, 33, 22, 2, -27 },
  { 2610, 19, 26, 19, 0, -26 },
  { 2672, 18, 27, 17, 0, -27 },
  { 2733, 16, 26, 16, 3, -26 },
  { 2785, 20, 26, 21, 2, -26 },
  { 2850, 19, 26, 19, 3, -26 },
  { 2912, 28, 26, 28, 3, -26 },
  { 3003, 23, 26, 18, -2, -26 },
  { 3078, 18, 26, 17, 3, -26 },
  { 3137, 19, 26, 16, -1, -26 },
  { 3199, 15, 32, 11, -1, -26 },
  { 3259, 8, 27, 14, 4, -27 },
  { 3286, 15, 32, 11, -3, -26 },
  { 3346, 17, 16, 17, 0, -26 },
  { 3380, 13, 3, 13, -3, 3 },
  { 3385, 7, 6, 11, 5, -28 },
  { 3391, 18, 21, 19, 1, -21 },
  { 3439, 18, 28, 19, 0, -28 },
  { 3502, 15, 21, 15, 1, -21 },
  { 3542, 19, 28, 19, 1, -28 },
  { 3609, 16, 21, 17, 1, -21 },
  { 3651, 20, 37, 11, -4, -28 },
  { 3744, 19, 30, 19, 0, -21 },
  { 3816, 17, 28, 19, 0, -28 },
  { 3876, 11, 28, 9, 0, -28 },
  { 3915, 16, 37, 9, -5, -28 },
  { 3989, 19, 28, 17, 0, -28 },
  { 4056, 11, 28, 9, 0, -28 },
  { 4095, 26, 21, 27, 0, -21 },
  { 4164, 17, 21, 19, 0, -21 },
  { 4209, 16, 21, 18, 1, -21 },
  { 4251, 20, 30, 19, -2, -21 },
  { 4326, 18, 30, 19, 1, -21 },
  { 4394, 15, 21, 13, 0, -21 },
  { 4434, 15, 21, 15, 0, -21 },
  { 4474, 12, 24, 12, 1, -24 },
  { 4510, 17, 20, 18, 1, -20 },
  { 4553, 16, 20, 16, 2, -20 },
  { 4593, 25, 20, 25, 2, -20 },
  { 4656, 20, 20, 16, -2, -20 },
  { 4706, 21, 29, 16, -3, -20 },
  { 4783, 16, 20, 14, -1, -20 },
  { 4823, 15, 32, 13, 0, -26 },
  { 4883, 4, 36, 16, 6, -28 },
  { 4901, 14, 32, 13, -2, -26 },
  { 4957, 16, 6, 18, 2, -16 },
};

const GFXfont NotoSans_Condensed_BoldItalic37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BoldItalic37pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BoldItalic37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_CONDENSED_BOLDITALIC37PT7B_H_
