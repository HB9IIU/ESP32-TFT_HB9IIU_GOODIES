#ifndef _NOTOSANS_CONDENSED_BOLDITALIC68PT7B_H_
#define _NOTOSANS_CONDENSED_BOLDITALIC68PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BoldItalic.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BoldItalic68pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xFC,
  0x00, 0x7F, 0x80, 0x01, 0xC0, 0x00, 0x3F, 0xE1, 0xFF, 0x3F, 0xE1, 0xFE,
  0x3F, 0xC3, 0xFE, 0x3F, 0xC3, 0xFE, 0x3F, 0xC3, 0xFE, 0x7F, 0xC3, 0xFC,
  0x7F, 0x83, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x83, 0xF8, 0x7F, 0x87, 0xF8,
  0x7F, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF0, 0xFE, 0x07, 0xF0,
  0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x3F, 0x80,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xC1, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x3F,
  0x03, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xBB, 0xF8, 0x03, 0xFE, 0x78, 0x70, 0x03,
  0xFC, 0x70, 0x30, 0x07, 0xFC, 0x70, 0x00, 0x07, 0xFC, 0x70, 0x00, 0x07,
  0xFC, 0x70, 0x00, 0x07, 0xFC, 0xF0, 0x00, 0x07, 0xFE, 0xE0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x07, 0xBF, 0xF0, 0x00, 0x07, 0xBF, 0xF0, 0x00, 0x07, 0x1F, 0xF0, 0x00,
  0x07, 0x1F, 0xF0, 0x80, 0x07, 0x1F, 0xF0, 0x60, 0x0F, 0x1F, 0xF0, 0xF0,
  0x0E, 0x3F, 0xE0, 0xFC, 0x0E, 0x7F, 0xE0, 0xFF, 0xEF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0x80,
  0x0F, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xC0, 0x07,
  0xFF, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x9F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8,
  0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x07, 0xE0, 0x01, 0xFC, 0x3F,
  0x80, 0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0,
  0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x03, 0xF8, 0x1F,
  0x80, 0x03, 0xF8, 0x1F, 0xC1, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0,
  0x00, 0xFE, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0x00,
  0x3F, 0x83, 0xF8, 0xFE, 0x00, 0x01, 0xF8, 0x1F, 0xC7, 0xF0, 0x3E, 0x0F,
  0xC1, 0xFC, 0x7F, 0x07, 0xFC, 0x7E, 0x0F, 0xE3, 0xF8, 0xFF, 0xF3, 0xF0,
  0xFE, 0x3F, 0x8F, 0xFF, 0xDF, 0xCF, 0xF3, 0xF8, 0xFF, 0xFE, 0xFF, 0xFF,
  0x1F, 0xC7, 0xFF, 0xF7, 0xFF, 0xF9, 0xFC, 0x7F, 0xBF, 0xDF, 0xFF, 0x8F,
  0xE7, 0xF8, 0xFE, 0xFF, 0xF8, 0xFE, 0x3F, 0x87, 0xF3, 0xFF, 0x8F, 0xE1,
  0xFC, 0x3F, 0x87, 0xF0, 0x7F, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0xFE,
  0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x03,
  0xF8, 0x00, 0x3F, 0x83, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC1, 0xFC,
  0x00, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xE0, 0x7F, 0x00,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0x07,
  0xF0, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8,
  0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0xCF, 0xF0, 0x03, 0xF8, 0x00,
  0xFF, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x0F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x0F,
  0xF0, 0xFF, 0x80, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x7F, 0xC0,
  0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x01, 0xFF,
  0x7F, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xF8,
  0x0F, 0xFF, 0xF0, 0x3F, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0x03, 0xFF, 0xFF,
  0x87, 0xFC, 0x1F, 0xFB, 0xFE, 0x1F, 0xF0, 0xFF, 0xCF, 0xFC, 0xFF, 0x83,
  0xFE, 0x1F, 0xF3, 0xFE, 0x1F, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xC0, 0xFF,
  0xFF, 0xC3, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F,
  0xE0, 0x1F, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFE, 0x00, 0xFF,
  0xF8, 0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF,
  0x80, 0x7F, 0xFC, 0x03, 0xFF, 0x87, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xBF, 0xF8, 0x07, 0xFF, 0xF8, 0x7F,
  0xE0, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xE7, 0xFC, 0xFF, 0x9F, 0xE3, 0xFC, 0xFF, 0x9F, 0xF3, 0xFC, 0x7F, 0x8F,
  0xF1, 0xFE, 0x3F, 0x8F, 0xF1, 0xFE, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x10, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x40, 0x3F, 0x80, 0x0C, 0x07, 0xF0, 0x03, 0xE0, 0xFE, 0x00, 0x7F,
  0x1F, 0x80, 0x0F, 0xFB, 0xF0, 0x0F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x01, 0xFF, 0x7F, 0x00, 0x7F, 0xEF, 0xE0, 0x1F, 0xF9,
  0xFE, 0x01, 0xFE, 0x1F, 0xC0, 0x1F, 0x83, 0xFC, 0x01, 0xF0, 0x7F, 0xC0,
  0x1C, 0x07, 0xF0, 0x01, 0x00, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFE,
  0x03, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF,
  0xFD, 0xFF, 0xFE, 0x7F, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE,
  0x1F, 0xC7, 0xFD, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F,
  0xCF, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0x0F,
  0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0xC1, 0xFF, 0x01, 0xFF,
  0x0F, 0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0xC7,
  0xFC, 0x01, 0xFF, 0x1F, 0xF0, 0x07, 0xFC, 0xFF, 0xC0, 0x3F, 0xE3, 0xFE,
  0x00, 0xFF, 0x8F, 0xF8, 0x03, 0xFE, 0x3F, 0xE0, 0x0F, 0xF9, 0xFF, 0x80,
  0x3F, 0xE7, 0xFC, 0x00, 0xFF, 0x9F, 0xF0, 0x03, 0xFE, 0x7F, 0xC0, 0x1F,
  0xFB, 0xFF, 0x00, 0x7F, 0xCF, 0xFC, 0x01, 0xFF, 0x3F, 0xE0, 0x07, 0xFC,
  0xFF, 0x80, 0x3F, 0xF3, 0xFE, 0x00, 0xFF, 0xCF, 0xF8, 0x03, 0xFE, 0x3F,
  0xE0, 0x0F, 0xF8, 0xFF, 0x80, 0x7F, 0xE3, 0xFE, 0x01, 0xFF, 0x0F, 0xF0,
  0x07, 0xFC, 0x3F, 0xC0, 0x3F, 0xF0, 0xFF, 0x00, 0xFF, 0x83, 0xFC, 0x07,
  0xFE, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC0, 0xFF, 0x87, 0xFE,
  0x03, 0xFF, 0xBF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F,
  0xF7, 0xF8, 0xFF, 0xEF, 0xF8, 0x7F, 0xCF, 0xF8, 0x3F, 0x8F, 0xF8, 0x1E,
  0x0F, 0xF0, 0x1C, 0x1F, 0xF0, 0x08, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xC1, 0xFF, 0xC0, 0x0F, 0xC0, 0x3F, 0xF0, 0x03, 0xE0, 0x0F,
  0xFC, 0x00, 0x60, 0x03, 0xFF, 0x00, 0x10, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3E, 0x03, 0xFF, 0x80, 0x0C, 0x00, 0xFF,
  0xC0, 0x04, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC1,
  0x80, 0x00, 0xFF, 0xE0, 0xF0, 0x00, 0xFF, 0xF0, 0x7F, 0x03, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xDF, 0xE0, 0x00, 0x0F, 0xEF, 0xF0,
  0x00, 0x0F, 0xEF, 0xF8, 0x00, 0x07, 0xE7, 0xFC, 0x00, 0x07, 0xF3, 0xFC,
  0x00, 0x07, 0xF1, 0xFE, 0x00, 0x03, 0xF1, 0xFF, 0x00, 0x03, 0xF8, 0xFF,
  0x80, 0x03, 0xF8, 0x7F, 0xC0, 0x03, 0xF8, 0x3F, 0xC0, 0x01, 0xFC, 0x1F,
  0xE0, 0x01, 0xFC, 0x1F, 0xF0, 0x01, 0xFC, 0x0F, 0xF8, 0x00, 0xFE, 0x07,
  0xFC, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x01,
  0xFF, 0x00, 0x7F, 0x00, 0xFF, 0x80, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x70,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x80, 0x00, 0x7F, 0xE0, 0xC0, 0x00, 0xFF,
  0xE0, 0xF0, 0x01, 0xFF, 0xC0, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0xF4, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x30, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x1F, 0xF7, 0xFF,
  0x80, 0x3F, 0xEF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFC, 0x7F,
  0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0x3F, 0xF0, 0x7F, 0xE0, 0x1F,
  0xF0, 0xFF, 0xC0, 0x1F, 0xF0, 0xFF, 0xC0, 0x1F, 0xF0, 0xFF, 0xC0, 0x3F,
  0xF0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x3F,
  0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0x80, 0x7F,
  0xC0, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC1, 0xFF,
  0x80, 0x7F, 0xF7, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x87, 0xFE, 0x01, 0xFF, 0x81,
  0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x07, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF,
  0xC3, 0xFE, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xE7, 0xFE, 0x00,
  0xFF, 0xC1, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0,
  0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x03, 0xFE,
  0x0F, 0xF8, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x7F,
  0xC3, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F,
  0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x0F,
  0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC3, 0xFF, 0x01, 0xFF,
  0x0F, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xF1, 0xFF, 0x80, 0x7F, 0xC7,
  0xFC, 0x01, 0xFF, 0x1F, 0xF0, 0x07, 0xFC, 0x7F, 0xC0, 0x1F, 0xF1, 0xFF,
  0x00, 0xFF, 0xC7, 0xFC, 0x03, 0xFF, 0x1F, 0xF0, 0x0F, 0xFC, 0x7F, 0xC0,
  0x7F, 0xF1, 0xFF, 0x01, 0xFF, 0xC7, 0xFE, 0x0F, 0xFE, 0x1F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0x7F, 0xC0, 0x1F, 0xF1, 0xFF, 0x00,
  0x1F, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x03, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC,
  0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F,
  0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x3F, 0x80, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x1F, 0xE7, 0xFF, 0x0F, 0x00, 0xFF, 0x86,
  0x00, 0x7F, 0xC2, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF0,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x3F, 0x80, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x0F,
  0xE0, 0x07, 0xFC, 0x07, 0xF0, 0x3F, 0x00, 0x7F, 0xFE, 0x1F, 0xC1, 0xFC,
  0x07, 0xFF, 0xF8, 0x3F, 0x07, 0xE0, 0x3F, 0xFF, 0xE0, 0xFC, 0x3F, 0x81,
  0xFF, 0xFF, 0x83, 0xF0, 0xFC, 0x0F, 0xF8, 0xFC, 0x0F, 0xC7, 0xF0, 0x7F,
  0x83, 0xF0, 0x3F, 0x1F, 0x81, 0xFC, 0x1F, 0xC0, 0xFC, 0xFE, 0x0F, 0xE0,
  0x7F, 0x03, 0xF3, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0xCF, 0xC1, 0xFC, 0x07,
  0xE0, 0x7E, 0x7F, 0x07, 0xF0, 0x3F, 0x81, 0xF9, 0xFC, 0x1F, 0x80, 0xFE,
  0x07, 0xE7, 0xE0, 0xFE, 0x03, 0xF0, 0x1F, 0x9F, 0x83, 0xF8, 0x0F, 0xC0,
  0xFE, 0x7E, 0x0F, 0xC0, 0x7F, 0x03, 0xF3, 0xF8, 0x3F, 0x01, 0xFC, 0x0F,
  0xCF, 0xE0, 0xFC, 0x07, 0xF0, 0x7F, 0x3F, 0x07, 0xF0, 0x3F, 0x81, 0xF8,
  0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE3, 0xF0, 0x7F, 0x07, 0xF8, 0x3F, 0x0F,
  0xC1, 0xFC, 0x1F, 0xE1, 0xFC, 0x3F, 0x03, 0xF8, 0xFF, 0x8F, 0xE0, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xF0, 0x3F, 0xFE, 0xFF, 0xF8, 0x0F, 0xC0,
  0x7F, 0xF3, 0xFF, 0xE0, 0x3F, 0x81, 0xFF, 0x87, 0xFE, 0x00, 0xFE, 0x03,
  0xFC, 0x0F, 0xF0, 0x01, 0xF8, 0x00, 0x80, 0x04, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x20, 0x00, 0x07, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x17, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x01, 0xFE,
  0xFF, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x01,
  0xFE, 0x7F, 0x80, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x0F, 0xF1, 0xFE, 0x00,
  0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xF0,
  0x7F, 0x80, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x1F,
  0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x00,
  0x1F, 0xF0, 0x1F, 0xE0, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xC1,
  0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0xE0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x3F,
  0xE3, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0x9F, 0xF8, 0x00,
  0x1F, 0xF3, 0xFE, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xDF, 0xF8,
  0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xC0, 0xFF, 0xE0, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xC0,
  0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xC3, 0xFF, 0xE0, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x7F,
  0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xF0, 0x03,
  0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0xE0,
  0x3F, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x3E, 0x00, 0xFF, 0xF0, 0x03, 0x80,
  0x3F, 0xF8, 0x00, 0x20, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x02, 0x00, 0x7F, 0xF0, 0x07, 0x80, 0x1F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFE, 0x07, 0xFF,
  0x80, 0x1F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xE0,
  0x3F, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xF8, 0x00,
  0xFF, 0xC0, 0x7F, 0xC0, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x3F,
  0xF0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x7F,
  0xE0, 0x7F, 0xC0, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x3F, 0xF0,
  0x00, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0xE0,
  0x7F, 0xC0, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x01,
  0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F,
  0xC0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x03, 0xFF,
  0x01, 0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xF8, 0x07, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xF1, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xF8, 0x0F, 0xC0, 0x0F, 0xFF, 0x00, 0x0E, 0x00, 0xFF, 0xF0,
  0x00, 0x10, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x7F, 0xFF, 0x0F, 0xFC, 0x07,
  0xFF, 0xF8, 0x7F, 0xE0, 0x3F, 0xFF, 0xC7, 0xFE, 0x01, 0xFF, 0xFC, 0x3F,
  0xF0, 0x0F, 0xFF, 0xE1, 0xFF, 0x80, 0xFF, 0xFF, 0x0F, 0xFC, 0x07, 0xFF,
  0xF8, 0x7F, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xF8,
  0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x3F, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x07, 0xFC, 0x0F, 0xFC, 0x00,
  0x3F, 0xE0, 0x7F, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x0F,
  0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x00,
  0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0xF0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x01, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x03,
  0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFC,
  0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x0F,
  0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F,
  0xF8, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00,
  0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x00,
  0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x10, 0x3F, 0xF8, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0xFC,
  0x01, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0x00,
  0x7F, 0xC0, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x00, 0x1F, 0xF0,
  0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x3F, 0xF0,
  0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x9F,
  0xF8, 0x00, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x00, 0x3F, 0xEF, 0xFC, 0x00,
  0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xF9, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x00,
  0x07, 0xFC, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0xFF,
  0xC0, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF8, 0x01, 0xFE, 0xFE, 0x00, 0x7F, 0x7F, 0x80, 0x0F, 0xF7, 0xF0,
  0x07, 0xFB, 0xFC, 0x00, 0x7F, 0xBF, 0x80, 0x3F, 0xBF, 0xE0, 0x03, 0xFD,
  0xFC, 0x03, 0xFD, 0xFF, 0x00, 0x3F, 0xEF, 0xE0, 0x1F, 0xCF, 0xF0, 0x01,
  0xFF, 0x7F, 0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xF3, 0xFC, 0x0F, 0xF7, 0xFC,
  0x00, 0x7F, 0x9F, 0xE0, 0xFF, 0x3F, 0xE0, 0x03, 0xFC, 0xFF, 0x07, 0xF9,
  0xFF, 0x00, 0x3F, 0xE7, 0xF8, 0x3F, 0x8F, 0xF0, 0x01, 0xFF, 0x3F, 0xC3,
  0xFC, 0x7F, 0x80, 0x0F, 0xF1, 0xFE, 0x1F, 0xC7, 0xFC, 0x00, 0x7F, 0x8F,
  0xF1, 0xFE, 0x3F, 0xE0, 0x03, 0xFC, 0x7F, 0x8F, 0xE1, 0xFF, 0x00, 0x3F,
  0xE3, 0xFC, 0xFF, 0x0F, 0xF0, 0x01, 0xFF, 0x0F, 0xE7, 0xF0, 0xFF, 0x80,
  0x0F, 0xF0, 0x7F, 0x7F, 0x87, 0xFC, 0x00, 0x7F, 0x83, 0xFB, 0xF8, 0x3F,
  0xE0, 0x07, 0xFC, 0x1F, 0xFF, 0xC1, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0xFC,
  0x0F, 0xF0, 0x01, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0x80, 0x0F, 0xF0, 0x3F,
  0xFF, 0x07, 0xFC, 0x00, 0x7F, 0x81, 0xFF, 0xF0, 0x3F, 0xE0, 0x07, 0xFC,
  0x0F, 0xFF, 0x81, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xF8, 0x0F, 0xF0, 0x01,
  0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0x80, 0x0F, 0xF0, 0x1F, 0xFC, 0x07, 0xFC,
  0x00, 0x7F, 0x80, 0xFF, 0xE0, 0x3F, 0xE0, 0x07, 0xFC, 0x07, 0xFE, 0x01,
  0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF0, 0x01, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xE0, 0x03, 0xFF,
  0xC0, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xC0,
  0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xF8, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xEF, 0xF0, 0x0F, 0xF8, 0x01, 0xFE, 0xFF,
  0x80, 0xFF, 0x00, 0x1F, 0xEF, 0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x7F, 0x81,
  0xFF, 0x00, 0x1F, 0xE7, 0xF8, 0x1F, 0xF0, 0x03, 0xFE, 0x7F, 0x81, 0xFF,
  0x00, 0x3F, 0xC7, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xC1, 0xFE, 0x00,
  0x3F, 0xC3, 0xFC, 0x3F, 0xE0, 0x03, 0xFC, 0x3F, 0xC3, 0xFE, 0x00, 0x7F,
  0xC3, 0xFE, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xE3, 0xFC, 0x00, 0x7F, 0x81,
  0xFE, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0x81, 0xFE,
  0x7F, 0xC0, 0x0F, 0xF8, 0x1F, 0xF7, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x7F,
  0x80, 0x0F, 0xF0, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x7F, 0x80,
  0x1F, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0xE0, 0x07, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xE0,
  0x07, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFF,
  0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xC0,
  0x07, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xC0, 0x07,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x01, 0xFF, 0x87,
  0xFE, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x03,
  0xFF, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0xFF, 0xCF, 0xFC,
  0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x01, 0xFF,
  0xBF, 0xF0, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00, 0x7F, 0xCF, 0xFC, 0x00,
  0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x01, 0xFF, 0xBF,
  0xF0, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x07,
  0xFE, 0x7F, 0xE0, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x01, 0xFF, 0x9F, 0xF8,
  0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x0F, 0xFE,
  0x3F, 0xF0, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x07, 0xFF, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xF8, 0x0F,
  0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xC3, 0xFF, 0xF0, 0x07, 0xFC, 0x07, 0xFF,
  0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x1F,
  0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xF0, 0x03, 0xFF,
  0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0xE0, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xE0,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFC, 0x0F,
  0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x0F,
  0xFC, 0x3F, 0xF0, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x03, 0xFF, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x07, 0xFE,
  0x7F, 0xE0, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x01, 0xFF, 0xBF, 0xF0, 0x00,
  0x0F, 0xFD, 0xFF, 0x80, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x07, 0xFE, 0x7F,
  0xE0, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x0F,
  0xFD, 0xFF, 0x80, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x07, 0xFE, 0x7F, 0xE0,
  0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x1F, 0xF8,
  0xFF, 0xC0, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x0F, 0xFE, 0x3F, 0xF0, 0x00,
  0x7F, 0xE1, 0xFF, 0x80, 0x07, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x7F,
  0xE0, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF,
  0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0xC0, 0x0F, 0xF8, 0x1F, 0xF8, 0x01,
  0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC,
  0x03, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07,
  0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0x87, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x0F,
  0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xE1, 0xFF, 0x80,
  0x0F, 0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x7F,
  0xE0, 0x07, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF0, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xF8,
  0x1F, 0xF0, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xF8, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0x80, 0x1F, 0xFC, 0x00,
  0x40, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x02, 0x00, 0x03, 0xFE, 0x01,
  0xE0, 0x01, 0xFF, 0x80, 0x7E, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x3F,
  0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xF8,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x07, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x01,
  0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x0F,
  0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x0F,
  0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x7F,
  0xC0, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFB, 0xFE, 0x00, 0x07, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0x3F, 0xE0,
  0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x0F, 0xF8, 0xFF,
  0x80, 0x07, 0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0xC1,
  0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x1F, 0xF8, 0x1F, 0xE0, 0x07, 0xFC,
  0x07, 0xF8, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x03,
  0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x1F, 0xE0, 0x3F, 0xE0, 0x07, 0xF8,
  0x1F, 0xF0, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x1F,
  0xE0, 0xFF, 0x80, 0x07, 0xF8, 0x7F, 0xC0, 0x01, 0xFE, 0x1F, 0xF0, 0x00,
  0x7F, 0x87, 0xF8, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x00,
  0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x1F, 0xE7, 0xF8,
  0x00, 0x07, 0xFB, 0xFE, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x7F, 0xBF,
  0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xEF, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xCF, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0x8F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xF8, 0xFF, 0x80,
  0x1F, 0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xF0, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xE0,
  0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFE, 0x0F, 0xF0, 0x07, 0xFF, 0xC0, 0x7F,
  0xC0, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFC, 0x0F, 0xF0, 0x0F, 0xFF, 0x80,
  0x7F, 0xC0, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x3F,
  0xBF, 0x81, 0xFF, 0x00, 0xFF, 0x03, 0xFB, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0,
  0x7F, 0xBF, 0x83, 0xFE, 0x00, 0xFF, 0x07, 0xF3, 0xF8, 0x3F, 0xE0, 0x0F,
  0xF0, 0xFF, 0x3F, 0x87, 0xFC, 0x00, 0xFF, 0x0F, 0xF3, 0xF8, 0x7F, 0xC0,
  0x0F, 0xF0, 0xFE, 0x3F, 0x87, 0xF8, 0x00, 0xFF, 0x1F, 0xE3, 0xF8, 0xFF,
  0x80, 0x0F, 0xF1, 0xFC, 0x3F, 0x8F, 0xF8, 0x00, 0xFF, 0x3F, 0xC3, 0xF9,
  0xFF, 0x00, 0x0F, 0xF3, 0xFC, 0x3F, 0x9F, 0xF0, 0x00, 0xFF, 0x3F, 0x83,
  0xF9, 0xFE, 0x00, 0x0F, 0xF7, 0xF8, 0x3F, 0xBF, 0xE0, 0x00, 0xFF, 0x7F,
  0x03, 0xFB, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x3F, 0xBF, 0xC0, 0x00, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x00,
  0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x00, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0x9F, 0xF0, 0x00, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x00, 0x07, 0xFB, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0xC7, 0xFC, 0x00, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x3F,
  0xE0, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0x7F, 0xC0, 0x0F, 0xFC, 0x7F,
  0xC0, 0x0F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F,
  0xC0, 0x3F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0xE0, 0x3F,
  0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x3F,
  0xE1, 0xFF, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x1F,
  0xE7, 0xFC, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0x80,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x0F,
  0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFE,
  0xFE, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x3F, 0xC7,
  0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0x1F,
  0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x7F,
  0x01, 0xFE, 0x00, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x01, 0xFC,
  0x3F, 0xC0, 0x03, 0xF8, 0xFF, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x0F, 0xF7,
  0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xC7, 0xFE, 0x1F,
  0xF8, 0xFF, 0xC3, 0xFE, 0x0F, 0xF0, 0x7F, 0xC1, 0xFE, 0x07, 0xF0, 0x1F,
  0xC0, 0xFE, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0xFF, 0x00, 0x7F,
  0xF8, 0xFF, 0x00, 0xFF, 0xF9, 0xFF, 0x01, 0xFF, 0xFD, 0xFE, 0x03, 0xFF,
  0xFD, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE,
  0x1F, 0xFE, 0x0F, 0xFC, 0x1F, 0xFC, 0x1F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF8,
  0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0,
  0x0F, 0xF8, 0x7F, 0xE0, 0x0F, 0xF8, 0x7F, 0xE0, 0x0F, 0xF8, 0x7F, 0xC0,
  0x0F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF0, 0xFF, 0xC0, 0x1F, 0xF0, 0xFF, 0xC0,
  0x1F, 0xF0, 0xFF, 0xC0, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0x80,
  0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0x80,
  0x7F, 0xE0, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC1,
  0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x7F, 0x80, 0x3F, 0xFE,
  0x7F, 0x80, 0x1F, 0xFC, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x83, 0xC0, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0xFF, 0x3F, 0xF8, 0x01, 0xFF,
  0x7F, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0x03, 0xFF,
  0x01, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x07, 0xFC,
  0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x07, 0xF8,
  0x01, 0xFF, 0x07, 0xF8, 0x01, 0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0x0F, 0xF8,
  0x01, 0xFF, 0x0F, 0xF0, 0x03, 0xFF, 0x0F, 0xF0, 0x03, 0xFE, 0x1F, 0xF0,
  0x03, 0xFE, 0x1F, 0xF0, 0x03, 0xFE, 0x1F, 0xF0, 0x07, 0xFE, 0x1F, 0xF0,
  0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0,
  0x1F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF8,
  0x7F, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0x3F, 0xFF, 0x00, 0xFF, 0x1F,
  0xFE, 0x00, 0xFE, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0x07, 0x01, 0xFF, 0x80, 0x20, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x81,
  0xFF, 0x80, 0x70, 0x3F, 0xF8, 0x3E, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xE0, 0x7F, 0xC0, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0xF9, 0xFF,
  0x00, 0x1F, 0xFF, 0xBF, 0xC0, 0x07, 0xFF, 0xF7, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0x87, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xF0, 0x1F, 0xF0, 0x03,
  0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF8,
  0x01, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x0F, 0xF8, 0x0F,
  0xF8, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x0F, 0xFC,
  0x1F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xBF, 0x80, 0x07, 0xFF, 0xEF, 0xF0,
  0x00, 0x7F, 0xF9, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF0, 0x7F, 0xE1, 0xFF, 0x0F, 0xFC, 0x0F, 0xF0, 0xFF, 0x80,
  0xFF, 0x1F, 0xF0, 0x0F, 0xF1, 0xFF, 0x00, 0xFF, 0x3F, 0xE0, 0x0F, 0xF3,
  0xFE, 0x01, 0xFF, 0x3F, 0xC0, 0x3F, 0xE7, 0xFC, 0x0F, 0xFE, 0x7F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x20, 0xFF,
  0xC0, 0x0E, 0x07, 0xFF, 0x07, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC3, 0xFC, 0x00, 0x3F, 0xFC, 0x7F, 0x80,
  0x0F, 0xFF, 0xCF, 0xF0, 0x03, 0xFF, 0xFB, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xC3,
  0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x0F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF8, 0x0F, 0xFC, 0x01,
  0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xF0, 0x07, 0xFC, 0x07, 0xFC,
  0x01, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC,
  0x01, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xF0, 0x07, 0xFF, 0x1F,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xEF, 0xF8, 0x00,
  0x3F, 0xF9, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0x0C, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x08, 0x00,
  0x0F, 0xFC, 0x01, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0x83, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x83, 0xE0, 0x00, 0xFF, 0x1F, 0xF8, 0x00,
  0xFF, 0x3F, 0xFC, 0x01, 0xFF, 0x7F, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x03,
  0xFF, 0x01, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x07,
  0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x0F,
  0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x0F,
  0xF8, 0x07, 0xFC, 0x0F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x1F,
  0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F,
  0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F,
  0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F,
  0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x03, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x07,
  0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0xE0,
  0x07, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x1F, 0xF0, 0xFF,
  0x80, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x1F, 0xF3,
  0xFF, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x0F,
  0xF7, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x3F,
  0xE0, 0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0x1F, 0xE0, 0x7F, 0xE0, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0x1F, 0xF0, 0x1F, 0xF0, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x7F,
  0xC0, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF,
  0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xFE, 0x1F, 0xF0,
  0x0F, 0xF8, 0x00, 0xFE, 0x3F, 0xFC, 0x3F, 0xFC, 0x01, 0xFE, 0x7F, 0xFC,
  0x7F, 0xFE, 0x01, 0xFC, 0xFF, 0xFE, 0xFF, 0xFF, 0x01, 0xFD, 0xFF, 0xFE,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0x03, 0xFF, 0x83, 0xFF,
  0xC1, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xF8,
  0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0,
  0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xFE, 0x0F, 0xF8, 0x00, 0xFE,
  0x3F, 0xFC, 0x01, 0xFC, 0x7F, 0xFE, 0x01, 0xFC, 0xFF, 0xFE, 0x01, 0xFD,
  0xFF, 0xFE, 0x01, 0xFD, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xC3, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x03, 0xFF,
  0x01, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x07, 0xFC,
  0x01, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF8,
  0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x0F, 0xF8,
  0x07, 0xFC, 0x0F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0,
  0x07, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0,
  0x0F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xC0,
  0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0xC0,
  0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x1F, 0xF8, 0x7F, 0xE0, 0x7F, 0xC7, 0xFE,
  0x03, 0xFE, 0x3F, 0xE0, 0x1F, 0xF3, 0xFF, 0x00, 0xFF, 0x9F, 0xF0, 0x07,
  0xFC, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0x7F, 0xC0, 0x0F, 0xFB,
  0xFE, 0x00, 0x7F, 0xDF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFB, 0xFE, 0x00, 0x7F, 0xDF, 0xF0, 0x03,
  0xFE, 0xFF, 0x80, 0x3F, 0xF7, 0xFC, 0x01, 0xFF, 0x3F, 0xE0, 0x0F, 0xF9,
  0xFF, 0x00, 0xFF, 0xCF, 0xF8, 0x0F, 0xFC, 0x7F, 0xE0, 0xFF, 0xE1, 0xFF,
  0x8F, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xF8, 0x7F, 0xC0, 0x00, 0x7F, 0x1F, 0xFE, 0x00, 0x1F, 0xE7,
  0xFF, 0xC0, 0x03, 0xFD, 0xFF, 0xFC, 0x00, 0x7F, 0x7F, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xE0,
  0x0F, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0,
  0x0F, 0xF8, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x3F,
  0xE0, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xE0,
  0x1F, 0xE0, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x1F,
  0xF0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x3F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xDF, 0xFF, 0xC0, 0x07, 0xF9, 0xFF, 0xF0, 0x01, 0xFF, 0x3F,
  0xFC, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x07, 0xFC, 0x0E, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0xFF, 0x00, 0x7F, 0xF8, 0xFF, 0x00, 0xFF, 0xFC, 0xFF, 0x01, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFE, 0x1F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x0F,
  0xFC, 0x1F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF0, 0x0F, 0xFC, 0x3F, 0xE0, 0x0F,
  0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0xC0, 0x0F,
  0xF8, 0x7F, 0xC0, 0x0F, 0xF8, 0x7F, 0xC0, 0x0F, 0xF0, 0x7F, 0xC0, 0x0F,
  0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x1F,
  0xE0, 0xFF, 0x80, 0x1F, 0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x3F,
  0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0x80, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFE, 0xFF, 0x80, 0x1F, 0xFC, 0xFF, 0x80, 0x0F, 0xF0, 0xFF,
  0x00, 0x01, 0xC1, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0xC3, 0xFC,
  0x03, 0xF8, 0xFF, 0x80, 0xFF, 0x3F, 0xE0, 0x1F, 0xEF, 0xFC, 0x03, 0xFD,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0x3F, 0xF9, 0xFC, 0x0F, 0xFC, 0x07, 0x01, 0xFF, 0x00, 0x20,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x08, 0x00, 0x7F, 0xE1, 0x80, 0x0F, 0xFC, 0x3E, 0x07, 0xFF, 0x07, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFA,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x07,
  0xFF, 0xF8, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFB, 0xFF, 0xFF, 0xC1, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC1, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xC0,
  0x03, 0xC0, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFE, 0x07,
  0xFC, 0x01, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xF8, 0x03, 0xFE, 0x07,
  0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFC, 0x0F, 0xF8, 0x07, 0xFC, 0x0F,
  0xF8, 0x07, 0xFC, 0x0F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x1F,
  0xF0, 0x07, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F,
  0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF0, 0x3F, 0xE0, 0x1F, 0xF0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x3F, 0xE0, 0x1F, 0xF0, 0x3F, 0xC0, 0x1F, 0xF0, 0x7F,
  0xC0, 0x1F, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F,
  0x80, 0x3F, 0xE0, 0x7F, 0x80, 0x7F, 0xE0, 0xFF, 0x80, 0x7F, 0xC0, 0xFF,
  0x80, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0xC0, 0xFF,
  0xC3, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x7F, 0x80, 0x3F, 0xFE, 0x7F, 0x00, 0x3F,
  0xFC, 0x7F, 0x00, 0x1F, 0xF8, 0x7F, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xBF, 0xE0, 0x07, 0xFD, 0xFF, 0x00,
  0x7F, 0xCF, 0xF8, 0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xE3, 0xFE, 0x01, 0xFF,
  0x1F, 0xF0, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x87, 0xFC, 0x07, 0xFC, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x3F, 0xE0, 0x3F, 0xC1,
  0xFF, 0x01, 0xFE, 0x1F, 0xF0, 0x0F, 0xF0, 0xFF, 0x80, 0x7F, 0x87, 0xF8,
  0x03, 0xFC, 0x7F, 0xC0, 0x1F, 0xE3, 0xFC, 0x00, 0xFF, 0x3F, 0xE0, 0x07,
  0xF9, 0xFE, 0x00, 0x3F, 0xDF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xF7,
  0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0xBF, 0xE0, 0x3F, 0xF8, 0x07, 0xFD, 0xFF, 0x01, 0xFF, 0xC0, 0x3F,
  0xCF, 0xF8, 0x0F, 0xFE, 0x03, 0xFE, 0x7F, 0xC0, 0xFF, 0xF0, 0x1F, 0xE3,
  0xFC, 0x07, 0xFF, 0x81, 0xFF, 0x1F, 0xE0, 0x7F, 0xFC, 0x0F, 0xF8, 0xFF,
  0x03, 0xFF, 0xE0, 0x7F, 0x87, 0xF8, 0x1F, 0xFF, 0x07, 0xFC, 0x3F, 0xC1,
  0xFF, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xFF, 0xC3, 0xFE, 0x0F, 0xF0, 0xFE,
  0xFE, 0x1F, 0xE0, 0x7F, 0x87, 0xF7, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xBF,
  0x8F, 0xF8, 0x1F, 0xE3, 0xF9, 0xFC, 0x7F, 0x80, 0xFF, 0x1F, 0xCF, 0xE7,
  0xFC, 0x07, 0xF9, 0xFC, 0x7F, 0x3F, 0xC0, 0x3F, 0xCF, 0xE3, 0xF9, 0xFE,
  0x01, 0xFE, 0x7F, 0x1F, 0xDF, 0xE0, 0x0F, 0xF7, 0xF0, 0xFE, 0xFF, 0x00,
  0x7F, 0xBF, 0x87, 0xF7, 0xF8, 0x03, 0xFD, 0xF8, 0x3F, 0x7F, 0x80, 0x1F,
  0xFF, 0xC1, 0xFB, 0xFC, 0x00, 0xFF, 0xFE, 0x0F, 0xDF, 0xC0, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x00,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xF0,
  0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x07, 0xFC, 0x0F,
  0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x3F,
  0xE3, 0xFF, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x3F, 0xE7, 0xFC, 0x00,
  0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x3F, 0xE7, 0xFC,
  0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x0F, 0xF8,
  0x3F, 0xE0, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x03,
  0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07,
  0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x03,
  0xFC, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x7F,
  0xC0, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x0F,
  0xF0, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0xFF, 0x07, 0xFC,
  0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x7F, 0xC0,
  0x00, 0x07, 0xF1, 0xFE, 0x00, 0x00, 0x1F, 0xCF, 0xF8, 0x00, 0x00, 0x7F,
  0x3F, 0xC0, 0x00, 0x01, 0xFD, 0xFF, 0x00, 0x00, 0x07, 0xF7, 0xF8, 0x00,
  0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x08, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x04, 0x7F, 0xE0, 0x00, 0x37, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFB,
  0x00, 0x0F, 0xFF, 0xC8, 0x00, 0x0F, 0xFC, 0x20, 0x00, 0x01, 0x80,
};

const GFXglyph NotoSans_Condensed_BoldItalic68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 20, 50, 18, 0, -49 },
  { 126, 24, 18, 28, 7, -49 },
  { 180, 37, 49, 36, 0, -49 },
  { 407, 32, 56, 31, 1, -52 },
  { 631, 45, 50, 51, 4, -49 },
  { 913, 38, 50, 39, 1, -49 },
  { 1151, 11, 18, 17, 7, -49 },
  { 1176, 24, 60, 20, 1, -49 },
  { 1356, 23, 61, 20, -5, -50 },
  { 1532, 27, 29, 31, 6, -52 },
  { 1630, 29, 32, 34, 3, -40 },
  { 1746, 16, 18, 17, -4, -9 },
  { 1782, 18, 8, 20, 1, -22 },
  { 1800, 11, 11, 17, 0, -10 },
  { 1816, 35, 49, 26, -3, -49 },
  { 2031, 30, 50, 31, 2, -49 },
  { 2219, 24, 49, 32, 6, -49 },
  { 2366, 34, 49, 31, -2, -49 },
  { 2575, 33, 50, 31, -1, -49 },
  { 2782, 33, 49, 32, -1, -49 },
  { 2985, 32, 50, 31, 0, -49 },
  { 3185, 32, 50, 31, 2, -49 },
  { 3385, 33, 49, 31, 2, -49 },
  { 3588, 33, 50, 31, 0, -49 },
  { 3795, 30, 50, 31, 1, -49 },
  { 3983, 17, 39, 17, 0, -38 },
  { 4066, 21, 47, 17, -4, -38 },
  { 4190, 29, 33, 34, 3, -41 },
  { 4310, 29, 20, 34, 3, -34 },
  { 4383, 30, 33, 34, 3, -41 },
  { 4507, 25, 50, 25, 3, -49 },
  { 4664, 46, 55, 48, 2, -49 },
  { 4981, 35, 49, 35, -4, -49 },
  { 5196, 36, 49, 35, 0, -49 },
  { 5417, 34, 50, 33, 3, -49 },
  { 5630, 37, 49, 38, 0, -49 },
  { 5857, 33, 49, 30, 0, -49 },
  { 6060, 33, 49, 29, 0, -49 },
  { 6263, 37, 50, 39, 3, -49 },
  { 6495, 41, 49, 40, 0, -49 },
  { 6747, 31, 49, 23, -3, -49 },
  { 6937, 31, 63, 19, -11, -49 },
  { 7182, 41, 49, 34, 0, -49 },
  { 7434, 25, 49, 29, 0, -49 },
  { 7588, 53, 49, 51, 0, -49 },
  { 7913, 44, 49, 42, 0, -49 },
  { 8183, 37, 50, 41, 3, -49 },
  { 8415, 36, 49, 34, 0, -49 },
  { 8636, 37, 61, 41, 3, -49 },
  { 8919, 35, 49, 35, 0, -49 },
  { 9134, 34, 50, 30, -1, -49 },
  { 9347, 30, 49, 30, 5, -49 },
  { 9531, 38, 50, 39, 3, -49 },
  { 9769, 34, 49, 34, 6, -49 },
  { 9978, 52, 49, 52, 6, -49 },
  { 10297, 42, 49, 33, -4, -49 },
  { 10555, 32, 49, 32, 6, -49 },
  { 10751, 37, 49, 29, -3, -49 },
  { 10978, 27, 60, 20, -2, -49 },
  { 11181, 15, 49, 26, 7, -49 },
  { 11273, 28, 60, 20, -5, -49 },
  { 11483, 31, 30, 32, 0, -49 },
  { 11600, 24, 4, 24, -6, 6 },
  { 11612, 13, 11, 21, 10, -52 },
  { 11630, 32, 39, 34, 2, -38 },
  { 11786, 32, 53, 34, 0, -52 },
  { 11998, 27, 39, 27, 2, -38 },
  { 12130, 35, 53, 34, 2, -52 },
  { 12362, 28, 39, 31, 2, -38 },
  { 12499, 37, 68, 21, -8, -52 },
  { 12814, 35, 54, 34, -1, -38 },
  { 13051, 32, 52, 34, 0, -52 },
  { 13259, 20, 52, 17, 0, -52 },
  { 13389, 29, 68, 17, -9, -52 },
  { 13636, 35, 52, 32, 0, -52 },
  { 13864, 20, 52, 17, 0, -52 },
  { 13994, 48, 38, 50, 0, -38 },
  { 14222, 32, 38, 34, 0, -38 },
  { 14374, 29, 39, 33, 2, -38 },
  { 14516, 35, 54, 34, -3, -38 },
  { 14753, 32, 54, 34, 2, -38 },
  { 14969, 27, 38, 24, 0, -38 },
  { 15098, 27, 39, 27, 0, -38 },
  { 15230, 21, 46, 22, 3, -45 },
  { 15351, 32, 38, 34, 2, -37 },
  { 15503, 29, 37, 29, 4, -37 },
  { 15638, 45, 37, 45, 4, -37 },
  { 15847, 36, 37, 30, -3, -37 },
  { 16014, 38, 53, 30, -5, -37 },
  { 16266, 29, 37, 26, -2, -37 },
  { 16401, 27, 60, 23, 1, -49 },
  { 16604, 8, 67, 29, 10, -52 },
  { 16671, 27, 60, 23, -4, -49 },
  { 16874, 30, 12, 34, 3, -30 },
};

const GFXfont NotoSans_Condensed_BoldItalic68pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BoldItalic68pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BoldItalic68pt7bGlyphs,
  0x20, 0x7E, 93
};

#endif // _NOTOSANS_CONDENSED_BOLDITALIC68PT7B_H_
