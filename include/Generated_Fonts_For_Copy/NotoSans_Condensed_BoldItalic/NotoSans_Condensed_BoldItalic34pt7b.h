#ifndef _NOTOSANS_CONDENSED_BOLDITALIC34PT7B_H_
#define _NOTOSANS_CONDENSED_BOLDITALIC34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BoldItalic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BoldItalic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x1F,
  0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x0F, 0x83, 0xC0, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x7C, 0x3F, 0x0F, 0x83, 0xE0, 0x7C, 0xF7, 0xCF, 0x79, 0xF7,
  0x9E, 0x79, 0xE7, 0x1E, 0x71, 0xCF, 0x1C, 0xF1, 0xC0, 0x00, 0xF3, 0xC0,
  0x1C, 0x70, 0x03, 0x8E, 0x00, 0xF3, 0xC0, 0x1C, 0x70, 0x03, 0x8E, 0x07,
  0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF8, 0x1C, 0x70, 0x03,
  0x8E, 0x00, 0x71, 0xC0, 0x1E, 0x78, 0x1F, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF,
  0xFF, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x1E, 0x78, 0x03, 0x8E, 0x00, 0x71,
  0xC0, 0x0E, 0x38, 0x03, 0xCF, 0x00, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30,
  0x01, 0xFE, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xFE, 0x1F, 0x66, 0x1E, 0x60,
  0x1F, 0x40, 0x1F, 0x40, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFC, 0x01, 0xFC, 0x01, 0xBC, 0x01, 0xBC, 0x41, 0x3C, 0x73, 0x7C,
  0x7F, 0xF8, 0xFF, 0xF8, 0x7F, 0xE0, 0x07, 0x80, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x00, 0x7E, 0x03, 0xC3, 0xFC, 0x0E, 0x0F, 0xF0,
  0x70, 0x79, 0xC3, 0xC1, 0xC7, 0x0E, 0x0F, 0x1C, 0x78, 0x3C, 0xF1, 0xC0,
  0xE3, 0xCE, 0x03, 0x8E, 0x78, 0x0E, 0x39, 0xC7, 0xB9, 0xEF, 0x7F, 0xFF,
  0x3B, 0xFF, 0xFD, 0xCF, 0x77, 0xEF, 0x79, 0xC4, 0x39, 0xC7, 0x01, 0xE7,
  0x1C, 0x07, 0x3C, 0x70, 0x38, 0xF1, 0xC1, 0xE3, 0xCF, 0x07, 0x0F, 0x38,
  0x3C, 0x3D, 0xE0, 0xE0, 0xFF, 0x07, 0x01, 0xFC, 0x3C, 0x07, 0xE0, 0x00,
  0x30, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x78, 0xF0, 0x0F,
  0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0xF0, 0x07, 0x9E, 0x00, 0xFF, 0x80, 0x1F,
  0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x1E, 0x3F, 0xE7, 0xCF, 0xFC, 0xF1, 0xE7,
  0xDE, 0x7C, 0xFF, 0x8F, 0x0F, 0xF3, 0xE1, 0xFC, 0x7C, 0x1F, 0x8F, 0x87,
  0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0x7C, 0x3F, 0xCF, 0xC0, 0x7D,
  0xF7, 0x9E, 0x79, 0xE7, 0x3C, 0xF0, 0x01, 0xE0, 0x78, 0x1E, 0x03, 0xC0,
  0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x81, 0xF0, 0x3C, 0x07, 0x80,
  0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00,
  0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x0F, 0x80, 0x03, 0xC0, 0x1C, 0x00, 0xE0,
  0xCF, 0x0F, 0x78, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0x1F, 0xB9, 0xFC, 0x1F,
  0xF1, 0xF3, 0xC3, 0x9E, 0x08, 0xE0, 0x04, 0x00, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x1F, 0x1E, 0x3E, 0x3E, 0x3C, 0x7C, 0x78, 0x70, 0xF0, 0x7F,
  0xDF, 0xE7, 0xFB, 0xFE, 0x79, 0xFF, 0xFE, 0xF8, 0x00, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xC0, 0x07, 0xF0, 0x1F, 0xF0, 0x7F,
  0xE1, 0xFB, 0xE3, 0xE7, 0xCF, 0x8F, 0x9E, 0x1F, 0x7C, 0x3E, 0xF8, 0x7D,
  0xE0, 0xFB, 0xC1, 0xEF, 0x83, 0xDF, 0x0F, 0xBE, 0x1F, 0x78, 0x3E, 0xF0,
  0x79, 0xE1, 0xF3, 0xC3, 0xE7, 0x87, 0x8F, 0x1F, 0x1F, 0xFC, 0x3F, 0xF0,
  0x3F, 0xE0, 0x3F, 0x00, 0x01, 0xF0, 0x3F, 0x07, 0xE1, 0xFE, 0x3F, 0xE7,
  0xFE, 0xFB, 0xC7, 0x3C, 0x23, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80,
  0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01,
  0xE0, 0x1E, 0x03, 0xE0, 0x00, 0x38, 0x00, 0xFF, 0x01, 0xFF, 0xC1, 0xFF,
  0xE0, 0xFD, 0xF8, 0x38, 0x7C, 0x10, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x00, 0x70,
  0x07, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0x07, 0x3F, 0x04, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0xFC, 0x07, 0xF8, 0x07, 0xE0,
  0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x80, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0x80,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFE,
  0x01, 0xFE, 0x03, 0xBC, 0x07, 0xBC, 0x07, 0x3C, 0x0E, 0x7C, 0x1E, 0x7C,
  0x3C, 0x78, 0x38, 0x78, 0x78, 0x78, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFC, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x0F, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC,
  0x1F, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x80, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0x80,
  0x00, 0x1E, 0x00, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0xE2, 0x0F, 0x80,
  0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0xE0, 0x7F, 0xF8, 0x7F, 0xF8,
  0x7F, 0xFC, 0xFC, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C,
  0xF0, 0x78, 0xF0, 0xF8, 0xF8, 0xF8, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xE0,
  0x3F, 0x80, 0x1F, 0xFF, 0x8F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE0, 0x01,
  0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x30, 0x03, 0xFC, 0x07, 0xFE, 0x0F,
  0xFF, 0x0F, 0x9F, 0x1F, 0x0F, 0x1F, 0x0F, 0x1F, 0x0F, 0x1F, 0x1F, 0x0F,
  0xBE, 0x0F, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x7C,
  0x7C, 0x7C, 0x3C, 0xF8, 0x3C, 0xF8, 0x3C, 0xF8, 0x3C, 0xF8, 0x7C, 0xFC,
  0xF8, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xE0, 0x00, 0x70, 0x03, 0xFC, 0x07,
  0xFE, 0x0F, 0xFE, 0x1F, 0xBE, 0x1F, 0x1F, 0x1E, 0x1F, 0x3E, 0x1F, 0x3E,
  0x1F, 0x3C, 0x1F, 0x3C, 0x3F, 0x3E, 0x3E, 0x3E, 0xFE, 0x3F, 0xFE, 0x1F,
  0xFE, 0x1F, 0xBC, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x01,
  0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0x00, 0x07, 0x07, 0x87,
  0xE3, 0xE1, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE1, 0xF8, 0xFC, 0x7C, 0x3E, 0x00, 0x01, 0xC0, 0x78, 0x1F, 0x83,
  0xE0, 0x7C, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0x80,
  0xF0, 0x1C, 0x07, 0x80, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x78, 0x03, 0xF0,
  0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0x80, 0xFC, 0x01, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xC0, 0x0F, 0x80, 0x07, 0x00, 0x02,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x01, 0xC0, 0x03, 0xE0,
  0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7E,
  0x00, 0xFC, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0x3F, 0x00, 0x78,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0xFF, 0x8F, 0xFC, 0x7F, 0xF3, 0xCF, 0x90,
  0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0x78, 0x03, 0x80, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0x78, 0x00, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0xE0, 0x0F, 0xC3, 0xE0, 0x3E, 0x01, 0xE0, 0xF0, 0x01, 0xC1, 0xC0,
  0x03, 0xC7, 0x07, 0xE3, 0x9E, 0x3F, 0xE7, 0x38, 0xFF, 0x8E, 0xF1, 0xC7,
  0x1D, 0xC7, 0x0E, 0x3B, 0x8E, 0x3C, 0x77, 0x3C, 0x71, 0xDC, 0x70, 0xE3,
  0xB8, 0xE3, 0xC7, 0x71, 0xC7, 0x9C, 0xE3, 0x8E, 0x39, 0xC7, 0xFE, 0xE3,
  0x8F, 0xDF, 0xC7, 0x0F, 0x1E, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x03, 0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x3D, 0xE0, 0x0F, 0x78, 0x07, 0xDE, 0x01, 0xE7, 0x80, 0xF9,
  0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x07, 0xC7, 0x81, 0xE1, 0xE0, 0xFF, 0xF8,
  0x3F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE3, 0xE0, 0x78, 0xF8, 0x1E, 0x3C,
  0x07, 0x9F, 0x01, 0xE7, 0x80, 0x7B, 0xE0, 0x1F, 0x07, 0xFE, 0x01, 0xFF,
  0xE0, 0x7F, 0xF8, 0x1F, 0xFF, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF0, 0x7C,
  0x3C, 0x1E, 0x1F, 0x0F, 0x87, 0xCF, 0xC1, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F,
  0xFE, 0x0F, 0x8F, 0x83, 0xE1, 0xF0, 0xF8, 0x7C, 0x3C, 0x1F, 0x0F, 0x07,
  0xC7, 0xC1, 0xF1, 0xF0, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0x83,
  0xFF, 0x80, 0x00, 0x18, 0x00, 0x3F, 0xE0, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F,
  0xFF, 0x03, 0xE0, 0x41, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C,
  0x08, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0xF8, 0xFC, 0x1F,
  0x0F, 0x83, 0xE0, 0xF8, 0x78, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C,
  0x0F, 0x8F, 0x83, 0xE1, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0,
  0x7C, 0x3E, 0x0F, 0x87, 0x83, 0xE1, 0xF0, 0xFC, 0x3E, 0x3F, 0x07, 0xFF,
  0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x83, 0xFF,
  0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0x81,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xE0, 0x07,
  0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xF8, 0x3F, 0xF8, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x00,
  0x0C, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F,
  0x81, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x3E, 0x1F, 0xE7, 0xC3, 0xF8, 0xF8, 0xFF, 0x1E, 0x1F, 0xE7, 0xC0,
  0x7C, 0xF8, 0x0F, 0x1F, 0x01, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0xE1,
  0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x07,
  0xC0, 0xF8, 0x3E, 0x07, 0x81, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0xF8, 0x1F,
  0x07, 0xC0, 0xF0, 0x3E, 0x0F, 0x81, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0xFF,
  0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0x03, 0xE0,
  0xF8, 0x1F, 0x07, 0xC0, 0xF0, 0x3E, 0x0F, 0x81, 0xE0, 0x7C, 0x1F, 0x03,
  0xE0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0x7C, 0x1F,
  0x03, 0xE0, 0x07, 0xFE, 0x1F, 0xF8, 0x1F, 0xE0, 0x0F, 0x00, 0x1E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x3E, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0x00, 0x07, 0xC1,
  0xF0, 0x78, 0x3E, 0x07, 0x87, 0xC0, 0x78, 0x7C, 0x0F, 0x8F, 0x80, 0xF9,
  0xF0, 0x0F, 0x3E, 0x00, 0xF3, 0xE0, 0x1F, 0x7C, 0x01, 0xFF, 0x80, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xEF, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0,
  0x78, 0x3C, 0x07, 0x83, 0xE0, 0x78, 0x3E, 0x0F, 0x83, 0xE0, 0x07, 0xC0,
  0x7C, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03,
  0xC0, 0x7C, 0x07, 0xC0, 0x7F, 0xF7, 0xFF, 0x7F, 0xFF, 0xFF, 0x07, 0xE0,
  0x0F, 0xC1, 0xF8, 0x07, 0xF0, 0x7E, 0x01, 0xFC, 0x1F, 0x80, 0xFF, 0x0F,
  0xF0, 0x3F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC3, 0xDE,
  0x1F, 0xF0, 0xFF, 0x07, 0xBC, 0x3B, 0xC1, 0xEF, 0x1E, 0xF0, 0x7B, 0xC7,
  0x3C, 0x1E, 0xF3, 0xDF, 0x0F, 0xBC, 0xF7, 0x83, 0xCF, 0x79, 0xE0, 0xF3,
  0xDE, 0x78, 0x3C, 0xFF, 0x3E, 0x0F, 0x3F, 0xCF, 0x87, 0xCF, 0xE3, 0xC1,
  0xE3, 0xF8, 0xF0, 0x78, 0xFC, 0x3C, 0x1E, 0x3F, 0x1F, 0x07, 0x87, 0x87,
  0xC3, 0xE1, 0xE1, 0xE0, 0x07, 0xE0, 0x3C, 0x1F, 0x81, 0xF0, 0x7E, 0x07,
  0x81, 0xF8, 0x1E, 0x0F, 0xF0, 0x78, 0x3F, 0xC3, 0xE0, 0xFF, 0x0F, 0x03,
  0xFC, 0x3C, 0x1F, 0xF0, 0xF0, 0x7B, 0xE3, 0xC1, 0xE7, 0x9F, 0x07, 0x9E,
  0x78, 0x1E, 0x79, 0xE0, 0xF9, 0xF7, 0x83, 0xC3, 0xDE, 0x0F, 0x0F, 0xF8,
  0x3C, 0x3F, 0xC0, 0xF0, 0xFF, 0x07, 0xC3, 0xFC, 0x1E, 0x07, 0xF0, 0x78,
  0x1F, 0xC1, 0xE0, 0x7E, 0x07, 0x81, 0xF8, 0x3E, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0xFE, 0xFC, 0x1F, 0x0F,
  0xC7, 0xC0, 0xF9, 0xF8, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7D, 0xF0, 0x0F,
  0xBE, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x0F, 0x9F, 0x01, 0xF7, 0xC0, 0x3E,
  0xF8, 0x07, 0xDF, 0x01, 0xF3, 0xE0, 0x3E, 0x3E, 0x0F, 0x87, 0xC3, 0xF0,
  0xFF, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x07, 0xFE,
  0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFF, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3C, 0x1F, 0x1F, 0x07, 0xC7, 0xC1, 0xF1, 0xF0, 0xF8, 0x7F,
  0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0x80, 0xF8, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0xE0, 0x0F, 0xFE, 0x03,
  0xFF, 0xE0, 0xFE, 0xFC, 0x1F, 0x0F, 0xC7, 0xC0, 0xF9, 0xF8, 0x1F, 0x3E,
  0x03, 0xE7, 0xC0, 0x7D, 0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x3E, 0xF8,
  0x0F, 0x9F, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x01, 0xF3, 0xE0,
  0x3E, 0x3E, 0x0F, 0x87, 0xC3, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x01, 0xFF,
  0xC0, 0x0F, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x07, 0xFC, 0x03, 0xFF, 0x81, 0xFF,
  0xE0, 0xFF, 0xF0, 0xF8, 0xF8, 0x7C, 0x3C, 0x3C, 0x1E, 0x1E, 0x1F, 0x1F,
  0x0F, 0x8F, 0x87, 0xC7, 0xCF, 0xC3, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xC0,
  0xFB, 0xE0, 0x7D, 0xF0, 0x3C, 0x78, 0x1E, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F,
  0x87, 0x83, 0xC3, 0xC1, 0xF1, 0xE0, 0xF9, 0xF0, 0x7C, 0x00, 0x30, 0x03,
  0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xFE, 0x1F, 0x82, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x80,
  0xF8, 0xC0, 0xF8, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x3C, 0x0F,
  0x8F, 0x81, 0xF1, 0xF0, 0x3C, 0x3E, 0x0F, 0x87, 0x81, 0xF0, 0xF0, 0x3E,
  0x3E, 0x07, 0x87, 0xC1, 0xF0, 0xF8, 0x3E, 0x1E, 0x07, 0xC7, 0xC0, 0xF8,
  0xF8, 0x1E, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x78, 0x1F, 0x0F, 0x03, 0xC3,
  0xE0, 0xF8, 0x3E, 0x3F, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00,
  0xFF, 0x00, 0xF8, 0x0F, 0xFC, 0x07, 0xBE, 0x07, 0xDF, 0x03, 0xCF, 0x83,
  0xE7, 0xC1, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E,
  0x3C, 0x1F, 0x3E, 0x07, 0x9E, 0x03, 0xDF, 0x01, 0xEF, 0x00, 0xF7, 0x80,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x1E, 0x07, 0xFC, 0x0F, 0x81, 0xEF,
  0x03, 0xE0, 0xFB, 0xC1, 0xF8, 0x3C, 0xF0, 0x7E, 0x1F, 0x3C, 0x1F, 0x87,
  0x8F, 0x0F, 0xE1, 0xE3, 0xC3, 0xF8, 0xF8, 0xF1, 0xFE, 0x3C, 0x3C, 0x7F,
  0x9F, 0x0F, 0x1D, 0xE7, 0x83, 0xCF, 0x79, 0xE0, 0xF3, 0x9E, 0xF8, 0x3D,
  0xE7, 0xBC, 0x0F, 0x79, 0xFF, 0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x1D, 0xE0,
  0x3F, 0x87, 0xF8, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFC, 0x1F,
  0x80, 0x3F, 0x07, 0xE0, 0x0F, 0x81, 0xF8, 0x03, 0xE0, 0x7C, 0x00, 0x03,
  0xC0, 0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0x78, 0x07, 0xC7, 0xC0, 0x1E, 0x7C,
  0x00, 0xF3, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7D, 0xF0, 0x03, 0xC7,
  0x80, 0x3E, 0x3C, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x81, 0xF0, 0x7C, 0x1F,
  0x01, 0xF0, 0xF8, 0x1F, 0xF8, 0x3E, 0x78, 0x3C, 0x78, 0x7C, 0x78, 0xF8,
  0x78, 0xF8, 0x7D, 0xF0, 0x7D, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7F,
  0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x03, 0xFC, 0x0F, 0xE0,
  0x3F, 0x81, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x00, 0xF0,
  0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x1C, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x0F, 0x0F,
  0x03, 0xF8, 0x1F, 0xC1, 0xFE, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8,
  0x07, 0xBC, 0x0F, 0x3C, 0x0F, 0x3C, 0x1E, 0x1C, 0x1C, 0x1E, 0x3C, 0x1E,
  0x78, 0x1E, 0x78, 0x0E, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF9, 0xE7, 0xCF,
  0x1C, 0x03, 0x8F, 0x0F, 0xEF, 0x1F, 0xFF, 0x1F, 0xFE, 0x3E, 0x3E, 0x7E,
  0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x78, 0x3C, 0xF8, 0x3C, 0xF8, 0x7C, 0xF8,
  0x7C, 0xF8, 0x7C, 0xF8, 0xF8, 0xF8, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F,
  0xF0, 0x3E, 0xF0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x3C, 0x0F, 0x7E, 0x1F, 0xFF, 0x1F,
  0xFF, 0x1F, 0x1F, 0x1F, 0x0F, 0x1E, 0x0F, 0x3E, 0x0F, 0x3C, 0x1F, 0x3C,
  0x1F, 0x3C, 0x1F, 0x3C, 0x1E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x7C, 0x7E,
  0xFC, 0x7F, 0xF8, 0xF7, 0xF0, 0xF3, 0xE0, 0x03, 0xF0, 0x3F, 0xC7, 0xFE,
  0x3F, 0xE3, 0xE1, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE1, 0x1F, 0xF8, 0x7F, 0xC3, 0xFE,
  0x0F, 0xE0, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x0E, 0x3C, 0x0F, 0xFF, 0x07, 0xFF,
  0xC1, 0xFF, 0xE0, 0xF8, 0xF8, 0x3C, 0x3E, 0x1F, 0x0F, 0x87, 0x83, 0xE1,
  0xE0, 0xF0, 0xF8, 0x3C, 0x3E, 0x0F, 0x0F, 0x87, 0xC3, 0xC1, 0xE0, 0xF0,
  0x78, 0x3E, 0x3E, 0x0F, 0xDF, 0x83, 0xFF, 0xE0, 0x7F, 0x70, 0x0F, 0x9C,
  0x00, 0x01, 0xE0, 0x1F, 0xE0, 0xFF, 0xC7, 0xFF, 0x3E, 0x3C, 0xF0, 0xF7,
  0xC3, 0xDE, 0x1F, 0xFF, 0xFB, 0xFF, 0xCF, 0xFC, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x80, 0x3E, 0x18, 0x7F, 0xE1, 0xFF, 0x81, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0,
  0x13, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xE7, 0x83, 0xFB, 0xC3, 0xFF, 0xE1, 0xFF,
  0xE1, 0xF1, 0xF0, 0xF0, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x3C, 0x1E, 0x3E,
  0x0F, 0x1F, 0x0F, 0x8F, 0x87, 0xC7, 0xC3, 0xE3, 0xE3, 0xE1, 0xF1, 0xF0,
  0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0xFC, 0x07, 0xDE, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x07, 0x82, 0x07, 0xC1, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F,
  0xC0, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x3C, 0x0F, 0x7E, 0x0F, 0xFF, 0x1F, 0xFF,
  0x1F, 0x9F, 0x1F, 0x1F, 0x1E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1E, 0x3E, 0x1E,
  0x3C, 0x1E, 0x3C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3C, 0x78, 0x3C, 0x78, 0x7C,
  0x78, 0x7C, 0xF8, 0x7C, 0xF8, 0x78, 0x03, 0x81, 0xF0, 0x7C, 0x1F, 0x07,
  0x80, 0x00, 0x00, 0x3E, 0x0F, 0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x03, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xE0,
  0xF8, 0x3E, 0x00, 0x00, 0x38, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x0F, 0xE0, 0x3F, 0x80, 0xFC,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x1F, 0x0F, 0x0F, 0x83,
  0xC7, 0xC1, 0xF3, 0xE0, 0x78, 0xF0, 0x1E, 0x78, 0x07, 0xBE, 0x03, 0xFF,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xF3, 0xC0,
  0x7C, 0xF0, 0x1E, 0x3E, 0x07, 0x8F, 0x81, 0xE1, 0xE0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x03, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xE0, 0xF8, 0x3E, 0x00, 0x0E,
  0x3C, 0x1C, 0x0E, 0x7E, 0x7E, 0x1E, 0xFE, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F,
  0x9F, 0x9F, 0x1F, 0x1F, 0x0F, 0x1E, 0x1F, 0x0F, 0x3E, 0x1E, 0x1F, 0x3E,
  0x1E, 0x1F, 0x3C, 0x1E, 0x1E, 0x3C, 0x3E, 0x1E, 0x3C, 0x3E, 0x1E, 0x7C,
  0x3C, 0x3E, 0x7C, 0x3C, 0x3E, 0x78, 0x7C, 0x3C, 0x78, 0x7C, 0x3C, 0x78,
  0x78, 0x7C, 0xF8, 0x78, 0x7C, 0xF8, 0x78, 0x78, 0x0E, 0x3C, 0x0E, 0x7E,
  0x0E, 0xFF, 0x1F, 0xFF, 0x1F, 0x9F, 0x1F, 0x1F, 0x1E, 0x1F, 0x3E, 0x1F,
  0x3E, 0x1E, 0x3E, 0x1E, 0x3C, 0x1E, 0x3C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3C,
  0x78, 0x3C, 0x78, 0x3C, 0x78, 0x7C, 0xF8, 0x7C, 0xF8, 0x78, 0x03, 0xE0,
  0x1F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE3, 0xE3, 0xCF, 0x87, 0xDF, 0x0F, 0xBC,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7B, 0xE0, 0xF7, 0x83, 0xEF, 0x07, 0xDE, 0x0F,
  0x3E, 0x3E, 0x7F, 0xF8, 0x7F, 0xF0, 0xFF, 0xC0, 0x7E, 0x00, 0x03, 0x8F,
  0x00, 0xE7, 0xE0, 0x3B, 0xFC, 0x1F, 0xFF, 0x07, 0xC7, 0xC1, 0xF0, 0xF0,
  0x78, 0x3C, 0x3E, 0x0F, 0x0F, 0x87, 0xC3, 0xC1, 0xF0, 0xF0, 0x7C, 0x3C,
  0x1E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF1, 0xF0, 0x7E, 0xFC, 0x1F, 0xFE,
  0x0F, 0xFF, 0x03, 0xEF, 0x80, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xCF, 0x0F, 0xEF, 0x1F, 0xEF, 0x1F, 0xFE, 0x3E, 0x3E, 0x3C, 0x3E, 0x7C,
  0x3E, 0x78, 0x3E, 0x78, 0x3C, 0xF8, 0x3C, 0xF8, 0x3C, 0xF8, 0x7C, 0xF0,
  0x78, 0xF0, 0x78, 0xF8, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0xF0, 0x3E,
  0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x0F, 0x3C, 0x39, 0xE1, 0xEF, 0x87, 0xFE,
  0x1F, 0xF0, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0,
  0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x3F, 0xF1, 0xFF, 0x8F, 0xFE, 0x3E, 0x10,
  0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0xF8,
  0x03, 0xF0, 0x07, 0xC8, 0x3E, 0x3D, 0xF8, 0xFF, 0xE3, 0xFF, 0x0F, 0xF0,
  0x00, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0xF3, 0xFE, 0xFF, 0xDF, 0xF1, 0xF0,
  0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78,
  0x1F, 0x03, 0xF4, 0x7F, 0x87, 0xF0, 0xFE, 0x00, 0x1E, 0x0F, 0x1E, 0x1F,
  0x3E, 0x1E, 0x3E, 0x1E, 0x3C, 0x1E, 0x3C, 0x3E, 0x3C, 0x3E, 0x7C, 0x3C,
  0x7C, 0x3C, 0x78, 0x3C, 0x78, 0x7C, 0xF8, 0x7C, 0xF8, 0x78, 0xF8, 0xF8,
  0xF8, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0x70, 0x7E, 0x70, 0xF0, 0x3F,
  0xE0, 0xFB, 0xC1, 0xF7, 0x83, 0xCF, 0x0F, 0x9E, 0x1E, 0x3C, 0x7C, 0x78,
  0xF0, 0xF3, 0xE1, 0xE7, 0x81, 0xCF, 0x03, 0xBC, 0x07, 0x78, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0xF0, 0x7C,
  0x3F, 0xC3, 0xF0, 0xFF, 0x0F, 0xC7, 0xFC, 0x3F, 0x1E, 0xF1, 0xF8, 0xFB,
  0xC7, 0xE3, 0xCF, 0x3F, 0x8F, 0x3C, 0xEE, 0x78, 0xF3, 0xB9, 0xE3, 0xDE,
  0xEF, 0x8F, 0x73, 0xBC, 0x3F, 0xCE, 0xF0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE,
  0x0F, 0xE3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xF8, 0x0F,
  0x83, 0xE0, 0x00, 0x0F, 0x83, 0xE0, 0xF0, 0xF8, 0x1F, 0x3E, 0x03, 0xE7,
  0xC0, 0x3D, 0xF0, 0x07, 0xBC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0,
  0x07, 0xDF, 0x00, 0xF3, 0xE0, 0x3E, 0x3C, 0x0F, 0x87, 0x83, 0xF0, 0xF8,
  0x00, 0x07, 0x81, 0xF0, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0x7C, 0x3C, 0x07,
  0xC7, 0xC0, 0x7C, 0x78, 0x07, 0xCF, 0x80, 0x3C, 0xF0, 0x03, 0xDF, 0x00,
  0x3D, 0xE0, 0x03, 0xDE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x1F,
  0xF8, 0x3F, 0xF0, 0xFF, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF0,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x0F,
  0x00, 0x3F, 0xF8, 0xFF, 0xF1, 0xFF, 0xC3, 0xFF, 0x80, 0x00, 0x7C, 0x07,
  0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07,
  0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x7F, 0x01, 0xF8, 0x07, 0x80, 0x3F,
  0x00, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xE0, 0x7F, 0x07, 0xF8, 0x3E, 0x03, 0xE0,
  0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x03, 0xF0, 0x3F,
  0x81, 0xF8, 0x0F, 0x80, 0x00, 0x1C, 0x02, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1F, 0xF0, 0x0F, 0x00,
};

const GFXglyph NotoSans_Condensed_BoldItalic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 10, 24, 9, 0, -24 },
  { 31, 12, 9, 14, 3, -24 },
  { 45, 19, 24, 18, 0, -24 },
  { 102, 16, 28, 16, 0, -26 },
  { 158, 22, 25, 26, 2, -25 },
  { 227, 19, 25, 20, 0, -25 },
  { 287, 6, 9, 8, 3, -24 },
  { 294, 11, 29, 10, 1, -24 },
  { 334, 12, 30, 10, -3, -25 },
  { 379, 13, 15, 15, 3, -26 },
  { 404, 15, 16, 17, 1, -20 },
  { 434, 8, 9, 9, -2, -4 },
  { 443, 10, 4, 10, 0, -11 },
  { 448, 6, 5, 9, 0, -5 },
  { 452, 18, 25, 13, -2, -25 },
  { 509, 15, 25, 16, 1, -25 },
  { 556, 12, 24, 16, 3, -24 },
  { 592, 17, 25, 16, -1, -25 },
  { 646, 16, 25, 16, 0, -25 },
  { 696, 16, 24, 16, 0, -24 },
  { 744, 16, 24, 16, 0, -24 },
  { 792, 16, 25, 16, 1, -25 },
  { 842, 17, 24, 16, 1, -24 },
  { 893, 16, 25, 16, 0, -25 },
  { 943, 16, 25, 16, 0, -25 },
  { 993, 9, 19, 9, 0, -19 },
  { 1015, 11, 24, 9, -2, -19 },
  { 1048, 15, 17, 17, 1, -21 },
  { 1080, 15, 10, 17, 1, -17 },
  { 1099, 15, 17, 17, 1, -21 },
  { 1131, 13, 25, 13, 1, -25 },
  { 1172, 23, 27, 24, 1, -24 },
  { 1250, 18, 24, 18, -2, -24 },
  { 1304, 18, 24, 18, 0, -24 },
  { 1358, 18, 25, 17, 1, -25 },
  { 1415, 19, 24, 19, 0, -24 },
  { 1472, 17, 24, 15, 0, -24 },
  { 1523, 16, 24, 15, 0, -24 },
  { 1571, 19, 25, 20, 1, -25 },
  { 1631, 21, 24, 20, 0, -24 },
  { 1694, 15, 24, 11, -1, -24 },
  { 1739, 15, 31, 9, -5, -24 },
  { 1798, 20, 24, 17, 0, -24 },
  { 1858, 12, 24, 14, 0, -24 },
  { 1894, 26, 24, 26, 0, -24 },
  { 1972, 22, 24, 21, 0, -24 },
  { 2038, 19, 25, 20, 1, -25 },
  { 2098, 18, 24, 17, 0, -24 },
  { 2152, 19, 31, 20, 1, -25 },
  { 2226, 17, 24, 17, 0, -24 },
  { 2277, 16, 25, 15, 0, -25 },
  { 2327, 14, 24, 15, 3, -24 },
  { 2369, 19, 24, 19, 1, -24 },
  { 2426, 17, 24, 17, 3, -24 },
  { 2477, 26, 24, 26, 3, -24 },
  { 2555, 21, 24, 17, -2, -24 },
  { 2618, 16, 24, 16, 3, -24 },
  { 2666, 18, 24, 15, -1, -24 },
  { 2720, 14, 29, 10, -1, -24 },
  { 2771, 8, 25, 13, 3, -25 },
  { 2796, 13, 29, 10, -2, -24 },
  { 2844, 16, 15, 16, 0, -24 },
  { 2874, 12, 2, 12, -3, 3 },
  { 2877, 6, 5, 10, 5, -26 },
  { 2881, 16, 19, 17, 1, -19 },
  { 2919, 16, 26, 17, 0, -26 },
  { 2971, 13, 19, 14, 1, -19 },
  { 3002, 18, 26, 17, 1, -26 },
  { 3061, 14, 19, 16, 1, -19 },
  { 3095, 18, 34, 10, -4, -26 },
  { 3172, 17, 27, 17, 0, -19 },
  { 3230, 16, 26, 17, 0, -26 },
  { 3282, 10, 26, 9, 0, -26 },
  { 3315, 14, 34, 9, -4, -26 },
  { 3375, 18, 26, 16, 0, -26 },
  { 3434, 10, 26, 8, 0, -26 },
  { 3467, 24, 19, 25, 0, -19 },
  { 3524, 16, 19, 17, 0, -19 },
  { 3562, 15, 19, 17, 1, -19 },
  { 3598, 18, 27, 17, -2, -19 },
  { 3659, 16, 27, 17, 1, -19 },
  { 3713, 14, 19, 12, 0, -19 },
  { 3747, 14, 19, 13, 0, -19 },
  { 3781, 11, 22, 11, 1, -22 },
  { 3812, 16, 19, 17, 1, -19 },
  { 3850, 15, 19, 15, 2, -19 },
  { 3886, 22, 19, 23, 2, -19 },
  { 3939, 19, 19, 15, -2, -19 },
  { 3985, 20, 27, 15, -3, -19 },
  { 4053, 15, 19, 13, -1, -19 },
  { 4089, 14, 29, 12, 0, -24 },
  { 4140, 4, 34, 14, 5, -26 },
  { 4157, 13, 29, 12, -2, -24 },
  { 4205, 15, 6, 17, 1, -15 },
};

const GFXfont NotoSans_Condensed_BoldItalic34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BoldItalic34pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BoldItalic34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_CONDENSED_BOLDITALIC34PT7B_H_
