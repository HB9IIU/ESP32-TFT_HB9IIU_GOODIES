#ifndef _NOTOSANS_CONDENSED_BOLDITALIC47PT7B_H_
#define _NOTOSANS_CONDENSED_BOLDITALIC47PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BoldItalic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BoldItalic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x01, 0xF0,
  0x01, 0x00, 0x00, 0x7E, 0x3F, 0x7E, 0x3F, 0x7E, 0x3F, 0x7E, 0x3E, 0x7C,
  0x7E, 0x7C, 0x7E, 0xFC, 0x7E, 0xFC, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8,
  0x78, 0xF0, 0xF8, 0xF0, 0xF8, 0x00, 0x0F, 0x0F, 0x80, 0x07, 0xC3, 0xC0,
  0x01, 0xF1, 0xF0, 0x00, 0x78, 0x7C, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x87,
  0x80, 0x03, 0xC3, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x1E,
  0x1F, 0x00, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xE0, 0x0F, 0x0F, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xE1, 0xF0,
  0x00, 0x78, 0x78, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x0F, 0x80, 0x7F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFC, 0x03, 0xE3, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x3C, 0x3C, 0x00,
  0x1F, 0x1F, 0x00, 0x07, 0x87, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF8, 0x78,
  0x00, 0x3C, 0x3E, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x01, 0xFF, 0x00, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xED,
  0xF0, 0x1F, 0x98, 0xC0, 0x7E, 0x70, 0x00, 0xFC, 0xC0, 0x01, 0xFD, 0x80,
  0x03, 0xFB, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x1B, 0xF8, 0x00, 0x33, 0xF0, 0x00, 0xE7, 0xE1, 0x01,
  0xCF, 0xC3, 0x83, 0x3F, 0x87, 0xE6, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xF8, 0x01, 0xF0, 0x0F, 0xFC, 0x01,
  0xE0, 0x0F, 0xFC, 0x03, 0xE0, 0x1F, 0x3E, 0x07, 0xC0, 0x3E, 0x3E, 0x07,
  0xC0, 0x3E, 0x3E, 0x0F, 0x80, 0x3C, 0x3E, 0x0F, 0x00, 0x7C, 0x3E, 0x1F,
  0x00, 0x7C, 0x3E, 0x3E, 0x00, 0x7C, 0x3C, 0x3E, 0x00, 0x78, 0x7C, 0x7C,
  0x00, 0x78, 0x7C, 0x78, 0x00, 0xF8, 0x7C, 0xF8, 0x60, 0xF8, 0xF9, 0xF1,
  0xFC, 0x78, 0xF9, 0xF3, 0xFE, 0x7D, 0xF3, 0xE7, 0xFE, 0x7F, 0xF3, 0xCF,
  0xFF, 0x7F, 0xE7, 0xCF, 0x9F, 0x3F, 0xCF, 0x9F, 0x1F, 0x1F, 0x0F, 0x9F,
  0x1F, 0x00, 0x1F, 0x3E, 0x1F, 0x00, 0x1E, 0x3E, 0x1F, 0x00, 0x3E, 0x3E,
  0x1F, 0x00, 0x7C, 0x3E, 0x1E, 0x00, 0x7C, 0x3C, 0x3E, 0x00, 0xF8, 0x3C,
  0x3E, 0x01, 0xF0, 0x3C, 0x3C, 0x01, 0xF0, 0x3C, 0x7C, 0x03, 0xE0, 0x3C,
  0x7C, 0x03, 0xE0, 0x3F, 0xF8, 0x07, 0xC0, 0x3F, 0xF0, 0x0F, 0x80, 0x1F,
  0xE0, 0x0F, 0x80, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xF1,
  0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0x87, 0xE0, 0x01, 0xF0, 0xFC, 0x00,
  0x3E, 0x1F, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x07, 0xE0, 0xFF, 0xE1, 0xF8, 0x3F, 0xFC, 0x3F, 0x0F, 0xFF, 0xCF,
  0xC3, 0xFB, 0xF9, 0xF8, 0x7E, 0x3F, 0xFF, 0x1F, 0xC7, 0xFF, 0xC3, 0xF0,
  0x7F, 0xF0, 0x7E, 0x0F, 0xFE, 0x1F, 0xC0, 0xFF, 0x83, 0xF8, 0x1F, 0xE0,
  0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFE, 0xFE, 0x01, 0xFF, 0x0F, 0xE0,
  0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0xFC, 0xFC, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF0, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x01,
  0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01,
  0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xF4, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x06, 0x0F, 0x80, 0xF1, 0xE0, 0x1F, 0xBC, 0x0F, 0xFF, 0xBF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0x80, 0x3F, 0xF0,
  0x0F, 0xDF, 0x03, 0xFB, 0xE0, 0x3E, 0x3E, 0x03, 0x87, 0xE0, 0x30, 0xF8,
  0x04, 0x0C, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0xC7, 0xF1, 0xF8, 0x7E, 0x3F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7E,
  0x1F, 0x0F, 0xC3, 0xE0, 0x7F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFE, 0x3E, 0x7F, 0x7F, 0xFF, 0xFE, 0xFE, 0x7C, 0x10, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x03,
  0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0x8F, 0xE1, 0xF8, 0x3F,
  0x0F, 0xC1, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x7F, 0x03, 0xF3, 0xF0,
  0x1F, 0x9F, 0x81, 0xFD, 0xFC, 0x0F, 0xEF, 0xE0, 0x7E, 0x7E, 0x03, 0xF3,
  0xF0, 0x1F, 0x9F, 0x81, 0xFD, 0xFC, 0x0F, 0xEF, 0xE0, 0x7E, 0x7E, 0x03,
  0xF3, 0xF0, 0x3F, 0x9F, 0x81, 0xFC, 0xFC, 0x0F, 0xC7, 0xE0, 0xFE, 0x3F,
  0x07, 0xE1, 0xF8, 0x7F, 0x0F, 0xE7, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xF8,
  0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8,
  0x7F, 0xFC, 0x7F, 0xFE, 0x7F, 0xBF, 0x1F, 0xBF, 0x07, 0x1F, 0x81, 0x0F,
  0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x01, 0xF0, 0x7F, 0x00, 0xE0, 0x7F, 0x00, 0x80,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF,
  0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xDF, 0xF0, 0x18, 0x1F, 0xC0,
  0x40, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xE0,
  0x01, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x20, 0x07, 0xF8, 0xE0, 0x3F, 0xC3,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xF7, 0xE0, 0x03, 0xEF,
  0xC0, 0x0F, 0x9F, 0x80, 0x1E, 0x7E, 0x00, 0x7C, 0xFC, 0x01, 0xF1, 0xF8,
  0x03, 0xC3, 0xF0, 0x0F, 0x87, 0xE0, 0x3E, 0x1F, 0x80, 0xF8, 0x3F, 0x01,
  0xF0, 0x7E, 0x07, 0xC0, 0xFC, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x61, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x20, 0x07, 0xF0, 0xF0, 0x7F, 0xC3,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFC, 0x60, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x8F, 0x00, 0xFC, 0xFE, 0x03, 0xF7, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x87, 0xF8, 0x7E, 0x1F, 0xC1, 0xFC, 0x7E, 0x07, 0xF1,
  0xF8, 0x1F, 0x8F, 0xE0, 0x7E, 0x3F, 0x81, 0xF8, 0xFE, 0x07, 0xE3, 0xF8,
  0x3F, 0x8F, 0xE0, 0xFC, 0x1F, 0x87, 0xF0, 0x7F, 0x3F, 0xC1, 0xFF, 0xFE,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xC7, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x7E, 0x07,
  0xF3, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0x8F, 0xE0,
  0xFC, 0x1F, 0x87, 0xE0, 0x7F, 0x1F, 0x80, 0xFC, 0xFE, 0x03, 0xF3, 0xF8,
  0x0F, 0xCF, 0xE0, 0x7F, 0x3F, 0x81, 0xF8, 0xFE, 0x0F, 0xE1, 0xFF, 0xFF,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0x0F, 0xE3, 0xF0, 0x7F, 0x1F, 0x83, 0xF9,
  0xFC, 0x1F, 0xCF, 0xC0, 0xFE, 0x7E, 0x07, 0xF3, 0xF0, 0x3F, 0x9F, 0x81,
  0xFC, 0xFC, 0x1F, 0xC7, 0xE0, 0xFE, 0x3F, 0x8F, 0xF1, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0x7E, 0x03, 0xE7, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFE, 0x08, 0x1F, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00,
  0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x7E, 0x07, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFE, 0x07, 0xC0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x7E, 0x07, 0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x07, 0xC0, 0x10, 0x00, 0x00,
  0x3C, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x3E,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF0,
  0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x00,
  0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xE0,
  0x00, 0xF8, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x07,
  0xFF, 0x0F, 0xFF, 0xC7, 0xFF, 0xF3, 0xFF, 0xF8, 0xF1, 0xFC, 0x60, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x07, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7C,
  0x01, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x1F,
  0x07, 0x80, 0xFE, 0x1F, 0x0F, 0x83, 0xFF, 0x8F, 0x0F, 0x07, 0xFF, 0x8F,
  0x1F, 0x0F, 0xFF, 0x0F, 0x1E, 0x1F, 0x0F, 0x0F, 0x3E, 0x1E, 0x1F, 0x0F,
  0x3C, 0x3E, 0x1F, 0x0F, 0x3C, 0x3C, 0x1E, 0x1F, 0x7C, 0x7C, 0x1E, 0x1F,
  0x78, 0x78, 0x3E, 0x1E, 0x78, 0x78, 0x3E, 0x1E, 0x78, 0xF8, 0x3C, 0x3E,
  0x78, 0xF8, 0x7C, 0x3C, 0xF8, 0xF8, 0x7C, 0x3C, 0xF8, 0xF8, 0xFC, 0x78,
  0xF8, 0xF8, 0xFC, 0xF8, 0xF8, 0x7F, 0xFF, 0xF0, 0xF8, 0x7F, 0xBF, 0xE0,
  0x78, 0x3F, 0x1F, 0xC0, 0x78, 0x1E, 0x0F, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x04, 0x00,
  0x1F, 0xC0, 0x3C, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xBE, 0x00,
  0x1F, 0xBF, 0x00, 0x1F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00,
  0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x3F, 0x00,
  0xFC, 0x3F, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0x03, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x0F, 0xC0, 0x3F, 0x1F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x3F,
  0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xC1, 0xFE,
  0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0x81, 0xF8, 0x0F,
  0xC0, 0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x3F, 0x0F, 0xF0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03, 0xFF,
  0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7E,
  0x03, 0xF0, 0x7F, 0x01, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0x80, 0xFE, 0x0F,
  0xC0, 0x7E, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0xFF, 0x83, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xF8, 0x18, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x80, 0x7F, 0xC7, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x3F, 0x8F, 0xF8, 0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x3F,
  0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xE0,
  0x1F, 0xC1, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F,
  0xC0, 0x1F, 0x83, 0xF0, 0x0F, 0xE0, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFE,
  0x1F, 0xC0, 0x3F, 0x87, 0xE0, 0x1F, 0xC1, 0xF8, 0x07, 0xF0, 0xFE, 0x03,
  0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0xC0, 0xFC,
  0x1F, 0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x80, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0,
  0x70, 0x3F, 0xC0, 0x08, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x1F, 0xFC, 0x7F, 0x07, 0xFE, 0x3F, 0x83, 0xFF,
  0x8F, 0xE0, 0xFF, 0xE3, 0xF8, 0x3F, 0xF8, 0xFE, 0x0F, 0xFE, 0x3F, 0x80,
  0x3F, 0x0F, 0xE0, 0x0F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F,
  0x80, 0x7E, 0x0F, 0xF0, 0x1F, 0x81, 0xFC, 0x07, 0xE0, 0x7F, 0xC3, 0xF8,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F,
  0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x01,
  0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F,
  0x80, 0x7E, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x01,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x07, 0xF0,
  0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x80, 0x7E, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xF8, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00,
  0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x01, 0xF8, 0x0F, 0xE0, 0x1F, 0x81,
  0xFC, 0x01, 0xF8, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x03, 0xF0, 0x7F, 0x00,
  0x3F, 0x0F, 0xE0, 0x03, 0xF1, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xE3,
  0xF8, 0x00, 0x7E, 0x7F, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7E, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0,
  0x01, 0xFC, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x3F,
  0x8F, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7F,
  0x00, 0x7F, 0x07, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0x7E, 0x03, 0xF0, 0x07,
  0xE0, 0x3F, 0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xFF, 0xFB,
  0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFE, 0x7F, 0xFF, 0x7F, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x1F, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xF0,
  0x07, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFE, 0x03,
  0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x01, 0xF7,
  0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xEF, 0xC0, 0x7D, 0xF0,
  0x3E, 0xFC, 0x0F, 0xDF, 0x07, 0xFF, 0x80, 0xFD, 0xF0, 0x7D, 0xF8, 0x0F,
  0xDF, 0x0F, 0xDF, 0x80, 0xFD, 0xF0, 0xF9, 0xF8, 0x0F, 0x9F, 0x1F, 0x9F,
  0x81, 0xF9, 0xF1, 0xF3, 0xF0, 0x1F, 0x9F, 0x3F, 0x3F, 0x01, 0xF9, 0xF3,
  0xE3, 0xF0, 0x1F, 0x9F, 0xBE, 0x3F, 0x03, 0xF1, 0xFF, 0xC3, 0xF0, 0x3F,
  0x0F, 0xFC, 0x7E, 0x03, 0xF0, 0xFF, 0x87, 0xE0, 0x3F, 0x0F, 0xF8, 0x7E,
  0x03, 0xE0, 0xFF, 0x07, 0xE0, 0x7E, 0x0F, 0xF0, 0x7C, 0x07, 0xE0, 0xFF,
  0x0F, 0xC0, 0x7E, 0x0F, 0xE0, 0xFC, 0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0x7C,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0xFC,
  0x07, 0xF8, 0x03, 0xF0, 0x1F, 0xE0, 0x0F, 0xC0, 0x7F, 0x80, 0x3F, 0x01,
  0xFE, 0x00, 0xF8, 0x0F, 0xFC, 0x07, 0xE0, 0x3F, 0xF0, 0x1F, 0x80, 0xFF,
  0xC0, 0x7E, 0x03, 0xFF, 0x01, 0xF8, 0x1F, 0xFC, 0x0F, 0xC0, 0x7F, 0xF8,
  0x3F, 0x01, 0xFF, 0xE0, 0xFC, 0x07, 0xDF, 0x83, 0xF0, 0x1F, 0x3E, 0x0F,
  0xC0, 0xFC, 0xFC, 0x7E, 0x03, 0xF3, 0xF1, 0xF8, 0x0F, 0xCF, 0xC7, 0xE0,
  0x3F, 0x1F, 0x1F, 0x80, 0xF8, 0x7C, 0x7C, 0x07, 0xE1, 0xFB, 0xF0, 0x1F,
  0x87, 0xEF, 0xC0, 0x7E, 0x1F, 0xBF, 0x01, 0xF8, 0x3E, 0xFC, 0x0F, 0xC0,
  0xFF, 0xE0, 0x3F, 0x03, 0xFF, 0x80, 0xFC, 0x0F, 0xFE, 0x03, 0xF0, 0x3F,
  0xF8, 0x0F, 0x80, 0x7F, 0xE0, 0x7E, 0x01, 0xFF, 0x01, 0xF8, 0x07, 0xFC,
  0x07, 0xE0, 0x1F, 0xF0, 0x1F, 0x80, 0x3F, 0xC0, 0x7C, 0x00, 0xFF, 0x03,
  0xF0, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0,
  0x7F, 0x87, 0xF8, 0x3F, 0x80, 0xFE, 0x1F, 0xE0, 0x1F, 0x87, 0xF0, 0x07,
  0xE3, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xDF, 0xC0,
  0x07, 0xE7, 0xF0, 0x01, 0xF9, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0xBF,
  0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x7F,
  0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xF3, 0xF8, 0x03, 0xF8, 0xFE, 0x00,
  0xFE, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x3F, 0xC3, 0xFC, 0x1F, 0xE0, 0x7F,
  0x8F, 0xF8, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFC, 0x0F, 0xE1, 0xFE, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x83,
  0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFC, 0x07, 0xF0, 0x7E, 0x03, 0xF8,
  0x3F, 0x01, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0xC7, 0xFE,
  0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xE0, 0x7F, 0x87, 0xF8, 0x3F, 0x80, 0xFE, 0x1F, 0xE0, 0x1F, 0x87,
  0xF0, 0x07, 0xE3, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F,
  0xDF, 0xC0, 0x07, 0xE7, 0xF0, 0x01, 0xF9, 0xFC, 0x00, 0xFE, 0x7F, 0x00,
  0x3F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFC, 0xFE,
  0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xF3, 0xF8, 0x03, 0xF8,
  0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x3F, 0xC3, 0xFC, 0x1F,
  0xE0, 0x7F, 0x8F, 0xF8, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xF0, 0xFF, 0x03, 0xF0, 0x7F, 0x03,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7F, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xE1, 0xFE, 0x0F, 0xC3, 0xFC, 0x0F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x1F, 0x9F, 0xC0, 0x1F, 0x8F, 0xC0, 0x3F, 0x8F, 0xC0, 0x3F,
  0x8F, 0xE0, 0x3F, 0x0F, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x7F,
  0x07, 0xF0, 0x7E, 0x07, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF8, 0x7E,
  0x03, 0xF8, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFE,
  0x0E, 0x07, 0xF8, 0x08, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x82, 0x00, 0x3F, 0x07, 0x00,
  0xFE, 0x0F, 0xCF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x0F, 0xC1,
  0xFC, 0x07, 0xF0, 0x7E, 0x01, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xE0, 0x1F,
  0x83, 0xF8, 0x0F, 0xE0, 0xFC, 0x03, 0xF8, 0x3F, 0x00, 0xFE, 0x1F, 0xC0,
  0x3F, 0x07, 0xF0, 0x0F, 0xC1, 0xFC, 0x07, 0xF0, 0x7E, 0x01, 0xFC, 0x1F,
  0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0x83, 0xF8, 0x07, 0xE0, 0xFE, 0x03, 0xF8,
  0x3F, 0x00, 0xFE, 0x0F, 0xC0, 0x3F, 0x07, 0xF0, 0x0F, 0xC1, 0xFC, 0x07,
  0xF0, 0x7E, 0x01, 0xFC, 0x1F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0x83, 0xF8,
  0x07, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFF, 0x1F, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0xFC, 0xFE,
  0x01, 0xFC, 0xFE, 0x01, 0xF8, 0xFE, 0x01, 0xF8, 0xFE, 0x03, 0xF8, 0x7E,
  0x03, 0xF0, 0x7E, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0x7E,
  0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E,
  0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x7F, 0x00, 0x7E, 0x7E, 0x00, 0x7E,
  0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7D,
  0xF8, 0x00, 0x7D, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xFF, 0xC0, 0x1F,
  0x80, 0x7E, 0xFC, 0x03, 0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0x80, 0xFE, 0xFC,
  0x03, 0xF8, 0x0F, 0xCF, 0xC0, 0x7F, 0x80, 0xFC, 0xFC, 0x07, 0xF8, 0x1F,
  0x8F, 0xC0, 0xFF, 0x81, 0xF8, 0xFC, 0x0F, 0xF8, 0x3F, 0x8F, 0xC0, 0xFF,
  0x83, 0xF0, 0xFC, 0x1F, 0xF8, 0x3F, 0x0F, 0xC1, 0xFF, 0x87, 0xE0, 0xFC,
  0x3E, 0xF0, 0x7E, 0x0F, 0xC3, 0xFF, 0x0F, 0xE0, 0xFC, 0x7F, 0xF0, 0xFC,
  0x0F, 0xC7, 0xDF, 0x0F, 0xC0, 0xFC, 0x7D, 0xF1, 0xF8, 0x0F, 0xCF, 0xDF,
  0x1F, 0x80, 0xFC, 0xF9, 0xF3, 0xF8, 0x0F, 0xDF, 0x9F, 0x3F, 0x00, 0xFD,
  0xF1, 0xF3, 0xF0, 0x0F, 0xDF, 0x1F, 0x7E, 0x00, 0xFF, 0xE1, 0xF7, 0xE0,
  0x0F, 0xBE, 0x1F, 0x7C, 0x00, 0xFB, 0xE1, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F,
  0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF,
  0x81, 0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0x01, 0xFF, 0x00,
  0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0,
  0x7F, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x01, 0xF8, 0x3F,
  0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0xFD, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xF9, 0xF8, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x7F, 0x1F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x7F, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xE0,
  0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xF7, 0xE0, 0x3F, 0x9F, 0x80, 0xFC, 0x7E, 0x07, 0xF1,
  0xF8, 0x1F, 0x87, 0xE0, 0xFE, 0x1F, 0x83, 0xF0, 0x3F, 0x1F, 0x80, 0xFC,
  0xFE, 0x03, 0xF3, 0xF0, 0x0F, 0xDF, 0xC0, 0x3F, 0x7E, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFF,
  0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0xF8, 0x3E, 0x0F,
  0xC3, 0xF0, 0xFC, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x87, 0xE1, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3F, 0x0F, 0xC3, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xEF, 0x80, 0x1F, 0x3E,
  0x00, 0xF8, 0xF8, 0x07, 0xE3, 0xF0, 0x1F, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x1F, 0x01, 0xF8, 0xFC, 0x03, 0xE3, 0xE0, 0x0F, 0x9F, 0x00,
  0x3E, 0xFC, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xC0, 0xFE,
  0x7F, 0x1F, 0x87, 0xE3, 0xF0, 0xF8, 0x3E, 0x1F, 0x00, 0xFC, 0x7E, 0x07,
  0xFC, 0xF8, 0x1F, 0xFB, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFC,
  0xFF, 0x87, 0xF0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7E, 0x07,
  0xF1, 0xFC, 0x0F, 0xC3, 0xF8, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E,
  0x1F, 0x81, 0xFC, 0x7F, 0x03, 0xF0, 0xFE, 0x07, 0xE1, 0xFC, 0x1F, 0xC3,
  0xF8, 0x3F, 0x87, 0xF0, 0xFF, 0x0F, 0xE3, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x3F, 0xF7, 0xE0, 0x3F, 0xCF, 0x80, 0x3F, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x3E, 0x01, 0xFB, 0xFC, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFC, 0x7F, 0x0F, 0xE0, 0xFC, 0x3F, 0x03,
  0xF0, 0xFC, 0x0F, 0xC7, 0xF0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF1,
  0xF8, 0x0F, 0xC7, 0xE0, 0x7F, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF0,
  0x3F, 0x8F, 0xC0, 0xFE, 0x3F, 0x03, 0xF1, 0xFC, 0x1F, 0xC7, 0xF8, 0xFE,
  0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xDF, 0xF0, 0x3E,
  0x3F, 0x80, 0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xE0,
  0xFF, 0xFC, 0x3F, 0xC3, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x01, 0x07, 0xF0, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F,
  0xFE, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x3F, 0x3F, 0x80, 0x3F, 0xDF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x3F, 0xCF, 0xF0, 0x1F, 0xC3, 0xF8, 0x1F, 0xC1, 0xFC,
  0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x1F,
  0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x7F, 0x03,
  0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0,
  0x7E, 0x03, 0xF8, 0x7F, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFB, 0xE0, 0x03, 0xF9, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0xFC, 0x3F,
  0x1F, 0x83, 0xF3, 0xF8, 0x3F, 0x3F, 0x03, 0xF3, 0xF0, 0x7E, 0x7E, 0x1F,
  0xE7, 0xFF, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xF8, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E,
  0x01, 0x07, 0xF9, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x10, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x47, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x3F, 0xCF, 0x80,
  0x7F, 0xF7, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xCF, 0xF8,
  0x1F, 0xC3, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x7F,
  0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x07,
  0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0xC1,
  0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0xFF, 0x03, 0xF8, 0xFF, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xF7, 0xE0, 0x0F, 0xF7, 0xE0, 0x03,
  0xF3, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7E, 0x02, 0x00, 0x7F, 0x01, 0xE0, 0x7F, 0x00, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x3E, 0x01, 0xFB, 0xFE, 0x07, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFE, 0x7F, 0x0F, 0xF0, 0xFC,
  0x3F, 0x83, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x1F, 0xC1, 0xFC, 0x7E,
  0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x3F, 0x81, 0xF8, 0xFC, 0x0F,
  0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF1, 0xFC, 0x1F, 0xC7,
  0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x8F, 0xE0,
  0xFE, 0x3F, 0x03, 0xF0, 0x00, 0x70, 0x03, 0xE0, 0x1F, 0xC0, 0x7F, 0x03,
  0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x01,
  0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x3E,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x08, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x3F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x07, 0xE1, 0xFC, 0x07,
  0xE3, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F, 0xC7, 0xE0, 0x0F, 0xCF, 0xC0, 0x0F,
  0xDF, 0xC0, 0x0F, 0xBF, 0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xBF, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x7E, 0x1F, 0xC0, 0x7E,
  0x1F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xE0, 0xFC,
  0x0F, 0xE0, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0x07, 0xC3, 0xE0, 0x7E,
  0x03, 0xE7, 0xF8, 0x7F, 0x81, 0xF7, 0xFE, 0x7F, 0xE0, 0xFF, 0xFF, 0x7F,
  0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xCF, 0xF9, 0xFC, 0x3F, 0x87, 0xF8,
  0x7E, 0x1F, 0xC3, 0xF8, 0x3F, 0x0F, 0xC1, 0xFC, 0x1F, 0x87, 0xE0, 0xFE,
  0x0F, 0xC7, 0xE0, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x07, 0xF1, 0xF8, 0x1F,
  0x83, 0xF0, 0xFC, 0x1F, 0xC1, 0xF8, 0xFE, 0x0F, 0xC0, 0xFC, 0x7E, 0x07,
  0xE0, 0x7E, 0x3F, 0x03, 0xF0, 0x7F, 0x1F, 0x81, 0xF8, 0x3F, 0x0F, 0xC1,
  0xF8, 0x1F, 0x8F, 0xC0, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x07, 0xE3, 0xF0,
  0x3F, 0x07, 0xE1, 0xF8, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x81, 0xF8, 0xFC,
  0x0F, 0xC0, 0xFC, 0x7E, 0x07, 0xE0, 0xFE, 0x00, 0x07, 0xC3, 0xE0, 0x1F,
  0x3F, 0xE0, 0x7D, 0xFF, 0x81, 0xF7, 0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0xE7,
  0xF0, 0xFE, 0x0F, 0xC3, 0xF8, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF1,
  0xFC, 0x1F, 0xC7, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE3, 0xF8,
  0x1F, 0x8F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F,
  0x1F, 0xC0, 0xFC, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F,
  0x81, 0xF8, 0xFE, 0x0F, 0xE3, 0xF0, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x0F,
  0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xF3, 0xF8,
  0x7F, 0x0F, 0xC7, 0xF0, 0x7F, 0x3F, 0x03, 0xF9, 0xF8, 0x1F, 0xDF, 0xC0,
  0xFE, 0xFC, 0x07, 0xF7, 0xE0, 0x3F, 0x3F, 0x01, 0xFB, 0xF8, 0x0F, 0xDF,
  0xC0, 0x7E, 0xFE, 0x07, 0xF7, 0xE0, 0x3F, 0x3F, 0x83, 0xF9, 0xFC, 0x1F,
  0xC7, 0xE1, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x1F,
  0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x20, 0x00, 0x01, 0xF0, 0xF8, 0x01, 0xF3,
  0xFC, 0x01, 0xF7, 0xFE, 0x01, 0xF7, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFC,
  0x7F, 0x03, 0xF8, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0,
  0x7F, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0xFE, 0x0F, 0xC0,
  0xFE, 0x0F, 0xC0, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xE3, 0xF8, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0x7F, 0xE0, 0x3F, 0x3F, 0xC0, 0x3F, 0x3F,
  0x80, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x7E, 0x03, 0xFC, 0xF8, 0x0F, 0xFD, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC1, 0xFC, 0xFF, 0x07, 0xF0, 0xFE, 0x0F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8,
  0x7E, 0x07, 0xF1, 0xFC, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F,
  0xC0, 0x7E, 0x3F, 0x80, 0xFC, 0x7F, 0x03, 0xF0, 0xFE, 0x07, 0xE1, 0xFC,
  0x0F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0x7E, 0x0F, 0xE1, 0xFC, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xF7, 0xE0, 0x3F, 0xDF, 0x80, 0x3F, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC3, 0xE0,
  0xF9, 0xF8, 0x1F, 0x7F, 0x03, 0xEF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0x03,
  0xFF, 0x20, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F,
  0x87, 0x07, 0xE0, 0x20, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x40, 0x3F, 0x8C, 0x0F,
  0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFC,
  0x00, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xFF,
  0xCF, 0xFF, 0xBF, 0xFE, 0x7F, 0xFD, 0xFF, 0xF8, 0x7E, 0x00, 0xFC, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x00,
  0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x1F,
  0x81, 0xFC, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x81,
  0xF8, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0,
  0xFC, 0x1F, 0xC7, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF8,
  0x3F, 0x87, 0xE0, 0xFE, 0x1F, 0x87, 0xF0, 0xFE, 0x3F, 0xC1, 0xFF, 0xFF,
  0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xEF, 0x80, 0x7E, 0x3E, 0x00,
  0xFC, 0x07, 0xFF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0xFC, 0xFC, 0x0F,
  0xCF, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC3, 0xF8, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0xFD,
  0xF8, 0x07, 0xDF, 0x80, 0x7D, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x7F, 0xF8, 0x3F, 0xC1,
  0xFB, 0xF0, 0x7F, 0x83, 0xF7, 0xE0, 0xFE, 0x0F, 0xCF, 0xC3, 0xFC, 0x1F,
  0x9F, 0x87, 0xF8, 0x3F, 0x3F, 0x1F, 0xF0, 0xFC, 0x7E, 0x3F, 0xE1, 0xF8,
  0xFC, 0x7B, 0xC7, 0xE1, 0xF9, 0xF7, 0x8F, 0xC3, 0xE3, 0xEF, 0x1F, 0x07,
  0xCF, 0x9E, 0x7E, 0x0F, 0x9F, 0x7C, 0xFC, 0x1F, 0x3C, 0xFB, 0xF0, 0x3E,
  0xF9, 0xF7, 0xE0, 0x7D, 0xF3, 0xEF, 0x80, 0xFB, 0xC7, 0xFF, 0x01, 0xFF,
  0x8F, 0xFC, 0x03, 0xFE, 0x1F, 0xF8, 0x07, 0xFC, 0x3F, 0xF0, 0x0F, 0xF8,
  0x7F, 0xC0, 0x1F, 0xE0, 0xFF, 0x80, 0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x3F, 0x81, 0xF8, 0x3F, 0x80, 0xFC, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x1F,
  0x8F, 0xC0, 0x0F, 0xCF, 0xC0, 0x07, 0xEF, 0xE0, 0x03, 0xF7, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFB, 0xF0, 0x01, 0xF9, 0xF8,
  0x01, 0xFC, 0xFC, 0x00, 0xFC, 0x7F, 0x00, 0xFE, 0x1F, 0x80, 0xFE, 0x0F,
  0xC0, 0x7E, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xC0,
  0xFC, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x3F,
  0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x07, 0xE0, 0x0F, 0xC3, 0xF8, 0x03, 0xF0,
  0xFC, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x1F, 0x80, 0x07, 0xC7, 0xE0, 0x01,
  0xF3, 0xF0, 0x00, 0x7C, 0xFC, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xDF, 0x80,
  0x01, 0xF7, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x20, 0x01, 0xFC, 0x00,
  0x7F, 0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0x80, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE,
  0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0,
  0x05, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0x7F, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0xC0, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0x80,
  0x1F, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x07, 0xFE, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xF8,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x1F, 0xC0,
};

const GFXglyph NotoSans_Condensed_BoldItalic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 14, 35, 12, 0, -34 },
  { 63, 16, 13, 19, 5, -34 },
  { 89, 26, 34, 25, 0, -34 },
  { 200, 23, 39, 22, 0, -36 },
  { 313, 32, 34, 35, 2, -34 },
  { 449, 27, 34, 27, 0, -34 },
  { 564, 8, 13, 12, 5, -34 },
  { 577, 16, 41, 14, 1, -34 },
  { 659, 17, 41, 14, -4, -34 },
  { 747, 19, 20, 21, 4, -36 },
  { 795, 20, 23, 23, 2, -28 },
  { 853, 10, 12, 12, -2, -6 },
  { 868, 12, 6, 14, 1, -16 },
  { 877, 8, 8, 12, 0, -7 },
  { 885, 24, 34, 18, -2, -34 },
  { 987, 21, 34, 22, 1, -34 },
  { 1077, 17, 34, 22, 4, -34 },
  { 1150, 24, 34, 22, -2, -34 },
  { 1252, 22, 34, 22, 0, -34 },
  { 1346, 23, 34, 22, -1, -34 },
  { 1444, 22, 34, 22, 0, -34 },
  { 1538, 22, 34, 22, 1, -34 },
  { 1632, 23, 34, 22, 1, -34 },
  { 1730, 22, 34, 22, 0, -34 },
  { 1824, 21, 34, 22, 1, -34 },
  { 1914, 12, 27, 12, 0, -26 },
  { 1955, 15, 32, 12, -3, -26 },
  { 2015, 20, 23, 23, 2, -28 },
  { 2073, 20, 15, 23, 2, -24 },
  { 2111, 20, 23, 23, 2, -28 },
  { 2169, 17, 35, 17, 2, -34 },
  { 2244, 32, 38, 33, 1, -34 },
  { 2396, 24, 34, 24, -3, -34 },
  { 2498, 25, 34, 24, 0, -34 },
  { 2605, 24, 34, 23, 2, -34 },
  { 2707, 26, 34, 26, 0, -34 },
  { 2818, 23, 34, 21, 0, -34 },
  { 2916, 23, 34, 20, 0, -34 },
  { 3014, 26, 34, 27, 2, -34 },
  { 3125, 29, 34, 27, 0, -34 },
  { 3249, 21, 34, 16, -2, -34 },
  { 3339, 21, 44, 13, -7, -34 },
  { 3455, 28, 34, 24, 0, -34 },
  { 3574, 17, 34, 20, 0, -34 },
  { 3647, 36, 34, 35, 0, -34 },
  { 3800, 30, 34, 29, 0, -34 },
  { 3928, 26, 34, 28, 2, -34 },
  { 4039, 25, 34, 24, 0, -34 },
  { 4146, 26, 42, 28, 2, -34 },
  { 4283, 24, 34, 24, 0, -34 },
  { 4385, 23, 34, 21, 0, -34 },
  { 4483, 20, 34, 21, 4, -34 },
  { 4568, 26, 34, 27, 2, -34 },
  { 4679, 24, 34, 24, 4, -34 },
  { 4781, 36, 34, 36, 4, -34 },
  { 4934, 30, 34, 23, -3, -34 },
  { 5062, 22, 34, 22, 4, -34 },
  { 5156, 25, 34, 20, -2, -34 },
  { 5263, 19, 41, 14, -2, -34 },
  { 5361, 10, 34, 18, 5, -34 },
  { 5404, 19, 41, 14, -3, -34 },
  { 5502, 22, 21, 22, 0, -34 },
  { 5560, 17, 3, 16, -4, 4 },
  { 5567, 9, 8, 14, 7, -36 },
  { 5576, 23, 26, 24, 1, -26 },
  { 5651, 22, 36, 24, 0, -36 },
  { 5750, 19, 26, 19, 1, -26 },
  { 5812, 25, 36, 24, 1, -36 },
  { 5925, 20, 26, 22, 1, -26 },
  { 5990, 25, 47, 14, -5, -36 },
  { 6137, 25, 37, 24, -1, -26 },
  { 6253, 22, 36, 24, 0, -36 },
  { 6352, 14, 36, 12, 0, -36 },
  { 6415, 20, 47, 12, -6, -36 },
  { 6533, 24, 36, 22, 0, -36 },
  { 6641, 14, 36, 12, 0, -36 },
  { 6704, 33, 26, 35, 0, -26 },
  { 6812, 22, 26, 24, 0, -26 },
  { 6884, 21, 27, 23, 1, -26 },
  { 6955, 24, 37, 24, -2, -26 },
  { 7066, 23, 37, 24, 1, -26 },
  { 7173, 19, 26, 17, 0, -26 },
  { 7235, 19, 26, 19, 0, -26 },
  { 7297, 15, 31, 15, 2, -31 },
  { 7356, 22, 26, 23, 1, -26 },
  { 7428, 20, 26, 20, 3, -26 },
  { 7493, 31, 26, 31, 3, -26 },
  { 7594, 25, 26, 21, -2, -26 },
  { 7676, 26, 37, 21, -3, -26 },
  { 7797, 21, 26, 18, -2, -26 },
  { 7866, 19, 41, 16, 0, -34 },
  { 7964, 5, 47, 20, 7, -36 },
  { 7994, 19, 41, 16, -3, -34 },
  { 8092, 20, 7, 23, 2, -20 },
};

const GFXfont NotoSans_Condensed_BoldItalic47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BoldItalic47pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BoldItalic47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_CONDENSED_BOLDITALIC47PT7B_H_
