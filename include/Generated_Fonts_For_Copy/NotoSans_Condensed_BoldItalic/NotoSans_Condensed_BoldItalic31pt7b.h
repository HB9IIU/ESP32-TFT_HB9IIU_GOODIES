#ifndef _NOTOSANS_CONDENSED_BOLDITALIC31PT7B_H_
#define _NOTOSANS_CONDENSED_BOLDITALIC31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BoldItalic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BoldItalic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0xC3, 0xE1, 0xE0, 0xF0, 0xF8, 0x7C, 0x3C, 0x1E, 0x0F,
  0x07, 0x87, 0x83, 0xC1, 0xE0, 0xE0, 0x00, 0x00, 0x18, 0x1E, 0x1F, 0x0F,
  0x87, 0x80, 0x79, 0xEF, 0x3D, 0xE7, 0x39, 0xEF, 0x3D, 0xE7, 0x38, 0xE7,
  0x1C, 0x00, 0xE7, 0x00, 0xE3, 0x80, 0x73, 0x80, 0x39, 0xC0, 0x38, 0xE0,
  0x1C, 0x60, 0x7F, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF, 0x83, 0x9C, 0x01, 0xCE,
  0x01, 0xC7, 0x00, 0xE7, 0x03, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFC, 0x1C,
  0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x07, 0x38, 0x07, 0x1C, 0x03, 0x9E, 0x00,
  0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x1F, 0xE0, 0x7F, 0xE1, 0xFF, 0x87,
  0xFF, 0x0F, 0x64, 0x1E, 0xC0, 0x3D, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0x79, 0x06, 0xF1, 0x89, 0xE3,
  0xFF, 0x8F, 0xFF, 0x1F, 0xFC, 0x07, 0xC0, 0x02, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x1F, 0x01, 0xC3, 0xF8, 0x38, 0x7F, 0x87, 0x87, 0x38, 0x70, 0xF3,
  0x8E, 0x0E, 0x38, 0xE0, 0xE3, 0x9C, 0x0E, 0x7B, 0xC0, 0xE7, 0x38, 0x8E,
  0x77, 0x3E, 0xEE, 0x77, 0xFF, 0xEE, 0xF7, 0x7D, 0xEE, 0x70, 0x1C, 0xE7,
  0x03, 0x9C, 0x70, 0x39, 0xC7, 0x07, 0x1C, 0x70, 0xF1, 0xCF, 0x0E, 0x1C,
  0xE1, 0xC1, 0xFE, 0x1C, 0x1F, 0xC3, 0x80, 0xF8, 0x01, 0xF8, 0x00, 0xFF,
  0x00, 0x7F, 0xC0, 0x1E, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x00, 0xF3, 0xC0,
  0x3D, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x3C, 0x7F, 0x9E, 0x3F,
  0xE7, 0x9F, 0x7B, 0xC7, 0x8F, 0xF3, 0xE3, 0xF8, 0xF0, 0xFE, 0x3E, 0x1F,
  0x0F, 0x9F, 0xC1, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xE7, 0xC0, 0x7B, 0xDE,
  0xEF, 0x7B, 0xDC, 0x03, 0xC1, 0xE0, 0x70, 0x3C, 0x1E, 0x07, 0x83, 0xC0,
  0xF0, 0x38, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0x03, 0xC0, 0xF0, 0x1C, 0x07,
  0x80, 0x07, 0x80, 0xE0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0x81, 0xE0,
  0x78, 0x3C, 0x0F, 0x03, 0x81, 0xE0, 0x70, 0x3C, 0x1E, 0x07, 0x03, 0xC0,
  0x06, 0x80, 0x70, 0x07, 0x0C, 0x70, 0xF7, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF,
  0x3F, 0x07, 0xF8, 0xFB, 0x87, 0x3C, 0x23, 0x80, 0x10, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00,
  0x1E, 0x3C, 0xF9, 0xE3, 0xCF, 0x1E, 0x78, 0x7F, 0xBF, 0x9F, 0xDF, 0xE0,
  0x33, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0x80, 0x03,
  0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x07, 0xC0, 0x00, 0x03, 0xF0, 0x7F, 0xC3, 0xFE, 0x3C, 0xF3, 0xE7, 0x9E,
  0x3D, 0xF1, 0xEF, 0x0F, 0x78, 0x7B, 0xC3, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F,
  0xF8, 0x7B, 0xC3, 0xDE, 0x3E, 0xF1, 0xE7, 0x9F, 0x3D, 0xF1, 0xFF, 0x87,
  0xF8, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x3F, 0x0F, 0xE7, 0xFD, 0xFF, 0x3D,
  0xE3, 0x3C, 0x07, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xFC,
  0x0F, 0xFC, 0x3F, 0xF8, 0x79, 0xF0, 0x61, 0xE0, 0x83, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xFF, 0xE7, 0xFF, 0xCF,
  0xFF, 0x1F, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xF8, 0x3F, 0xF0, 0x71, 0xF0,
  0x83, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x0F, 0xE0, 0x3F,
  0x00, 0x7F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF9,
  0x01, 0xE3, 0x8F, 0xC7, 0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x77, 0x00, 0xFE, 0x03,
  0xBC, 0x0F, 0x78, 0x1C, 0xF0, 0x73, 0xC1, 0xC7, 0x83, 0x8F, 0x0E, 0x1E,
  0x3F, 0xFF, 0x7F, 0xFC, 0xFF, 0xF8, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0xE0, 0x7F, 0xE0, 0xFF,
  0xC0, 0xFF, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF9,
  0x03, 0xE3, 0xDF, 0xC7, 0xFF, 0x0F, 0xFC, 0x0F, 0xF0, 0x00, 0x01, 0xFC,
  0x0F, 0xF0, 0x7F, 0xC3, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00,
  0x7B, 0xE1, 0xFF, 0xC7, 0xFF, 0x3F, 0x3C, 0xF8, 0xFB, 0xC3, 0xCF, 0x0F,
  0x3C, 0x3C, 0xF0, 0xF3, 0xC7, 0xCF, 0xBE, 0x1F, 0xF8, 0x7F, 0xC0, 0xFC,
  0x00, 0x1F, 0xFE, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xE0, 0x07, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0,
  0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0xF8, 0x3F,
  0xF8, 0xF9, 0xF1, 0xE1, 0xE3, 0xC3, 0xC7, 0x8F, 0x0F, 0x9E, 0x0F, 0xF8,
  0x1F, 0xE0, 0x1F, 0x00, 0xFF, 0x03, 0xFF, 0x0F, 0x9F, 0x1E, 0x1E, 0x7C,
  0x3C, 0xF0, 0x79, 0xE0, 0xF3, 0xE3, 0xC3, 0xFF, 0x87, 0xFE, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x3F, 0xE0, 0xFF, 0xC7, 0xCF, 0x1E, 0x3C, 0xF0, 0xF3,
  0xC3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF1, 0xF3, 0xEF, 0xCF, 0xFF, 0x3F, 0xF8,
  0x7D, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x88, 0x7E, 0x3F, 0xF0,
  0xFF, 0x83, 0xF8, 0x00, 0x0E, 0x1F, 0x1F, 0x1E, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x78, 0xF8, 0xF8, 0xF0, 0x03, 0x81, 0xF0,
  0x7C, 0x1E, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x00,
  0x00, 0x04, 0x00, 0x70, 0x07, 0xC0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x3F, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x00,
  0xF0, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x03, 0x80,
  0x0F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00,
  0xFC, 0x0F, 0xE1, 0xFE, 0x1F, 0xE0, 0xFE, 0x03, 0xC0, 0x0C, 0x00, 0x00,
  0x1F, 0xC3, 0xFE, 0x3F, 0xF3, 0x1F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x38, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0x00, 0x7F, 0x80,
  0x0F, 0xFE, 0x00, 0xF8, 0x78, 0x0E, 0x01, 0xE0, 0xE0, 0x07, 0x0E, 0x00,
  0x1C, 0xE1, 0xFC, 0xE7, 0x1F, 0xE7, 0x71, 0xC7, 0x3B, 0x9C, 0x71, 0xDC,
  0xE3, 0x8F, 0xC7, 0x1C, 0x6E, 0x70, 0xE7, 0x73, 0x8E, 0x3B, 0x9C, 0x71,
  0x9C, 0xE7, 0x9C, 0xE7, 0xEF, 0xC7, 0x1F, 0x7C, 0x38, 0x20, 0x81, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x3E, 0x06, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x80,
  0x01, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0xFF, 0x00, 0xEF, 0x01, 0xEF, 0x01, 0xCF, 0x03, 0xCF, 0x03, 0xCF, 0x07,
  0x8F, 0x07, 0x8F, 0x0F, 0x8F, 0x0F, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x1E,
  0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x7C, 0x0F, 0x78, 0x0F, 0xF8, 0x0F, 0x07,
  0xFC, 0x07, 0xFE, 0x0F, 0xFF, 0x0F, 0x1F, 0x0F, 0x0F, 0x0F, 0x0F, 0x1F,
  0x0F, 0x1E, 0x1F, 0x1E, 0x3E, 0x1F, 0xFC, 0x1F, 0xF0, 0x3F, 0xF8, 0x3C,
  0x7C, 0x3C, 0x3C, 0x3C, 0x3E, 0x3C, 0x3C, 0x78, 0x3C, 0x78, 0x7C, 0x79,
  0xFC, 0x7F, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0x01, 0xFE, 0x03, 0xFF, 0x0F,
  0xFE, 0x0F, 0xCE, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x10, 0x7E, 0xF0, 0x7F, 0xF0, 0x3F,
  0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xE0,
  0xF0, 0xF8, 0x78, 0x7C, 0x7C, 0x3E, 0x3E, 0x0F, 0x1E, 0x0F, 0x8F, 0x07,
  0xC7, 0x83, 0xE7, 0xC1, 0xF3, 0xE0, 0xF1, 0xE0, 0xF8, 0xF0, 0x7C, 0x78,
  0x7C, 0x7C, 0x3E, 0x3C, 0x3E, 0x1F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x07,
  0xFC, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x3F, 0xF8, 0x7F, 0xE0, 0xF0, 0x01,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3F, 0xF0, 0x7F, 0xC1, 0xFF,
  0x83, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01,
  0xFF, 0x83, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x0F, 0xFC,
  0x3F, 0xF8, 0x7F, 0xE0, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E,
  0x00, 0x3F, 0xF0, 0x7F, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE1, 0xF8, 0xE1, 0xF0,
  0x11, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E,
  0x1F, 0xCF, 0x1F, 0xEF, 0x8F, 0xE7, 0xC0, 0xF3, 0xE0, 0x79, 0xF0, 0x7C,
  0xF8, 0x3C, 0x3E, 0x1E, 0x1F, 0xDF, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0x7F,
  0x80, 0x07, 0x83, 0xE0, 0xF0, 0x78, 0x3E, 0x0F, 0x07, 0x81, 0xE0, 0xF0,
  0x3C, 0x1E, 0x0F, 0x87, 0xC1, 0xE0, 0xF8, 0x3C, 0x1E, 0x07, 0x83, 0xFF,
  0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0x83, 0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x07,
  0xC1, 0xE0, 0xF8, 0x7C, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x1F,
  0x0F, 0x83, 0xC1, 0xF0, 0x78, 0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0x7F, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00,
  0x78, 0x01, 0xE0, 0x1F, 0xE0, 0xFF, 0x83, 0xFE, 0x00, 0x00, 0x3C, 0x00,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00,
  0x78, 0x01, 0xE0, 0x8F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0x20, 0x00,
  0x07, 0x87, 0xE0, 0xF0, 0xF0, 0x3C, 0x3E, 0x07, 0x8F, 0x80, 0xF1, 0xE0,
  0x1E, 0x78, 0x07, 0xDF, 0x00, 0xF7, 0xC0, 0x1E, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7D, 0xE0, 0x0F, 0x3C, 0x01,
  0xE7, 0x80, 0x78, 0xF8, 0x0F, 0x1F, 0x01, 0xE1, 0xE0, 0x3C, 0x3C, 0x0F,
  0x87, 0xC1, 0xE0, 0xF8, 0x00, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0x80, 0xF0,
  0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x01, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x7F, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xDC,
  0x1F, 0xE3, 0xFC, 0x1F, 0xE3, 0xBC, 0x1D, 0xE7, 0xBC, 0x3D, 0xE7, 0x3C,
  0x3D, 0xEF, 0x78, 0x3C, 0xEE, 0x78, 0x3C, 0xEE, 0x78, 0x38, 0xFE, 0x78,
  0x78, 0xFC, 0x70, 0x78, 0xFC, 0xF0, 0x78, 0xF8, 0xF0, 0x78, 0xF8, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF1, 0xE0, 0x07, 0xC0, 0xF0, 0x7C, 0x0F, 0x0F,
  0xC0, 0xE0, 0xFC, 0x1E, 0x0F, 0xE1, 0xE0, 0xFE, 0x1E, 0x1F, 0xE1, 0xE1,
  0xFE, 0x3C, 0x1E, 0xE3, 0xC1, 0xEF, 0x3C, 0x1C, 0xF3, 0xC3, 0xCF, 0x3C,
  0x3C, 0x77, 0x83, 0xC7, 0xF8, 0x3C, 0x7F, 0x83, 0x87, 0xF8, 0x78, 0x7F,
  0x07, 0x83, 0xF0, 0x78, 0x3F, 0x07, 0x83, 0xF0, 0xF0, 0x3F, 0x0F, 0x01,
  0xE0, 0x01, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0xC1, 0xF3, 0xF1, 0xF0, 0xF9,
  0xF0, 0x3C, 0xF8, 0x1E, 0x78, 0x0F, 0x7C, 0x07, 0xBE, 0x03, 0xDE, 0x03,
  0xEF, 0x01, 0xFF, 0x80, 0xF7, 0xC0, 0x7B, 0xE0, 0x7D, 0xF0, 0x3C, 0xF8,
  0x3E, 0x3C, 0x3E, 0x1F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xFE, 0x00,
  0x07, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0xF0, 0xF0, 0x78,
  0x7C, 0x7C, 0x3C, 0x3E, 0x1E, 0x1E, 0x0F, 0x0F, 0x0F, 0x87, 0xFF, 0x87,
  0xFF, 0x83, 0xFF, 0x81, 0xFF, 0x80, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x01,
  0xFC, 0x03, 0xFF, 0x83, 0xFF, 0xC1, 0xF3, 0xF1, 0xF0, 0xF9, 0xF0, 0x3C,
  0xF8, 0x1E, 0x78, 0x0F, 0x7C, 0x07, 0xBE, 0x03, 0xDE, 0x03, 0xEF, 0x01,
  0xFF, 0x80, 0xF7, 0xC0, 0x7B, 0xE0, 0x7D, 0xF0, 0x3C, 0xF8, 0x3E, 0x3C,
  0x3F, 0x1F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x07, 0xF8, 0x07,
  0xFC, 0x0F, 0xFE, 0x0F, 0x3F, 0x0F, 0x1F, 0x0F, 0x1F, 0x1F, 0x1F, 0x1E,
  0x1F, 0x1E, 0x1E, 0x1E, 0x3E, 0x1F, 0xFC, 0x3F, 0xF8, 0x3F, 0xE0, 0x3C,
  0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x78, 0xF0, 0x78, 0xF8, 0x78, 0x78, 0x78,
  0x78, 0xF8, 0x7C, 0xF0, 0x7C, 0x03, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0xFD,
  0xE1, 0xF0, 0x43, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF1, 0x03, 0xE3, 0xFF, 0x87, 0xFF, 0x0F, 0xFC, 0x0F, 0xE0, 0x00, 0x7F,
  0xFD, 0xFF, 0xF7, 0xFF, 0xBF, 0xFE, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01,
  0xE0, 0x00, 0x0F, 0x07, 0xC7, 0xC1, 0xE1, 0xE0, 0x78, 0x78, 0x3E, 0x1E,
  0x0F, 0x87, 0x83, 0xC3, 0xE0, 0xF0, 0xF0, 0x3C, 0x3C, 0x1F, 0x0F, 0x07,
  0x87, 0xC1, 0xE1, 0xF0, 0x78, 0x78, 0x3E, 0x1E, 0x0F, 0x87, 0x83, 0xC3,
  0xE0, 0xF0, 0xF8, 0x7C, 0x3E, 0x1E, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x3F,
  0xF0, 0x07, 0xF0, 0x00, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0xF7, 0x83, 0xEF,
  0x07, 0x9E, 0x0F, 0x3C, 0x3C, 0x78, 0x78, 0xF1, 0xE1, 0xE3, 0xC3, 0xCF,
  0x07, 0x9E, 0x0F, 0x3C, 0x1E, 0xF0, 0x3D, 0xE0, 0x7F, 0x80, 0xFF, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0xF0, 0x78,
  0x1F, 0xE0, 0xF0, 0x7F, 0xC1, 0xE0, 0xF7, 0x87, 0xC1, 0xEF, 0x0F, 0x87,
  0x9E, 0x3F, 0x0F, 0x3C, 0x7E, 0x1E, 0x78, 0xFC, 0x78, 0xF3, 0xF8, 0xF1,
  0xE7, 0x73, 0xC3, 0x9E, 0xE7, 0x87, 0x39, 0xCF, 0x0E, 0x73, 0xBC, 0x1D,
  0xE7, 0x78, 0x3B, 0x8F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFC, 0x3F, 0x81, 0xF8,
  0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1E, 0x07,
  0xC0, 0x00, 0x07, 0xC1, 0xE0, 0x78, 0x78, 0x0F, 0x1F, 0x01, 0xE3, 0xC0,
  0x3C, 0xF8, 0x03, 0xDE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01,
  0xFE, 0x00, 0x7D, 0xE0, 0x0F, 0x3C, 0x03, 0xC7, 0x80, 0xF8, 0xF0, 0x1E,
  0x1F, 0x07, 0xC1, 0xE1, 0xF0, 0x3C, 0x00, 0xF0, 0x7F, 0xC1, 0xEF, 0x0F,
  0xBC, 0x3C, 0x79, 0xF1, 0xE7, 0x87, 0xBC, 0x1E, 0xF0, 0x7F, 0x81, 0xFE,
  0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x07, 0xFF,
  0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80,
  0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7F, 0xF8,
  0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x78,
  0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0xFE, 0x0F, 0xE0, 0xFE, 0x00, 0xF1,
  0xE1, 0xC3, 0x87, 0x0F, 0x1E, 0x3C, 0x78, 0xF0, 0xE1, 0xC3, 0xC7, 0x8F,
  0x1E, 0x3C, 0x38, 0x70, 0xE1, 0xE3, 0xC0, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x00,
  0x00, 0xE0, 0x03, 0x80, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0xF7,
  0x83, 0x9E, 0x1E, 0x38, 0x70, 0xE3, 0x83, 0xDE, 0x0F, 0xF0, 0x1C, 0xFF,
  0xFF, 0xFC, 0xF9, 0xE3, 0xCF, 0x1C, 0x0F, 0x9E, 0x3F, 0xB8, 0xFF, 0xF1,
  0xF7, 0xE7, 0xC7, 0xCF, 0x0F, 0x1E, 0x1E, 0x7C, 0x3C, 0xF0, 0x79, 0xE1,
  0xF3, 0xC3, 0xC7, 0x87, 0x8F, 0x1F, 0x1F, 0x7E, 0x3F, 0xFC, 0x3F, 0x70,
  0x7C, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x0F, 0xBC, 0x1E, 0xFC, 0x3F, 0xF8, 0x7C, 0xF8, 0xF1,
  0xF3, 0xE1, 0xE7, 0x83, 0xCF, 0x0F, 0x9E, 0x1E, 0x3C, 0x3C, 0xF0, 0x79,
  0xE1, 0xF3, 0xC3, 0xC7, 0xCF, 0x8F, 0xFE, 0x3F, 0xF8, 0x73, 0xE0, 0x07,
  0xF0, 0xFF, 0x1F, 0xE3, 0xE6, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x98, 0xFF, 0x87, 0xF8, 0x3F,
  0x80, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x0F, 0xBC, 0x1F, 0xFC, 0x1F, 0xFC, 0x3E, 0xFC, 0x7C,
  0x7C, 0x78, 0x78, 0x78, 0x78, 0xF8, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF9, 0xF0, 0xFF, 0xE0, 0x7E, 0xE0, 0x7C,
  0xE0, 0x07, 0xE0, 0x7F, 0x87, 0xFE, 0x78, 0xF7, 0xC7, 0xBC, 0x3D, 0xE3,
  0xDF, 0xFE, 0xFF, 0xC7, 0xF8, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x23,
  0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x0E, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xFC, 0x07, 0xFC, 0x07,
  0xF8, 0x0B, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x07, 0xCF, 0x0F, 0xEE, 0x0F,
  0xFE, 0x1F, 0x7E, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x7C, 0x3C, 0x78,
  0x3C, 0x78, 0x7C, 0x78, 0x78, 0x78, 0x78, 0x78, 0xF8, 0x7D, 0xF8, 0x7F,
  0xF8, 0x7F, 0xF0, 0x3E, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x83,
  0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x3C, 0x1F, 0xFC,
  0x3F, 0xF8, 0x7D, 0xF8, 0xF1, 0xF3, 0xE3, 0xC7, 0x87, 0x8F, 0x0F, 0x1E,
  0x1E, 0x3C, 0x3C, 0xF0, 0xF1, 0xE1, 0xE3, 0xC3, 0xC7, 0x87, 0x8F, 0x0F,
  0x3C, 0x3C, 0x78, 0x78, 0x02, 0x03, 0xC3, 0xE1, 0xF0, 0x70, 0x00, 0x00,
  0x3E, 0x1E, 0x0F, 0x07, 0x83, 0xC3, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x3E,
  0x1E, 0x0F, 0x07, 0x83, 0xC3, 0xC1, 0xE0, 0x00, 0x20, 0x03, 0xC0, 0x3E,
  0x01, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x07, 0xC0, 0x3C, 0x0F, 0xE0, 0x7E, 0x03, 0xE0, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x1E, 0x1F, 0x1E, 0x1E, 0x1E, 0x3C, 0x1E, 0x78, 0x1E, 0xF0, 0x3D, 0xF0,
  0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x7F, 0xE0, 0x79, 0xE0,
  0x79, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0xF0, 0xF0, 0xF0, 0xF8, 0x07, 0x83,
  0xC1, 0xE1, 0xF0, 0xF0, 0x78, 0x3C, 0x3E, 0x1E, 0x0F, 0x07, 0x83, 0xC3,
  0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x3E, 0x1E, 0x0F, 0x07, 0x83, 0xC3, 0xC1,
  0xE0, 0x1E, 0x78, 0xF8, 0x7F, 0xF7, 0xF1, 0xFF, 0xFF, 0xC7, 0xCF, 0xDF,
  0x1E, 0x3E, 0x3C, 0xF8, 0xF0, 0xF3, 0xC3, 0xC3, 0xCF, 0x0F, 0x1E, 0x3C,
  0x3C, 0x78, 0xF1, 0xE1, 0xE7, 0x87, 0x87, 0x9E, 0x1E, 0x1E, 0x78, 0x78,
  0xF1, 0xE1, 0xE3, 0xC7, 0x8F, 0x0F, 0x3C, 0x3C, 0x3C, 0xF0, 0xF1, 0xF0,
  0x0E, 0x78, 0x3D, 0xF8, 0x77, 0xF0, 0xF9, 0xF1, 0xE3, 0xE7, 0xC7, 0x8F,
  0x0F, 0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0x79, 0xE1, 0xE3, 0xC3, 0xC7, 0x87,
  0x8F, 0x0F, 0x1E, 0x1E, 0x78, 0x78, 0xF0, 0xF0, 0x07, 0xE0, 0xFF, 0x87,
  0xFE, 0x7D, 0xF7, 0xC7, 0xBC, 0x3D, 0xE1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83,
  0xFC, 0x3F, 0xE1, 0xEF, 0x1F, 0x7D, 0xF1, 0xFF, 0x8F, 0xF8, 0x3F, 0x80,
  0x03, 0x9E, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xF9, 0xF0, 0x78, 0xF8, 0x7C,
  0x3C, 0x3C, 0x1E, 0x1E, 0x1F, 0x0F, 0x0F, 0x07, 0x87, 0x87, 0x83, 0xC3,
  0xC3, 0xE1, 0xE1, 0xE0, 0xF9, 0xF0, 0x7F, 0xF0, 0x7B, 0xF0, 0x3D, 0xF0,
  0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0x07, 0x9E, 0x3F, 0xB8, 0x7F, 0xF1, 0xF7, 0xE7, 0xC7,
  0xCF, 0x0F, 0x1E, 0x1E, 0x7C, 0x3C, 0xF0, 0x79, 0xE0, 0xF3, 0xC3, 0xC7,
  0x87, 0x8F, 0x0F, 0x1F, 0x7E, 0x3F, 0xF8, 0x3F, 0xF0, 0x7D, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0,
  0x1E, 0x71, 0xEF, 0x1F, 0xF1, 0xFE, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x00,
  0xF0, 0x00, 0x0F, 0xE1, 0xFF, 0x3F, 0xF3, 0xC2, 0x3C, 0x03, 0xC0, 0x3E,
  0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xC0, 0x3E, 0x03, 0xCC, 0x7C, 0xFF,
  0xCF, 0xF8, 0xFF, 0x00, 0x0F, 0x03, 0x80, 0xE0, 0xFF, 0x7F, 0xDF, 0xFB,
  0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x83, 0xC0,
  0xF1, 0x3F, 0x87, 0xE1, 0xF8, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x0F,
  0x3C, 0x79, 0xE1, 0xE7, 0x87, 0x9E, 0x1E, 0x78, 0x79, 0xE3, 0xCF, 0x0F,
  0x3C, 0x3C, 0xF1, 0xF3, 0xCF, 0xCF, 0xFE, 0x3F, 0xB8, 0x7C, 0xE0, 0xF0,
  0x7F, 0x87, 0xBC, 0x3D, 0xE3, 0xCF, 0x1E, 0x78, 0xF3, 0xCF, 0x1E, 0x78,
  0xF7, 0x87, 0xBC, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0x3F, 0x01, 0xF0, 0x0F,
  0x80, 0x78, 0x00, 0xF0, 0xF0, 0xFF, 0x1F, 0x0F, 0xF1, 0xF1, 0xEF, 0x3F,
  0x1E, 0xF3, 0xF3, 0xCF, 0x3F, 0x3C, 0xF7, 0x73, 0xCF, 0x77, 0x78, 0xFF,
  0x77, 0x8E, 0xE7, 0x70, 0xEE, 0x7F, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F,
  0xC7, 0xE0, 0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x78, 0x00, 0x0F, 0x8F,
  0x83, 0xC7, 0x81, 0xE7, 0xC0, 0xF3, 0xC0, 0x7B, 0xC0, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0xF3, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0xF8, 0x7C, 0x00, 0x0F,
  0x07, 0x87, 0x87, 0xC3, 0xC3, 0xC1, 0xE3, 0xE0, 0xF1, 0xE0, 0x78, 0xF0,
  0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x78, 0x03, 0xBC, 0x01, 0xDC, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01,
  0xF0, 0x00, 0x0F, 0xFC, 0x3F, 0xE1, 0xFF, 0x80, 0x3C, 0x01, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xF0, 0x07, 0xFE, 0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0xF8, 0x0F, 0x80,
  0xFC, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78,
  0x03, 0xC0, 0xFE, 0x07, 0xE0, 0x38, 0x03, 0xF0, 0x07, 0xC0, 0x1E, 0x00,
  0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xE0, 0x3F,
  0x00, 0xF8, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0x80, 0x7C, 0x07, 0xE0, 0x3E, 0x01, 0xE0,
  0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x03, 0xF0, 0x7C, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01,
  0xE0, 0x1E, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xF0, 0x00, 0x00, 0x05, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFA, 0x00, 0x80,
};

const GFXglyph NotoSans_Condensed_BoldItalic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 9, 22, 8, 0, -22 },
  { 26, 11, 8, 13, 3, -22 },
  { 37, 17, 22, 16, 0, -22 },
  { 84, 15, 26, 14, 0, -24 },
  { 133, 20, 22, 23, 2, -22 },
  { 188, 18, 22, 18, 0, -22 },
  { 238, 5, 8, 8, 3, -22 },
  { 243, 10, 27, 9, 1, -22 },
  { 277, 10, 28, 9, -2, -23 },
  { 312, 12, 14, 14, 3, -24 },
  { 333, 14, 15, 15, 1, -18 },
  { 360, 7, 8, 8, -2, -4 },
  { 367, 9, 4, 9, 0, -10 },
  { 372, 5, 5, 8, 0, -5 },
  { 376, 17, 22, 12, -2, -22 },
  { 423, 13, 22, 14, 1, -22 },
  { 459, 11, 22, 15, 3, -22 },
  { 490, 15, 22, 14, -1, -22 },
  { 532, 15, 22, 14, 0, -22 },
  { 574, 15, 22, 15, 0, -22 },
  { 616, 15, 22, 14, 0, -22 },
  { 658, 14, 22, 14, 1, -22 },
  { 697, 15, 22, 14, 1, -22 },
  { 739, 15, 22, 14, 0, -22 },
  { 781, 14, 22, 14, 0, -22 },
  { 820, 8, 17, 8, 0, -17 },
  { 837, 10, 21, 8, -2, -17 },
  { 864, 14, 15, 15, 1, -19 },
  { 891, 14, 10, 15, 1, -16 },
  { 909, 14, 15, 15, 1, -19 },
  { 936, 12, 22, 12, 1, -22 },
  { 969, 21, 25, 22, 1, -22 },
  { 1035, 16, 22, 16, -2, -22 },
  { 1079, 16, 22, 16, 0, -22 },
  { 1123, 16, 22, 15, 1, -22 },
  { 1167, 17, 22, 17, 0, -22 },
  { 1214, 15, 22, 14, 0, -22 },
  { 1256, 15, 22, 13, 0, -22 },
  { 1298, 17, 22, 18, 1, -22 },
  { 1345, 19, 22, 18, 0, -22 },
  { 1398, 14, 22, 10, -1, -22 },
  { 1437, 14, 29, 8, -5, -22 },
  { 1488, 19, 22, 16, 0, -22 },
  { 1541, 11, 22, 13, 0, -22 },
  { 1572, 24, 22, 23, 0, -22 },
  { 1638, 20, 22, 19, 0, -22 },
  { 1693, 17, 22, 19, 1, -22 },
  { 1740, 17, 22, 16, 0, -22 },
  { 1787, 17, 27, 19, 1, -22 },
  { 1845, 16, 22, 16, 0, -22 },
  { 1889, 15, 22, 14, 0, -22 },
  { 1931, 14, 22, 14, 2, -22 },
  { 1970, 18, 22, 18, 1, -22 },
  { 2020, 15, 22, 16, 3, -22 },
  { 2062, 23, 22, 24, 3, -22 },
  { 2126, 19, 22, 15, -2, -22 },
  { 2179, 14, 22, 14, 3, -22 },
  { 2218, 16, 22, 13, -1, -22 },
  { 2262, 12, 27, 9, -1, -22 },
  { 2303, 7, 22, 12, 3, -22 },
  { 2323, 12, 27, 9, -2, -22 },
  { 2364, 14, 13, 15, 0, -22 },
  { 2387, 11, 2, 11, -3, 3 },
  { 2390, 6, 5, 9, 4, -24 },
  { 2394, 15, 17, 16, 1, -17 },
  { 2426, 15, 24, 16, 0, -24 },
  { 2471, 12, 17, 12, 1, -17 },
  { 2497, 16, 24, 16, 1, -24 },
  { 2545, 13, 17, 14, 1, -17 },
  { 2573, 16, 31, 10, -3, -24 },
  { 2635, 16, 24, 16, 0, -17 },
  { 2683, 15, 24, 16, 0, -24 },
  { 2728, 9, 24, 8, 0, -24 },
  { 2755, 13, 31, 8, -4, -24 },
  { 2806, 16, 24, 15, 0, -24 },
  { 2854, 9, 24, 8, 0, -24 },
  { 2881, 22, 17, 23, 0, -17 },
  { 2928, 15, 17, 16, 0, -17 },
  { 2960, 13, 17, 15, 1, -17 },
  { 2988, 17, 24, 16, -2, -17 },
  { 3039, 15, 24, 16, 1, -17 },
  { 3084, 12, 17, 11, 0, -17 },
  { 3110, 12, 17, 12, 0, -17 },
  { 3136, 10, 20, 10, 1, -20 },
  { 3161, 14, 17, 15, 1, -17 },
  { 3191, 13, 17, 13, 2, -17 },
  { 3219, 20, 17, 21, 2, -17 },
  { 3262, 17, 17, 14, -2, -17 },
  { 3299, 17, 24, 14, -2, -17 },
  { 3350, 14, 17, 12, -1, -17 },
  { 3380, 13, 27, 11, 0, -22 },
  { 3424, 3, 31, 13, 5, -24 },
  { 3436, 12, 27, 11, -2, -22 },
  { 3477, 14, 6, 15, 1, -14 },
};

const GFXfont NotoSans_Condensed_BoldItalic31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BoldItalic31pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BoldItalic31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_CONDENSED_BOLDITALIC31PT7B_H_
