#ifndef _NOTOSANS_CONDENSED_BOLDITALIC8PT7B_H_
#define _NOTOSANS_CONDENSED_BOLDITALIC8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BoldItalic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BoldItalic8pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0xA0, 0xB8, 0x33, 0x76, 0xFA, 0x27, 0x42, 0xAC, 0x69, 0xAB,
  0x9B, 0x35, 0x60, 0x22, 0x98, 0xFB, 0x78, 0xC0, 0x29, 0x49, 0x20, 0x24,
  0x92, 0xB0, 0x5F, 0x00, 0x22, 0xF2, 0xC0, 0xC0, 0x80, 0x12, 0x24, 0x88,
  0x25, 0xDB, 0xAE, 0x79, 0x25, 0x00, 0x65, 0x22, 0x4E, 0x65, 0x26, 0x2E,
  0x13, 0x6A, 0xF2, 0x74, 0x62, 0x2E, 0x34, 0x6F, 0xAE, 0x71, 0x22, 0x4C,
  0x65, 0x66, 0xAE, 0x65, 0xF6, 0x2C, 0x42, 0x42, 0x80, 0x16, 0xC3, 0xFF,
  0x86, 0x3C, 0x64, 0xA1, 0x80, 0x39, 0x1B, 0x6D, 0xBA, 0x07, 0x00, 0x22,
  0x55, 0xF9, 0x75, 0x57, 0x9E, 0x34, 0x4C, 0xC6, 0x75, 0x55, 0x9E, 0x74,
  0x46, 0x8E, 0x74, 0x46, 0x88, 0x3A, 0x51, 0xED, 0x38, 0x4A, 0xD4, 0xE9,
  0x48, 0x69, 0x25, 0x80, 0x24, 0x96, 0x94, 0x5A, 0x98, 0xCA, 0x58, 0x49,
  0x29, 0xC0, 0x65, 0xB6, 0xDD, 0xBA, 0xA0, 0x6B, 0x5A, 0xEB, 0x48, 0x32,
  0xD3, 0xBD, 0x30, 0x75, 0x56, 0x88, 0x32, 0xD3, 0xBD, 0x30, 0xC0, 0x65,
  0x56, 0xAB, 0x75, 0x42, 0x2E, 0xEB, 0x49, 0x00, 0x4A, 0xD4, 0xA9, 0x30,
  0xBA, 0xAC, 0xC8, 0xA6, 0xAE, 0xBC, 0xB2, 0xC0, 0x5A, 0x98, 0xC6, 0x50,
  0xB7, 0x69, 0x00, 0x73, 0x24, 0xCE, 0x69, 0x29, 0x30, 0xAA, 0xB0, 0x32,
  0x22, 0x22, 0xC0, 0x26, 0x69, 0xE0, 0xC0, 0x79, 0xAE, 0x44, 0x75, 0xBE,
  0x72, 0x70, 0x11, 0x79, 0xAE, 0x7E, 0x8E, 0x32, 0x72, 0x64, 0x4C, 0x79,
  0xAE, 0x2C, 0x44, 0x75, 0xAA, 0x45, 0xA0, 0x20, 0x94, 0x96, 0x44, 0x76,
  0xAA, 0x55, 0xA0, 0x7D, 0x5A, 0xAA, 0x75, 0xAA, 0x79, 0xAE, 0x75, 0xBE,
  0x88, 0x79, 0xAE, 0x22, 0x6A, 0x40, 0xE8, 0xE0, 0x5D, 0x4C, 0x55, 0xAE,
  0xB6, 0x64, 0xBE, 0xED, 0xB4, 0x76, 0x6A, 0x79, 0x8C, 0x42, 0x60, 0x6B,
  0x70, 0x29, 0x64, 0xB0, 0xFF, 0x49, 0x35, 0x20, 0xF0,
};

const GFXglyph NotoSans_Condensed_BoldItalic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 3, 2, 3, 1, -6 },
  { 4, 4, 6, 4, 0, -6 },
  { 7, 4, 6, 4, 0, -6 },
  { 10, 6, 6, 6, 0, -6 },
  { 15, 5, 6, 5, 0, -6 },
  { 19, 1, 2, 2, 1, -6 },
  { 20, 3, 7, 2, 0, -6 },
  { 23, 3, 7, 2, -1, -6 },
  { 26, 3, 3, 4, 1, -6 },
  { 28, 4, 4, 4, 0, -5 },
  { 30, 1, 2, 2, 0, -1 },
  { 31, 2, 1, 2, 0, -3 },
  { 32, 1, 1, 2, 0, -1 },
  { 33, 4, 6, 3, 0, -6 },
  { 36, 4, 6, 4, 0, -6 },
  { 39, 3, 6, 4, 1, -6 },
  { 42, 4, 6, 4, 0, -6 },
  { 45, 4, 6, 4, 0, -6 },
  { 48, 4, 6, 4, 0, -6 },
  { 51, 4, 6, 4, 0, -6 },
  { 54, 4, 6, 4, 0, -6 },
  { 57, 4, 6, 4, 0, -6 },
  { 60, 4, 6, 4, 0, -6 },
  { 63, 4, 6, 4, 0, -6 },
  { 66, 2, 4, 2, 0, -4 },
  { 67, 2, 5, 2, 0, -4 },
  { 69, 4, 4, 4, 0, -5 },
  { 71, 4, 2, 4, 0, -4 },
  { 72, 4, 4, 4, 0, -5 },
  { 74, 3, 6, 3, 0, -6 },
  { 77, 6, 7, 6, 0, -6 },
  { 83, 4, 6, 4, 0, -6 },
  { 86, 4, 6, 4, 0, -6 },
  { 89, 4, 6, 4, 0, -6 },
  { 92, 4, 6, 5, 0, -6 },
  { 95, 4, 6, 4, 0, -6 },
  { 98, 4, 6, 3, 0, -6 },
  { 101, 5, 6, 5, 0, -6 },
  { 105, 5, 6, 5, 0, -6 },
  { 109, 3, 6, 3, 0, -6 },
  { 112, 3, 8, 2, -1, -6 },
  { 115, 5, 6, 4, 0, -6 },
  { 119, 3, 6, 3, 0, -6 },
  { 122, 6, 6, 6, 0, -6 },
  { 127, 5, 6, 5, 0, -6 },
  { 131, 5, 6, 5, 0, -6 },
  { 135, 4, 6, 4, 0, -6 },
  { 138, 5, 7, 5, 0, -6 },
  { 143, 4, 6, 4, 0, -6 },
  { 146, 4, 6, 4, 0, -6 },
  { 149, 3, 6, 4, 1, -6 },
  { 152, 5, 6, 5, 0, -6 },
  { 156, 4, 6, 4, 1, -6 },
  { 159, 6, 6, 6, 1, -6 },
  { 164, 5, 6, 4, 0, -6 },
  { 168, 3, 6, 4, 1, -6 },
  { 171, 4, 6, 3, 0, -6 },
  { 174, 3, 7, 2, 0, -6 },
  { 177, 2, 6, 3, 1, -6 },
  { 179, 4, 7, 2, -1, -6 },
  { 183, 4, 4, 4, 0, -6 },
  { 185, 3, 1, 3, -1, 0 },
  { 186, 2, 1, 2, 1, -6 },
  { 187, 4, 4, 4, 0, -4 },
  { 189, 4, 6, 4, 0, -6 },
  { 192, 3, 4, 3, 0, -4 },
  { 194, 4, 6, 4, 0, -6 },
  { 197, 4, 4, 4, 0, -4 },
  { 199, 4, 8, 2, -1, -6 },
  { 203, 4, 6, 4, 0, -4 },
  { 206, 4, 6, 4, 0, -6 },
  { 209, 2, 6, 2, 0, -6 },
  { 211, 3, 8, 2, -1, -6 },
  { 214, 4, 6, 4, 0, -6 },
  { 217, 2, 6, 2, 0, -6 },
  { 219, 6, 4, 6, 0, -4 },
  { 222, 4, 4, 4, 0, -4 },
  { 224, 4, 4, 4, 0, -4 },
  { 226, 4, 6, 4, 0, -4 },
  { 229, 4, 6, 4, 0, -4 },
  { 232, 3, 4, 3, 0, -4 },
  { 234, 3, 4, 3, 0, -4 },
  { 236, 3, 5, 3, 0, -5 },
  { 238, 4, 4, 4, 0, -4 },
  { 240, 4, 4, 3, 0, -4 },
  { 242, 6, 4, 5, 0, -4 },
  { 245, 4, 4, 4, 0, -4 },
  { 247, 5, 6, 4, -1, -4 },
  { 251, 3, 4, 3, 0, -4 },
  { 253, 3, 7, 3, 0, -6 },
  { 256, 1, 8, 3, 1, -6 },
  { 257, 3, 7, 3, 0, -6 },
  { 260, 4, 1, 4, 0, -3 },
};

const GFXfont NotoSans_Condensed_BoldItalic8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BoldItalic8pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BoldItalic8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_CONDENSED_BOLDITALIC8PT7B_H_
