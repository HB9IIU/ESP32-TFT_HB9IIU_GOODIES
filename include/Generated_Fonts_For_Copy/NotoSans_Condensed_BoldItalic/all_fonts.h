#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/NotoSans_Condensed_BoldItalic
// Headers: 67

#include "NotoSans_Condensed_BoldItalic6pt7b.h"
#include "NotoSans_Condensed_BoldItalic7pt7b.h"
#include "NotoSans_Condensed_BoldItalic8pt7b.h"
#include "NotoSans_Condensed_BoldItalic9pt7b.h"
#include "NotoSans_Condensed_BoldItalic10pt7b.h"
#include "NotoSans_Condensed_BoldItalic11pt7b.h"
#include "NotoSans_Condensed_BoldItalic12pt7b.h"
#include "NotoSans_Condensed_BoldItalic13pt7b.h"
#include "NotoSans_Condensed_BoldItalic14pt7b.h"
#include "NotoSans_Condensed_BoldItalic15pt7b.h"
#include "NotoSans_Condensed_BoldItalic16pt7b.h"
#include "NotoSans_Condensed_BoldItalic17pt7b.h"
#include "NotoSans_Condensed_BoldItalic18pt7b.h"
#include "NotoSans_Condensed_BoldItalic19pt7b.h"
#include "NotoSans_Condensed_BoldItalic20pt7b.h"
#include "NotoSans_Condensed_BoldItalic21pt7b.h"
#include "NotoSans_Condensed_BoldItalic22pt7b.h"
#include "NotoSans_Condensed_BoldItalic23pt7b.h"
#include "NotoSans_Condensed_BoldItalic24pt7b.h"
#include "NotoSans_Condensed_BoldItalic25pt7b.h"
#include "NotoSans_Condensed_BoldItalic26pt7b.h"
#include "NotoSans_Condensed_BoldItalic27pt7b.h"
#include "NotoSans_Condensed_BoldItalic28pt7b.h"
#include "NotoSans_Condensed_BoldItalic29pt7b.h"
#include "NotoSans_Condensed_BoldItalic30pt7b.h"
#include "NotoSans_Condensed_BoldItalic31pt7b.h"
#include "NotoSans_Condensed_BoldItalic32pt7b.h"
#include "NotoSans_Condensed_BoldItalic33pt7b.h"
#include "NotoSans_Condensed_BoldItalic34pt7b.h"
#include "NotoSans_Condensed_BoldItalic35pt7b.h"
#include "NotoSans_Condensed_BoldItalic36pt7b.h"
#include "NotoSans_Condensed_BoldItalic37pt7b.h"
#include "NotoSans_Condensed_BoldItalic38pt7b.h"
#include "NotoSans_Condensed_BoldItalic39pt7b.h"
#include "NotoSans_Condensed_BoldItalic40pt7b.h"
#include "NotoSans_Condensed_BoldItalic41pt7b.h"
#include "NotoSans_Condensed_BoldItalic42pt7b.h"
#include "NotoSans_Condensed_BoldItalic43pt7b.h"
#include "NotoSans_Condensed_BoldItalic44pt7b.h"
#include "NotoSans_Condensed_BoldItalic45pt7b.h"
#include "NotoSans_Condensed_BoldItalic46pt7b.h"
#include "NotoSans_Condensed_BoldItalic47pt7b.h"
#include "NotoSans_Condensed_BoldItalic48pt7b.h"
#include "NotoSans_Condensed_BoldItalic49pt7b.h"
#include "NotoSans_Condensed_BoldItalic50pt7b.h"
#include "NotoSans_Condensed_BoldItalic51pt7b.h"
#include "NotoSans_Condensed_BoldItalic52pt7b.h"
#include "NotoSans_Condensed_BoldItalic53pt7b.h"
#include "NotoSans_Condensed_BoldItalic54pt7b.h"
#include "NotoSans_Condensed_BoldItalic55pt7b.h"
#include "NotoSans_Condensed_BoldItalic56pt7b.h"
#include "NotoSans_Condensed_BoldItalic57pt7b.h"
#include "NotoSans_Condensed_BoldItalic58pt7b.h"
#include "NotoSans_Condensed_BoldItalic59pt7b.h"
#include "NotoSans_Condensed_BoldItalic60pt7b.h"
#include "NotoSans_Condensed_BoldItalic61pt7b.h"
#include "NotoSans_Condensed_BoldItalic62pt7b.h"
#include "NotoSans_Condensed_BoldItalic63pt7b.h"
#include "NotoSans_Condensed_BoldItalic64pt7b.h"
#include "NotoSans_Condensed_BoldItalic65pt7b.h"
#include "NotoSans_Condensed_BoldItalic66pt7b.h"
#include "NotoSans_Condensed_BoldItalic67pt7b.h"
#include "NotoSans_Condensed_BoldItalic68pt7b.h"
#include "NotoSans_Condensed_BoldItalic69pt7b.h"
#include "NotoSans_Condensed_BoldItalic70pt7b.h"
#include "NotoSans_Condensed_BoldItalic71pt7b.h"
#include "NotoSans_Condensed_BoldItalic72pt7b.h"
