#ifndef _NOTOSANS_CONDENSED_BOLDITALIC64PT7B_H_
#define _NOTOSANS_CONDENSED_BOLDITALIC64PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BoldItalic.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BoldItalic64pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xF8, 0x00,
  0xFE, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xE3, 0xFE, 0x7F, 0xC7, 0xFC, 0xFF,
  0x0F, 0xF1, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0x0F, 0xE0,
  0xFE, 0x1F, 0xC3, 0xFC, 0x7F, 0x87, 0xF8, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F,
  0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0x7E, 0x0F, 0xC0, 0xFC, 0x3F, 0x83, 0xF8,
  0x7F, 0x07, 0xF0, 0xFC, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0xFC,
  0x1F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F,
  0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFB, 0x87, 0x80, 0x7F, 0xCE, 0x0C,
  0x01, 0xFE, 0x38, 0x00, 0x07, 0xF8, 0xE0, 0x00, 0x1F, 0xE3, 0x80, 0x00,
  0x7F, 0x9C, 0x00, 0x01, 0xFF, 0x70, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0x7F, 0xC0, 0x00, 0x38, 0xFF, 0x00,
  0x00, 0xE3, 0xFC, 0x20, 0x03, 0x8F, 0xF0, 0x60, 0x0E, 0x7F, 0xC3, 0xC0,
  0x71, 0xFF, 0x0F, 0xE1, 0xCF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xFF,
  0x00, 0x07, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xE0, 0x07, 0xF1, 0xFC, 0x03, 0xF8,
  0x00, 0xFE, 0x3F, 0x80, 0x7E, 0x00, 0x3F, 0x87, 0xF0, 0x1F, 0xC0, 0x07,
  0xF0, 0xFE, 0x03, 0xF0, 0x00, 0xFC, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x83,
  0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x00, 0xFE, 0x0F, 0xC1,
  0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x7F, 0x0F, 0xE0,
  0x00, 0x7E, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0xC1, 0xF8, 0x7E, 0x00, 0x03,
  0xF8, 0x7F, 0x1F, 0xC1, 0xF8, 0x7F, 0x0F, 0xE3, 0xF0, 0xFF, 0xCF, 0xE1,
  0xF8, 0xFE, 0x3F, 0xF9, 0xFC, 0x7F, 0x3F, 0x8F, 0xFF, 0x9F, 0xDF, 0xC7,
  0xE3, 0xFF, 0xF3, 0xFF, 0xF9, 0xFC, 0xFF, 0xFF, 0x7F, 0xFE, 0x3F, 0x1F,
  0xCF, 0xE7, 0xFF, 0x8F, 0xC7, 0xF0, 0xFC, 0x7F, 0xE3, 0xF8, 0xFC, 0x1F,
  0x87, 0xF0, 0x7E, 0x3F, 0x83, 0xF0, 0x00, 0x1F, 0xC7, 0xF0, 0x7E, 0x00,
  0x03, 0xF0, 0xFC, 0x1F, 0xC0, 0x00, 0xFC, 0x1F, 0x83, 0xF8, 0x00, 0x3F,
  0x87, 0xF0, 0x7F, 0x00, 0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0x01, 0xFC, 0x1F,
  0x81, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0x7E, 0x0F,
  0xE0, 0x03, 0xF8, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x7F, 0x00,
  0x1F, 0xC0, 0x3F, 0x0F, 0xE0, 0x03, 0xF0, 0x07, 0xE3, 0xF8, 0x00, 0xFC,
  0x00, 0xFE, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0xC0, 0x07, 0xE0, 0x03,
  0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0x00, 0x03, 0xFF,
  0x80, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x01, 0xFE, 0x1F,
  0xE0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFC, 0x07, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0x07, 0xFF, 0xF8,
  0x3F, 0xC1, 0xFF, 0xFF, 0x07, 0xF8, 0x7F, 0xDF, 0xF1, 0xFF, 0x1F, 0xF3,
  0xFE, 0x3F, 0xC3, 0xFC, 0x3F, 0xEF, 0xF8, 0xFF, 0x87, 0xFD, 0xFE, 0x1F,
  0xE0, 0x7F, 0xFF, 0xC7, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0x00, 0xFF, 0xFC,
  0x1F, 0xE0, 0x1F, 0xFF, 0x83, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0x80, 0x3F,
  0xF8, 0x0F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xE0,
  0x7F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFB, 0xFF,
  0x01, 0xFF, 0xFC, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFE, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1F, 0xE7, 0xFC, 0xFF, 0x9F, 0xE3, 0xFC, 0x7F, 0x8F, 0xE1,
  0xFC, 0x7F, 0x8F, 0xF1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0x87, 0xF0,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x08, 0x07, 0xF0, 0x03, 0x81, 0xFC, 0x00,
  0xF8, 0x7E, 0x00, 0x3F, 0x9F, 0x80, 0x1F, 0xFF, 0xE1, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xDF, 0x80, 0x3F, 0xE7, 0xF0, 0x1F, 0xF9, 0xFC,
  0x01, 0xFC, 0x3F, 0x80, 0x3E, 0x0F, 0xF0, 0x07, 0x83, 0xFC, 0x00, 0xC0,
  0x7C, 0x00, 0x10, 0x1C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0x83, 0xFE,
  0x0F, 0xF8, 0x3F, 0xC1, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC,
  0x0F, 0xE0, 0x7F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x00, 0x7F,
  0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFB,
  0xFF, 0xFD, 0xFF, 0xFC, 0x07, 0x03, 0xF8, 0xFF, 0x3F, 0xE7, 0xFF, 0xFF,
  0xBF, 0xF7, 0xFE, 0x7F, 0x8F, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xF3, 0xFE, 0x01,
  0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x03, 0xFE, 0x0F, 0xF8,
  0x1F, 0xF0, 0x7F, 0x80, 0xFF, 0x87, 0xFC, 0x07, 0xFC, 0x3F, 0xC0, 0x3F,
  0xE3, 0xFE, 0x01, 0xFF, 0x1F, 0xF0, 0x0F, 0xF8, 0xFF, 0x80, 0x7F, 0xC7,
  0xF8, 0x03, 0xFC, 0x7F, 0xC0, 0x1F, 0xE3, 0xFE, 0x00, 0xFF, 0x1F, 0xF0,
  0x0F, 0xF8, 0xFF, 0x00, 0x7F, 0xCF, 0xF8, 0x03, 0xFE, 0x7F, 0xC0, 0x1F,
  0xF3, 0xFE, 0x00, 0xFF, 0x1F, 0xF0, 0x0F, 0xF8, 0xFF, 0x00, 0x7F, 0xC7,
  0xF8, 0x03, 0xFE, 0x3F, 0xC0, 0x3F, 0xE1, 0xFE, 0x01, 0xFF, 0x1F, 0xF0,
  0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x87, 0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x3F,
  0xE0, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xC1, 0xFF, 0x01,
  0xFF, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x03,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC3, 0xFF, 0xFF, 0x1F, 0xFB, 0xFC, 0xFF, 0xDF, 0xE1, 0xFE, 0x7F, 0x83,
  0xF1, 0xFE, 0x0F, 0x8F, 0xF8, 0x18, 0x3F, 0xE0, 0x40, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xC7, 0xFF,
  0x00, 0x7F, 0x03, 0xFF, 0x00, 0x7C, 0x01, 0xFF, 0x00, 0x38, 0x01, 0xFF,
  0x00, 0x10, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80,
  0x1F, 0x87, 0xFF, 0x00, 0x38, 0x03, 0xFE, 0x00, 0x60, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x08, 0x00, 0x07, 0xFE, 0x1C, 0x00, 0x1F, 0xF8, 0x3E,
  0x00, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F,
  0x7F, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFB, 0xFC, 0x00, 0x07, 0xE7,
  0xF8, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x7F, 0x3F, 0xE0, 0x00, 0xFC, 0x7F,
  0x80, 0x03, 0xF8, 0xFF, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x1F, 0x83, 0xFC,
  0x00, 0x7F, 0x0F, 0xF0, 0x01, 0xFC, 0x1F, 0xE0, 0x07, 0xF0, 0x3F, 0xC0,
  0x0F, 0xC0, 0x7F, 0x80, 0x3F, 0x81, 0xFF, 0x00, 0xFE, 0x03, 0xFC, 0x01,
  0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xFB, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xE7, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x08, 0x00, 0x1F, 0xF8, 0x1C, 0x00, 0x7F,
  0xF0, 0x3E, 0x01, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3A, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x80, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xF8, 0x04, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0xF0, 0x00, 0x7F, 0x8F, 0xF0, 0x03, 0xFE, 0xFF, 0xE0,
  0x0F, 0xF7, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xC1, 0xFF,
  0x81, 0xFF, 0x0F, 0xFC, 0x07, 0xFC, 0x3F, 0xF0, 0x1F, 0xF0, 0xFF, 0x80,
  0x7F, 0xC3, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x3F, 0xC0, 0x1F,
  0xE0, 0xFF, 0x00, 0x7F, 0x83, 0xFC, 0x03, 0xFE, 0x0F, 0xF0, 0x0F, 0xF8,
  0x3F, 0xC0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x0F, 0xFC, 0x0F,
  0xFC, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xF7, 0xFF,
  0x00, 0xFF, 0x83, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xFC,
  0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x07, 0xFC, 0x01,
  0xFF, 0x1F, 0xF0, 0x03, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xC7, 0xFE, 0x03, 0xFF, 0x07,
  0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F,
  0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x7F,
  0x87, 0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x07, 0xF8,
  0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xF8, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xE7, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F,
  0x83, 0xFE, 0x03, 0xFE, 0x1F, 0xE0, 0x1F, 0xF1, 0xFF, 0x00, 0xFF, 0x8F,
  0xF8, 0x07, 0xFC, 0x7F, 0xC0, 0x3F, 0xE3, 0xFC, 0x01, 0xFF, 0x1F, 0xE0,
  0x1F, 0xF0, 0xFF, 0x00, 0xFF, 0x8F, 0xF8, 0x07, 0xFC, 0x7F, 0xC0, 0x7F,
  0xE3, 0xFE, 0x03, 0xFF, 0x0F, 0xF8, 0x3F, 0xF8, 0x7F, 0xE3, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0x7F, 0x80, 0x3F, 0xE3, 0xFC, 0x00, 0x7C, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x02, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0x7F,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03,
  0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00,
  0x3F, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F,
  0xC1, 0xFF, 0x06, 0x00, 0xFF, 0x04, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80,
  0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x7F, 0xC0, 0x7E, 0x0F, 0xE0, 0x3F,
  0xFF, 0x0F, 0xC1, 0xF8, 0x0F, 0xFF, 0xE1, 0xF8, 0x7E, 0x03, 0xFF, 0xFC,
  0x3F, 0x0F, 0xC0, 0xFF, 0xFF, 0x07, 0xE3, 0xF0, 0x3F, 0x87, 0xE0, 0xFC,
  0x7E, 0x0F, 0xE0, 0xFC, 0x1F, 0x9F, 0x81, 0xF8, 0x1F, 0x83, 0xF3, 0xF0,
  0x7E, 0x07, 0xE0, 0x7E, 0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0xDF, 0x83, 0xF0,
  0x1F, 0x81, 0xFB, 0xF0, 0x7E, 0x03, 0xF0, 0x3E, 0x7E, 0x0F, 0xC0, 0xFE,
  0x0F, 0xCF, 0xC3, 0xF0, 0x1F, 0x81, 0xF9, 0xF0, 0x7E, 0x03, 0xF0, 0x3F,
  0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xCF, 0xC1, 0xF8, 0x1F, 0xC1, 0xF9, 0xF8,
  0x3F, 0x03, 0xF0, 0x3F, 0x3F, 0x07, 0xE0, 0xFE, 0x0F, 0xC7, 0xE0, 0xFC,
  0x1F, 0xC1, 0xF8, 0xFC, 0x1F, 0x87, 0xF8, 0x7E, 0x1F, 0x83, 0xF9, 0xFF,
  0x1F, 0x83, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7E, 0x0F, 0xFF, 0x7F, 0xFC,
  0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x01, 0xF8, 0x0F, 0xF0, 0xFF, 0x80, 0x3F,
  0x00, 0x7C, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x01, 0x80,
  0x00, 0x3F, 0xF0, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0x7F, 0x00,
  0x00, 0x3F, 0xBF, 0x80, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x0F, 0xF1, 0xFC,
  0x00, 0x07, 0xF8, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x03, 0xFC, 0x3F,
  0x80, 0x01, 0xFE, 0x1F, 0xC0, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0xFF, 0x07,
  0xF0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x7F, 0xC0,
  0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x3F, 0xE0, 0x3F, 0x80, 0x1F, 0xE0,
  0x1F, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0xC0, 0x07, 0xFC, 0x7F,
  0xC0, 0x03, 0xFE, 0x3F, 0xE0, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0x9F,
  0xF0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x1F, 0xF7,
  0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0x0F, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xC0,
  0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFC,
  0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF,
  0x83, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0x80, 0x3F, 0xE0,
  0x3F, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xFC,
  0x0F, 0xF8, 0x03, 0xFE, 0x07, 0xF8, 0x01, 0xFF, 0x03, 0xFC, 0x01, 0xFF,
  0x03, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0x03, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xF9, 0xF8, 0x03, 0xFF, 0xC0, 0x38, 0x07, 0xFF, 0x00, 0x08, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x06, 0x00, 0x7F, 0xF8, 0x3E, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0x83, 0xFF, 0xC0, 0x1F, 0xF0, 0x1F, 0xF8, 0x03, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xF0, 0x07, 0xFE, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF8, 0x01, 0xFF,
  0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x07, 0xFC, 0x0F, 0xF8, 0x00,
  0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xFE, 0x07, 0xF8,
  0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x03, 0xFE, 0x07,
  0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0x03, 0xFF,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xF0, 0x03,
  0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xF8, 0x1F, 0xF0,
  0x03, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xF8, 0x0F,
  0xF0, 0x0F, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xC3, 0xF8, 0x03, 0xFF, 0xC0,
  0x0F, 0x00, 0x7F, 0xF0, 0x00, 0x40, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x07, 0xFF, 0xF0, 0xFF, 0x80, 0xFF, 0xFE, 0x1F, 0xF0,
  0x1F, 0xFF, 0x87, 0xFE, 0x03, 0xFF, 0xF0, 0xFF, 0x80, 0x7F, 0xFE, 0x1F,
  0xF0, 0x1F, 0xFF, 0xC3, 0xFE, 0x03, 0xFF, 0xF8, 0x7F, 0xC0, 0x7F, 0xFE,
  0x0F, 0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x01,
  0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x07, 0xF8, 0x1F, 0xF0,
  0x01, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x07, 0xFC, 0x0F,
  0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xE0, 0x1F, 0xFE, 0x0F, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3F,
  0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x07,
  0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x07, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x83, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x01, 0xFF,
  0x80, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x01, 0xFE,
  0x01, 0xFF, 0x80, 0x07, 0xF8, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xE0,
  0x00, 0xFF, 0x81, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x0F, 0xF0,
  0x7F, 0xE0, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x7F, 0xE0, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x00, 0x7F, 0x8F,
  0xF8, 0x00, 0x01, 0xFE, 0x7F, 0xE0, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x00,
  0x3F, 0xEF, 0xF8, 0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x03, 0xFD, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0xFF, 0x00, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x00, 0xFF, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x7F,
  0xC1, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x03, 0xFC,
  0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xE0,
  0x07, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xDF, 0xE0,
  0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xFC,
  0x00, 0xFF, 0x7F, 0x00, 0xFE, 0xFF, 0x00, 0x3F, 0xDF, 0xC0, 0x7F, 0xBF,
  0xC0, 0x0F, 0xF7, 0xF0, 0x1F, 0xDF, 0xF0, 0x03, 0xFD, 0xFC, 0x0F, 0xF7,
  0xF8, 0x00, 0xFE, 0x7F, 0x03, 0xF9, 0xFE, 0x00, 0x7F, 0x9F, 0xC1, 0xFE,
  0x7F, 0x80, 0x1F, 0xE7, 0xF0, 0x7F, 0x1F, 0xE0, 0x07, 0xF9, 0xFC, 0x1F,
  0xCF, 0xF0, 0x01, 0xFE, 0x7F, 0x0F, 0xE3, 0xFC, 0x00, 0xFF, 0x1F, 0xC3,
  0xF8, 0xFF, 0x00, 0x3F, 0xC7, 0xF1, 0xFC, 0x3F, 0xC0, 0x0F, 0xF1, 0xFC,
  0x7F, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0x3F, 0x87, 0xF8, 0x00, 0xFF, 0x0F,
  0xEF, 0xE1, 0xFE, 0x00, 0x7F, 0x83, 0xFF, 0xF0, 0x7F, 0x80, 0x1F, 0xE0,
  0xFF, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xFF, 0x0F, 0xF8, 0x01, 0xFE,
  0x0F, 0xFF, 0x83, 0xFC, 0x00, 0x7F, 0x83, 0xFF, 0xE0, 0xFF, 0x00, 0x3F,
  0xC0, 0xFF, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x3F, 0xFC, 0x0F, 0xF0, 0x03,
  0xFC, 0x0F, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x03, 0xFF, 0x81, 0xFE, 0x00,
  0x3F, 0x80, 0xFF, 0xC0, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0xF0, 0x1F, 0xE0,
  0x07, 0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x00, 0x3F,
  0xC0, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x0F, 0xFE, 0x00, 0x0F, 0xF0, 0x07,
  0xFF, 0x80, 0x0F, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0xE0,
  0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0x80, 0x1F,
  0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xFF, 0xC0, 0x1F, 0xE0, 0x0F, 0xFF, 0xF0,
  0x1F, 0xE0, 0x07, 0xFF, 0xF8, 0x0F, 0xF0, 0x03, 0xFB, 0xFC, 0x07, 0xF8,
  0x01, 0xFC, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x7F, 0x81, 0xFE, 0x00, 0xFF,
  0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0x9F, 0xE0, 0xFF, 0x00, 0x3F, 0xCF, 0xF0,
  0x7F, 0x80, 0x1F, 0xC3, 0xF8, 0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x1F, 0xE0,
  0x0F, 0xF0, 0xFF, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x8F, 0xF0, 0x03, 0xFC,
  0x3F, 0xC7, 0xF8, 0x03, 0xFC, 0x0F, 0xF3, 0xFC, 0x01, 0xFE, 0x07, 0xF9,
  0xFC, 0x00, 0xFF, 0x03, 0xFD, 0xFE, 0x00, 0x7F, 0x81, 0xFE, 0xFF, 0x00,
  0x3F, 0xC0, 0x7F, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xE0,
  0x1F, 0xFF, 0xC0, 0x0F, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xF8, 0x07, 0xFF,
  0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0xFC, 0x01,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0x80,
  0x0F, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xC0, 0x03, 0xFF,
  0xC0, 0x1F, 0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0xFF, 0xE0, 0x07,
  0xF8, 0x00, 0x3F, 0xF0, 0x07, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0x3F, 0xFC, 0x03, 0xFF, 0x80,
  0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0x07, 0xFE,
  0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0x87,
  0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x7F,
  0xC7, 0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x01, 0xFF, 0x3F, 0xF0, 0x00,
  0x3F, 0xE7, 0xFC, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0xFF, 0x9F, 0xF0,
  0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0xFF, 0xDF,
  0xF0, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0xFF,
  0xCF, 0xF8, 0x00, 0x1F, 0xF9, 0xFF, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00,
  0xFF, 0xC7, 0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x07, 0xFE, 0x1F, 0xF0,
  0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x07, 0xFE, 0x0F,
  0xFC, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xFC, 0x3F, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0x81, 0xFF, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x07, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x7F,
  0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF8, 0x07,
  0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0x3F, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF8,
  0x1F, 0xF8, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x07,
  0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x80,
  0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x0F, 0xF8, 0xFF,
  0x80, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x07, 0xFC,
  0xFF, 0x80, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x07,
  0xFE, 0xFF, 0xC0, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x1F, 0xF3, 0xFE, 0x00,
  0x03, 0xFE, 0x7F, 0xC0, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x1F, 0xF1, 0xFF,
  0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x1F, 0xF0,
  0xFF, 0x80, 0x07, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x3F,
  0xF0, 0x7F, 0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0xC0,
  0x7F, 0xF0, 0x1F, 0xFC, 0x3F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x3F, 0xFE, 0x00,
  0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xF8,
  0x07, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0xFF,
  0xC0, 0x3F, 0xC0, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x8F,
  0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x3F, 0xE1,
  0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xC0, 0x07, 0xF8,
  0x1F, 0xF0, 0x03, 0xFC, 0x0F, 0xF8, 0x03, 0xFE, 0x07, 0xFC, 0x01, 0xFF,
  0x01, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x3F,
  0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x0F,
  0xF0, 0x03, 0xFE, 0x07, 0xF8, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x78,
  0x01, 0xFF, 0x80, 0x18, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x40, 0x00, 0x7F, 0xC0,
  0x70, 0x00, 0xFF, 0xC0, 0x7C, 0x01, 0xFF, 0x80, 0x7F, 0x8F, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x07, 0xFC, 0x0F, 0xF8,
  0x00, 0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x07,
  0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x03, 0xFE,
  0x07, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xF0, 0x03,
  0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xF0,
  0x01, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x0F, 0xF8, 0x1F,
  0xF0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF8,
  0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x07,
  0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xE0,
  0x07, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xF0, 0x3F,
  0xE0, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x1F, 0xF0,
  0x3F, 0xE0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x1F,
  0xF0, 0x1F, 0xF0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xC0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F,
  0xF8, 0x7F, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFE, 0xFF,
  0x00, 0x03, 0xFE, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x07, 0xFC, 0xFF,
  0x00, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x3F, 0xE0, 0xFF,
  0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0xC0, 0xFF,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x01, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF,
  0x03, 0xFE, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x7F, 0x07, 0xFC, 0x00, 0x7F,
  0x07, 0xF8, 0x00, 0x7F, 0x0F, 0xF8, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x7F,
  0x0F, 0xF0, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x7F,
  0x3F, 0xC0, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x7F,
  0x7F, 0x80, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0xBF, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xDF, 0xE0, 0x03, 0xFE, 0x00,
  0x3F, 0xCF, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0xFF, 0x80,
  0x1F, 0xF3, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF1, 0xFE, 0x00, 0x7F, 0xE0,
  0x0F, 0xF8, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xF0,
  0x07, 0xFC, 0x3F, 0xC0, 0x3F, 0xF8, 0x03, 0xFE, 0x1F, 0xE0, 0x1F, 0xFC,
  0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x07, 0xF8, 0x0F, 0xFF,
  0x00, 0xFF, 0x03, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0x81, 0xFE, 0x07, 0xFF,
  0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xC0, 0x7F, 0x81, 0xFB,
  0xF0, 0x3F, 0xE0, 0x3F, 0x81, 0xFD, 0xF8, 0x1F, 0xE0, 0x1F, 0xC0, 0xFF,
  0xFC, 0x1F, 0xF0, 0x0F, 0xE0, 0xFE, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F,
  0x7F, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xBF, 0x87, 0xFC, 0x03, 0xFC, 0x3F,
  0x9F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xCF, 0xE1, 0xFE, 0x00, 0xFF, 0x1F,
  0xC7, 0xF1, 0xFE, 0x00, 0x7F, 0x8F, 0xE3, 0xF8, 0xFF, 0x00, 0x3F, 0xCF,
  0xF1, 0xFC, 0xFF, 0x80, 0x1F, 0xE7, 0xF0, 0xFE, 0x7F, 0x80, 0x0F, 0xF3,
  0xF8, 0x7F, 0x3F, 0xC0, 0x07, 0xFB, 0xF8, 0x3F, 0xBF, 0xC0, 0x03, 0xFD,
  0xFC, 0x1F, 0xDF, 0xE0, 0x01, 0xFE, 0xFE, 0x0F, 0xEF, 0xF0, 0x00, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x0F, 0xF0,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0x07,
  0xF8, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x00, 0xFF,
  0x8F, 0xF0, 0x00, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x01, 0xFF, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x07,
  0xFC, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0xC0,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xEF, 0xF8,
  0x01, 0xFF, 0x3F, 0xE0, 0x07, 0xFC, 0xFF, 0x80, 0x3F, 0xE1, 0xFE, 0x00,
  0xFF, 0x87, 0xF8, 0x07, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF,
  0x81, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF0, 0xFF, 0x80,
  0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x1F, 0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x0F,
  0xF3, 0xFE, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x7F, 0x83,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0,
  0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0x9F, 0x80, 0x01, 0xFE, 0x7F, 0x00,
  0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x07,
  0xF0, 0x3F, 0x80, 0x3F, 0xC0, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0,
  0x07, 0xF0, 0x3F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x01,
  0xFC, 0x3F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x3F,
  0xBF, 0xC0, 0x00, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xC3, 0xFE, 0x1F, 0xF0, 0x7F, 0xC3, 0xFE,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xFE, 0x3F, 0xC0, 0x7F, 0xFC, 0xFF,
  0x03, 0xFF, 0xFB, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFC, 0x3F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF,
  0x01, 0xFF, 0x0F, 0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0x80,
  0x7F, 0x87, 0xFC, 0x01, 0xFE, 0x1F, 0xF0, 0x07, 0xF8, 0x7F, 0xC0, 0x3F,
  0xE1, 0xFE, 0x00, 0xFF, 0x8F, 0xF8, 0x03, 0xFC, 0x3F, 0xE0, 0x0F, 0xF0,
  0xFF, 0x80, 0x3F, 0xC3, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x3F,
  0xE0, 0x1F, 0xE0, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x0F, 0xF8,
  0x1F, 0xF8, 0x3F, 0xE0, 0xFF, 0xE0, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFE, 0xFE,
  0x00, 0xFF, 0xF3, 0xF8, 0x03, 0xFF, 0x8F, 0xE0, 0x03, 0xFC, 0x3F, 0x80,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x08, 0x00, 0x1F, 0xF3, 0xFC,
  0x00, 0x7F, 0x9F, 0xFC, 0x01, 0xFE, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x00, 0xFF, 0x07, 0xFC,
  0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x00,
  0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xF0, 0xFF, 0x00, 0x7F,
  0xC3, 0xFC, 0x01, 0xFF, 0x1F, 0xF0, 0x07, 0xF8, 0x7F, 0xC0, 0x1F, 0xE1,
  0xFE, 0x00, 0xFF, 0x87, 0xF8, 0x03, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF,
  0x80, 0x7F, 0xC3, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x07, 0xFF, 0xDF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFD, 0xFF, 0xF8, 0x07, 0xF7, 0xFF, 0xC0,
  0x3F, 0x8F, 0xFE, 0x00, 0xFE, 0x1F, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFC, 0x0C, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x04, 0x0F, 0xFC, 0x0E, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x30, 0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x01, 0xFF,
  0xCF, 0xF8, 0x01, 0xFF, 0xF7, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xC1, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x0F,
  0xF8, 0x03, 0xFC, 0x07, 0xFC, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x3F, 0xC0,
  0x7F, 0xC0, 0x1F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF8,
  0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFE,
  0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xC1, 0xFF,
  0x80, 0x3F, 0xFB, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFB, 0xF8, 0x00, 0x7F, 0xF9,
  0xFC, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F,
  0xE1, 0xFF, 0x0F, 0xF8, 0x1F, 0xE3, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0x7F,
  0x9F, 0xF0, 0x0F, 0xE3, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x9F, 0xF0,
  0x3F, 0xE3, 0xFC, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x81, 0xFF, 0x80, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0x88, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x87, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x07, 0xFF, 0x9F,
  0xE0, 0x07, 0xFF, 0xCF, 0xF0, 0x07, 0xFF, 0xF7, 0xF0, 0x03, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x87,
  0xFF, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x3F, 0xE0,
  0x0F, 0xF0, 0x1F, 0xF0, 0x07, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xF8,
  0x03, 0xFE, 0x07, 0xFC, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F,
  0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x07,
  0xFC, 0x0F, 0xFC, 0x03, 0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0x0F, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xDF, 0xE0, 0x01, 0xFF, 0xCF, 0xF0,
  0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x02, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x30, 0x00, 0x7F, 0xC0, 0x1F, 0x00, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x08, 0x00,
  0x1F, 0xF3, 0xFE, 0x00, 0x7F, 0x9F, 0xFC, 0x01, 0xFE, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFE, 0x1F, 0xF0, 0x3F, 0xF0, 0x7F, 0xC1, 0xFF, 0x81,
  0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F,
  0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xF8, 0x07, 0xF8, 0x3F, 0xE0, 0x1F, 0xE0,
  0xFF, 0x00, 0xFF, 0x83, 0xFC, 0x03, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F,
  0xC0, 0x3F, 0xC1, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xFC, 0x1F, 0xE0,
  0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0x83, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x0F,
  0xF8, 0x3F, 0xC0, 0x3F, 0xE0, 0xFF, 0x00, 0xFF, 0x07, 0xFC, 0x03, 0xFC,
  0x1F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0xC1, 0xFE, 0x01, 0xFF, 0x07,
  0xF8, 0x07, 0xF8, 0x3F, 0xE0, 0x1F, 0xE0, 0xFF, 0x80, 0x7F, 0x80, 0x00,
  0x07, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x87, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFC,
  0x03, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0xFF,
  0x81, 0xFF, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x1F,
  0xE1, 0xFF, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x07,
  0xF8, 0xFF, 0x80, 0x03, 0xFC, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x80, 0x00,
  0xFE, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0x3F, 0xE0, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x7F, 0x83, 0xFE, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x1F, 0xE0, 0xFF,
  0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0, 0x07, 0xF8, 0x0F,
  0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x02, 0x00, 0x02, 0x00, 0x07, 0xF0,
  0xFF, 0x80, 0xFF, 0x00, 0x1F, 0xC7, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0x3F,
  0xFC, 0x7F, 0xFC, 0x01, 0xFD, 0xFF, 0xFB, 0xFF, 0xF8, 0x0F, 0xEF, 0xFF,
  0xEF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0x81, 0xFF, 0x01, 0xFF, 0x01,
  0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x03, 0xFE,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x07, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x81, 0xFE,
  0x01, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xE0,
  0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x03,
  0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F,
  0xC0, 0x3F, 0xC1, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x07, 0xF8, 0x07, 0xF8,
  0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x80,
  0x7F, 0x81, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x07,
  0xF0, 0x7F, 0x80, 0x1F, 0xC7, 0xFF, 0x00, 0x7F, 0x3F, 0xFE, 0x01, 0xF9,
  0xFF, 0xF8, 0x07, 0xEF, 0xFF, 0xF0, 0x3F, 0xBF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0x87, 0xFC, 0x0F, 0xFC, 0x1F, 0xF0, 0x7F, 0xE0, 0x7F,
  0xC1, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0,
  0x7F, 0x80, 0x7F, 0x83, 0xFE, 0x01, 0xFE, 0x0F, 0xF8, 0x07, 0xF8, 0x3F,
  0xC0, 0x3F, 0xE0, 0xFF, 0x00, 0xFF, 0x83, 0xFC, 0x03, 0xFC, 0x1F, 0xF0,
  0x0F, 0xF0, 0x7F, 0xC0, 0x3F, 0xC1, 0xFE, 0x01, 0xFF, 0x07, 0xF8, 0x07,
  0xFC, 0x3F, 0xE0, 0x1F, 0xE0, 0xFF, 0x80, 0x7F, 0x83, 0xFC, 0x01, 0xFE,
  0x0F, 0xF0, 0x0F, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1, 0xFF, 0x00, 0xFF, 0x07,
  0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0xC1, 0xFE,
  0x01, 0xFE, 0x0F, 0xF8, 0x07, 0xF8, 0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x0F, 0xF8, 0x3F, 0xE3, 0xFE, 0x07, 0xFC, 0x7F, 0xC0, 0x7F, 0x9F,
  0xF0, 0x0F, 0xF3, 0xFE, 0x01, 0xFE, 0xFF, 0x80, 0x3F, 0xDF, 0xF0, 0x07,
  0xFB, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F,
  0xBF, 0xC0, 0x0F, 0xF7, 0xF8, 0x03, 0xFE, 0xFF, 0x00, 0x7F, 0xDF, 0xE0,
  0x1F, 0xF3, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0xFF, 0x8F, 0xF8, 0x3F, 0xF0,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xC3, 0xFC, 0x00,
  0x0F, 0xE3, 0xFF, 0x80, 0x07, 0xF3, 0xFF, 0xE0, 0x03, 0xFB, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x03,
  0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0xFF, 0x80, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x3F, 0xE0, 0x3F, 0xC0,
  0x1F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF0,
  0x07, 0xFC, 0x07, 0xF8, 0x03, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFE,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x7F,
  0xE0, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFB, 0xFF, 0xE0, 0x07,
  0xFC, 0xFF, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x07, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xFF, 0x87, 0xF0, 0x07, 0xFF, 0x1F, 0xC0, 0x3F, 0xFE,
  0xFF, 0x01, 0xFF, 0xFB, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xC1,
  0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF,
  0x00, 0x7F, 0x87, 0xFC, 0x01, 0xFE, 0x1F, 0xF0, 0x07, 0xF8, 0x7F, 0x80,
  0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x8F, 0xF8, 0x03, 0xFC, 0x3F, 0xE0, 0x0F,
  0xF0, 0xFF, 0x80, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xFC,
  0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x83, 0xFC, 0x03, 0xFE, 0x0F,
  0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x83, 0xFF, 0x03, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFE, 0x01, 0xFF, 0xF7, 0xF8, 0x03, 0xFF, 0x9F, 0xE0, 0x07, 0xFC, 0xFF,
  0x80, 0x03, 0x83, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x00, 0xFE, 0x1F, 0xC0, 0x7F, 0x1F, 0xE0, 0x3F, 0x9F, 0xF0, 0x1F,
  0xDF, 0xF8, 0x1F, 0xEF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x01, 0xFF, 0xE1, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFC, 0x1F, 0xF8, 0x7C, 0x0F, 0xF8, 0x06, 0x07, 0xFC, 0x01, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x10, 0x01, 0xFF, 0x0E, 0x00, 0xFF, 0x87, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0x1F, 0xFF, 0xF7, 0xFF, 0xFE,
  0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0x0F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F,
  0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF9, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x03, 0x00, 0x00, 0x07,
  0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xF0, 0x7F, 0x80, 0x7F, 0x81, 0xFE,
  0x01, 0xFE, 0x0F, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xE0, 0xFF, 0x00,
  0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x1F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F,
  0xC1, 0xFE, 0x01, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0,
  0xFF, 0x80, 0x7F, 0x83, 0xFC, 0x03, 0xFE, 0x0F, 0xF0, 0x0F, 0xF8, 0x3F,
  0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x07, 0xFC, 0x03, 0xFC, 0x1F, 0xE0,
  0x1F, 0xF0, 0x7F, 0x80, 0x7F, 0x81, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x0F,
  0xF8, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xBF, 0x80, 0x7F,
  0xFC, 0xFE, 0x00, 0xFF, 0xE3, 0xF8, 0x01, 0xFF, 0x0F, 0xE0, 0x00, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x01, 0xFF,
  0x7F, 0x80, 0x3F, 0xEF, 0xF0, 0x07, 0xF9, 0xFE, 0x01, 0xFF, 0x3F, 0xC0,
  0x3F, 0xC7, 0xF8, 0x0F, 0xF8, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x7F, 0xC3,
  0xFC, 0x0F, 0xF0, 0x7F, 0x83, 0xFE, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F,
  0xF0, 0x3F, 0xC3, 0xFC, 0x03, 0xF8, 0x7F, 0x80, 0x7F, 0x1F, 0xE0, 0x0F,
  0xE3, 0xFC, 0x01, 0xFC, 0xFF, 0x00, 0x3F, 0x9F, 0xE0, 0x07, 0xF3, 0xF8,
  0x00, 0xFE, 0xFF, 0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xEF,
  0xF0, 0x1F, 0xF8, 0x07, 0xFB, 0xFC, 0x07, 0xFE, 0x03, 0xFC, 0xFF, 0x03,
  0xFF, 0x80, 0xFF, 0x3F, 0xC0, 0xFF, 0xE0, 0x7F, 0xCF, 0xF0, 0x3F, 0xF8,
  0x1F, 0xE3, 0xFC, 0x1F, 0xFE, 0x07, 0xF8, 0xFF, 0x07, 0xFF, 0x83, 0xFC,
  0x3F, 0xC3, 0xFF, 0xE0, 0xFF, 0x0F, 0xF0, 0xFD, 0xF8, 0x7F, 0xC3, 0xFC,
  0x3F, 0x7E, 0x1F, 0xE0, 0xFF, 0x1F, 0xDF, 0x87, 0xF8, 0x3F, 0xC7, 0xE7,
  0xE3, 0xFC, 0x0F, 0xF3, 0xF9, 0xF8, 0xFF, 0x03, 0xFC, 0xFE, 0xFE, 0x3F,
  0x80, 0xFE, 0x3F, 0x3F, 0x9F, 0xE0, 0x3F, 0x9F, 0xCF, 0xE7, 0xF8, 0x0F,
  0xE7, 0xE3, 0xFB, 0xFC, 0x03, 0xF9, 0xF8, 0xFE, 0xFF, 0x00, 0xFE, 0xFE,
  0x3F, 0xBF, 0x80, 0x3F, 0xBF, 0x0F, 0xFF, 0xE0, 0x0F, 0xEF, 0xC3, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0xFD, 0xFC, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0x00,
  0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x0F,
  0xFE, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF8, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x7F,
  0x83, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x07, 0xFC, 0x7F, 0xC0, 0x00,
  0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x0F, 0xF7, 0xFC, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x3F, 0xC7, 0xF8, 0x00,
  0x1F, 0xF1, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xF0,
  0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x3F, 0xE0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x07, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x07, 0xF8, 0x07,
  0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x7F,
  0x80, 0xFF, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0x81, 0xFE, 0x00,
  0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x03, 0xFC, 0x3F,
  0xC0, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x3F,
  0xCF, 0xF8, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00,
  0x03, 0xFD, 0xFE, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x03, 0xFD, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x13,
  0xFF, 0x80, 0x03, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFE,
  0xC0, 0x0F, 0xFF, 0xC8, 0x00, 0x1F, 0xF8, 0x80, 0x00, 0x1C, 0x00,
};

const GFXglyph NotoSans_Condensed_BoldItalic64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 19, 47, 17, 0, -46 },
  { 113, 23, 17, 26, 6, -46 },
  { 162, 35, 46, 34, 0, -46 },
  { 364, 30, 53, 30, 1, -49 },
  { 563, 43, 47, 48, 3, -46 },
  { 816, 35, 47, 37, 1, -46 },
  { 1022, 11, 17, 16, 6, -46 },
  { 1046, 22, 56, 19, 1, -46 },
  { 1200, 22, 57, 19, -5, -47 },
  { 1357, 26, 28, 29, 5, -49 },
  { 1448, 27, 31, 32, 3, -38 },
  { 1553, 14, 17, 16, -3, -8 },
  { 1583, 17, 8, 19, 1, -21 },
  { 1600, 11, 11, 16, 0, -10 },
  { 1616, 33, 46, 25, -3, -46 },
  { 1806, 29, 47, 30, 1, -46 },
  { 1977, 22, 46, 30, 6, -46 },
  { 2104, 32, 46, 30, -2, -46 },
  { 2288, 31, 47, 30, -1, -46 },
  { 2471, 31, 46, 30, -1, -46 },
  { 2650, 31, 47, 30, 0, -46 },
  { 2833, 30, 47, 30, 2, -46 },
  { 3010, 31, 46, 30, 2, -46 },
  { 3189, 31, 47, 30, 0, -46 },
  { 3372, 29, 47, 30, 1, -46 },
  { 3543, 16, 36, 16, 0, -35 },
  { 3615, 20, 44, 16, -4, -35 },
  { 3725, 27, 32, 32, 3, -39 },
  { 3833, 27, 19, 32, 3, -32 },
  { 3898, 28, 32, 32, 3, -39 },
  { 4010, 24, 47, 24, 2, -46 },
  { 4151, 43, 51, 45, 2, -46 },
  { 4426, 33, 46, 33, -4, -46 },
  { 4616, 33, 46, 33, 0, -46 },
  { 4806, 32, 47, 31, 3, -46 },
  { 4994, 35, 46, 36, 0, -46 },
  { 5196, 31, 46, 28, 0, -46 },
  { 5375, 31, 46, 27, 0, -46 },
  { 5554, 35, 47, 37, 3, -46 },
  { 5760, 39, 46, 37, 0, -46 },
  { 5985, 29, 46, 22, -3, -46 },
  { 6152, 29, 60, 17, -10, -46 },
  { 6370, 38, 46, 32, 0, -46 },
  { 6589, 23, 46, 27, 0, -46 },
  { 6722, 50, 46, 48, 0, -46 },
  { 7010, 41, 46, 40, 0, -46 },
  { 7246, 35, 47, 38, 3, -46 },
  { 7452, 34, 46, 32, 0, -46 },
  { 7648, 35, 57, 38, 3, -46 },
  { 7898, 33, 46, 33, 0, -46 },
  { 8088, 32, 47, 29, -1, -46 },
  { 8276, 28, 46, 28, 5, -46 },
  { 8437, 35, 47, 36, 3, -46 },
  { 8643, 32, 46, 32, 6, -46 },
  { 8827, 49, 46, 49, 5, -46 },
  { 9109, 40, 46, 31, -4, -46 },
  { 9339, 30, 46, 30, 6, -46 },
  { 9512, 34, 46, 28, -2, -46 },
  { 9708, 26, 56, 19, -2, -46 },
  { 9890, 13, 46, 25, 7, -46 },
  { 9965, 26, 56, 19, -5, -46 },
  { 10147, 30, 28, 30, 0, -46 },
  { 10252, 23, 4, 22, -6, 6 },
  { 10264, 13, 10, 20, 9, -49 },
  { 10281, 30, 37, 32, 2, -36 },
  { 10420, 30, 50, 32, 0, -49 },
  { 10608, 25, 37, 26, 2, -36 },
  { 10724, 33, 50, 32, 2, -49 },
  { 10931, 27, 37, 30, 2, -36 },
  { 11056, 34, 64, 20, -7, -49 },
  { 11328, 33, 51, 32, -1, -36 },
  { 11539, 30, 49, 32, 0, -49 },
  { 11723, 19, 49, 16, 0, -49 },
  { 11840, 27, 64, 16, -8, -49 },
  { 12056, 33, 49, 30, 0, -49 },
  { 12259, 19, 49, 16, 0, -49 },
  { 12376, 46, 36, 47, 0, -36 },
  { 12583, 30, 36, 32, 0, -36 },
  { 12718, 27, 37, 31, 2, -36 },
  { 12843, 33, 51, 32, -3, -36 },
  { 13054, 30, 51, 32, 2, -36 },
  { 13246, 25, 36, 23, 0, -36 },
  { 13359, 25, 37, 25, 0, -36 },
  { 13475, 20, 43, 21, 3, -42 },
  { 13583, 30, 36, 32, 2, -35 },
  { 13718, 27, 35, 28, 4, -35 },
  { 13837, 42, 35, 43, 4, -35 },
  { 14021, 34, 35, 28, -3, -35 },
  { 14170, 36, 50, 28, -5, -35 },
  { 14395, 28, 35, 24, -2, -35 },
  { 14518, 25, 56, 22, 1, -46 },
  { 14693, 7, 64, 27, 10, -49 },
  { 14749, 25, 56, 22, -4, -46 },
  { 14924, 28, 11, 32, 3, -28 },
};

const GFXfont NotoSans_Condensed_BoldItalic64pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BoldItalic64pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BoldItalic64pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _NOTOSANS_CONDENSED_BOLDITALIC64PT7B_H_
