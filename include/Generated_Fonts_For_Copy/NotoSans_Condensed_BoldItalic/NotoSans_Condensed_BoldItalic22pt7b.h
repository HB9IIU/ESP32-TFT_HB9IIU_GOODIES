#ifndef _NOTOSANS_CONDENSED_BOLDITALIC22PT7B_H_
#define _NOTOSANS_CONDENSED_BOLDITALIC22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BoldItalic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BoldItalic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x38, 0x70, 0xE3, 0x87, 0x0E, 0x1C, 0x30, 0x61, 0xC0, 0x00,
  0x0E, 0x3C, 0x70, 0x77, 0x67, 0x66, 0xE6, 0xEE, 0xCC, 0x07, 0x60, 0x66,
  0x06, 0x60, 0x6C, 0x0C, 0xC3, 0xFF, 0x3F, 0xF1, 0x98, 0x19, 0x81, 0x98,
  0xFF, 0xEF, 0xFC, 0x33, 0x07, 0x60, 0x66, 0x06, 0x60, 0x01, 0x00, 0x20,
  0x3F, 0x8F, 0xE3, 0xFC, 0x74, 0x0E, 0x81, 0xE0, 0x1F, 0x01, 0xF0, 0x1E,
  0x03, 0xC8, 0xB9, 0xDF, 0x3F, 0xC3, 0xF0, 0x08, 0x02, 0x00, 0x1C, 0x18,
  0x7C, 0x71, 0x98, 0xC3, 0x33, 0x0E, 0x66, 0x19, 0xD8, 0x33, 0x76, 0x66,
  0xDE, 0xFB, 0x7E, 0xE6, 0xCC, 0x19, 0x98, 0x77, 0x70, 0xCC, 0xC3, 0x19,
  0x86, 0x3E, 0x18, 0x3C, 0x07, 0x80, 0x7E, 0x07, 0x30, 0x39, 0x81, 0xDC,
  0x0E, 0xE0, 0x7E, 0x03, 0xE1, 0x3E, 0x73, 0xBB, 0x9D, 0xF9, 0xC7, 0xCE,
  0x3C, 0x7B, 0xE1, 0xFF, 0x8F, 0xDC, 0x77, 0x66, 0xEC, 0x07, 0x06, 0x0E,
  0x1C, 0x18, 0x38, 0x38, 0x30, 0x70, 0x70, 0x60, 0x60, 0x60, 0xE0, 0xE0,
  0x60, 0x60, 0x60, 0x70, 0x0E, 0x06, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x06, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C, 0x38, 0x30, 0xF0, 0x0C,
  0x06, 0x37, 0x1F, 0x3F, 0xF9, 0xFD, 0xF1, 0xDC, 0x66, 0x02, 0x00, 0x0C,
  0x06, 0x03, 0x01, 0x8F, 0xFF, 0xFC, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00,
  0x3B, 0x9C, 0xEE, 0x60, 0x7F, 0xF0, 0xFF, 0xE0, 0x00, 0xE0, 0x1C, 0x07,
  0x00, 0xE0, 0x38, 0x06, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x70, 0x1C,
  0x03, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0x07, 0x83, 0xF1, 0xFC, 0xE7, 0x39,
  0xCE, 0x77, 0x1D, 0xC7, 0x71, 0xDC, 0x76, 0x3B, 0x8E, 0x67, 0x9D, 0xC7,
  0xE0, 0xF0, 0x07, 0x0E, 0x3E, 0x7E, 0xFE, 0x4E, 0x1C, 0x1C, 0x1C, 0x1C,
  0x18, 0x38, 0x38, 0x38, 0x38, 0x70, 0x07, 0xC1, 0xFC, 0x7F, 0x84, 0x70,
  0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xFF, 0x1F, 0xE7, 0xFC, 0x0F, 0x8F, 0xF1, 0xFC, 0x47, 0x01, 0xC0, 0x70,
  0x38, 0x7C, 0x1F, 0x01, 0xE0, 0x38, 0x0E, 0x03, 0xB3, 0xCF, 0xF3, 0xF0,
  0x01, 0xC0, 0x70, 0x3C, 0x1F, 0x0F, 0x83, 0x61, 0xB8, 0xEE, 0x33, 0x98,
  0xCF, 0xFF, 0xFF, 0xFF, 0x81, 0xC0, 0x60, 0x38, 0x0F, 0xE3, 0xF8, 0x7F,
  0x0C, 0x03, 0x80, 0x70, 0x0F, 0xC1, 0xFC, 0x3F, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x39, 0x9E, 0x3F, 0xC7, 0xE0, 0x07, 0xC3, 0xF1, 0xF8, 0xE0, 0x70,
  0x1C, 0x06, 0xF3, 0xFC, 0xF7, 0xB8, 0xEE, 0x3B, 0x9C, 0xE7, 0x3B, 0xCF,
  0xE1, 0xF0, 0x3F, 0xDF, 0xF7, 0xFC, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x38,
  0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x0F, 0x03, 0x80, 0x07, 0x83,
  0xF8, 0x77, 0x1C, 0x73, 0x8C, 0x73, 0x87, 0xE0, 0xF8, 0x3F, 0x0F, 0x71,
  0xCE, 0x71, 0xCE, 0x39, 0xE7, 0x1F, 0xC1, 0xF0, 0x0F, 0x87, 0xF3, 0xFC,
  0xE7, 0x31, 0xDC, 0x77, 0x1D, 0xCF, 0x7F, 0xCF, 0x60, 0x38, 0x0E, 0x07,
  0x23, 0x8F, 0xE3, 0xE0, 0x18, 0xF3, 0x80, 0x00, 0x00, 0x00, 0x03, 0xCF,
  0x38, 0x0C, 0x3C, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x71, 0xC3, 0x86,
  0x1C, 0x30, 0x00, 0x00, 0x81, 0xC3, 0xE7, 0xCF, 0x87, 0x81, 0xF0, 0x3F,
  0x07, 0x80, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0xC0,
  0x3C, 0x0F, 0xC0, 0x7C, 0x07, 0xC1, 0xF1, 0xF1, 0xF0, 0xF0, 0x30, 0x00,
  0x3E, 0x7F, 0x7F, 0x47, 0x07, 0x06, 0x1E, 0x3C, 0x38, 0x70, 0x70, 0x00,
  0x00, 0xE0, 0xE0, 0xE0, 0x01, 0xE0, 0x0F, 0xF0, 0x70, 0x71, 0xC0, 0x63,
  0x1C, 0xCC, 0xFD, 0xD9, 0x99, 0x66, 0x66, 0xCC, 0xCD, 0xB9, 0x9B, 0x67,
  0x36, 0xEE, 0xCC, 0xFF, 0x18, 0x8C, 0x30, 0x00, 0x30, 0x20, 0x3F, 0xC0,
  0x3E, 0x00, 0x01, 0xC0, 0x78, 0x0F, 0x83, 0xF0, 0x6E, 0x1D, 0xC3, 0xB8,
  0x67, 0x1C, 0xE3, 0x9C, 0xFF, 0x9F, 0xF7, 0x0E, 0xE1, 0xF8, 0x3F, 0x07,
  0x1F, 0x81, 0xFE, 0x1F, 0xE1, 0xCF, 0x18, 0xE3, 0x8E, 0x39, 0xE3, 0xF8,
  0x3F, 0x83, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x7C, 0xFF, 0x8F, 0xE0,
  0x07, 0xC1, 0xFC, 0x7F, 0x1E, 0x27, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xF6, 0x1F, 0xC1, 0xF8, 0x1F, 0x81,
  0xFE, 0x1F, 0xE1, 0xCF, 0x1C, 0x73, 0x87, 0x38, 0x73, 0x87, 0x38, 0x73,
  0x8F, 0x70, 0xE7, 0x1E, 0x71, 0xC7, 0xF8, 0xFF, 0x0F, 0xE0, 0x1F, 0xE3,
  0xF8, 0x7F, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xFC, 0x3F, 0x87, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xFE, 0x3F, 0xC7, 0xF0, 0x1F, 0xE3, 0xF8, 0x7F,
  0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xFC, 0x3F, 0x87, 0xE1, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0x03, 0xE0, 0xFF, 0x1F, 0xE3, 0xC2,
  0x78, 0x07, 0x00, 0x70, 0x0F, 0x3E, 0xE3, 0xEE, 0x7E, 0xE1, 0xCE, 0x1C,
  0xE1, 0xCF, 0xBC, 0x7F, 0x83, 0xF8, 0x1C, 0x38, 0xE1, 0xC7, 0x0E, 0x38,
  0x71, 0xC7, 0x1C, 0x38, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xC7, 0x1C, 0x38,
  0xE1, 0xC7, 0x0E, 0x38, 0xF3, 0x87, 0x1C, 0x38, 0x1F, 0xC7, 0xF0, 0x70,
  0x18, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x0E, 0x0F, 0xE3, 0xF8, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x70,
  0x1C, 0x0F, 0x0F, 0x83, 0xE0, 0xE0, 0x00, 0x1C, 0x38, 0xE3, 0x87, 0x3C,
  0x39, 0xC1, 0x9C, 0x1D, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1D,
  0xE0, 0xE7, 0x07, 0x38, 0x39, 0xC3, 0x8F, 0x1C, 0x38, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x38, 0x38, 0x38, 0x38, 0x30, 0x70, 0x70, 0x70, 0x7F, 0xFF,
  0xFF, 0x1E, 0x07, 0x8F, 0x07, 0xC7, 0x83, 0xE3, 0xC3, 0xE1, 0xE1, 0xF1,
  0xF8, 0xF8, 0xFC, 0xFC, 0x7E, 0x6E, 0x37, 0x76, 0x1B, 0xB7, 0x1D, 0xFB,
  0x8E, 0xF9, 0xC7, 0x7C, 0xC3, 0x3C, 0xE3, 0x9E, 0x71, 0xC6, 0x38, 0x1E,
  0x1C, 0x78, 0x71, 0xE1, 0xC7, 0x86, 0x1F, 0x18, 0xFC, 0xE3, 0xF3, 0x8E,
  0xCE, 0x33, 0xB0, 0xCE, 0xC7, 0x3F, 0x1C, 0x7C, 0x71, 0xF1, 0x87, 0x8E,
  0x1E, 0x38, 0x78, 0x07, 0xC0, 0xFE, 0x1F, 0xE3, 0x8F, 0x78, 0x77, 0x07,
  0x70, 0x7F, 0x07, 0xE0, 0xFE, 0x0E, 0xE0, 0xEE, 0x1E, 0xE1, 0xCF, 0x7C,
  0x7F, 0x83, 0xE0, 0x1F, 0x81, 0xFE, 0x1F, 0xE1, 0xCF, 0x1C, 0x73, 0x87,
  0x38, 0xE3, 0x9E, 0x3F, 0xC3, 0xF8, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0xE0, 0x0E, 0x00, 0x07, 0xC0, 0xFE, 0x1F, 0xE3, 0x8F, 0x78, 0x77, 0x07,
  0x70, 0x7F, 0x07, 0xE0, 0xFE, 0x0E, 0xE0, 0xEE, 0x1E, 0xE1, 0xCF, 0x7C,
  0x7F, 0x83, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x78, 0x1F, 0x83, 0xF8,
  0x7F, 0x8E, 0x71, 0x8E, 0x71, 0xCE, 0x39, 0xDE, 0x3F, 0x87, 0xE1, 0xDC,
  0x39, 0xC7, 0x38, 0xE7, 0x38, 0xF7, 0x0E, 0x07, 0x83, 0xFC, 0xFF, 0x1C,
  0x23, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x1F, 0x00, 0xE0, 0x1E, 0x01, 0xC8,
  0x79, 0xFE, 0x3F, 0xC7, 0xE0, 0xFF, 0xFF, 0xFF, 0xE3, 0x83, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0x83, 0x81, 0xC0, 0x38,
  0x73, 0x87, 0x38, 0x73, 0x8E, 0x78, 0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0x71,
  0xCE, 0x1C, 0xE1, 0xCE, 0x1C, 0xE3, 0x8F, 0x78, 0x7F, 0x07, 0xE0, 0xE0,
  0xFC, 0x3B, 0x87, 0x70, 0xEE, 0x39, 0xC7, 0x39, 0xC7, 0x38, 0xEE, 0x1D,
  0xC3, 0xB0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0x80, 0xE1, 0xC3, 0xF0,
  0xE3, 0xB8, 0xF1, 0xDC, 0x71, 0xCE, 0x78, 0xE7, 0x3C, 0x73, 0xBE, 0x71,
  0xDF, 0x38, 0xED, 0xB8, 0x7E, 0xDC, 0x36, 0x6E, 0x1F, 0x3E, 0x0F, 0x1F,
  0x07, 0x8F, 0x03, 0xC7, 0x81, 0xC3, 0x80, 0x1C, 0x38, 0x71, 0xC3, 0x9C,
  0x1D, 0xC0, 0xEE, 0x07, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x07,
  0xE0, 0x3F, 0x03, 0x9C, 0x38, 0xE1, 0xC7, 0x1C, 0x38, 0xE1, 0xF8, 0xFE,
  0x39, 0x9C, 0x67, 0x1F, 0x87, 0xE1, 0xF0, 0x78, 0x0E, 0x03, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x03, 0x80, 0x0F, 0xF1, 0xFF, 0x1F, 0xE0, 0x1E, 0x01,
  0xC0, 0x38, 0x07, 0x80, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x38,
  0x07, 0xF8, 0xFF, 0x8F, 0xF8, 0x0F, 0x87, 0xC3, 0x81, 0x81, 0xC0, 0xE0,
  0x70, 0x30, 0x18, 0x1C, 0x0E, 0x07, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x70,
  0x3E, 0x3E, 0x1F, 0x00, 0xE7, 0x18, 0xC6, 0x39, 0xCE, 0x71, 0x8C, 0x63,
  0x1C, 0xE7, 0x0F, 0x87, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x1C, 0x0E, 0x07,
  0x03, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x38, 0x1C, 0x3E, 0x1E, 0x1F,
  0x00, 0x03, 0x01, 0xC0, 0x70, 0x3E, 0x1F, 0x86, 0x63, 0x98, 0xC7, 0x61,
  0xF8, 0x30, 0xFF, 0xF7, 0x73, 0x1D, 0xCF, 0xF7, 0xBD, 0xCE, 0xE3, 0xB8,
  0xEE, 0x3B, 0x9C, 0xE7, 0x3B, 0xCF, 0xF1, 0xDC, 0x0C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x0E, 0xE3, 0xFC, 0xF7, 0x39, 0xCC, 0x77, 0x1D, 0xC7, 0x71,
  0xDC, 0xE7, 0x3B, 0xFC, 0xDE, 0x00, 0x1F, 0x3F, 0x79, 0x70, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE4, 0xFC, 0x7C, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE0,
  0x1C, 0x3B, 0x8F, 0xF3, 0x9C, 0x73, 0x9C, 0x73, 0x8E, 0x71, 0xCE, 0x31,
  0xCE, 0x3B, 0xC7, 0xF8, 0x77, 0x00, 0x1F, 0x1F, 0xDC, 0xEC, 0x7E, 0x77,
  0xFB, 0xF1, 0x80, 0xC0, 0x71, 0x3F, 0x8F, 0xC0, 0x01, 0xE0, 0x7C, 0x0F,
  0x03, 0x80, 0x70, 0x1F, 0x87, 0xE0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x06,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x0F,
  0x01, 0xC0, 0x00, 0x0E, 0xE3, 0xFC, 0xE7, 0x9C, 0xE7, 0x1C, 0xE3, 0x9C,
  0x73, 0x9C, 0x73, 0x8E, 0xF1, 0xFE, 0x3D, 0xC0, 0x70, 0x0E, 0x23, 0xC7,
  0xF0, 0xFC, 0x00, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0xF3, 0xFC,
  0xF7, 0x39, 0xCE, 0x77, 0x1D, 0xC7, 0x71, 0xDC, 0xE6, 0x3B, 0x8E, 0xE3,
  0x80, 0x0C, 0x71, 0xC0, 0x04, 0xE3, 0x8E, 0x38, 0xE7, 0x1C, 0x71, 0xC6,
  0x38, 0xE0, 0x01, 0x81, 0xC0, 0xE0, 0x00, 0x00, 0x3C, 0x1C, 0x0E, 0x07,
  0x03, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x1C, 0x0E, 0x07, 0x07,
  0x0F, 0x87, 0x80, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x71, 0xCE,
  0x71, 0xDC, 0x3F, 0x06, 0xE1, 0xF8, 0x3F, 0x07, 0x70, 0xEE, 0x19, 0xC7,
  0x1C, 0xE3, 0x80, 0x0E, 0x38, 0x70, 0xE1, 0xC7, 0x0E, 0x1C, 0x38, 0x71,
  0xC3, 0x87, 0x0E, 0x18, 0x70, 0xE0, 0x3B, 0xDE, 0x3F, 0xFF, 0x3D, 0xE7,
  0x39, 0xC7, 0x39, 0xC6, 0x71, 0xCE, 0x71, 0xCE, 0x73, 0x8E, 0x73, 0x8E,
  0x63, 0x8C, 0xE3, 0x9C, 0xE3, 0x1C, 0x3B, 0xCF, 0xF3, 0xDC, 0xE7, 0x39,
  0xDC, 0x77, 0x1D, 0xC7, 0x73, 0x98, 0xEE, 0x3B, 0x8E, 0x1F, 0x1F, 0xDC,
  0xFE, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE7, 0x77, 0xBF, 0x8F, 0x80, 0x1D,
  0xE3, 0xFC, 0x7B, 0x8E, 0x71, 0x8E, 0x71, 0xCE, 0x39, 0xC7, 0x39, 0xC7,
  0x39, 0xFE, 0x3B, 0x87, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x00, 0x1F,
  0xCF, 0xF7, 0x39, 0xCE, 0xE3, 0xB8, 0xEE, 0x3B, 0x8C, 0xE7, 0x3B, 0xCF,
  0xF3, 0xDC, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1E, 0x00, 0x3B, 0x9F, 0x8F,
  0xC7, 0x03, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x1C, 0x00, 0x1F,
  0x9F, 0x9E, 0x4E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x0E, 0x47, 0x3F, 0x9F,
  0x80, 0x18, 0x30, 0xE3, 0xFF, 0xEE, 0x1C, 0x38, 0x61, 0xC3, 0x87, 0x0E,
  0x1F, 0x3E, 0x00, 0x71, 0xDC, 0x77, 0x19, 0xCE, 0x63, 0xB8, 0xEE, 0x3B,
  0x9C, 0xE7, 0x3B, 0xCF, 0xF3, 0xD8, 0xE1, 0xF8, 0xEE, 0x3B, 0x9C, 0x67,
  0x1B, 0x86, 0xE1, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xC0, 0xE3, 0x8F, 0xCF,
  0x3B, 0x9E, 0x77, 0x3C, 0xCE, 0xDB, 0x9D, 0xB6, 0x3F, 0x7C, 0x7C, 0xF8,
  0xF9, 0xE1, 0xE3, 0xC3, 0xC7, 0x07, 0x9E, 0x00, 0x1C, 0xF1, 0xCE, 0x1D,
  0xC0, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x01, 0xF0, 0x3B, 0x03, 0xB8, 0x73,
  0x8E, 0x38, 0x1C, 0x38, 0xE3, 0x83, 0x1C, 0x19, 0xC0, 0xCE, 0x06, 0xE0,
  0x37, 0x01, 0xB0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0E,
  0x00, 0x70, 0x0F, 0x00, 0xF0, 0x00, 0x1F, 0xC7, 0xF0, 0x38, 0x1C, 0x07,
  0x03, 0x81, 0xC0, 0x70, 0x38, 0x1C, 0x07, 0xF3, 0xFC, 0x01, 0x83, 0xC3,
  0xE1, 0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x78, 0x78, 0x3C, 0x07, 0x03, 0x81,
  0xC0, 0xC0, 0xE0, 0x70, 0x3C, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x18, 0x1E, 0x1E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x07, 0x0F, 0x1C, 0x18, 0x38, 0x38, 0x38, 0x38, 0xF0, 0xF0, 0x20,
  0x7F, 0x3F, 0xFE, 0x1E,
};

const GFXglyph NotoSans_Condensed_BoldItalic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 7, 16, 6, 0, -16 },
  { 15, 8, 6, 9, 2, -16 },
  { 21, 12, 16, 12, 0, -16 },
  { 45, 11, 18, 10, 0, -17 },
  { 70, 15, 16, 17, 1, -16 },
  { 100, 13, 16, 13, 0, -16 },
  { 126, 4, 6, 5, 2, -16 },
  { 129, 8, 19, 6, 0, -16 },
  { 148, 8, 19, 6, -2, -16 },
  { 167, 9, 10, 10, 2, -17 },
  { 179, 9, 11, 11, 1, -13 },
  { 192, 5, 6, 6, -1, -3 },
  { 196, 6, 2, 7, 0, -7 },
  { 198, 4, 3, 6, 0, -3 },
  { 200, 11, 16, 9, -1, -16 },
  { 222, 10, 16, 10, 0, -16 },
  { 242, 8, 16, 10, 2, -16 },
  { 258, 11, 16, 10, -1, -16 },
  { 280, 10, 16, 10, 0, -16 },
  { 300, 10, 16, 10, 0, -16 },
  { 320, 11, 16, 10, 0, -16 },
  { 342, 10, 16, 10, 1, -16 },
  { 362, 10, 16, 10, 1, -16 },
  { 382, 11, 16, 10, 0, -16 },
  { 404, 10, 16, 10, 0, -16 },
  { 424, 6, 12, 6, 0, -12 },
  { 433, 7, 15, 6, -1, -12 },
  { 447, 9, 10, 11, 1, -13 },
  { 459, 9, 7, 11, 1, -11 },
  { 467, 10, 10, 11, 1, -13 },
  { 480, 8, 16, 8, 1, -16 },
  { 496, 15, 18, 16, 1, -16 },
  { 530, 11, 16, 11, -1, -16 },
  { 552, 12, 16, 11, 0, -16 },
  { 576, 11, 16, 11, 1, -16 },
  { 598, 12, 16, 12, 0, -16 },
  { 622, 11, 16, 10, 0, -16 },
  { 644, 11, 16, 9, 0, -16 },
  { 666, 12, 16, 13, 1, -16 },
  { 690, 13, 16, 13, 0, -16 },
  { 716, 10, 16, 7, -1, -16 },
  { 736, 10, 21, 6, -3, -16 },
  { 763, 13, 16, 11, 0, -16 },
  { 789, 8, 16, 9, 0, -16 },
  { 805, 17, 16, 17, 0, -16 },
  { 839, 14, 16, 14, 0, -16 },
  { 867, 12, 16, 13, 1, -16 },
  { 891, 12, 16, 11, 0, -16 },
  { 915, 12, 20, 13, 1, -16 },
  { 945, 11, 16, 11, 0, -16 },
  { 967, 11, 16, 10, 0, -16 },
  { 989, 9, 16, 10, 2, -16 },
  { 1007, 12, 16, 13, 1, -16 },
  { 1031, 11, 16, 11, 2, -16 },
  { 1053, 17, 16, 17, 2, -16 },
  { 1087, 13, 16, 11, -1, -16 },
  { 1113, 10, 16, 10, 2, -16 },
  { 1133, 12, 16, 10, -1, -16 },
  { 1157, 9, 20, 7, -1, -16 },
  { 1180, 5, 16, 9, 2, -16 },
  { 1190, 9, 20, 7, -2, -16 },
  { 1213, 10, 10, 10, 0, -16 },
  { 1226, 8, 1, 8, -2, 2 },
  { 1227, 4, 4, 7, 3, -17 },
  { 1229, 10, 12, 11, 1, -12 },
  { 1244, 10, 17, 11, 0, -17 },
  { 1266, 8, 12, 9, 1, -12 },
  { 1278, 11, 17, 11, 1, -17 },
  { 1302, 9, 12, 10, 1, -12 },
  { 1316, 11, 22, 7, -2, -17 },
  { 1347, 11, 17, 11, 0, -12 },
  { 1371, 10, 17, 11, 0, -17 },
  { 1393, 6, 17, 6, 0, -17 },
  { 1406, 9, 22, 6, -3, -17 },
  { 1431, 11, 17, 10, 0, -17 },
  { 1455, 7, 17, 5, 0, -17 },
  { 1470, 16, 12, 16, 0, -12 },
  { 1494, 10, 12, 11, 0, -12 },
  { 1509, 9, 12, 11, 1, -12 },
  { 1523, 11, 17, 11, -1, -12 },
  { 1547, 10, 17, 11, 1, -12 },
  { 1569, 9, 12, 8, 0, -12 },
  { 1583, 9, 12, 9, 0, -12 },
  { 1597, 7, 15, 7, 1, -15 },
  { 1611, 10, 12, 11, 1, -12 },
  { 1626, 10, 12, 10, 1, -12 },
  { 1641, 15, 12, 15, 1, -12 },
  { 1664, 12, 12, 10, -1, -12 },
  { 1682, 13, 17, 10, -2, -12 },
  { 1710, 10, 12, 8, -1, -12 },
  { 1725, 9, 19, 8, 0, -16 },
  { 1747, 3, 22, 9, 3, -17 },
  { 1756, 8, 19, 8, -1, -16 },
  { 1775, 10, 4, 11, 1, -10 },
};

const GFXfont NotoSans_Condensed_BoldItalic22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BoldItalic22pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BoldItalic22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_CONDENSED_BOLDITALIC22PT7B_H_
