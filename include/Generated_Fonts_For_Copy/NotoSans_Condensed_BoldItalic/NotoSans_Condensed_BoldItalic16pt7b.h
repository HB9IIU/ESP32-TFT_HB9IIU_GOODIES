#ifndef _NOTOSANS_CONDENSED_BOLDITALIC16PT7B_H_
#define _NOTOSANS_CONDENSED_BOLDITALIC16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BoldItalic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BoldItalic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0x8C, 0x66, 0x31, 0x80, 0x07, 0x30, 0xDE, 0xE5, 0x20, 0x0D,
  0x0D, 0x86, 0x8F, 0xF1, 0x61, 0xB3, 0xFD, 0xFE, 0x6C, 0x34, 0x16, 0x00,
  0x04, 0x1F, 0x3E, 0x3A, 0x78, 0x38, 0x1C, 0x1E, 0x16, 0xFE, 0xFC, 0x20,
  0x20, 0x20, 0x0F, 0x33, 0x64, 0x6D, 0x8D, 0x61, 0x6B, 0xBF, 0x52, 0x5B,
  0x1A, 0x46, 0x48, 0x8B, 0x31, 0xC0, 0x04, 0x0F, 0x0C, 0xC6, 0xC3, 0x60,
  0xE0, 0xE6, 0xDE, 0xCF, 0x63, 0x3F, 0x8F, 0x60, 0xFA, 0x1C, 0x63, 0x0C,
  0x61, 0x86, 0x30, 0xC3, 0x0C, 0x30, 0x61, 0x80, 0x18, 0xC6, 0x31, 0x8C,
  0x63, 0x18, 0x8C, 0x66, 0x23, 0x00, 0x18, 0xB3, 0xF9, 0xF7, 0x8D, 0x82,
  0x00, 0x30, 0x60, 0xC7, 0xFF, 0xE6, 0x0C, 0x18, 0x76, 0x6C, 0xFF, 0x80,
  0xF8, 0x01, 0x81, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x18,
  0x18, 0x1C, 0x00, 0x0C, 0x3C, 0xDB, 0xB6, 0x6C, 0xD9, 0xF3, 0xCF, 0x99,
  0xF3, 0xC0, 0x1C, 0xFF, 0x96, 0x18, 0x63, 0x8C, 0x30, 0xC7, 0x00, 0x06,
  0x1F, 0x3B, 0x13, 0x03, 0x07, 0x06, 0x0C, 0x18, 0x30, 0x7E, 0xFE, 0x0C,
  0x3E, 0x27, 0x06, 0x06, 0x3C, 0x3C, 0x0E, 0x0E, 0x0C, 0xFC, 0xF8, 0x07,
  0x0E, 0x1E, 0x16, 0x3C, 0x6C, 0xCC, 0xFE, 0xFE, 0x18, 0x18, 0x3F, 0x3E,
  0x30, 0x30, 0x7C, 0x7E, 0x0E, 0x0E, 0x8C, 0xFC, 0xF8, 0x07, 0x1F, 0x38,
  0x30, 0x60, 0x7E, 0x76, 0x66, 0xE6, 0x6E, 0x7C, 0x78, 0x3F, 0x7F, 0x06,
  0x06, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0x70, 0xE0, 0x0C, 0x3E, 0x37, 0x33,
  0x36, 0x3C, 0x3C, 0x6E, 0xC6, 0xC6, 0xFC, 0x78, 0x0C, 0x7C, 0xDB, 0x36,
  0x6C, 0xDF, 0x9B, 0x0C, 0x1B, 0xE7, 0x80, 0x37, 0x20, 0x00, 0x0E, 0xC0,
  0x19, 0xC4, 0x00, 0x00, 0x0E, 0x63, 0x30, 0x02, 0x1C, 0xF7, 0x8E, 0x0F,
  0x07, 0x83, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x81, 0x83, 0xC0, 0xE0, 0xEF,
  0x38, 0x40, 0x33, 0xE5, 0xC3, 0x18, 0xC6, 0x10, 0x80, 0x0C, 0x30, 0x01,
  0x01, 0xF8, 0x61, 0x99, 0x16, 0x7A, 0xD2, 0x56, 0x4A, 0xDB, 0xDB, 0x4B,
  0xB9, 0x00, 0x30, 0x83, 0xF0, 0x07, 0x0F, 0x0F, 0x1B, 0x1B, 0x1B, 0x3F,
  0x3F, 0x63, 0x63, 0xE3, 0x3F, 0x33, 0x33, 0x33, 0x7E, 0x7E, 0x66, 0x66,
  0x66, 0xFE, 0xFC, 0x0C, 0x3F, 0x72, 0x60, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xFC, 0x7C, 0x3F, 0x1F, 0x8C, 0xE6, 0x77, 0x3B, 0x1D, 0x8C, 0xC6,
  0x66, 0x7F, 0x3E, 0x00, 0x3F, 0x30, 0x30, 0x30, 0x7E, 0x7C, 0x60, 0x60,
  0x60, 0xFC, 0xF8, 0x3F, 0x30, 0x30, 0x30, 0x72, 0x7C, 0x60, 0x60, 0x60,
  0xE0, 0xC0, 0x06, 0x3F, 0x7B, 0x60, 0xE0, 0xC0, 0xCF, 0xC6, 0xC6, 0xC6,
  0xFE, 0x7C, 0x39, 0xCC, 0x63, 0x18, 0xC6, 0x7F, 0x9F, 0xC6, 0x31, 0x8C,
  0x63, 0x39, 0xCC, 0x60, 0x1E, 0x18, 0x70, 0xC1, 0x83, 0x06, 0x1C, 0x30,
  0x63, 0xE0, 0x0E, 0x18, 0x30, 0x60, 0xC3, 0x86, 0x0C, 0x18, 0x70, 0xC1,
  0x8F, 0x1C, 0x00, 0x39, 0xCC, 0xC3, 0x60, 0xF8, 0x7C, 0x1F, 0x07, 0xC1,
  0xB0, 0x6E, 0x39, 0x8C, 0x60, 0x38, 0xC3, 0x0C, 0x71, 0x86, 0x18, 0x63,
  0xFF, 0xC0, 0x38, 0x73, 0x87, 0x38, 0xF3, 0x8B, 0x6D, 0xE6, 0xD6, 0x6F,
  0x66, 0xF6, 0x6E, 0xEC, 0xEC, 0xCC, 0xC0, 0x38, 0xCE, 0x33, 0xCC, 0xF6,
  0x6D, 0x9B, 0x66, 0x59, 0x9E, 0x67, 0x31, 0xCC, 0x70, 0x0C, 0x3F, 0x73,
  0x63, 0xE3, 0xC3, 0xC3, 0xC3, 0xC7, 0xC6, 0xFC, 0x78, 0x3F, 0x1B, 0x8C,
  0xE6, 0x67, 0x33, 0xF1, 0xF0, 0xC0, 0x60, 0x70, 0x30, 0x00, 0x0C, 0x3F,
  0x77, 0x63, 0xE3, 0xC3, 0xC3, 0xC3, 0xC7, 0xC6, 0xFC, 0x78, 0x18, 0x1C,
  0x0C, 0x3F, 0x37, 0x33, 0x33, 0x77, 0x7E, 0x7C, 0x6C, 0x6E, 0xE6, 0xC6,
  0x0C, 0x3F, 0x3A, 0x70, 0x70, 0x38, 0x3C, 0x0C, 0x0C, 0x8C, 0xFC, 0xF8,
  0xFF, 0xFC, 0xC1, 0x83, 0x06, 0x1C, 0x30, 0x60, 0xC3, 0x80, 0x73, 0xB1,
  0x98, 0xCC, 0x6E, 0x76, 0x33, 0x19, 0x8C, 0xCE, 0x7E, 0x1E, 0x00, 0xE3,
  0x67, 0x66, 0x66, 0x6C, 0x6C, 0x78, 0x78, 0x70, 0x70, 0x60, 0xC6, 0x3E,
  0x31, 0xB3, 0x99, 0x9C, 0xCC, 0xAE, 0x6D, 0x63, 0x6B, 0x1E, 0x70, 0xF3,
  0x87, 0x1C, 0x39, 0xC0, 0x19, 0xC6, 0x61, 0xB0, 0x3C, 0x0E, 0x03, 0x81,
  0xE0, 0xF8, 0x36, 0x19, 0x8E, 0x70, 0xE7, 0x66, 0x6C, 0x7C, 0x78, 0x70,
  0x30, 0x70, 0x60, 0x60, 0x60, 0x1F, 0x81, 0x81, 0xC0, 0xC0, 0xC0, 0xE0,
  0x60, 0x60, 0x70, 0x3F, 0x3F, 0x80, 0x1E, 0x30, 0x60, 0xC3, 0x06, 0x0C,
  0x18, 0x20, 0xC1, 0x83, 0x07, 0x1E, 0x00, 0x9B, 0x6D, 0xB2, 0x6D, 0xB0,
  0x1C, 0xB0, 0xC2, 0x18, 0x61, 0x86, 0x30, 0xC3, 0x0C, 0xF3, 0x80, 0x0C,
  0x38, 0x51, 0xB6, 0x6C, 0xF0, 0x80, 0xF8, 0xEC, 0x1B, 0x3F, 0x77, 0x66,
  0x66, 0xE6, 0xEE, 0x7C, 0x7C, 0x38, 0x30, 0x30, 0x3E, 0x3E, 0x77, 0x67,
  0x66, 0x66, 0x66, 0xFC, 0xF8, 0x1E, 0x79, 0xC3, 0x06, 0x1C, 0x38, 0x3C,
  0x78, 0x03, 0x81, 0x80, 0xC3, 0x63, 0xF3, 0xB9, 0x98, 0xCC, 0xE6, 0x73,
  0x1F, 0x0E, 0x80, 0x1C, 0x7D, 0x9B, 0x37, 0xDC, 0x38, 0x36, 0x7C, 0x07,
  0x83, 0x83, 0x01, 0xE1, 0xE0, 0x60, 0x70, 0x30, 0x18, 0x0C, 0x06, 0x06,
  0x03, 0x01, 0x83, 0xC1, 0xC0, 0x1B, 0x3F, 0x77, 0x66, 0x66, 0xE6, 0xEE,
  0x7C, 0x7C, 0x0C, 0x9C, 0xF8, 0xF0, 0x38, 0x30, 0x30, 0x3E, 0x3E, 0x77,
  0x66, 0x66, 0x66, 0x66, 0xCE, 0xCC, 0x39, 0x80, 0x63, 0x39, 0x8C, 0x63,
  0x31, 0x80, 0x0E, 0x18, 0x00, 0x60, 0xC3, 0x86, 0x0C, 0x18, 0x30, 0xC1,
  0x83, 0x06, 0x38, 0x70, 0x38, 0x30, 0x30, 0x33, 0x36, 0x6C, 0x7C, 0x78,
  0x7C, 0x6C, 0xCC, 0xCE, 0x39, 0x8C, 0x63, 0x39, 0x8C, 0x63, 0x31, 0x80,
  0x2E, 0xE7, 0xFD, 0xDD, 0xB3, 0x36, 0x66, 0xCC, 0xD9, 0x9E, 0x66, 0xCC,
  0xC0, 0x2E, 0x2E, 0x77, 0x66, 0x66, 0x66, 0x66, 0xCE, 0xCC, 0x1C, 0x7D,
  0xDB, 0x36, 0x7C, 0xFB, 0xBE, 0x78, 0x17, 0x0F, 0x8E, 0xE6, 0x73, 0x31,
  0x98, 0xCC, 0xFC, 0x6E, 0x30, 0x18, 0x1C, 0x0C, 0x00, 0x1B, 0x3F, 0x77,
  0x66, 0x66, 0xE6, 0xE6, 0x7C, 0x7C, 0x0C, 0x0C, 0x0C, 0x18, 0x3C, 0xB7,
  0x18, 0x61, 0x86, 0x30, 0xC0, 0x3D, 0xF6, 0x1C, 0x38, 0x61, 0xBE, 0xF0,
  0x21, 0x1F, 0xE6, 0x63, 0x18, 0xC7, 0x38, 0x66, 0xCF, 0x36, 0x6C, 0xD9,
  0xB7, 0x7C, 0xF8, 0xC7, 0x9B, 0x36, 0xCD, 0x9E, 0x3C, 0x70, 0xE0, 0xCC,
  0xF3, 0x3D, 0xCF, 0x56, 0xF5, 0xBD, 0xCE, 0x73, 0x98, 0xCE, 0x00, 0x33,
  0x9D, 0x87, 0x83, 0xC1, 0xC0, 0xE0, 0xF0, 0xCC, 0xE6, 0x00, 0x31, 0x99,
  0x8C, 0xC6, 0xC3, 0x61, 0xE0, 0xF0, 0x30, 0x18, 0x18, 0x0C, 0x1C, 0x0C,
  0x00, 0x3E, 0x7C, 0x38, 0x61, 0x86, 0x0C, 0x3E, 0xFC, 0x1E, 0x30, 0x60,
  0xC3, 0x0E, 0x30, 0x30, 0x60, 0xC1, 0x83, 0x07, 0x02, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x18, 0xF1, 0x86, 0x18, 0x60, 0xC7, 0x30, 0xC3, 0x1C, 0xE2,
  0x00, 0xE3, 0xFE, 0x30,
};

const GFXglyph NotoSans_Condensed_BoldItalic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 5, 11, 4, 0, -11 },
  { 8, 5, 4, 7, 2, -11 },
  { 11, 9, 11, 8, 0, -11 },
  { 24, 8, 13, 7, 0, -12 },
  { 37, 11, 12, 12, 1, -12 },
  { 54, 9, 12, 9, 0, -12 },
  { 68, 2, 4, 4, 2, -11 },
  { 69, 6, 14, 5, 0, -11 },
  { 80, 5, 15, 5, -1, -12 },
  { 90, 7, 7, 7, 1, -12 },
  { 97, 7, 8, 8, 1, -10 },
  { 104, 4, 4, 4, -1, -2 },
  { 106, 5, 2, 5, 0, -5 },
  { 108, 3, 2, 4, 0, -2 },
  { 109, 9, 12, 6, -1, -12 },
  { 123, 7, 12, 7, 0, -12 },
  { 134, 6, 11, 8, 1, -11 },
  { 143, 8, 12, 7, -1, -12 },
  { 155, 8, 12, 7, 0, -12 },
  { 167, 8, 11, 8, 0, -11 },
  { 178, 8, 11, 7, 0, -11 },
  { 189, 8, 12, 7, 0, -12 },
  { 201, 8, 11, 7, 0, -11 },
  { 212, 8, 12, 7, 0, -12 },
  { 224, 7, 12, 7, 0, -12 },
  { 235, 4, 9, 4, 0, -9 },
  { 240, 5, 11, 4, -1, -9 },
  { 247, 7, 8, 8, 1, -10 },
  { 254, 7, 5, 8, 1, -8 },
  { 259, 7, 8, 8, 1, -10 },
  { 266, 6, 12, 6, 1, -12 },
  { 275, 11, 13, 11, 0, -12 },
  { 293, 8, 11, 8, -1, -11 },
  { 304, 8, 11, 8, 0, -11 },
  { 315, 8, 12, 8, 1, -12 },
  { 327, 9, 11, 9, 0, -11 },
  { 340, 8, 11, 7, 0, -11 },
  { 351, 8, 11, 7, 0, -11 },
  { 362, 8, 12, 9, 1, -12 },
  { 374, 10, 11, 9, 0, -11 },
  { 388, 7, 11, 5, -1, -11 },
  { 398, 7, 14, 4, -2, -11 },
  { 411, 10, 11, 8, 0, -11 },
  { 425, 6, 11, 7, 0, -11 },
  { 434, 12, 11, 12, 0, -11 },
  { 451, 10, 11, 10, 0, -11 },
  { 465, 8, 12, 10, 1, -12 },
  { 477, 9, 11, 8, 0, -11 },
  { 490, 8, 15, 10, 1, -12 },
  { 505, 8, 11, 8, 0, -11 },
  { 516, 8, 12, 7, 0, -12 },
  { 528, 7, 11, 7, 1, -11 },
  { 538, 9, 11, 9, 1, -11 },
  { 551, 8, 11, 8, 1, -11 },
  { 562, 13, 11, 12, 1, -11 },
  { 580, 10, 11, 8, -1, -11 },
  { 594, 8, 11, 7, 1, -11 },
  { 605, 9, 11, 7, -1, -11 },
  { 618, 7, 14, 5, -1, -11 },
  { 631, 3, 12, 6, 2, -12 },
  { 636, 6, 14, 5, -1, -11 },
  { 647, 7, 7, 8, 0, -11 },
  { 654, 5, 1, 6, -1, 1 },
  { 655, 3, 2, 5, 2, -12 },
  { 656, 8, 9, 8, 0, -9 },
  { 665, 8, 12, 8, 0, -12 },
  { 677, 7, 9, 6, 0, -9 },
  { 685, 9, 12, 8, 0, -12 },
  { 699, 7, 9, 7, 0, -9 },
  { 707, 9, 16, 5, -2, -12 },
  { 725, 8, 13, 8, 0, -9 },
  { 738, 8, 12, 8, 0, -12 },
  { 750, 5, 12, 4, 0, -12 },
  { 758, 7, 16, 4, -2, -12 },
  { 772, 8, 12, 7, 0, -12 },
  { 784, 5, 12, 4, 0, -12 },
  { 792, 11, 9, 12, 0, -9 },
  { 805, 8, 9, 8, 0, -9 },
  { 814, 7, 9, 8, 0, -9 },
  { 822, 9, 13, 8, -1, -9 },
  { 837, 8, 13, 8, 0, -9 },
  { 850, 6, 9, 6, 0, -9 },
  { 857, 6, 9, 6, 0, -9 },
  { 864, 5, 11, 5, 1, -11 },
  { 871, 7, 9, 8, 1, -9 },
  { 879, 7, 9, 7, 1, -9 },
  { 887, 10, 9, 11, 1, -9 },
  { 899, 9, 9, 7, -1, -9 },
  { 910, 9, 13, 7, -1, -9 },
  { 925, 7, 9, 6, -1, -9 },
  { 933, 7, 14, 6, 0, -11 },
  { 946, 2, 16, 7, 2, -12 },
  { 950, 6, 14, 5, -1, -11 },
  { 961, 7, 3, 8, 1, -7 },
};

const GFXfont NotoSans_Condensed_BoldItalic16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BoldItalic16pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BoldItalic16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_CONDENSED_BOLDITALIC16PT7B_H_
