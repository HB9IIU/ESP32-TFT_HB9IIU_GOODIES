#ifndef _NOTOSANS_CONDENSED_BOLDITALIC17PT7B_H_
#define _NOTOSANS_CONDENSED_BOLDITALIC17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BoldItalic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BoldItalic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0xCC, 0x63, 0x39, 0x8C, 0x02, 0x39, 0xC0, 0xFF, 0x6D, 0xA6,
  0x0D, 0x84, 0x86, 0xCF, 0xF7, 0xF8, 0x90, 0xD9, 0xFE, 0xFF, 0x36, 0x1B,
  0x09, 0x00, 0x04, 0x0E, 0x3F, 0x36, 0x38, 0x38, 0x3C, 0x1E, 0x16, 0x96,
  0xFE, 0xFC, 0x10, 0x20, 0x78, 0xCF, 0x33, 0x64, 0x6D, 0x8D, 0xA1, 0xEF,
  0xFF, 0x68, 0x59, 0x1B, 0x62, 0x6C, 0xCF, 0x30, 0xE0, 0x1F, 0x06, 0xC3,
  0x30, 0xFC, 0x1E, 0x07, 0x17, 0xD9, 0xB6, 0xEF, 0x31, 0xCF, 0xF1, 0xEE,
  0xFB, 0x60, 0x0C, 0x63, 0x8C, 0x71, 0x86, 0x18, 0xE3, 0x0C, 0x30, 0x61,
  0x86, 0x00, 0x18, 0x61, 0xC3, 0x0C, 0x71, 0x86, 0x18, 0x63, 0x0C, 0x61,
  0x8C, 0x00, 0x18, 0xB1, 0xEF, 0xF3, 0x8D, 0x8B, 0x00, 0x30, 0x60, 0xC7,
  0xFF, 0xE6, 0x0C, 0x18, 0x76, 0x6C, 0x7F, 0xC0, 0x5F, 0x80, 0x03, 0x81,
  0x81, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x18, 0x18, 0x1C, 0x00,
  0x1E, 0x3F, 0x33, 0x73, 0x63, 0x67, 0x67, 0xE6, 0xE6, 0xEE, 0x7C, 0x78,
  0x1B, 0xFF, 0xF3, 0x18, 0xC6, 0x73, 0x18, 0xC0, 0x0F, 0x1F, 0xC4, 0x60,
  0x70, 0x30, 0x38, 0x38, 0x38, 0x18, 0x18, 0x1F, 0xDF, 0xC0, 0x3E, 0x3F,
  0x23, 0x03, 0x06, 0x3C, 0x3E, 0x06, 0x06, 0x8E, 0xFC, 0xF8, 0x07, 0x07,
  0x0E, 0x1E, 0x36, 0x26, 0x6E, 0xCD, 0xFE, 0xFE, 0x0C, 0x1C, 0x1F, 0x3F,
  0x30, 0x30, 0x3C, 0x7E, 0x4E, 0x06, 0x06, 0x8E, 0xFC, 0xF8, 0x1E, 0x7D,
  0xC3, 0x0D, 0xDF, 0xB3, 0x66, 0xCD, 0x9B, 0xE7, 0xC0, 0x3F, 0x9F, 0x80,
  0xC0, 0xC0, 0x60, 0x60, 0x70, 0x30, 0x38, 0x18, 0x1C, 0x1C, 0x00, 0x1F,
  0x3F, 0x33, 0x33, 0x3E, 0x1C, 0x7C, 0x66, 0xC6, 0xC6, 0xFE, 0x7C, 0x1E,
  0x3F, 0x73, 0x63, 0x67, 0x67, 0x7E, 0x36, 0x0E, 0x0C, 0xF8, 0xF0, 0x33,
  0x00, 0x00, 0x4E, 0xC0, 0x18, 0xC0, 0x00, 0x00, 0x0E, 0x63, 0x30, 0x02,
  0x3D, 0xE7, 0x0F, 0x07, 0x83, 0x81, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0,
  0x81, 0xC1, 0xE0, 0x71, 0xEF, 0x38, 0x40, 0xFD, 0xF0, 0xC3, 0x18, 0xC6,
  0x18, 0x01, 0x0C, 0x30, 0x0F, 0x87, 0x18, 0x81, 0xB7, 0xBD, 0xB7, 0xB6,
  0xE4, 0xDD, 0x92, 0xB6, 0xD3, 0x72, 0x00, 0x60, 0x87, 0xE0, 0x07, 0x03,
  0x83, 0xC1, 0xE1, 0xB0, 0xDC, 0xEE, 0x7F, 0x3F, 0xB1, 0xD8, 0xFC, 0x70,
  0x1F, 0x1F, 0xCC, 0xE6, 0x73, 0x33, 0xF1, 0xFC, 0xC6, 0x63, 0x33, 0xBF,
  0x9F, 0x80, 0x1F, 0x3F, 0x70, 0x60, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0xE0,
  0xFC, 0x7C, 0x1F, 0x1F, 0xCC, 0xE6, 0x33, 0x1B, 0x8D, 0xC6, 0xC7, 0x63,
  0x33, 0xBF, 0x9F, 0x00, 0x1F, 0x3F, 0x30, 0x30, 0x30, 0x7E, 0x7E, 0x60,
  0x60, 0x60, 0xFC, 0xFC, 0x1F, 0x3F, 0x30, 0x30, 0x30, 0x7E, 0x7E, 0x60,
  0x60, 0x60, 0xE0, 0xE0, 0x1F, 0x9F, 0xDC, 0x0C, 0x0E, 0x06, 0x7B, 0x3D,
  0x8E, 0xC7, 0x73, 0x3F, 0x8F, 0xC0, 0x18, 0xCE, 0x33, 0x1C, 0xC7, 0x31,
  0x9F, 0xE7, 0xF9, 0x8E, 0x63, 0x18, 0xCE, 0x33, 0x9C, 0x1F, 0x0C, 0x0C,
  0x1C, 0x1C, 0x18, 0x18, 0x18, 0x38, 0x30, 0x7C, 0xF8, 0x03, 0x07, 0x07,
  0x06, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x0C, 0x1C, 0x1C, 0x18, 0xB8, 0xF0,
  0x60, 0x19, 0xCE, 0xE3, 0x30, 0xDC, 0x3E, 0x1F, 0x07, 0xC1, 0xB8, 0x6E,
  0x19, 0x8E, 0x63, 0x1C, 0x18, 0xE3, 0x0C, 0x31, 0xC7, 0x18, 0x61, 0x8F,
  0xFF, 0x1C, 0x39, 0xE3, 0xCF, 0x1E, 0x79, 0xE3, 0xCF, 0x3E, 0xD9, 0xB6,
  0xCD, 0xEE, 0x6F, 0x63, 0x73, 0x3B, 0x99, 0x9D, 0xC0, 0x18, 0x67, 0x9C,
  0xF3, 0x1E, 0x63, 0xCC, 0xF9, 0x99, 0xF3, 0x3C, 0x67, 0x8C, 0xF3, 0x9E,
  0x61, 0x80, 0x1F, 0x1F, 0xDC, 0xEC, 0x3E, 0x3E, 0x1F, 0x0F, 0x86, 0xC7,
  0x63, 0xBF, 0x8F, 0x80, 0x1F, 0x1F, 0xCC, 0x66, 0x33, 0x3B, 0xB9, 0xFC,
  0xF8, 0x60, 0x30, 0x38, 0x1C, 0x00, 0x1F, 0x1F, 0xDC, 0xEC, 0x3E, 0x3E,
  0x1F, 0x0F, 0x86, 0xC7, 0x63, 0xBF, 0x8F, 0x81, 0xC0, 0x60, 0x38, 0x1F,
  0x1F, 0x8C, 0xE6, 0x73, 0x33, 0xF9, 0xF8, 0xD8, 0x6E, 0x33, 0x39, 0x98,
  0xE0, 0x1F, 0x3F, 0x30, 0x70, 0x38, 0x3C, 0x1C, 0x0E, 0x0E, 0x8E, 0xFC,
  0xF8, 0x7F, 0xFE, 0x18, 0x38, 0x30, 0x30, 0x30, 0x70, 0x70, 0x60, 0x60,
  0xE0, 0x71, 0xB9, 0xD8, 0xEC, 0x66, 0x37, 0x1B, 0x9D, 0x8E, 0xC6, 0x67,
  0x3F, 0x0F, 0x00, 0xC7, 0xC6, 0xC6, 0xCC, 0xCC, 0xD8, 0xD8, 0xF8, 0xF0,
  0xF0, 0xE0, 0xE0, 0x63, 0x1B, 0x39, 0xF9, 0xCD, 0xDE, 0x6E, 0xF7, 0x77,
  0xB3, 0xED, 0x9B, 0x78, 0xF3, 0xC7, 0x9C, 0x3C, 0xE1, 0xC7, 0x00, 0x18,
  0xE3, 0x38, 0x76, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xF0, 0x3E, 0x06,
  0xE1, 0x8C, 0x71, 0x80, 0xC7, 0x9B, 0x36, 0xCD, 0x9E, 0x1C, 0x30, 0x61,
  0xC3, 0x06, 0x00, 0x1F, 0x8F, 0xC0, 0xC0, 0xE0, 0x60, 0x60, 0x70, 0x30,
  0x30, 0x38, 0x1F, 0x9F, 0xC0, 0x1E, 0x3C, 0x60, 0xC1, 0x86, 0x0C, 0x18,
  0x30, 0x61, 0x83, 0x06, 0x0E, 0x3C, 0x00, 0xDB, 0x6C, 0x9B, 0x6D, 0xB0,
  0x1E, 0x38, 0x30, 0x60, 0xC3, 0x06, 0x0C, 0x18, 0x30, 0xC1, 0x83, 0x1E,
  0x3C, 0x00, 0x0C, 0x0C, 0x1E, 0x36, 0x36, 0x62, 0xC3, 0x7F, 0xF8, 0xE6,
  0x30, 0x3F, 0x9F, 0x9C, 0xCC, 0xE6, 0x77, 0x33, 0x98, 0xFC, 0x76, 0x00,
  0x18, 0x38, 0x30, 0x30, 0x3F, 0x3F, 0x73, 0x63, 0x63, 0x67, 0x66, 0xFE,
  0xDC, 0x3E, 0x7D, 0xC3, 0x06, 0x1C, 0x38, 0x3E, 0x7C, 0x01, 0x80, 0xC0,
  0x60, 0x73, 0xF1, 0xB9, 0xCC, 0xC6, 0x66, 0x73, 0x39, 0x8F, 0xC7, 0x60,
  0x1E, 0x37, 0x67, 0x6E, 0x7C, 0xE0, 0xE0, 0x7C, 0x7C, 0x03, 0x83, 0xC1,
  0x81, 0xC1, 0xF0, 0xF8, 0x30, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x81,
  0x80, 0xC1, 0xE0, 0xE0, 0x00, 0x3F, 0x9F, 0x9C, 0xCC, 0xE6, 0x77, 0x33,
  0xB8, 0xFC, 0x7E, 0x06, 0x03, 0x1F, 0x8F, 0x80, 0x18, 0x38, 0x30, 0x30,
  0x3F, 0x3F, 0x73, 0x63, 0x67, 0x66, 0x66, 0xE6, 0xCE, 0x19, 0xC4, 0x03,
  0x19, 0xCC, 0x63, 0x19, 0xCC, 0x00, 0x06, 0x1C, 0x10, 0x00, 0xC1, 0x87,
  0x0C, 0x18, 0x30, 0x61, 0xC3, 0x06, 0x0C, 0x78, 0xE0, 0x18, 0x1C, 0x0C,
  0x06, 0x13, 0x31, 0xB1, 0xF8, 0xF8, 0x7C, 0x36, 0x1B, 0x19, 0xCC, 0x60,
  0x19, 0xCE, 0x63, 0x19, 0xCC, 0x63, 0x19, 0xCC, 0x00, 0x3F, 0xF3, 0xFF,
  0x73, 0x36, 0x73, 0x66, 0x76, 0x66, 0x66, 0x6E, 0x66, 0xCE, 0xE0, 0x3F,
  0x3F, 0x73, 0x63, 0x67, 0x66, 0x66, 0xE6, 0xCE, 0x3E, 0x3F, 0x63, 0x63,
  0x67, 0xE6, 0xE6, 0x7E, 0x7C, 0x1F, 0x8F, 0xCE, 0x66, 0x33, 0x19, 0x9C,
  0xCC, 0xFE, 0x6E, 0x30, 0x18, 0x1C, 0x0C, 0x00, 0x3F, 0x9B, 0x9C, 0xCC,
  0x66, 0x67, 0x33, 0x98, 0xFC, 0x7E, 0x06, 0x03, 0x01, 0x81, 0xC0, 0x3E,
  0x79, 0xC3, 0x86, 0x0C, 0x18, 0x70, 0xC0, 0x3E, 0xE9, 0x83, 0x83, 0x83,
  0x87, 0x7C, 0xF8, 0x33, 0x3F, 0xF6, 0x73, 0x18, 0xC7, 0x38, 0x66, 0xCF,
  0x9E, 0x7C, 0xD9, 0xB3, 0x7E, 0xEC, 0xC7, 0x9B, 0x36, 0xCD, 0x9F, 0x3C,
  0x78, 0xE0, 0xCE, 0x79, 0xDB, 0x7B, 0x6F, 0x6F, 0x79, 0xEF, 0x39, 0xC7,
  0x38, 0xE6, 0x00, 0x3B, 0x8D, 0x87, 0x83, 0xC1, 0xC0, 0xE0, 0xD8, 0xEC,
  0xE6, 0x00, 0x31, 0x99, 0x8C, 0xC6, 0xE3, 0x61, 0xB0, 0x70, 0x38, 0x18,
  0x1C, 0x0C, 0x1E, 0x0E, 0x00, 0x3F, 0x3E, 0x0E, 0x0C, 0x18, 0x38, 0x30,
  0x7C, 0xFC, 0x0E, 0x3C, 0x60, 0xC1, 0x87, 0x3C, 0x70, 0x70, 0xE1, 0x83,
  0x06, 0x0E, 0x0C, 0x00, 0xFF, 0xFF, 0x80, 0x18, 0x38, 0x30, 0xE1, 0x83,
  0x07, 0x86, 0x18, 0x60, 0xC1, 0x87, 0x1C, 0x30, 0x00, 0xFB, 0x7C,
};

const GFXglyph NotoSans_Condensed_BoldItalic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 5, 12, 4, 0, -12 },
  { 9, 6, 4, 7, 2, -12 },
  { 12, 9, 12, 9, 0, -12 },
  { 26, 8, 14, 8, 0, -13 },
  { 40, 11, 12, 13, 1, -12 },
  { 57, 10, 12, 10, 0, -12 },
  { 72, 3, 4, 4, 2, -12 },
  { 74, 6, 15, 5, 0, -12 },
  { 86, 6, 15, 5, -1, -12 },
  { 98, 7, 7, 8, 1, -13 },
  { 105, 7, 8, 8, 1, -10 },
  { 112, 4, 4, 4, -1, -2 },
  { 114, 5, 2, 5, 0, -6 },
  { 116, 3, 3, 4, 0, -3 },
  { 118, 9, 12, 7, -1, -12 },
  { 132, 8, 12, 8, 0, -12 },
  { 144, 5, 12, 8, 2, -12 },
  { 152, 9, 12, 8, -1, -12 },
  { 166, 8, 12, 8, 0, -12 },
  { 178, 8, 12, 8, 0, -12 },
  { 190, 8, 12, 8, 0, -12 },
  { 202, 7, 12, 8, 1, -12 },
  { 213, 9, 12, 8, 0, -12 },
  { 227, 8, 12, 8, 0, -12 },
  { 239, 8, 12, 8, 0, -12 },
  { 251, 4, 9, 4, 0, -9 },
  { 256, 5, 11, 4, -1, -9 },
  { 263, 7, 8, 8, 1, -10 },
  { 270, 7, 6, 8, 1, -9 },
  { 276, 7, 8, 8, 1, -10 },
  { 283, 6, 12, 6, 1, -12 },
  { 292, 11, 13, 12, 1, -12 },
  { 310, 9, 12, 9, -1, -12 },
  { 324, 9, 12, 9, 0, -12 },
  { 338, 8, 12, 8, 1, -12 },
  { 350, 9, 12, 10, 0, -12 },
  { 364, 8, 12, 8, 0, -12 },
  { 376, 8, 12, 7, 0, -12 },
  { 388, 9, 12, 10, 1, -12 },
  { 402, 10, 12, 10, 0, -12 },
  { 417, 8, 12, 6, -1, -12 },
  { 429, 8, 16, 5, -3, -12 },
  { 445, 10, 12, 9, 0, -12 },
  { 460, 6, 12, 7, 0, -12 },
  { 469, 13, 12, 13, 0, -12 },
  { 489, 11, 12, 11, 0, -12 },
  { 506, 9, 12, 10, 1, -12 },
  { 520, 9, 12, 9, 0, -12 },
  { 534, 9, 15, 10, 1, -12 },
  { 551, 9, 12, 9, 0, -12 },
  { 565, 8, 12, 8, 0, -12 },
  { 577, 8, 12, 7, 1, -12 },
  { 589, 9, 12, 10, 1, -12 },
  { 603, 8, 12, 9, 2, -12 },
  { 615, 13, 12, 13, 1, -12 },
  { 635, 11, 12, 8, -1, -12 },
  { 652, 7, 12, 8, 2, -12 },
  { 663, 9, 12, 7, -1, -12 },
  { 677, 7, 15, 5, -1, -12 },
  { 691, 3, 12, 7, 2, -12 },
  { 696, 7, 15, 5, -1, -12 },
  { 710, 8, 7, 8, 0, -12 },
  { 717, 7, 2, 6, -2, 1 },
  { 719, 4, 3, 5, 2, -13 },
  { 721, 9, 9, 9, 0, -9 },
  { 732, 8, 13, 9, 0, -13 },
  { 745, 7, 9, 7, 0, -9 },
  { 753, 9, 13, 9, 0, -13 },
  { 768, 8, 9, 8, 0, -9 },
  { 777, 9, 17, 5, -2, -13 },
  { 797, 9, 13, 9, 0, -9 },
  { 812, 8, 13, 9, 0, -13 },
  { 825, 5, 13, 4, 0, -13 },
  { 834, 7, 17, 4, -2, -13 },
  { 849, 9, 13, 8, 0, -13 },
  { 864, 5, 13, 4, 0, -13 },
  { 873, 12, 9, 13, 0, -9 },
  { 887, 8, 9, 9, 0, -9 },
  { 896, 8, 9, 8, 0, -9 },
  { 905, 9, 13, 9, -1, -9 },
  { 920, 9, 13, 9, 0, -9 },
  { 935, 7, 9, 6, 0, -9 },
  { 943, 7, 9, 7, 0, -9 },
  { 951, 5, 11, 6, 1, -11 },
  { 958, 7, 9, 8, 1, -9 },
  { 966, 7, 9, 7, 1, -9 },
  { 974, 11, 9, 11, 1, -9 },
  { 987, 9, 9, 8, -1, -9 },
  { 998, 9, 13, 7, -1, -9 },
  { 1013, 8, 9, 6, -1, -9 },
  { 1022, 7, 15, 6, 0, -12 },
  { 1036, 1, 17, 7, 3, -13 },
  { 1039, 7, 15, 6, -1, -12 },
  { 1053, 7, 2, 8, 1, -7 },
};

const GFXfont NotoSans_Condensed_BoldItalic17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BoldItalic17pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BoldItalic17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_CONDENSED_BOLDITALIC17PT7B_H_
