#ifndef _NOTOSANS_CONDENSED_BOLDITALIC38PT7B_H_
#define _NOTOSANS_CONDENSED_BOLDITALIC38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BoldItalic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BoldItalic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x1F, 0x07, 0xE0, 0xFC, 0x1F,
  0x81, 0xE0, 0x00, 0x7C, 0xFB, 0xE7, 0xDE, 0x3C, 0xF1, 0xEF, 0x9F, 0x7C,
  0xFB, 0xC7, 0x9E, 0x3C, 0xF1, 0xE7, 0x0E, 0x00, 0x00, 0x78, 0xF0, 0x03,
  0xC7, 0x00, 0x1C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1C, 0x00, 0x71, 0xE0,
  0x07, 0x8F, 0x03, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFC, 0x07, 0x8E, 0x00, 0x38, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x38, 0x00,
  0xE3, 0xC4, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x1C, 0x78,
  0x01, 0xE3, 0xC0, 0x0F, 0x1C, 0x00, 0x71, 0xE0, 0x07, 0x8F, 0x00, 0x3C,
  0x70, 0x01, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x01, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F,
  0xDE, 0x0F, 0xB1, 0x03, 0xCC, 0x00, 0xF3, 0x00, 0x3E, 0x80, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0x7C, 0x00, 0xDF, 0x10, 0x67, 0xC7, 0x1B, 0xF1, 0xFF,
  0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x03, 0xFF, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0x07,
  0xF8, 0x0F, 0x07, 0xFC, 0x0F, 0x03, 0xCE, 0x07, 0x83, 0xC7, 0x87, 0x81,
  0xE3, 0xC7, 0x80, 0xF1, 0xC3, 0xC0, 0xF1, 0xE3, 0xC0, 0x78, 0xF1, 0xE0,
  0x3C, 0x79, 0xE0, 0x1E, 0x3D, 0xE1, 0x8F, 0x3C, 0xF3, 0xF7, 0x9E, 0xF3,
  0xFF, 0xFE, 0x7B, 0xFE, 0xFE, 0x79, 0xEF, 0x7E, 0x79, 0xE3, 0x84, 0x3C,
  0xF3, 0xC0, 0x3C, 0xF1, 0xE0, 0x1E, 0x78, 0xF0, 0x1E, 0x3C, 0x78, 0x1E,
  0x1E, 0x3C, 0x0F, 0x0F, 0x3C, 0x0F, 0x07, 0x9E, 0x07, 0x83, 0xDE, 0x07,
  0x81, 0xFF, 0x07, 0x80, 0x7F, 0x03, 0xC0, 0x3F, 0x00, 0x00, 0x08, 0x00,
  0x01, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x03, 0xE7, 0xC0, 0x0F,
  0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0x80, 0x1F, 0x3E,
  0x00, 0x7D, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x10,
  0xFF, 0x8F, 0x87, 0xFE, 0x3E, 0x3F, 0xFC, 0xF0, 0xF9, 0xF7, 0xC7, 0xC7,
  0xFF, 0x1F, 0x0F, 0xF8, 0xFC, 0x3F, 0xC3, 0xE0, 0x7F, 0x0F, 0xC1, 0xF8,
  0x3F, 0x0F, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0x7E, 0x07,
  0xF9, 0xFC, 0x7D, 0xF7, 0x9E, 0xFB, 0xEF, 0x3C, 0xF3, 0xC0, 0x00, 0xF8,
  0x0F, 0x80, 0xF8, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F,
  0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00,
  0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xE0,
  0x0F, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x03,
  0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xE0,
  0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x00,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x83, 0x1E, 0x07, 0x3C, 0x0F, 0xF8, 0xFF,
  0xFF, 0xBF, 0xFF, 0x0F, 0xFE, 0x1F, 0x84, 0x7F, 0x81, 0xFF, 0x07, 0xCF,
  0x07, 0x9F, 0x06, 0x3E, 0x04, 0x30, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x1F, 0x8F, 0x87, 0xC7,
  0xC3, 0xE1, 0xF1, 0xF0, 0xF8, 0x78, 0x78, 0x00, 0x7F, 0xEF, 0xF9, 0xFF,
  0x3F, 0xEF, 0xFC, 0x39, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x20, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFF,
  0xE0, 0xFF, 0xF0, 0x7C, 0xF8, 0x7C, 0x3E, 0x3E, 0x1F, 0x3E, 0x0F, 0x9F,
  0x07, 0xDF, 0x83, 0xEF, 0x83, 0xE7, 0xC1, 0xF3, 0xE0, 0xFB, 0xF0, 0x7D,
  0xF0, 0x3E, 0xF8, 0x3F, 0x7C, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x87,
  0xC7, 0xC3, 0xE3, 0xE3, 0xF1, 0xF3, 0xF0, 0xFF, 0xF0, 0x3F, 0xF8, 0x1F,
  0xF8, 0x07, 0xF0, 0x00, 0x00, 0xF8, 0x1F, 0x81, 0xFC, 0x1F, 0xE1, 0xFF,
  0x3F, 0xF3, 0xFF, 0x9F, 0x7C, 0x73, 0xE3, 0x1F, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x00, 0x08, 0x00, 0x1F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xFC,
  0x0F, 0x8F, 0xC0, 0xC1, 0xF8, 0x10, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F,
  0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x00, 0x00, 0x10, 0x00, 0x7F, 0xC0,
  0x7F, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0xC1, 0xC3, 0xF0, 0x40, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xFE,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x88, 0x07, 0xE3, 0x03,
  0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F,
  0x80, 0x1F, 0xF0, 0x07, 0xBC, 0x00, 0xFF, 0x80, 0x3D, 0xF0, 0x0F, 0x3E,
  0x01, 0xC7, 0x80, 0x79, 0xF0, 0x1E, 0x3E, 0x07, 0x87, 0xC0, 0xF0, 0xF8,
  0x3C, 0x1E, 0x0F, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xF9,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xFE,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xC0, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0x87,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3E, 0x20, 0x1F, 0x8E, 0x0F, 0xC3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F,
  0xFC, 0x07, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFE, 0x03, 0xFF, 0x81, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x03, 0xE3, 0x00, 0xFB, 0xF0, 0x7D, 0xFE, 0x1F, 0xFF, 0x87,
  0xFF, 0xE1, 0xF8, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0xCF, 0x83, 0xE3, 0xE0,
  0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x87, 0xC3, 0xF3, 0xF0, 0x7F, 0xFC,
  0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0xE3, 0xFF, 0xF8,
  0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE3, 0xE0, 0xF9,
  0xF8, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xF0,
  0x3F, 0x7E, 0x0F, 0x8F, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0xF8, 0x1F, 0x3E,
  0x07, 0xCF, 0x81, 0xF3, 0xF0, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x03, 0xFF,
  0x80, 0x7F, 0xC0, 0x00, 0x10, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0xFE,
  0x0F, 0xFF, 0x83, 0xE3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3F, 0x1F, 0x0F, 0xCF,
  0x83, 0xF3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x1F, 0x8F, 0xC7, 0xE3, 0xFF,
  0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x03, 0xF7, 0xC0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC2, 0x07, 0xE0, 0xFF, 0xF0, 0x3F,
  0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x07, 0x83, 0xE0, 0xFC, 0x7E, 0x1F,
  0x83, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x7C, 0x3F, 0x0F, 0xC3, 0xF0, 0xF8, 0x00, 0x01, 0xE0, 0x3E,
  0x03, 0xF0, 0x7E, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x81, 0xF0,
  0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x00,
  0x00, 0x01, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFF, 0x07, 0xFC,
  0x1F, 0xF0, 0x7F, 0x80, 0xFE, 0x00, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x03,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0xFF, 0x03, 0xFE,
  0x0F, 0xF8, 0x7F, 0xE0, 0xFF, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0xC0, 0x00,
  0x80, 0x00, 0x00, 0xC0, 0x1F, 0xF0, 0x7F, 0xF1, 0xFF, 0xE1, 0xFF, 0xE3,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0x78, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x03, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x07, 0x81,
  0xE0, 0x01, 0xE0, 0xF0, 0x00, 0x38, 0x78, 0x3F, 0x8F, 0x1E, 0x1F, 0xF3,
  0xCF, 0x0F, 0xF8, 0xF3, 0xC7, 0x8E, 0x3D, 0xE3, 0xC7, 0x8F, 0x78, 0xE1,
  0xE3, 0xDC, 0x78, 0x78, 0xE7, 0x1E, 0x1C, 0x3B, 0xC7, 0x0F, 0x1E, 0xF1,
  0xC3, 0xC7, 0xBC, 0xF0, 0xF1, 0xCF, 0x3C, 0x78, 0xF3, 0xC7, 0xBF, 0x78,
  0xF1, 0xFD, 0xFC, 0x3C, 0x7E, 0x7E, 0x0F, 0x07, 0x0F, 0x01, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x18, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0xC0,
  0x1E, 0xF8, 0x03, 0xDF, 0x00, 0xFB, 0xE0, 0x1E, 0x7C, 0x07, 0xCF, 0x80,
  0xF9, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC1, 0xF0, 0xF8, 0x3E, 0x1F, 0x0F,
  0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xF1, 0xF0, 0x3E, 0x7C,
  0x07, 0xCF, 0x80, 0xFB, 0xF0, 0x1F, 0x7C, 0x03, 0xFF, 0x80, 0x7F, 0xE0,
  0x0F, 0x80, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF,
  0x07, 0xC3, 0xF0, 0x7C, 0x3F, 0x07, 0xC1, 0xF0, 0xF8, 0x3F, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x8F, 0xC1, 0xFF, 0xF8, 0x1F, 0xFE, 0x01, 0xFF,
  0xF0, 0x1F, 0xFF, 0x81, 0xF0, 0xF8, 0x3E, 0x0F, 0xC3, 0xE0, 0x7C, 0x3E,
  0x07, 0xC3, 0xE0, 0xFC, 0x3E, 0x0F, 0x87, 0xC1, 0xF8, 0x7C, 0x3F, 0x87,
  0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x00, 0x08,
  0x00, 0x1F, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xC3,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3F, 0x01, 0x07, 0xF1, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x00,
  0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x7C, 0xFF, 0x03, 0xE1, 0xF8, 0x1F, 0x07, 0xE1,
  0xF8, 0x3F, 0x0F, 0x81, 0xF8, 0x7C, 0x0F, 0xC3, 0xE0, 0x7E, 0x3F, 0x03,
  0xF1, 0xF8, 0x1F, 0x8F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x7E, 0x3F,
  0x03, 0xF1, 0xF8, 0x1F, 0x0F, 0x81, 0xF8, 0x7C, 0x0F, 0xC3, 0xE0, 0xFC,
  0x3F, 0x0F, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F,
  0xFF, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x81,
  0xFF, 0xE0, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF8,
  0x1F, 0xFE, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFC,
  0x1F, 0xFF, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xFE, 0x07, 0xFF,
  0x81, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x07, 0xFE, 0x01,
  0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFE, 0x0E, 0x1F, 0xC0, 0x23,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC3, 0xFE, 0xFC, 0x3F, 0xCF, 0x83, 0xFC, 0xF8, 0x7F,
  0xCF, 0x80, 0x7C, 0xF8, 0x0F, 0xCF, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x80,
  0xF8, 0xFC, 0x1F, 0x8F, 0xE1, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0xFC, 0x1F, 0x81,
  0xF8, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x3F,
  0x07, 0xE0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F,
  0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0,
  0x1F, 0x03, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x01, 0xF0, 0x3E, 0x03,
  0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x1F, 0x83, 0xF0, 0x3E, 0x00, 0x07, 0xFF,
  0x07, 0xFF, 0x07, 0xFF, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0xFF, 0xE0,
  0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03,
  0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0xFF, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x00, 0x03, 0xE0, 0x7E, 0x07, 0xC1,
  0xF8, 0x1F, 0x07, 0xE0, 0x3E, 0x1F, 0x80, 0x7C, 0x3E, 0x00, 0xF8, 0xFC,
  0x01, 0xF3, 0xF0, 0x07, 0xC7, 0xC0, 0x0F, 0x9F, 0x00, 0x1F, 0x7E, 0x00,
  0x3E, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0x7C, 0x00, 0x7C, 0xFC, 0x00, 0xF8,
  0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x0F, 0x87, 0xE0, 0x1F, 0x07,
  0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x80, 0xF8, 0x3F, 0x03, 0xE0, 0x7E,
  0x00, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x01, 0xF8, 0x07, 0xFF, 0xDF, 0xFF, 0x7F, 0xF9, 0xFF, 0xEF, 0xFF,
  0x80, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC1, 0xFE, 0x01, 0xFE,
  0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x1F,
  0xE0, 0x7F, 0xC1, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xC1,
  0xEF, 0x03, 0xDE, 0x1F, 0xF8, 0x3E, 0xF0, 0xF7, 0xC1, 0xF7, 0x87, 0xBE,
  0x0F, 0xBC, 0x79, 0xF0, 0x7D, 0xE3, 0xCF, 0x03, 0xCF, 0x3C, 0xF8, 0x3E,
  0x79, 0xE7, 0xC1, 0xF3, 0xDF, 0x3E, 0x0F, 0x9E, 0xF1, 0xE0, 0x7C, 0xFF,
  0x9F, 0x03, 0xC7, 0xF8, 0xF8, 0x3E, 0x3F, 0xC7, 0xC1, 0xF1, 0xFC, 0x3E,
  0x0F, 0x8F, 0xE1, 0xE0, 0x78, 0x7E, 0x1F, 0x03, 0xC1, 0xF0, 0xF8, 0x3E,
  0x0F, 0x07, 0xC0, 0x03, 0xF0, 0x0F, 0x03, 0xF0, 0x1F, 0x07, 0xF0, 0x1F,
  0x07, 0xF8, 0x1F, 0x07, 0xF8, 0x1F, 0x07, 0xF8, 0x1E, 0x07, 0xF8, 0x3E,
  0x0F, 0xF8, 0x3E, 0x0F, 0xFC, 0x3E, 0x0F, 0x7C, 0x3C, 0x0F, 0x7C, 0x7C,
  0x1F, 0x3C, 0x7C, 0x1F, 0x3E, 0x7C, 0x1F, 0x3E, 0x7C, 0x1F, 0x3E, 0x78,
  0x1E, 0x1E, 0xF8, 0x3E, 0x1E, 0xF8, 0x3E, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8,
  0x3E, 0x1F, 0xF0, 0x3C, 0x0F, 0xF0, 0x7C, 0x0F, 0xF0, 0x7C, 0x0F, 0xF0,
  0x7C, 0x0F, 0xE0, 0x78, 0x0F, 0xE0, 0x78, 0x07, 0xE0, 0xF8, 0x07, 0xE0,
  0x00, 0x08, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF,
  0xE0, 0xFC, 0x7F, 0x1F, 0x83, 0xF3, 0xF0, 0x1F, 0x3F, 0x01, 0xF7, 0xE0,
  0x1F, 0x7E, 0x01, 0xF7, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x07, 0xEF,
  0x80, 0x7C, 0xF8, 0x0F, 0xCF, 0x80, 0xFC, 0xFC, 0x1F, 0x8F, 0xE7, 0xF0,
  0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xC7, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0xFC, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F,
  0x83, 0xF1, 0xF8, 0x7E, 0x1F, 0x0F, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x81,
  0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x08, 0x00, 0x0F, 0xF8, 0x03,
  0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFC, 0x7F, 0x1F, 0x83, 0xF3,
  0xF0, 0x1F, 0x3F, 0x01, 0xF7, 0xE0, 0x1F, 0x7E, 0x01, 0xF7, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xEF, 0x80, 0x7E, 0xF8, 0x07, 0xEF, 0x80, 0x7C, 0xF8, 0x0F, 0xCF, 0x80,
  0xFC, 0xFC, 0x1F, 0x8F, 0xE7, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x3F,
  0xF8, 0x01, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xF0,
  0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7C, 0x7E, 0x0F, 0x87, 0xC1, 0xF0, 0xF8,
  0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x3E, 0x1F, 0x8F, 0xC7, 0xE1,
  0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0x7C, 0x07,
  0xCF, 0x80, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0xF8, 0x7E, 0x1F,
  0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xF3, 0xE0, 0x3E, 0x00,
  0x00, 0x08, 0x00, 0x3F, 0xE0, 0x3F, 0xFC, 0x1F, 0xFF, 0x0F, 0xFF, 0x83,
  0xF8, 0xE0, 0xF8, 0x08, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x8C, 0x07, 0xE3, 0xC7, 0xF0, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF,
  0x01, 0xFF, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x0F, 0x81, 0xF8,
  0xFC, 0x0F, 0x87, 0xE0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x3F, 0x0F, 0x81,
  0xF0, 0xFC, 0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x3F, 0x0F,
  0x81, 0xF0, 0xFC, 0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x07, 0xE1, 0xF0, 0x3F,
  0x1F, 0x81, 0xF0, 0xFC, 0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x07, 0xE1, 0xF0,
  0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x1F, 0x83, 0xF1, 0xF8, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0xF8, 0x03, 0xFF, 0x00,
  0xFD, 0xE0, 0x1F, 0x3C, 0x03, 0xE7, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x07,
  0xC3, 0xE0, 0xF8, 0x7C, 0x3F, 0x0F, 0x87, 0xC1, 0xF1, 0xF8, 0x3E, 0x3E,
  0x07, 0xC7, 0xC0, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xEF, 0x80, 0x7D, 0xF0,
  0x0F, 0xBC, 0x01, 0xFF, 0x80, 0x3D, 0xE0, 0x07, 0xBC, 0x00, 0xFF, 0x80,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00,
  0x00, 0xF8, 0x0F, 0x80, 0xFF, 0xC0, 0x7C, 0x0F, 0xFE, 0x03, 0xE0, 0x7D,
  0xF0, 0x3F, 0x03, 0xEF, 0x81, 0xF8, 0x3E, 0x7C, 0x1F, 0xC1, 0xF3, 0xE0,
  0xFE, 0x1F, 0x9F, 0x0F, 0xF0, 0xF8, 0xF8, 0x7F, 0x87, 0xC7, 0xC3, 0xFC,
  0x7C, 0x3E, 0x3D, 0xE3, 0xE1, 0xF1, 0xEF, 0x1E, 0x0F, 0x9F, 0x79, 0xF0,
  0x7C, 0xF3, 0xCF, 0x83, 0xE7, 0x9E, 0xF8, 0x1F, 0x78, 0xF7, 0xC0, 0xFB,
  0xC7, 0xBC, 0x07, 0xFE, 0x3F, 0xE0, 0x3F, 0xE1, 0xFF, 0x01, 0xFF, 0x0E,
  0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0x83, 0xF8, 0x03, 0xFC, 0x3F, 0xC0,
  0x1F, 0xC1, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xE0, 0x7F, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0xF8, 0x07, 0xC3, 0xF0,
  0x0F, 0x87, 0xC0, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3E, 0xF8,
  0x00, 0xF8, 0xF8, 0x03, 0xF1, 0xF0, 0x07, 0xC3, 0xE0, 0x1F, 0x07, 0xC0,
  0x7E, 0x0F, 0xC0, 0xF8, 0x0F, 0x83, 0xF0, 0x1F, 0x00, 0xFC, 0x0F, 0xDF,
  0x03, 0xE7, 0xC1, 0xF9, 0xF0, 0x7C, 0x7C, 0x3E, 0x1F, 0x0F, 0x83, 0xC7,
  0xC0, 0xF9, 0xF0, 0x3E, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80,
  0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFF,
  0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xE0, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0x00, 0xF0, 0xF8, 0xF8, 0xF8,
  0x78, 0x78, 0x78, 0x78, 0x7C, 0x7C, 0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3E, 0x3E, 0x3E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1F, 0x1F, 0x1F, 0x0F, 0x01,
  0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x7F, 0x80, 0x7F,
  0x80, 0x7F, 0x80, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0x78, 0x07,
  0x9F, 0x03, 0xE3, 0xC0, 0xF0, 0xF0, 0x7C, 0x3C, 0x1E, 0x0F, 0x8F, 0x01,
  0xE7, 0xC0, 0x79, 0xE0, 0x1E, 0xF0, 0x07, 0xC0, 0x7F, 0xFD, 0xFF, 0xFF,
  0xFF, 0xC0, 0xF9, 0xF9, 0xF3, 0xE3, 0xC3, 0xC0, 0x03, 0xE3, 0xC1, 0xFD,
  0xF0, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0x9F, 0x8F, 0xC7, 0xE3, 0xE1, 0xF9,
  0xF8, 0x7E, 0x7C, 0x1F, 0x1F, 0x07, 0xCF, 0xC1, 0xF3, 0xF0, 0x7C, 0xF8,
  0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xE3, 0xE1, 0xF8, 0xFC, 0xFE, 0x3F, 0xFF,
  0x07, 0xFB, 0xC1, 0xFE, 0xF0, 0x3E, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0x9F, 0x03, 0xEF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFF, 0x1F,
  0xCF, 0xC7, 0xE1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1E, 0x07, 0xCF, 0x81,
  0xF3, 0xE0, 0xFC, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xE7, 0xE1, 0xF9,
  0xF8, 0x7C, 0x7E, 0x3F, 0x1F, 0xFF, 0x87, 0xFF, 0xC3, 0xEF, 0xE0, 0xF3,
  0xF0, 0x00, 0x01, 0xFC, 0x0F, 0xFC, 0x3F, 0xF8, 0xFF, 0xE1, 0xF8, 0xC7,
  0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x30, 0xFF, 0xE1,
  0xFF, 0xC1, 0xFF, 0x81, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x03, 0xE7, 0xC0, 0x7F, 0x7C, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8,
  0x1F, 0x1F, 0x83, 0xF1, 0xF8, 0x3E, 0x1F, 0x87, 0xC1, 0xF8, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0xFC, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x87, 0xE0, 0xFC, 0x7E, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFC, 0x07, 0xFB, 0xC0, 0x3F, 0x3C, 0x00, 0x01, 0xF8, 0x07, 0xFE, 0x0F,
  0xFE, 0x1F, 0xFF, 0x1F, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x7C, 0x1F, 0x7C,
  0x7E, 0x7F, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xFC, 0x08, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00,
  0x3E, 0x20, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x80,
  0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x09,
  0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0xF0, 0x1F, 0xDF, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xE7,
  0xE0, 0xFC, 0x7E, 0x0F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x3F, 0x07, 0xC3, 0xF0, 0x7C, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE1, 0xF8, 0x3F, 0x3F, 0x83, 0xFF, 0xF0, 0x1F, 0xFF, 0x01,
  0xFD, 0xF0, 0x0F, 0x9F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x80, 0x7E, 0x0E, 0x0F, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0,
  0x03, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x9F, 0x03,
  0xEF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F, 0xCF, 0xC7, 0xE1, 0xF1, 0xF8,
  0x7C, 0x7C, 0x1F, 0x1F, 0x0F, 0x8F, 0xC3, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E,
  0x3E, 0x0F, 0x8F, 0x87, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F,
  0x07, 0xC7, 0xC3, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x00, 0x01, 0xC0, 0x7C,
  0x1F, 0x83, 0xF0, 0x7C, 0x03, 0x00, 0x00, 0x00, 0x0F, 0xC1, 0xF0, 0x3E,
  0x07, 0xC1, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x7C, 0x0F,
  0x80, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01,
  0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x9F, 0x80, 0xFF, 0x80, 0xFF,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x83, 0xF0, 0xF8, 0x7E, 0x0F, 0x8F, 0xC0, 0xF8, 0xF8, 0x0F,
  0x1F, 0x01, 0xF3, 0xE0, 0x1F, 0x7E, 0x01, 0xFF, 0xC0, 0x1E, 0xF8, 0x03,
  0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xEF, 0xC0,
  0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xE0, 0x78, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0x00, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xF0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC1, 0xF8,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x80, 0x0F, 0x1F,
  0x0F, 0x81, 0xEF, 0xF3, 0xF8, 0x3D, 0xFE, 0xFF, 0x87, 0xFF, 0xFF, 0xF1,
  0xFC, 0xFF, 0x7E, 0x3F, 0x0F, 0x87, 0xC7, 0xC1, 0xF0, 0xF8, 0xF8, 0x7C,
  0x1F, 0x1F, 0x0F, 0x83, 0xE7, 0xC1, 0xF0, 0xF8, 0xF8, 0x3E, 0x1F, 0x1F,
  0x07, 0x83, 0xE3, 0xE1, 0xF0, 0x7C, 0x7C, 0x3E, 0x0F, 0x1F, 0x07, 0xC3,
  0xE3, 0xE0, 0xF8, 0x7C, 0x7C, 0x3E, 0x0F, 0x8F, 0x87, 0xC1, 0xF1, 0xE0,
  0xF8, 0x7C, 0x7C, 0x1F, 0x0F, 0x8F, 0x83, 0xE1, 0xF0, 0x0F, 0x1F, 0x03,
  0xCF, 0xE0, 0xF7, 0xF8, 0x3F, 0xFF, 0x0F, 0xCF, 0xC7, 0xE1, 0xF1, 0xF8,
  0x7C, 0x7C, 0x1F, 0x1F, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E,
  0x3E, 0x0F, 0x8F, 0x87, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F,
  0x07, 0xC7, 0xC3, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x00, 0x01, 0xF8, 0x07,
  0xFC, 0x0F, 0xFE, 0x1F, 0xFF, 0x3F, 0x3F, 0x3E, 0x1F, 0x7E, 0x1F, 0x7C,
  0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x3F, 0xF8, 0x3E, 0xF8, 0x7E, 0xFC, 0xFC, 0x7F, 0xFC, 0x7F, 0xF8, 0x3F,
  0xF0, 0x1F, 0xE0, 0x03, 0xC7, 0xC0, 0x3C, 0xFE, 0x03, 0xDF, 0xE0, 0x3F,
  0xFF, 0x03, 0xF3, 0xF0, 0x7E, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x83, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x1F, 0x87, 0xE1, 0xF8, 0x7C, 0x1F, 0x8F, 0xC1, 0xFF, 0xF8,
  0x1F, 0xFF, 0x03, 0xEF, 0xE0, 0x3E, 0x7C, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE3, 0xC1, 0xFD, 0xF0, 0xFF,
  0xFC, 0x7F, 0xFE, 0x1F, 0x3F, 0x8F, 0x87, 0xE3, 0xE1, 0xF9, 0xF0, 0x7E,
  0x7C, 0x1F, 0x1F, 0x07, 0xCF, 0xC1, 0xF3, 0xE0, 0x7C, 0xF8, 0x1E, 0x3E,
  0x0F, 0x8F, 0x83, 0xE3, 0xE1, 0xF8, 0xFC, 0x7E, 0x3F, 0xFF, 0x07, 0xFF,
  0xC1, 0xFF, 0xF0, 0x3E, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x1E, 0x1E, 0x7C, 0x3D, 0xF8, 0x7F, 0xE1, 0xFF, 0xC3,
  0xFC, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x1F, 0xFC, 0x7F, 0xF8,
  0xFF, 0xE3, 0xF0, 0xC7, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0xC0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0xFC,
  0xC1, 0xF9, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x07, 0xF8, 0x00, 0x07, 0x80,
  0x70, 0x0F, 0x00, 0xF0, 0x1F, 0xF7, 0xFE, 0xFF, 0xEF, 0xFE, 0x3E, 0x03,
  0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7F, 0x00,
  0x1F, 0x07, 0xC7, 0xC1, 0xF1, 0xF0, 0x78, 0x7C, 0x3E, 0x3E, 0x0F, 0x8F,
  0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x7C, 0x3C, 0x1F, 0x1F, 0x07, 0xC7, 0xC1,
  0xF1, 0xF0, 0x7C, 0x7C, 0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xE3, 0xE1, 0xF8,
  0xF8, 0xFC, 0x3F, 0xFF, 0x0F, 0xFB, 0xC1, 0xFE, 0xF0, 0x3F, 0x3C, 0x00,
  0xF8, 0x1F, 0xFC, 0x0F, 0xBE, 0x0F, 0x9F, 0x07, 0xCF, 0x87, 0xE7, 0xC3,
  0xE1, 0xE1, 0xF0, 0xF1, 0xF0, 0x78, 0xF8, 0x3C, 0xF8, 0x1E, 0x7C, 0x0F,
  0x7C, 0x07, 0xBE, 0x03, 0xDE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0xF8, 0x3E, 0x0F,
  0xFC, 0x1F, 0x07, 0xFE, 0x1F, 0x87, 0xDF, 0x0F, 0xC3, 0xEF, 0x8F, 0xE1,
  0xE7, 0xC7, 0xF1, 0xF3, 0xE7, 0xB8, 0xF9, 0xF3, 0xFC, 0xF8, 0xF9, 0xFE,
  0x7C, 0x7D, 0xEF, 0x3C, 0x3E, 0xF7, 0xBE, 0x1F, 0x73, 0xDF, 0x0F, 0xF9,
  0xEF, 0x07, 0xFC, 0xFF, 0x83, 0xFC, 0x7F, 0x81, 0xFE, 0x3F, 0xC0, 0xFE,
  0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0x83, 0xF0, 0x0F,
  0xC1, 0xF8, 0x00, 0x07, 0xC1, 0xF8, 0x3E, 0x1F, 0x81, 0xF0, 0xF8, 0x07,
  0xCF, 0x80, 0x3E, 0xFC, 0x01, 0xF7, 0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xF7, 0xC0, 0x1F, 0x3E, 0x00,
  0xF9, 0xF0, 0x0F, 0x87, 0xC0, 0xFC, 0x3E, 0x0F, 0xC1, 0xF0, 0x00, 0x07,
  0xC0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x80, 0xF0, 0x7C, 0x03, 0xC1,
  0xF0, 0x0F, 0x0F, 0x80, 0x3C, 0x3E, 0x00, 0xF1, 0xF0, 0x03, 0xC7, 0xC0,
  0x0F, 0x3E, 0x00, 0x3C, 0xF8, 0x00, 0xF3, 0xC0, 0x03, 0xDF, 0x00, 0x0F,
  0x78, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7F, 0xF8, 0xFF, 0xF8,
  0xFF, 0xF8, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFE,
  0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x7F, 0x80, 0x7F, 0x00,
  0x78, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x07, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F,
  0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7F, 0x80, 0x7F, 0x00,
  0x3C, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xF0, 0x1F,
  0xE0, 0x3F, 0x80, 0x7E, 0x00, 0xF0, 0x00, 0x00, 0x01, 0x7F, 0x01, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFE, 0x80, 0x38,
};

const GFXglyph NotoSans_Condensed_BoldItalic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 11, 27, 10, 0, -27 },
  { 39, 13, 10, 16, 4, -27 },
  { 56, 21, 27, 20, 0, -27 },
  { 127, 18, 31, 18, 0, -29 },
  { 197, 25, 28, 29, 2, -28 },
  { 285, 22, 28, 22, 0, -28 },
  { 362, 6, 10, 9, 4, -27 },
  { 370, 13, 33, 11, 1, -27 },
  { 424, 13, 34, 11, -3, -28 },
  { 480, 15, 16, 17, 3, -29 },
  { 510, 16, 19, 19, 2, -23 },
  { 548, 9, 10, 10, -2, -5 },
  { 560, 11, 5, 11, 0, -13 },
  { 567, 6, 6, 10, 0, -6 },
  { 572, 20, 27, 15, -2, -27 },
  { 640, 17, 28, 18, 1, -28 },
  { 700, 13, 27, 18, 4, -27 },
  { 744, 19, 28, 18, -1, -28 },
  { 811, 18, 28, 18, 0, -28 },
  { 874, 19, 27, 18, -1, -27 },
  { 939, 18, 27, 18, 0, -27 },
  { 1000, 18, 28, 18, 1, -28 },
  { 1063, 19, 27, 18, 1, -27 },
  { 1128, 18, 28, 18, 0, -28 },
  { 1191, 18, 28, 18, 0, -28 },
  { 1254, 10, 21, 10, 0, -21 },
  { 1281, 12, 26, 10, -2, -21 },
  { 1320, 16, 19, 19, 2, -23 },
  { 1358, 16, 11, 19, 2, -19 },
  { 1380, 16, 19, 19, 2, -23 },
  { 1418, 15, 28, 14, 1, -28 },
  { 1471, 26, 30, 27, 1, -27 },
  { 1569, 19, 27, 20, -2, -27 },
  { 1634, 20, 27, 20, 0, -27 },
  { 1702, 19, 28, 19, 2, -28 },
  { 1769, 21, 27, 21, 0, -27 },
  { 1840, 18, 27, 17, 0, -27 },
  { 1901, 18, 27, 16, 0, -27 },
  { 1962, 20, 28, 22, 2, -28 },
  { 2032, 23, 27, 22, 0, -27 },
  { 2110, 16, 27, 13, -1, -27 },
  { 2164, 17, 35, 10, -6, -27 },
  { 2239, 23, 27, 19, 0, -27 },
  { 2317, 14, 27, 16, 0, -27 },
  { 2365, 29, 27, 29, 0, -27 },
  { 2463, 24, 27, 24, 0, -27 },
  { 2544, 20, 28, 23, 2, -28 },
  { 2614, 20, 27, 19, 0, -27 },
  { 2682, 20, 34, 23, 2, -28 },
  { 2767, 19, 27, 19, 0, -27 },
  { 2832, 18, 28, 17, 0, -28 },
  { 2895, 16, 27, 17, 3, -27 },
  { 2949, 21, 27, 22, 2, -27 },
  { 3020, 19, 27, 19, 3, -27 },
  { 3085, 29, 27, 29, 3, -27 },
  { 3183, 23, 27, 19, -2, -27 },
  { 3261, 18, 27, 18, 3, -27 },
  { 3322, 20, 27, 16, -1, -27 },
  { 3390, 15, 33, 11, -1, -27 },
  { 3452, 8, 27, 15, 4, -27 },
  { 3479, 16, 33, 11, -3, -27 },
  { 3545, 18, 17, 18, 0, -27 },
  { 3584, 14, 3, 13, -4, 3 },
  { 3590, 7, 6, 12, 6, -29 },
  { 3596, 18, 21, 19, 1, -21 },
  { 3644, 18, 29, 19, 0, -29 },
  { 3710, 15, 21, 15, 1, -21 },
  { 3750, 20, 29, 19, 1, -29 },
  { 3823, 16, 21, 18, 1, -21 },
  { 3865, 20, 38, 12, -4, -29 },
  { 3960, 20, 30, 19, -1, -21 },
  { 4035, 18, 29, 19, 0, -29 },
  { 4101, 11, 29, 10, 0, -29 },
  { 4141, 16, 38, 10, -5, -29 },
  { 4217, 20, 29, 18, 0, -29 },
  { 4290, 11, 29, 9, 0, -29 },
  { 4330, 27, 21, 28, 0, -21 },
  { 4401, 18, 21, 19, 0, -21 },
  { 4449, 16, 21, 19, 1, -21 },
  { 4491, 20, 30, 19, -2, -21 },
  { 4566, 18, 30, 19, 1, -21 },
  { 4634, 15, 21, 13, 0, -21 },
  { 4674, 15, 21, 15, 0, -21 },
  { 4714, 12, 25, 12, 2, -25 },
  { 4752, 18, 21, 19, 1, -21 },
  { 4800, 17, 21, 16, 2, -21 },
  { 4845, 25, 21, 25, 2, -21 },
  { 4911, 21, 21, 17, -2, -21 },
  { 4967, 22, 30, 17, -3, -21 },
  { 5050, 16, 21, 14, -1, -21 },
  { 5092, 16, 33, 13, 0, -27 },
  { 5158, 4, 38, 16, 6, -29 },
  { 5177, 15, 33, 13, -2, -27 },
  { 5239, 16, 7, 19, 2, -17 },
};

const GFXfont NotoSans_Condensed_BoldItalic38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BoldItalic38pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BoldItalic38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_CONDENSED_BOLDITALIC38PT7B_H_
