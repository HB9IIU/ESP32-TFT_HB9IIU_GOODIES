#ifndef _NOTOSANS_CONDENSED_BOLDITALIC39PT7B_H_
#define _NOTOSANS_CONDENSED_BOLDITALIC39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BoldItalic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BoldItalic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x0F, 0xC0,
  0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x07,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0x80, 0x7C, 0xFD, 0xF3, 0xE7, 0xCF,
  0x9E, 0x3E, 0x78, 0xF3, 0xE3, 0xCF, 0x8F, 0x3C, 0x7C, 0xF1, 0xE3, 0xC7,
  0x80, 0x00, 0x3C, 0x70, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xE1, 0xC0,
  0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x00, 0x3C, 0x78, 0x1F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x01,
  0xC3, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC0, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78,
  0xF0, 0x03, 0x87, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0E, 0x1C, 0x00,
  0xF1, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x1F,
  0x00, 0x1F, 0xFC, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0x91,
  0x81, 0xF6, 0x00, 0x3E, 0xC0, 0x07, 0xD8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x6F, 0xC0, 0x0D, 0xF8, 0x81, 0xBF, 0x10, 0x37, 0xC3, 0x8D, 0xF8,
  0x7F, 0xFF, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0xC0, 0x1E, 0x03, 0xF8,
  0x07, 0x81, 0xFF, 0x03, 0xC0, 0xFF, 0xC1, 0xE0, 0x3C, 0xF0, 0x78, 0x1E,
  0x3C, 0x3C, 0x07, 0x8F, 0x0F, 0x01, 0xE3, 0xC7, 0x80, 0xF0, 0xF3, 0xC0,
  0x3C, 0x78, 0xF0, 0x0F, 0x1E, 0x78, 0x03, 0xC7, 0x9E, 0x7C, 0xF3, 0xCF,
  0x3F, 0xBF, 0xF7, 0x9F, 0xFF, 0xF9, 0xEF, 0xFD, 0xFC, 0xF3, 0xCF, 0x3E,
  0x3D, 0xE3, 0xC0, 0x1E, 0x78, 0xF0, 0x0F, 0x1E, 0x3C, 0x03, 0xC7, 0x8F,
  0x01, 0xE3, 0xC3, 0xC0, 0x78, 0xF1, 0xE0, 0x3C, 0x3C, 0x78, 0x1E, 0x0F,
  0x1E, 0x07, 0x83, 0xEF, 0x03, 0xC0, 0x7F, 0x80, 0xF0, 0x1F, 0xE0, 0x78,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x0F, 0x00, 0x7C, 0x3C, 0x01, 0xF1, 0xF0,
  0x07, 0xC7, 0x80, 0x0F, 0xBE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE1, 0xF0, 0xFF, 0x87, 0xC7, 0xFF, 0x3E, 0x3F, 0x7C,
  0xF8, 0xF9, 0xFF, 0xC7, 0xC7, 0xFF, 0x1F, 0x0F, 0xF8, 0xFC, 0x3F, 0xE3,
  0xF0, 0x7F, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xF8, 0xFC, 0x7D, 0xF7, 0xDF, 0x7B, 0xEF,
  0xBC, 0xF3, 0xC0, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x03,
  0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xE0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0,
  0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x00, 0x01,
  0xD0, 0x01, 0xE0, 0x01, 0xE0, 0x41, 0xE0, 0x71, 0xE0, 0x7D, 0xC1, 0x7F,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0x07, 0xFF, 0x0F, 0xE0, 0x1F, 0xE0, 0x3E,
  0xF0, 0x7C, 0xF8, 0x3C, 0x78, 0x18, 0x7C, 0x00, 0x60, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x1F, 0x8F, 0x87, 0xC7, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0x78,
  0x7C, 0x00, 0x7F, 0xEF, 0xFD, 0xFF, 0x3F, 0xEF, 0xFC, 0x39, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xF0, 0xFD, 0xF8, 0xFC,
  0x7C, 0x7C, 0x3E, 0x7E, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xDF, 0x83, 0xEF,
  0x81, 0xF7, 0xC0, 0xFB, 0xE0, 0xFF, 0xF0, 0x7D, 0xF8, 0x3E, 0xF8, 0x1F,
  0x7C, 0x1F, 0xBE, 0x0F, 0x9F, 0x07, 0xCF, 0x87, 0xE7, 0xC3, 0xE3, 0xE3,
  0xF1, 0xFB, 0xF0, 0xFF, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x07, 0xF0, 0x00,
  0x00, 0xF8, 0x0F, 0xC0, 0xFE, 0x1F, 0xE1, 0xFF, 0x1F, 0xF9, 0xFF, 0xDF,
  0xBE, 0xFB, 0xE3, 0x9F, 0x08, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x7F,
  0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0xF0, 0x7E, 0xFE, 0x0F, 0x0F,
  0xC0, 0xC0, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xC3,
  0xFF, 0xF8, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC,
  0x1F, 0xFF, 0x07, 0x8F, 0xC0, 0x81, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x01, 0xFC, 0x03, 0xFE, 0x01, 0xFC,
  0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC8, 0x03, 0xE3, 0x83, 0xF8, 0xFF,
  0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x03, 0xFE, 0x00, 0xF7, 0xC0, 0x1C, 0xF0, 0x07, 0xBE, 0x01, 0xE7,
  0xC0, 0x78, 0xF8, 0x0F, 0x1F, 0x03, 0xC7, 0xC0, 0xF0, 0xF8, 0x1E, 0x1F,
  0x07, 0x83, 0xE1, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF,
  0xA0, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF,
  0xE0, 0x7F, 0xFC, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x80, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFE,
  0x07, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x20, 0x1F, 0x87, 0x8F, 0xF0,
  0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x1F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0x07, 0xF0, 0x81, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE7, 0xC0, 0xFF,
  0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0xC7, 0xF3, 0xF1, 0xF8, 0x7C, 0xFC, 0x1F,
  0x3F, 0x07, 0xCF, 0xC1, 0xF3, 0xE0, 0xFC, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F,
  0xC7, 0xE3, 0xF3, 0xF0, 0x7F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x7F,
  0x80, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x3F,
  0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFC, 0x7E, 0x1F, 0x0F, 0xC3, 0xE0,
  0xF8, 0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xF1, 0xF8, 0x3F, 0x7E, 0x03, 0xFF,
  0x80, 0x3F, 0xE0, 0x07, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0x3F,
  0x0F, 0xC3, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x8F, 0xC1, 0xF9, 0xF0, 0x3E,
  0x3F, 0x07, 0xC7, 0xE1, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xE0,
  0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE,
  0x0F, 0xCF, 0xC7, 0xE1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xCF,
  0xC1, 0xF3, 0xE0, 0xFC, 0xF8, 0x3F, 0x3F, 0x1F, 0xCF, 0xCF, 0xE3, 0xFF,
  0xF8, 0x7F, 0xFE, 0x1F, 0xEF, 0x83, 0xF7, 0xC0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC2, 0x07, 0xE0, 0xFF, 0xF8, 0x3F,
  0xFC, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0x03, 0x01, 0xE0, 0xFC, 0x3F, 0x1F,
  0x83, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x1F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3E, 0x00, 0x00, 0xC0,
  0x1E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x07,
  0x80, 0xF0, 0x00, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0x00,
  0x3F, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x00, 0xE0, 0x00, 0x10, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x80, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0,
  0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0x81, 0xFF, 0x01, 0xFE, 0x00, 0xFC, 0x00,
  0x78, 0x00, 0x30, 0x00, 0x10, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0xE7, 0xFF,
  0xCF, 0xFF, 0x38, 0xFC, 0x81, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0x3E,
  0x00, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x3E,
  0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x3E, 0x00,
  0x78, 0x0F, 0x80, 0x07, 0x83, 0xE0, 0x00, 0xF0, 0x78, 0x1C, 0x0E, 0x1E,
  0x1F, 0xF1, 0xC3, 0x87, 0xFE, 0x38, 0xF1, 0xF3, 0xC7, 0x9E, 0x3C, 0x78,
  0xE7, 0x8F, 0x0E, 0x1C, 0xF1, 0xE3, 0xC3, 0x9C, 0x78, 0x78, 0xF3, 0x8F,
  0x0F, 0x1E, 0xF1, 0xE1, 0xC3, 0x9E, 0x38, 0x78, 0x73, 0xC7, 0x0F, 0x1E,
  0x78, 0xF3, 0xE7, 0x8F, 0x1E, 0xFD, 0xF1, 0xE3, 0xFB, 0xFC, 0x3C, 0x3F,
  0x7F, 0x07, 0x81, 0x83, 0x80, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xDE, 0x00, 0x7D, 0xE0, 0x07,
  0xDE, 0x00, 0xF9, 0xE0, 0x0F, 0x9E, 0x00, 0xF1, 0xE0, 0x1F, 0x1E, 0x01,
  0xF1, 0xE0, 0x3E, 0x1E, 0x03, 0xE1, 0xE0, 0x7C, 0x1E, 0x07, 0xC1, 0xE0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xF0, 0x3F,
  0x3F, 0x03, 0xF3, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0x80, 0x3F, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F,
  0xFF, 0x07, 0xCF, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F,
  0xC1, 0xF0, 0xF8, 0x3F, 0x0F, 0x83, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x81,
  0xFF, 0xE0, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0x0F, 0xC3, 0xF0, 0x7C,
  0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0xFC, 0x7E, 0x0F,
  0xC7, 0xC3, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF,
  0xFC, 0x3F, 0x81, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0x07, 0xF9, 0xE0, 0x7F, 0xFC,
  0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xE1, 0xFC,
  0x1F, 0x07, 0xE0, 0xF8, 0x3F, 0x0F, 0xC0, 0xF8, 0x7E, 0x07, 0xC3, 0xE0,
  0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x8F, 0xC0, 0xFC, 0x7E, 0x07, 0xE3,
  0xE0, 0x3F, 0x1F, 0x01, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0xFC, 0x7C, 0x0F,
  0xC3, 0xE0, 0x7E, 0x1F, 0x07, 0xE1, 0xF8, 0x7F, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81,
  0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xF0,
  0x3F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF,
  0xBF, 0x0F, 0xE0, 0x10, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC3, 0xFE, 0x7E, 0x1F,
  0xF3, 0xF0, 0xFF, 0x9F, 0x87, 0xFC, 0xF8, 0x7F, 0xC7, 0xC0, 0x3E, 0x3E,
  0x01, 0xF1, 0xF0, 0x1F, 0x8F, 0x80, 0xFC, 0x7E, 0x07, 0xC3, 0xF0, 0x3E,
  0x1F, 0xE3, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x1F,
  0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07,
  0xE0, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x7E, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x0F, 0xC0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x3E,
  0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x03, 0xE0, 0x7E,
  0x07, 0xE0, 0x7C, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xFC,
  0x0F, 0xC0, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xFC, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x1F, 0xE0, 0x1F, 0xFC,
  0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x7E, 0x01, 0x3F, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03,
  0xF8, 0x00, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0xF8, 0x0F, 0x83, 0xF0, 0x3F,
  0x0F, 0xC0, 0x7C, 0x3F, 0x00, 0xF8, 0x7C, 0x01, 0xF1, 0xF8, 0x03, 0xE7,
  0xE0, 0x0F, 0xCF, 0x80, 0x1F, 0x3F, 0x00, 0x3E, 0xFC, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x7E, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03,
  0xE3, 0xF0, 0x07, 0xC7, 0xE0, 0x1F, 0x87, 0xC0, 0x3E, 0x0F, 0x80, 0x7C,
  0x1F, 0x80, 0xF8, 0x3F, 0x01, 0xF0, 0x3E, 0x07, 0xE0, 0x7E, 0x00, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x07, 0xE0, 0x1F, 0xFF, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE,
  0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xF0, 0x3F, 0x80, 0x3F, 0xC1,
  0xFE, 0x01, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F,
  0x80, 0xFF, 0x81, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x83, 0xFF, 0x03, 0xDE, 0x0F, 0x7C, 0x0F, 0x78, 0x7D,
  0xF0, 0x7D, 0xF1, 0xEF, 0x81, 0xF7, 0xCF, 0xBE, 0x07, 0xDF, 0x3C, 0xF8,
  0x1E, 0x7D, 0xF3, 0xE0, 0xF9, 0xF7, 0x8F, 0x83, 0xE7, 0xDE, 0x7C, 0x0F,
  0x8F, 0xF1, 0xF0, 0x3E, 0x3F, 0xC7, 0xC0, 0xF0, 0xFE, 0x1F, 0x07, 0xC3,
  0xF8, 0x78, 0x1F, 0x0F, 0xE3, 0xE0, 0x7C, 0x3F, 0x0F, 0x81, 0xF0, 0xFC,
  0x3E, 0x07, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x87, 0xC0, 0x03, 0xF0, 0x0F,
  0x81, 0xF8, 0x07, 0xC0, 0xFE, 0x03, 0xE0, 0xFF, 0x01, 0xE0, 0x7F, 0x81,
  0xF0, 0x3F, 0xC0, 0xF8, 0x1F, 0xE0, 0x7C, 0x0F, 0xF8, 0x3E, 0x0F, 0xFC,
  0x3E, 0x07, 0xFE, 0x1F, 0x03, 0xEF, 0x0F, 0x81, 0xE7, 0xC7, 0xC0, 0xF3,
  0xE3, 0xE0, 0xF9, 0xF3, 0xE0, 0x7C, 0xF9, 0xF0, 0x3E, 0x3C, 0xF8, 0x1E,
  0x1F, 0x7C, 0x1F, 0x0F, 0xBC, 0x0F, 0x87, 0xDE, 0x07, 0xC1, 0xFF, 0x03,
  0xE0, 0xFF, 0x81, 0xE0, 0x7F, 0xC1, 0xF0, 0x3F, 0xC0, 0xF8, 0x1F, 0xE0,
  0x7C, 0x07, 0xF0, 0x3E, 0x03, 0xF8, 0x1E, 0x01, 0xFC, 0x1F, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0xFF, 0x7F, 0x0F, 0xE1, 0xF8, 0x7E, 0x07, 0xE7, 0xE0, 0x3F, 0x3F, 0x01,
  0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x7E, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0xFF, 0xF0, 0x07, 0xDF, 0x80, 0x7E, 0xF8, 0x03, 0xF7, 0xC0, 0x1F,
  0xBE, 0x01, 0xF9, 0xF0, 0x0F, 0xCF, 0x80, 0xFC, 0x7E, 0x07, 0xE3, 0xF0,
  0x7E, 0x1F, 0xEF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xE0, 0xFC, 0x1F, 0x07, 0xE0, 0xF8, 0x3F,
  0x0F, 0xC1, 0xF8, 0x7C, 0x0F, 0xC3, 0xE0, 0x7C, 0x1F, 0x07, 0xE0, 0xF8,
  0x7F, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x01,
  0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFE, 0x00, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0x7F, 0x0F, 0xE1, 0xF8, 0x7E, 0x07, 0xE7,
  0xE0, 0x3F, 0x3F, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x7E, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xDF, 0x80, 0x7E, 0xF8,
  0x03, 0xF7, 0xC0, 0x1F, 0xBE, 0x01, 0xF9, 0xF0, 0x0F, 0xCF, 0x80, 0xFC,
  0x7E, 0x07, 0xE3, 0xF0, 0x7E, 0x1F, 0xEF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x07,
  0xDF, 0xF0, 0x7C, 0x3F, 0x07, 0xC3, 0xF0, 0x7C, 0x3F, 0x0F, 0xC3, 0xF0,
  0xF8, 0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x7E, 0x0F, 0x8F, 0xC1, 0xFF, 0xFC,
  0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xF3, 0xE0, 0x3E, 0x3E,
  0x03, 0xE3, 0xE0, 0x3E, 0x3F, 0x03, 0xE3, 0xF0, 0x7E, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x87, 0xC1, 0xF8, 0x7C, 0x0F, 0x8F, 0xC0, 0xFC, 0x00,
  0xFF, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F,
  0x83, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE1, 0x00, 0x7C, 0x30, 0x1F, 0x87, 0xDF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF,
  0x03, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF,
  0xDF, 0xFF, 0xEF, 0xFF, 0xF0, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC7,
  0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07,
  0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C,
  0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8,
  0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x81,
  0xF8, 0x7C, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0xCF, 0xE0, 0xFF, 0xFE, 0x03,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xF8, 0x07, 0xFF, 0x00,
  0xFB, 0xE0, 0x1F, 0x7C, 0x07, 0xEF, 0x80, 0xF9, 0xF0, 0x3F, 0x3E, 0x07,
  0xC7, 0xC1, 0xF8, 0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xE1, 0xF0, 0x7C, 0x3E,
  0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xFB, 0xF0,
  0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x7F, 0xE0, 0x3E, 0x03, 0xFF, 0x80,
  0xF8, 0x0F, 0xBE, 0x03, 0xE0, 0x7E, 0xF8, 0x1F, 0x81, 0xF3, 0xE0, 0x7E,
  0x07, 0xCF, 0x83, 0xF8, 0x3E, 0x3E, 0x0F, 0xE0, 0xF8, 0xF8, 0x3F, 0x83,
  0xE3, 0xE1, 0xFE, 0x1F, 0x0F, 0x87, 0xF8, 0x7C, 0x3E, 0x3F, 0xE3, 0xE0,
  0xF8, 0xF7, 0x8F, 0x83, 0xE7, 0xDE, 0x3E, 0x0F, 0x9E, 0x79, 0xF0, 0x3E,
  0x79, 0xE7, 0xC0, 0xFB, 0xE7, 0xBE, 0x03, 0xEF, 0x1E, 0xF8, 0x0F, 0xBC,
  0x7B, 0xE0, 0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x03, 0xFE, 0x1F,
  0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x00, 0xFE, 0x07, 0xF0,
  0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x01, 0xF0, 0x7E, 0x01, 0xF0, 0xFC,
  0x01, 0xF0, 0xF8, 0x01, 0xF9, 0xF8, 0x00, 0xF9, 0xF0, 0x00, 0xFB, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xEF, 0x80,
  0x07, 0xCF, 0x80, 0x0F, 0x8F, 0x80, 0x1F, 0x8F, 0x80, 0x1F, 0x0F, 0xC0,
  0x3F, 0x0F, 0xC0, 0x7E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x07, 0xE0,
  0xF8, 0x0F, 0xFE, 0x07, 0xEF, 0x81, 0xF3, 0xE0, 0xFC, 0xF8, 0x3E, 0x3E,
  0x1F, 0x87, 0xC7, 0xC1, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x7C, 0x07, 0xFF,
  0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x03, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x07, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x10, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3E, 0x00, 0x78,
  0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFE, 0x00, 0xF8, 0xF8, 0xF8, 0xF8, 0x78, 0x78, 0x78,
  0x7C, 0x7C, 0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3E, 0x3E, 0x3E, 0x3E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1F, 0x1F, 0x1F, 0x1F, 0x0F, 0x0F, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x7F, 0x80, 0x7F,
  0x80, 0x7F, 0x80, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xFC, 0x03,
  0xCF, 0x01, 0xE3, 0xC0, 0xF8, 0xF0, 0x3C, 0x3E, 0x1E, 0x07, 0x8F, 0x81,
  0xE3, 0xC0, 0x79, 0xF0, 0x1F, 0xF8, 0x03, 0xC0, 0x7F, 0xFD, 0xFF, 0xFF,
  0xFF, 0xC0, 0xF9, 0xF9, 0xF3, 0xE3, 0xE3, 0xC0, 0x01, 0xC0, 0x20, 0xFE,
  0x78, 0x3F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x7E, 0x3F, 0x8F, 0xC3,
  0xE3, 0xF0, 0x7C, 0x7E, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x7E, 0x7E, 0x0F,
  0x8F, 0xC1, 0xF1, 0xF0, 0x3E, 0x3E, 0x0F, 0xC7, 0xC1, 0xF0, 0xFC, 0x7E,
  0x1F, 0x9F, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFB, 0xC0, 0x7E, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC6, 0x01, 0xF7,
  0xF0, 0x3E, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0x8F, 0x87, 0xE1,
  0xF8, 0xF8, 0x3F, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03,
  0xE3, 0xE0, 0x7C, 0x7C, 0x1F, 0x8F, 0x83, 0xE3, 0xF0, 0xFC, 0x7E, 0x1F,
  0x0F, 0xC7, 0xE1, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F, 0xBF, 0xC1, 0xE3, 0xE0,
  0x00, 0x00, 0x78, 0x03, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F,
  0x84, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x10, 0xFC,
  0x30, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0xC7, 0xE0, 0x3F, 0x7C, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xF1, 0xFC, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x7E, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x1F, 0x0F, 0xC1, 0xF0, 0xFC,
  0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0xC7, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xBC, 0x03, 0xF3, 0xC0,
  0x00, 0x30, 0x03, 0xFE, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0x9F, 0x3F, 0x0F,
  0x3E, 0x0F, 0x7E, 0x1F, 0x7C, 0x1F, 0x7D, 0xFE, 0x7F, 0xFC, 0xFF, 0xF8,
  0xFF, 0xE0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x08,
  0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x30,
  0x08, 0x0F, 0xE7, 0x80, 0xFF, 0xBC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07,
  0xE3, 0xF8, 0x3F, 0x0F, 0x81, 0xF0, 0x7C, 0x1F, 0x83, 0xE0, 0xF8, 0x1F,
  0x07, 0xC1, 0xF8, 0x7E, 0x0F, 0x83, 0xF0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8,
  0x3F, 0x07, 0xC1, 0xF0, 0x3F, 0x1F, 0x81, 0xF9, 0xFC, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xEF, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x04, 0x01, 0xF0, 0x38, 0x1F, 0x81, 0xFF, 0xF8, 0x0F,
  0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xCE, 0x03, 0xEF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F,
  0xFF, 0xC3, 0xF1, 0xF1, 0xF8, 0x7C, 0x7E, 0x1F, 0x1F, 0x07, 0xC7, 0xC1,
  0xF3, 0xF0, 0xFC, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xF9,
  0xF8, 0x7E, 0x7C, 0x1F, 0x1F, 0x07, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0xF8,
  0x3E, 0x3E, 0x0F, 0x80, 0x00, 0xC0, 0x7C, 0x0F, 0x83, 0xF0, 0x7E, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x3F, 0x07,
  0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x83,
  0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0xC1, 0xF0, 0x00, 0x00, 0x06,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0xFF, 0x80, 0xFF, 0x00,
  0xFF, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x3F, 0x0F, 0x87, 0xE0, 0xF8, 0xFC, 0x0F, 0x8F,
  0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x01, 0xF7, 0xE0, 0x1F, 0xFC, 0x01, 0xEF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x3E,
  0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7E, 0x07, 0xC7, 0xE0, 0x7C, 0x3E, 0x07,
  0xC3, 0xE0, 0xF8, 0x3F, 0x0F, 0x81, 0xF0, 0x03, 0xF0, 0x3E, 0x03, 0xE0,
  0x3E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0x80,
  0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0xFC, 0x0F, 0x80, 0x00, 0x8E, 0x01, 0x00, 0xF3, 0xF8, 0xFC, 0x0F,
  0x7F, 0x9F, 0xE0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFC, 0x7E,
  0x3F, 0x1F, 0x87, 0xE1, 0xF1, 0xF0, 0x7C, 0x3F, 0x1F, 0x07, 0xC3, 0xE1,
  0xF0, 0xF8, 0x3E, 0x3E, 0x0F, 0x83, 0xE3, 0xE0, 0xF8, 0x3E, 0x3E, 0x0F,
  0x87, 0xE3, 0xE0, 0xF8, 0x7C, 0x3E, 0x1F, 0x07, 0xC7, 0xC1, 0xF0, 0x7C,
  0x7C, 0x1F, 0x07, 0xC7, 0xC1, 0xF0, 0xF8, 0x7C, 0x1F, 0x0F, 0x87, 0xC3,
  0xE0, 0xF8, 0xF8, 0x3E, 0x0F, 0x8F, 0x83, 0xE1, 0xF8, 0x00, 0x06, 0x03,
  0xC7, 0xE0, 0xF7, 0xFC, 0x3D, 0xFF, 0x0F, 0xFF, 0xC3, 0xF1, 0xF1, 0xF8,
  0x7C, 0x7E, 0x1F, 0x1F, 0x07, 0xC7, 0xC1, 0xF3, 0xF0, 0x7C, 0xF8, 0x3E,
  0x3E, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xF9, 0xF8, 0x7E, 0x7C, 0x1F, 0x1F,
  0x07, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0xF8, 0x3E, 0x3E, 0x0F, 0x80, 0x00,
  0xF0, 0x01, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xF1, 0xF8, 0xFC,
  0xF8, 0x3E, 0xFC, 0x1F, 0x7C, 0x0F, 0xBE, 0x07, 0xDF, 0x03, 0xFF, 0x83,
  0xFF, 0x81, 0xF7, 0xC0, 0xFB, 0xE0, 0x7D, 0xF0, 0x7E, 0xF8, 0x3E, 0x7E,
  0x3F, 0x1F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0x80, 0x1E, 0x7F, 0x00, 0xF7, 0xFC, 0x07, 0xBF, 0xE0, 0x3F, 0xFF, 0x01,
  0xF8, 0xF8, 0x1F, 0x87, 0xE0, 0xF8, 0x3F, 0x07, 0xC1, 0xF0, 0x3E, 0x0F,
  0x83, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC1, 0xF8, 0x3E,
  0x0F, 0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xC0, 0xFC, 0x7E, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x03, 0xEF, 0xF0, 0x1F, 0x3F, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x20, 0x7E,
  0x78, 0x1F, 0xEF, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x7E, 0x3F, 0x8F, 0x83,
  0xE1, 0xF0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3C, 0x7E, 0x0F,
  0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC1, 0xF0, 0xF8, 0x3E,
  0x1F, 0x8F, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0x7E, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0x0F, 0xBE, 0x0F, 0xBE, 0x0F, 0x7E, 0x0F, 0xFC, 0x1F, 0xFC, 0x1F, 0xC0,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x07, 0xFE, 0x0F, 0xFF,
  0x1F, 0xFE, 0x1F, 0xBC, 0x3F, 0x04, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0xF8, 0x80, 0xF8, 0xC1, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0,
  0x7F, 0xC0, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x1F, 0x03, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xE3, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFF,
  0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0x1F, 0x07, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C,
  0x7C, 0x1F, 0x3E, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E,
  0x1F, 0x9F, 0x07, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x0F,
  0x8F, 0x83, 0xE3, 0xE1, 0xF8, 0xFC, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xC1,
  0xFE, 0xF0, 0x3F, 0x3C, 0x00, 0xF8, 0x1F, 0xFC, 0x0F, 0xBE, 0x07, 0xDF,
  0x07, 0xCF, 0x83, 0xE3, 0xC3, 0xE1, 0xE1, 0xF0, 0xF1, 0xF0, 0x78, 0xF8,
  0x3C, 0xF8, 0x1E, 0x7C, 0x0F, 0x3C, 0x07, 0xBE, 0x03, 0xDE, 0x01, 0xFF,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xE0, 0x00, 0xF8, 0x3F, 0x07, 0xFE, 0x0F, 0xC3, 0xEF, 0x87, 0xF0, 0xFB,
  0xE1, 0xFC, 0x7C, 0xF8, 0xFF, 0x1F, 0x3E, 0x3F, 0xC7, 0xCF, 0x8F, 0xF3,
  0xE3, 0xE7, 0xBC, 0xF8, 0xF9, 0xEF, 0x7C, 0x3E, 0xF3, 0xDF, 0x0F, 0xBC,
  0xF7, 0x83, 0xEF, 0x3F, 0xE0, 0xFF, 0x8E, 0xF8, 0x3F, 0xE3, 0xBC, 0x0F,
  0xF1, 0xFF, 0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x1F, 0xE0, 0x3F, 0x87, 0xF0,
  0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x07,
  0xC1, 0xF8, 0x3F, 0x1F, 0x80, 0xF8, 0xF8, 0x07, 0xCF, 0x80, 0x3E, 0xFC,
  0x01, 0xF7, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x01, 0xF7, 0xC0, 0x1F, 0x3F, 0x01, 0xF8, 0xF8, 0x0F, 0x87,
  0xC0, 0xFC, 0x3E, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xC0, 0xFC, 0x1F, 0x03,
  0xE0, 0x3C, 0x0F, 0x80, 0xF0, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x8F, 0x80,
  0x3E, 0x3E, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9E, 0x00, 0x3E,
  0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0x83, 0xFF,
  0xC1, 0xFF, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF,
  0x0F, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x01,
  0xFE, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x1F, 0xC0, 0x7F, 0x80, 0x7E,
  0x00, 0x7C, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x07, 0xE0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x7E, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFC, 0x07, 0xF2,
  0x00, 0x00,
};

const GFXglyph NotoSans_Condensed_BoldItalic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 12, 28, 10, 0, -28 },
  { 43, 14, 10, 16, 4, -28 },
  { 61, 21, 28, 21, 0, -28 },
  { 135, 19, 32, 18, 0, -30 },
  { 211, 26, 28, 29, 2, -28 },
  { 302, 22, 28, 22, 0, -28 },
  { 379, 6, 10, 10, 4, -28 },
  { 387, 13, 34, 11, 1, -28 },
  { 443, 14, 34, 11, -3, -28 },
  { 503, 16, 17, 18, 3, -30 },
  { 537, 17, 19, 19, 2, -23 },
  { 578, 9, 10, 10, -2, -5 },
  { 590, 11, 5, 12, 0, -13 },
  { 597, 6, 6, 10, 0, -6 },
  { 602, 20, 28, 15, -2, -28 },
  { 672, 17, 28, 18, 1, -28 },
  { 732, 13, 28, 18, 4, -28 },
  { 778, 19, 28, 18, -1, -28 },
  { 845, 18, 28, 18, 0, -28 },
  { 908, 19, 28, 18, -1, -28 },
  { 975, 19, 28, 18, 0, -28 },
  { 1042, 18, 28, 18, 1, -28 },
  { 1105, 19, 28, 18, 1, -28 },
  { 1172, 19, 28, 18, 0, -28 },
  { 1239, 18, 28, 18, 0, -28 },
  { 1302, 10, 22, 10, 0, -22 },
  { 1330, 12, 27, 10, -2, -22 },
  { 1371, 17, 20, 19, 2, -24 },
  { 1414, 17, 12, 19, 2, -20 },
  { 1440, 17, 20, 19, 2, -24 },
  { 1483, 14, 28, 15, 2, -28 },
  { 1532, 27, 31, 28, 1, -28 },
  { 1637, 20, 28, 20, -2, -28 },
  { 1707, 20, 28, 20, 0, -28 },
  { 1777, 19, 28, 19, 2, -28 },
  { 1844, 21, 28, 22, 0, -28 },
  { 1918, 19, 28, 17, 0, -28 },
  { 1985, 19, 28, 17, 0, -28 },
  { 2052, 21, 28, 22, 2, -28 },
  { 2126, 24, 28, 23, 0, -28 },
  { 2210, 18, 28, 13, -2, -28 },
  { 2273, 18, 36, 11, -6, -28 },
  { 2354, 23, 28, 20, 0, -28 },
  { 2435, 14, 28, 17, 0, -28 },
  { 2484, 30, 28, 29, 0, -28 },
  { 2589, 25, 28, 24, 0, -28 },
  { 2677, 21, 28, 23, 2, -28 },
  { 2751, 21, 28, 20, 0, -28 },
  { 2825, 21, 35, 23, 2, -28 },
  { 2917, 20, 28, 20, 0, -28 },
  { 2987, 19, 28, 17, 0, -28 },
  { 3054, 17, 28, 17, 3, -28 },
  { 3114, 21, 28, 22, 2, -28 },
  { 3188, 19, 28, 20, 4, -28 },
  { 3255, 30, 28, 30, 3, -28 },
  { 3360, 24, 28, 19, -2, -28 },
  { 3444, 18, 28, 18, 4, -28 },
  { 3507, 20, 28, 17, -1, -28 },
  { 3577, 15, 34, 12, -1, -28 },
  { 3641, 8, 28, 15, 4, -28 },
  { 3669, 16, 34, 12, -3, -28 },
  { 3737, 18, 17, 18, 0, -28 },
  { 3776, 14, 3, 14, -4, 3 },
  { 3782, 7, 6, 12, 6, -30 },
  { 3788, 19, 22, 20, 1, -22 },
  { 3841, 19, 30, 20, 0, -30 },
  { 3913, 16, 22, 16, 1, -22 },
  { 3957, 20, 30, 20, 1, -30 },
  { 4032, 16, 22, 18, 1, -22 },
  { 4076, 20, 39, 12, -4, -30 },
  { 4174, 21, 31, 20, -1, -22 },
  { 4256, 18, 30, 20, 0, -30 },
  { 4324, 11, 30, 10, 0, -30 },
  { 4366, 16, 39, 10, -5, -30 },
  { 4444, 20, 30, 18, 0, -30 },
  { 4519, 12, 30, 10, 0, -30 },
  { 4564, 28, 22, 29, 0, -22 },
  { 4641, 18, 22, 20, 0, -22 },
  { 4691, 17, 22, 19, 1, -22 },
  { 4738, 21, 31, 20, -2, -22 },
  { 4820, 19, 31, 20, 1, -22 },
  { 4894, 16, 22, 14, 0, -22 },
  { 4938, 16, 22, 15, 0, -22 },
  { 4982, 12, 26, 13, 2, -26 },
  { 5021, 18, 21, 19, 1, -21 },
  { 5069, 17, 21, 17, 2, -21 },
  { 5114, 26, 21, 26, 2, -21 },
  { 5183, 21, 21, 17, -2, -21 },
  { 5239, 22, 30, 17, -3, -21 },
  { 5322, 17, 21, 15, -1, -21 },
  { 5367, 16, 34, 13, 0, -28 },
  { 5435, 4, 39, 17, 6, -30 },
  { 5455, 15, 34, 13, -2, -28 },
  { 5519, 17, 7, 19, 2, -17 },
};

const GFXfont NotoSans_Condensed_BoldItalic39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BoldItalic39pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BoldItalic39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_CONDENSED_BOLDITALIC39PT7B_H_
