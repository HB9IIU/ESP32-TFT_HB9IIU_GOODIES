#ifndef _NOTOSANS_CONDENSED_BOLDITALIC36PT7B_H_
#define _NOTOSANS_CONDENSED_BOLDITALIC36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BoldItalic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BoldItalic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x3E,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x00, 0x3E, 0xF9, 0xE7, 0xDF, 0x3E, 0xF9, 0xE7, 0x8F, 0x3C, 0x79, 0xE3,
  0xCF, 0x3C, 0x71, 0xE7, 0x8F, 0x00, 0x00, 0x71, 0xE0, 0x07, 0x1C, 0x00,
  0xF1, 0xC0, 0x0E, 0x3C, 0x00, 0xE3, 0xC0, 0x1E, 0x38, 0x01, 0xE7, 0x81,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x38, 0xE0,
  0x07, 0x8E, 0x00, 0x71, 0xE0, 0x07, 0x1C, 0x07, 0xFF, 0xFC, 0x7F, 0xFF,
  0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x81, 0xE3, 0x80, 0x1C, 0x78, 0x01, 0xC7,
  0x00, 0x3C, 0x70, 0x03, 0x8F, 0x00, 0x38, 0xE0, 0x07, 0x8E, 0x00, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0F, 0x00, 0x3F, 0xF0, 0x7F, 0xF8, 0x7F, 0xF8,
  0x3F, 0xFC, 0x1E, 0x44, 0x1F, 0x60, 0x0F, 0xB0, 0x07, 0xF8, 0x01, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00,
  0x5F, 0x00, 0x6F, 0x88, 0x37, 0xC6, 0x1B, 0xE3, 0xFF, 0xF3, 0xFF, 0xF1,
  0xFF, 0xF0, 0x7F, 0xF0, 0x03, 0xC0, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x0F, 0x80, 0x38, 0x1F, 0xC0, 0x78, 0x3F, 0xC0, 0xF0, 0x3D, 0xE0,
  0xF0, 0x79, 0xE1, 0xE0, 0x79, 0xE1, 0xC0, 0x71, 0xE3, 0xC0, 0xF1, 0xE7,
  0x80, 0xF1, 0xC7, 0x80, 0xF3, 0xCF, 0x00, 0xF3, 0xCE, 0x3C, 0xE3, 0x9E,
  0x7E, 0xF7, 0xBC, 0xFE, 0xFF, 0x39, 0xEF, 0x7F, 0x7B, 0xCF, 0x3C, 0x73,
  0xCF, 0x00, 0xF3, 0x8F, 0x01, 0xE7, 0x8F, 0x01, 0xC7, 0x8F, 0x03, 0xC7,
  0x8E, 0x03, 0x87, 0x9E, 0x07, 0x87, 0x9E, 0x0F, 0x07, 0xBC, 0x0E, 0x07,
  0xFC, 0x1E, 0x03, 0xF8, 0x3C, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xC7, 0x80, 0x7C, 0x78, 0x07, 0x8F,
  0x80, 0x78, 0xF0, 0x07, 0xDF, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0xF0, 0xFF, 0x1F, 0x1F, 0xF9, 0xF3, 0xEF, 0x9E, 0x7C,
  0xFF, 0xE7, 0xC7, 0xFC, 0xF8, 0x7F, 0xCF, 0x83, 0xF8, 0xF8, 0x3F, 0x0F,
  0xC7, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0xC1, 0xFC, 0x7E,
  0x7D, 0xE7, 0xBE, 0xFB, 0xCF, 0x3C, 0xE3, 0x80, 0x00, 0xF0, 0x1E, 0x03,
  0xE0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3C,
  0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF8, 0x07, 0x80, 0x78, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07,
  0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0x00,
  0x02, 0x20, 0x0F, 0x00, 0x3C, 0x10, 0xF0, 0x63, 0xC1, 0xEE, 0x1F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFC, 0x3F, 0x31, 0xFC, 0x0F, 0xF8, 0x7D, 0xE0, 0xE3,
  0xC1, 0x0F, 0x00, 0x30, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x1F, 0x1F, 0x1F, 0x3E, 0x3E, 0x3C, 0x7C, 0x78, 0x78, 0xF0, 0x7F, 0xDF,
  0xF7, 0xFD, 0xFE, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0xBF, 0x1F, 0x1F, 0x3E,
  0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1E, 0x78,
  0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8,
  0x7C, 0xF0, 0xF8, 0xF8, 0xF8, 0xF9, 0xF0, 0xFF, 0xF0, 0x7F, 0xE0, 0x7F,
  0xC0, 0x3F, 0x80, 0x00, 0xF8, 0x0F, 0xC0, 0xFC, 0x0F, 0xE1, 0xFF, 0x1F,
  0xF9, 0xFF, 0x9F, 0xBC, 0x73, 0xE1, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x7F, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x07, 0xCF, 0xC1, 0xC1, 0xF0,
  0x20, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x00, 0x01, 0xFC, 0x03,
  0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xF0, 0x71, 0xF8, 0x20, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0xFF, 0x80, 0x7F,
  0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC4, 0x07, 0xE3, 0xFF, 0xE1, 0xFF, 0xF0,
  0xFF, 0xF0, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xDE,
  0x01, 0xDF, 0x01, 0xEF, 0x81, 0xE7, 0xC0, 0xE3, 0xC0, 0xF1, 0xE0, 0xF1,
  0xF0, 0xF0, 0xF8, 0x78, 0x7C, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xCF,
  0xFF, 0xE0, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x03, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF0,
  0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xFE,
  0x03, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC8, 0x07, 0xC6, 0x07, 0xE3,
  0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x30, 0x1F, 0x7E, 0x0F, 0xFF, 0x87, 0xFF,
  0xC3, 0xFB, 0xF3, 0xF0, 0xF9, 0xF8, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x3E,
  0x1F, 0x1F, 0x0F, 0x8F, 0x87, 0xC7, 0xC7, 0xC1, 0xFF, 0xE0, 0xFF, 0xE0,
  0x3F, 0xE0, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0xC7, 0xFF, 0xE1, 0xFF, 0xF8,
  0x7F, 0xFE, 0x3F, 0xFF, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0xE1, 0xFF,
  0xF0, 0xF8, 0xF8, 0x78, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x0F, 0x0F, 0x87,
  0xCF, 0x83, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0x00, 0x7F, 0xC0, 0x7F, 0xF0,
  0x7C, 0xF8, 0x7C, 0x3E, 0x3E, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x83,
  0xE7, 0xE1, 0xF1, 0xFB, 0xF0, 0xFF, 0xF0, 0x3F, 0xF0, 0x0F, 0xF0, 0x00,
  0x00, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0xF9, 0xF0, 0xF8,
  0x7C, 0x7C, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0x9F, 0x0F, 0xCF, 0x87, 0xC7,
  0xC3, 0xE3, 0xE3, 0xF1, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xBC, 0x0F, 0xBE,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC3, 0xFF,
  0xC1, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0x80, 0x00, 0x07, 0x07, 0xC7, 0xE3,
  0xF1, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x00, 0x01, 0xC0, 0x7C, 0x1F, 0x83,
  0xF0, 0x7C, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xC0,
  0xF8, 0x1E, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xF8,
  0x07, 0xF0, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0x80, 0xFC, 0x01, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0x80, 0x1F,
  0x00, 0x0E, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x07, 0xF8, 0x7F, 0xC3,
  0xFE, 0x1F, 0xF0, 0x3F, 0x80, 0x7C, 0x00, 0xE0, 0x01, 0x00, 0x00, 0x07,
  0xE0, 0x7F, 0xE3, 0xFF, 0x8F, 0xFF, 0x18, 0x7C, 0x41, 0xF0, 0x07, 0xC0,
  0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3C, 0x01,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0x1E,
  0x07, 0x80, 0x0F, 0x0F, 0x00, 0x07, 0x1E, 0x1F, 0xC7, 0x1C, 0x3F, 0xE7,
  0x3C, 0x7F, 0xC7, 0x38, 0xF1, 0xC7, 0x78, 0xE3, 0xC7, 0x71, 0xE3, 0xC7,
  0x71, 0xC3, 0x87, 0xF3, 0xC3, 0x8F, 0xF3, 0xC7, 0x8E, 0xE3, 0xC7, 0x8E,
  0xE3, 0xC7, 0x1E, 0xE3, 0xCF, 0x1C, 0xE3, 0xFF, 0xF8, 0xE1, 0xFB, 0xF0,
  0xF0, 0xF1, 0xE0, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3E, 0x03, 0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3B, 0xC0,
  0x1E, 0xF0, 0x07, 0xBC, 0x03, 0xEF, 0x00, 0xF3, 0xC0, 0x7C, 0xF0, 0x1E,
  0x3C, 0x0F, 0x8F, 0x03, 0xE3, 0xC1, 0xF0, 0xF0, 0x7C, 0x3C, 0x1F, 0xFF,
  0x0F, 0xFF, 0xC3, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x3E, 0x07, 0xCF,
  0x81, 0xF7, 0xC0, 0x3D, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7C, 0xFE, 0x0F,
  0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x87, 0xC1, 0xE0, 0xF8, 0x7C,
  0x7E, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xC1, 0xF0,
  0xFC, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x3E, 0x1E, 0x07, 0xC7, 0xC1,
  0xF0, 0xF8, 0x7E, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xC7,
  0x07, 0xE0, 0x43, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3F, 0x06, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF,
  0xE0, 0x7C, 0x7E, 0x0F, 0x83, 0xF0, 0xF8, 0x3F, 0x0F, 0x81, 0xF0, 0xF8,
  0x1F, 0x1F, 0x03, 0xF1, 0xF0, 0x3F, 0x1F, 0x03, 0xE1, 0xF0, 0x3E, 0x1F,
  0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x07, 0xE3, 0xE0, 0x7C, 0x3E, 0x0F, 0xC3,
  0xE1, 0xF8, 0x7C, 0x3F, 0x87, 0xCF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0,
  0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF8,
  0x1F, 0xFE, 0x07, 0xFF, 0x81, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7F, 0xF8, 0x1F, 0xFC, 0x07, 0xFF,
  0x01, 0xFF, 0xC0, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F,
  0xF0, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF,
  0xF0, 0x7F, 0xF8, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x07, 0xE0, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0,
  0x7F, 0xF8, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0x87, 0xFF, 0xE0, 0xFE, 0x3C,
  0x3F, 0x00, 0x8F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x2F, 0x87, 0xF9, 0xF0, 0xFF, 0x3E, 0x1F, 0xE7,
  0xC3, 0xFC, 0xF8, 0x0F, 0x9F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F,
  0x81, 0xF1, 0xF8, 0x3E, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFE, 0x03,
  0xFF, 0x00, 0x03, 0xE0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0x80, 0xF8, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x7C, 0x07, 0xC1,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xE0,
  0x7E, 0x00, 0x07, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x03, 0xF8, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x03, 0xC0, 0xFC, 0x1F, 0x07,
  0xE0, 0x7C, 0x1F, 0x01, 0xF0, 0xF8, 0x07, 0xC7, 0xE0, 0x1E, 0x3F, 0x00,
  0xF8, 0xF8, 0x03, 0xE7, 0xC0, 0x0F, 0xBF, 0x00, 0x3C, 0xF8, 0x01, 0xF7,
  0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x0F,
  0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F,
  0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xFF, 0xEF, 0xFF, 0x7F, 0xF7,
  0xFF, 0x80, 0x03, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x0F,
  0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x01, 0xFE, 0x0F,
  0xF0, 0x3F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7B, 0xC0, 0xFF, 0x07,
  0xFC, 0x1F, 0x70, 0xFF, 0xC1, 0xF7, 0x0F, 0x7C, 0x1F, 0x70, 0xF7, 0x81,
  0xE7, 0x9E, 0x78, 0x1E, 0x79, 0xEF, 0x83, 0xE7, 0xBC, 0xF8, 0x3E, 0x7B,
  0xCF, 0x03, 0xC7, 0xF8, 0xF0, 0x3C, 0x7F, 0x9F, 0x03, 0xC7, 0xF1, 0xF0,
  0x7C, 0x7F, 0x1F, 0x07, 0xC7, 0xE1, 0xE0, 0x78, 0x7E, 0x1E, 0x07, 0x87,
  0xC3, 0xE0, 0x78, 0x7C, 0x3E, 0x0F, 0x87, 0xC3, 0xE0, 0x03, 0xE0, 0x1E,
  0x0F, 0xC0, 0x7C, 0x1F, 0xC0, 0xF8, 0x3F, 0x81, 0xF0, 0x7F, 0x03, 0xC0,
  0xFE, 0x07, 0x83, 0xFC, 0x1F, 0x07, 0xFC, 0x3E, 0x0F, 0x78, 0x78, 0x1E,
  0xF0, 0xF0, 0x7D, 0xE3, 0xE0, 0xFB, 0xE7, 0xC1, 0xF7, 0xCF, 0x83, 0xC7,
  0x9E, 0x07, 0x8F, 0x3C, 0x1F, 0x1E, 0x78, 0x3E, 0x3F, 0xF0, 0x78, 0x7F,
  0xE0, 0xF0, 0x7F, 0x81, 0xE0, 0xFF, 0x07, 0xC1, 0xFE, 0x0F, 0x83, 0xFC,
  0x1E, 0x03, 0xF8, 0x3C, 0x07, 0xE0, 0x78, 0x0F, 0xC1, 0xF0, 0x1F, 0x80,
  0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xFC, 0xFC,
  0x3E, 0x0F, 0xCF, 0xC0, 0xF9, 0xF0, 0x1F, 0x7E, 0x03, 0xEF, 0x80, 0x7D,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xF7,
  0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x01, 0xFB, 0xE0, 0x3E, 0x7C, 0x0F, 0xCF,
  0x83, 0xF1, 0xF8, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xF8, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0,
  0x7F, 0xFE, 0x0F, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE1,
  0xF0, 0x7C, 0x7C, 0x1F, 0x8F, 0x83, 0xE1, 0xF3, 0xFC, 0x3F, 0xFF, 0x07,
  0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xF0, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07,
  0xFF, 0xE1, 0xFC, 0xFC, 0x3F, 0x0F, 0xCF, 0xC0, 0xF9, 0xF0, 0x1F, 0x7E,
  0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x0F, 0xFE, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x0F, 0xDF, 0x01, 0xFB, 0xE0,
  0x3E, 0x7C, 0x0F, 0xCF, 0x83, 0xF1, 0xF8, 0xFE, 0x3F, 0xFF, 0x83, 0xFF,
  0xE0, 0x3F, 0xF8, 0x03, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x03, 0xF8, 0x01, 0xFF,
  0xC0, 0x7F, 0xF8, 0x1F, 0xFF, 0x07, 0xCF, 0xC1, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF1, 0xF0, 0xFC, 0x7C, 0x7E, 0x1F,
  0xFF, 0x87, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0x3E, 0x7C, 0x0F, 0x9F,
  0x03, 0xE7, 0xC0, 0xF0, 0xF0, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xFC, 0x78, 0x1F, 0x3E, 0x07, 0xC0, 0x00, 0xFE, 0x01, 0xFF, 0xC1,
  0xFF, 0xE1, 0xFF, 0xF0, 0xFE, 0xF0, 0xFC, 0x08, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x88, 0x07, 0xC7, 0x0F, 0xE3, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xE0,
  0x3F, 0xE0, 0x00, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE1, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0xFC, 0x01, 0xF0, 0x00, 0x1F, 0x83, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F,
  0x81, 0xF1, 0xF0, 0x3E, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3E,
  0x07, 0xC7, 0xC0, 0xF9, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xF8,
  0x1F, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xE0,
  0x7C, 0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0xFC, 0x3F, 0xFF, 0x07, 0xFF,
  0xC0, 0x7F, 0xF0, 0x03, 0xFC, 0x00, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0xFB, 0xE0, 0x3E, 0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xE3, 0xE0, 0xF8,
  0x78, 0x3E, 0x1E, 0x1F, 0x07, 0x87, 0xC1, 0xE3, 0xE0, 0x78, 0xF8, 0x1E,
  0x7C, 0x07, 0x9F, 0x01, 0xE7, 0x80, 0x7B, 0xE0, 0x1E, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x0F, 0x01, 0xFF, 0x03, 0xE0, 0x7F,
  0xE0, 0x7C, 0x0F, 0xFC, 0x1F, 0x83, 0xEF, 0x83, 0xF0, 0x7D, 0xF0, 0x7E,
  0x0F, 0x3E, 0x1F, 0xC3, 0xE7, 0xC3, 0xF8, 0x7C, 0xF8, 0xFF, 0x1F, 0x1F,
  0x1F, 0xE3, 0xE3, 0xE3, 0xBC, 0x78, 0x7C, 0xF7, 0x9F, 0x0F, 0x9E, 0xF3,
  0xE1, 0xF7, 0x9E, 0x78, 0x3C, 0xF3, 0xDF, 0x07, 0x9E, 0x7B, 0xC0, 0xF7,
  0x8F, 0xF8, 0x1E, 0xF1, 0xFF, 0x03, 0xFC, 0x3B, 0xC0, 0x7F, 0x87, 0xF8,
  0x0F, 0xF0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xE0,
  0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF0, 0x00, 0x03, 0xE0, 0x7C,
  0x0F, 0x83, 0xF0, 0x3E, 0x0F, 0x80, 0x78, 0x7C, 0x01, 0xF1, 0xF0, 0x07,
  0xCF, 0x80, 0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0x78, 0x00, 0x7D,
  0xF0, 0x03, 0xE7, 0xC0, 0x1F, 0x9F, 0x00, 0x7C, 0x7C, 0x03, 0xE0, 0xF8,
  0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0x3E, 0x00, 0xF8, 0x0F, 0xFC,
  0x0F, 0x9E, 0x07, 0xCF, 0x87, 0xC7, 0xC3, 0xE3, 0xE3, 0xE1, 0xF3, 0xE0,
  0xF9, 0xF0, 0x3D, 0xF0, 0x1E, 0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF,
  0x03, 0xFF, 0xE0, 0x80, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x04, 0x3F, 0xFF, 0x07,
  0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xF1, 0xE3, 0xC7, 0x8F, 0x1F, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xC7, 0xCF, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xF3, 0xE3, 0xC7, 0x8F,
  0x1E, 0x3C, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0,
  0x7F, 0x80, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F,
  0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0x38, 0x07, 0x9E, 0x07, 0x8F, 0x03,
  0xC7, 0x83, 0xC1, 0xC3, 0xC0, 0xF1, 0xE0, 0x79, 0xE0, 0x3D, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFC, 0xFC, 0xF9, 0xF1, 0xE1, 0xE3, 0xC0, 0x03,
  0xC7, 0x87, 0xF3, 0xC7, 0xFF, 0xE3, 0xFF, 0xE3, 0xF3, 0xF1, 0xF0, 0xF9,
  0xF8, 0x7C, 0xF8, 0x3E, 0x7C, 0x1E, 0x7C, 0x1F, 0x3E, 0x0F, 0x9F, 0x07,
  0xCF, 0x83, 0xE7, 0xC3, 0xE3, 0xE1, 0xF1, 0xF1, 0xF8, 0xFF, 0xFC, 0x7F,
  0xFC, 0x1F, 0xDE, 0x07, 0xCF, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x3C, 0x0F,
  0xFF, 0x07, 0xFF, 0x87, 0xFF, 0xE3, 0xF1, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C,
  0x78, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x07, 0xC7, 0x83,
  0xE7, 0xC1, 0xF3, 0xE1, 0xF1, 0xF8, 0xF8, 0xFF, 0xF8, 0x7F, 0xFC, 0x7B,
  0xFC, 0x3C, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0xF0, 0xFF, 0xC7, 0xFE, 0x3F,
  0x08, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x08, 0xFF, 0xE1, 0xFF, 0x87,
  0xFE, 0x07, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x1E, 0x7C, 0x07, 0xEF,
  0x81, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0x9F, 0x83, 0xE1, 0xF0, 0xF8, 0x3E,
  0x1F, 0x07, 0xC3, 0xE0, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xE0, 0xF8,
  0x7C, 0x1E, 0x0F, 0x83, 0xC1, 0xF0, 0xF8, 0x3E, 0x3F, 0x07, 0xFF, 0xE0,
  0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xF9, 0xE0, 0x00, 0x01, 0xF0, 0x0F, 0xF8,
  0x3F, 0xF8, 0xFF, 0xF3, 0xE1, 0xE7, 0xC3, 0xDF, 0x0F, 0xBE, 0x1F, 0x7B,
  0xFD, 0xFF, 0xF3, 0xFF, 0xC7, 0xF8, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x04, 0xFC, 0x70, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0x00, 0x03,
  0x00, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xE3, 0xC1, 0xFC, 0xF0, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F,
  0x9F, 0x87, 0xC7, 0xE3, 0xF0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x1F, 0x07,
  0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF1, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x03, 0xFB, 0xC0, 0x7D, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x82, 0x03, 0xE0, 0xE3, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F,
  0x3C, 0x0F, 0x7F, 0x07, 0xFF, 0xC3, 0xFF, 0xE3, 0xF3, 0xF1, 0xF8, 0xF8,
  0xF8, 0x7C, 0x7C, 0x3E, 0x7C, 0x1E, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0x87,
  0xC7, 0x83, 0xE7, 0xC1, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0x78,
  0x3E, 0x7C, 0x1E, 0x3E, 0x1F, 0x00, 0x03, 0xC1, 0xF0, 0x7C, 0x1F, 0x03,
  0x80, 0x00, 0x00, 0x3E, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x78, 0x3E, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0,
  0x03, 0xE0, 0x7F, 0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x3F, 0x0F, 0x87, 0xC1, 0xE1, 0xF0,
  0x3C, 0x7C, 0x0F, 0x9F, 0x01, 0xF7, 0xC0, 0x3C, 0xF8, 0x07, 0xBE, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x07,
  0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x1F, 0x03, 0xC3, 0xE0, 0x78, 0x7C, 0x1F,
  0x0F, 0x83, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x78, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x3E, 0x1F, 0x03, 0xDF,
  0xCF, 0xE0, 0xFF, 0xF7, 0xF8, 0x7F, 0xFF, 0xFF, 0x1F, 0x8F, 0xCF, 0xC7,
  0xC3, 0xE1, 0xF1, 0xF0, 0xF8, 0x78, 0x78, 0x3C, 0x1E, 0x3E, 0x1F, 0x0F,
  0x8F, 0x87, 0xC3, 0xE3, 0xE1, 0xF0, 0xF8, 0xF0, 0x78, 0x3C, 0x3C, 0x1E,
  0x0F, 0x1F, 0x0F, 0x87, 0xC7, 0xC3, 0xE1, 0xF1, 0xF0, 0xF8, 0x7C, 0x78,
  0x3C, 0x1E, 0x1E, 0x0F, 0x0F, 0x8F, 0x87, 0xC3, 0xE3, 0xE1, 0xF0, 0xF8,
  0x0F, 0x1E, 0x07, 0xBF, 0x83, 0xFF, 0xE1, 0xDF, 0xF1, 0xF8, 0xF8, 0xFC,
  0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x3E, 0x0F, 0x1F, 0x07, 0x8F, 0x87, 0xC7,
  0xC3, 0xE3, 0xC1, 0xF3, 0xE0, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0x78, 0x3E,
  0x3C, 0x1F, 0x3E, 0x0F, 0x1F, 0x0F, 0x80, 0x03, 0xF0, 0x07, 0xFC, 0x0F,
  0xFC, 0x1F, 0xFE, 0x3F, 0x3E, 0x3E, 0x1E, 0x7C, 0x1F, 0x7C, 0x1F, 0x78,
  0x1F, 0xF8, 0x1E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8,
  0x7C, 0xF8, 0xFC, 0xFF, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x03,
  0xC7, 0x80, 0x7B, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x7E, 0x3E, 0x0F,
  0x87, 0xC1, 0xF0, 0xF8, 0x3C, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x3E,
  0x0F, 0x87, 0x83, 0xE0, 0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0xC3, 0xE0, 0xFC,
  0x7C, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0xFB, 0xF8, 0x1F, 0x7E, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC7, 0x83, 0xFB,
  0xC3, 0xFF, 0xE3, 0xFF, 0xE3, 0xF3, 0xF1, 0xF0, 0xF9, 0xF0, 0x7C, 0xF8,
  0x3E, 0x7C, 0x1E, 0x7C, 0x0F, 0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xC7,
  0xC1, 0xE3, 0xE1, 0xF1, 0xF1, 0xF8, 0xFF, 0xFC, 0x7F, 0xFC, 0x1F, 0xDE,
  0x07, 0xDF, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x0F, 0x1C,
  0x3D, 0xF0, 0xFF, 0xC7, 0xFE, 0x1F, 0xF8, 0x7F, 0x01, 0xF0, 0x07, 0xC0,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x03, 0xF0, 0x3F,
  0xF1, 0xFF, 0xC7, 0xFE, 0x3E, 0x08, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x20,
  0x7C, 0xFF, 0xF3, 0xFF, 0x8F, 0xFC, 0x1F, 0xE0, 0x03, 0x80, 0x78, 0x07,
  0x80, 0xF0, 0x0F, 0xF3, 0xFF, 0x7F, 0xE7, 0xFE, 0x1E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78,
  0x0F, 0x80, 0xFF, 0x87, 0xF8, 0x7F, 0x83, 0xF8, 0x1F, 0x0F, 0x8F, 0x07,
  0xC7, 0x83, 0xC7, 0xC1, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0xF0, 0x7C, 0x78,
  0x3C, 0x7C, 0x1E, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0x07, 0xCF, 0x83, 0xC7,
  0xC3, 0xE3, 0xE1, 0xF1, 0xF1, 0xF8, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0xDE,
  0x07, 0xCF, 0x00, 0xF8, 0x1F, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7C, 0xF8,
  0x7C, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF0, 0x79, 0xF0, 0x79, 0xE0, 0x7B,
  0xE0, 0x7B, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E,
  0x1E, 0xF8, 0x7C, 0x3E, 0xF8, 0xFC, 0x3E, 0xF8, 0xFC, 0x3C, 0xF9, 0xFC,
  0x7C, 0xF9, 0xFC, 0x78, 0xFB, 0xDC, 0xF8, 0xFB, 0xDC, 0xF0, 0xF3, 0x9C,
  0xF0, 0xF7, 0x9D, 0xF0, 0xF7, 0x9D, 0xE0, 0xF7, 0x3D, 0xE0, 0xFF, 0x3F,
  0xC0, 0xFE, 0x3F, 0xC0, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFC, 0x3F,
  0x80, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xC3, 0xF0, 0x7C, 0x3E,
  0x07, 0xC7, 0xC0, 0x7C, 0xF8, 0x03, 0xCF, 0x80, 0x3F, 0xF0, 0x03, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x01, 0xF3, 0xC0, 0x1F,
  0x3E, 0x03, 0xE3, 0xE0, 0x7C, 0x3E, 0x0F, 0xC1, 0xF0, 0x07, 0xC0, 0xF8,
  0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x01, 0xE3,
  0xE0, 0x0F, 0x1F, 0x00, 0x78, 0xF0, 0x03, 0xCF, 0x80, 0x1E, 0x78, 0x00,
  0xF7, 0xC0, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x5F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7F, 0xF0,
  0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x06, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xE0, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x1F, 0xC0, 0x3F, 0x00,
  0x7C, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0x80, 0x0F, 0x80, 0x3F, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x0F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x07,
  0xC0, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x0F, 0xE0, 0x7E, 0x01, 0xF0, 0x07,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x0F,
  0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x30, 0x00, 0x18, 0x03, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xF0, 0x1F, 0x80,
};

const GFXglyph NotoSans_Condensed_BoldItalic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 11, 26, 9, 0, -26 },
  { 37, 13, 10, 15, 3, -26 },
  { 54, 20, 26, 19, 0, -26 },
  { 119, 17, 29, 17, 0, -27 },
  { 181, 24, 26, 27, 2, -26 },
  { 259, 20, 26, 21, 0, -26 },
  { 324, 6, 10, 9, 4, -26 },
  { 332, 12, 32, 10, 1, -26 },
  { 380, 13, 32, 11, -3, -26 },
  { 432, 14, 16, 16, 3, -28 },
  { 460, 15, 17, 18, 2, -21 },
  { 492, 8, 10, 9, -2, -5 },
  { 502, 10, 5, 11, 0, -12 },
  { 509, 6, 5, 9, 0, -5 },
  { 513, 19, 26, 14, -2, -26 },
  { 575, 16, 26, 17, 1, -26 },
  { 627, 13, 26, 17, 3, -26 },
  { 670, 18, 26, 17, -1, -26 },
  { 729, 17, 26, 17, 0, -26 },
  { 785, 17, 26, 17, 0, -26 },
  { 841, 17, 26, 17, 0, -26 },
  { 897, 17, 26, 17, 1, -26 },
  { 953, 18, 26, 17, 1, -26 },
  { 1012, 17, 26, 17, 0, -26 },
  { 1068, 17, 26, 17, 0, -26 },
  { 1124, 9, 20, 9, 0, -20 },
  { 1147, 11, 25, 9, -2, -20 },
  { 1182, 15, 18, 18, 2, -22 },
  { 1216, 15, 11, 18, 2, -18 },
  { 1237, 15, 18, 18, 2, -22 },
  { 1271, 14, 26, 13, 1, -26 },
  { 1317, 24, 29, 26, 1, -26 },
  { 1404, 18, 26, 19, -2, -26 },
  { 1463, 19, 26, 19, 0, -26 },
  { 1525, 18, 26, 18, 2, -26 },
  { 1584, 20, 26, 20, 0, -26 },
  { 1649, 18, 26, 16, 0, -26 },
  { 1708, 17, 26, 15, 0, -26 },
  { 1764, 19, 26, 21, 2, -26 },
  { 1826, 22, 26, 21, 0, -26 },
  { 1898, 16, 26, 12, -1, -26 },
  { 1950, 17, 34, 10, -6, -26 },
  { 2023, 22, 26, 18, 0, -26 },
  { 2095, 13, 26, 15, 0, -26 },
  { 2138, 28, 26, 27, 0, -26 },
  { 2229, 23, 26, 22, 0, -26 },
  { 2304, 19, 26, 22, 2, -26 },
  { 2366, 19, 26, 18, 0, -26 },
  { 2428, 19, 32, 22, 2, -26 },
  { 2504, 18, 26, 18, 0, -26 },
  { 2563, 17, 26, 16, 0, -26 },
  { 2619, 15, 26, 16, 3, -26 },
  { 2668, 19, 26, 20, 2, -26 },
  { 2730, 18, 26, 18, 3, -26 },
  { 2789, 27, 26, 27, 3, -26 },
  { 2877, 22, 26, 18, -2, -26 },
  { 2949, 17, 26, 17, 3, -26 },
  { 3005, 19, 26, 16, -1, -26 },
  { 3067, 14, 32, 11, -1, -26 },
  { 3123, 7, 26, 14, 4, -26 },
  { 3146, 15, 32, 11, -3, -26 },
  { 3206, 17, 16, 17, 0, -26 },
  { 3240, 13, 3, 12, -3, 3 },
  { 3245, 7, 6, 11, 5, -28 },
  { 3251, 17, 20, 18, 1, -20 },
  { 3294, 17, 27, 18, 0, -27 },
  { 3352, 14, 20, 14, 1, -20 },
  { 3387, 19, 27, 18, 1, -27 },
  { 3452, 15, 20, 17, 1, -20 },
  { 3490, 19, 37, 11, -4, -28 },
  { 3578, 18, 29, 18, 0, -20 },
  { 3644, 17, 27, 18, 0, -27 },
  { 3702, 10, 27, 9, 0, -27 },
  { 3736, 15, 36, 9, -5, -27 },
  { 3804, 19, 27, 17, 0, -27 },
  { 3869, 11, 27, 9, 0, -27 },
  { 3907, 26, 20, 27, 0, -20 },
  { 3972, 17, 20, 18, 0, -20 },
  { 4015, 16, 20, 18, 1, -20 },
  { 4055, 19, 29, 18, -2, -20 },
  { 4124, 17, 29, 18, 1, -20 },
  { 4186, 14, 20, 13, 0, -20 },
  { 4221, 14, 20, 14, 0, -20 },
  { 4256, 12, 24, 12, 1, -24 },
  { 4292, 17, 20, 18, 1, -20 },
  { 4335, 16, 20, 16, 2, -20 },
  { 4375, 24, 20, 24, 2, -20 },
  { 4435, 20, 20, 16, -2, -20 },
  { 4485, 21, 29, 16, -3, -20 },
  { 4562, 16, 20, 14, -1, -20 },
  { 4602, 15, 32, 12, 0, -26 },
  { 4662, 4, 36, 15, 5, -28 },
  { 4680, 14, 32, 12, -2, -26 },
  { 4736, 15, 6, 18, 2, -16 },
};

const GFXfont NotoSans_Condensed_BoldItalic36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BoldItalic36pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BoldItalic36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_CONDENSED_BOLDITALIC36PT7B_H_
