#ifndef _NOTOSANS_CONDENSED_BOLDITALIC19PT7B_H_
#define _NOTOSANS_CONDENSED_BOLDITALIC19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BoldItalic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BoldItalic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x63, 0x8E, 0x38, 0xC3, 0x0C, 0x71, 0x80, 0x18, 0xE3, 0x80,
  0x6F, 0xDB, 0x36, 0x6D, 0x80, 0x06, 0xC3, 0x30, 0xD8, 0x36, 0x3F, 0xDF,
  0xF1, 0xB0, 0x4C, 0xFF, 0xBF, 0xE2, 0x61, 0x98, 0x6C, 0x1B, 0x00, 0x02,
  0x07, 0xCF, 0xE7, 0xA3, 0x41, 0xE0, 0xF8, 0x3E, 0x0F, 0x05, 0xA3, 0xDF,
  0xEF, 0xE0, 0x80, 0x40, 0x18, 0x63, 0xE3, 0x1B, 0x31, 0x99, 0x8C, 0xD8,
  0x6D, 0x83, 0x6D, 0xDE, 0xDB, 0x67, 0x98, 0x6C, 0xC6, 0x6C, 0x33, 0x63,
  0x1F, 0x38, 0xF0, 0x07, 0x01, 0xF0, 0x66, 0x0C, 0xC1, 0xB8, 0x3E, 0x07,
  0x81, 0xE7, 0x7E, 0xDC, 0xFB, 0x9E, 0x73, 0x8F, 0xF8, 0xFB, 0x80, 0x7F,
  0xEC, 0x06, 0x18, 0x70, 0xC3, 0x06, 0x1C, 0x30, 0x60, 0xC1, 0x87, 0x0E,
  0x1C, 0x18, 0x30, 0x60, 0x18, 0x70, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x71,
  0x86, 0x38, 0xC7, 0x18, 0xC0, 0x10, 0x32, 0x67, 0xB7, 0xEF, 0x3E, 0x26,
  0x08, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x77, 0x6E,
  0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x01, 0xC0, 0x60, 0x38, 0x0C, 0x07, 0x01,
  0x80, 0xE0, 0x30, 0x18, 0x06, 0x03, 0x01, 0xC0, 0x60, 0x38, 0x00, 0x06,
  0x0F, 0x8F, 0xE7, 0x77, 0x3B, 0x9D, 0x8E, 0xC6, 0x63, 0x73, 0xB9, 0xCD,
  0xC7, 0xC3, 0xC0, 0x0C, 0x73, 0xFF, 0xDA, 0x61, 0x8E, 0x38, 0xC3, 0x1C,
  0x71, 0xC0, 0x07, 0x07, 0xE1, 0xFC, 0x47, 0x01, 0xC0, 0x60, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0x7F, 0x3F, 0xC0, 0x0E, 0x1F, 0xC7, 0xE0,
  0x70, 0x38, 0x38, 0x78, 0x7C, 0x07, 0x03, 0x81, 0xD1, 0xCF, 0xE7, 0xE0,
  0x03, 0x81, 0xC1, 0xE1, 0xE0, 0xB0, 0xF8, 0xDC, 0xCC, 0x66, 0x7F, 0xBF,
  0xC1, 0xC0, 0xC0, 0x60, 0x1F, 0x8F, 0xC7, 0xE7, 0x03, 0x01, 0xA1, 0xF8,
  0x7E, 0x07, 0x03, 0x81, 0xD1, 0xCF, 0xE7, 0xE0, 0x07, 0x1F, 0x3D, 0x70,
  0x60, 0xEC, 0xFE, 0xEE, 0xC6, 0xC6, 0xCE, 0xCE, 0xFC, 0x78, 0x7F, 0xBF,
  0xDF, 0xC0, 0xE0, 0x60, 0x70, 0x30, 0x38, 0x18, 0x1C, 0x1C, 0x0E, 0x0E,
  0x07, 0x00, 0x0E, 0x0F, 0xCE, 0xE6, 0x33, 0x39, 0xF8, 0x78, 0x7C, 0x77,
  0x73, 0xB8, 0xDC, 0xEF, 0xE3, 0xE0, 0x0E, 0x0F, 0x8E, 0xE6, 0x77, 0x3B,
  0x9D, 0xCE, 0xFE, 0x3B, 0x03, 0x81, 0x81, 0xCF, 0xC7, 0xC0, 0x11, 0xCE,
  0x60, 0x00, 0x00, 0x67, 0x38, 0x08, 0x71, 0xC6, 0x00, 0x00, 0x00, 0x01,
  0xC7, 0x18, 0xE3, 0x00, 0x01, 0x03, 0x0F, 0x3C, 0xF0, 0xE0, 0x7C, 0x1F,
  0x07, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xC0, 0xF0, 0x7C,
  0x0F, 0x07, 0x3E, 0xF8, 0xE0, 0x80, 0x38, 0xFD, 0xB8, 0x70, 0xE3, 0x8E,
  0x38, 0x60, 0xC0, 0x06, 0x0E, 0x18, 0x00, 0x03, 0x80, 0xFE, 0x18, 0x33,
  0x03, 0x67, 0x94, 0xD9, 0xD9, 0x9D, 0x9B, 0x99, 0x39, 0xB2, 0x9F, 0xE9,
  0xDC, 0xC0, 0x0E, 0x10, 0x7F, 0x00, 0xC0, 0x03, 0x80, 0xE0, 0x78, 0x1E,
  0x0D, 0x83, 0x61, 0xD8, 0x66, 0x3F, 0x8F, 0xE7, 0xFD, 0xC7, 0x61, 0xF8,
  0x70, 0x1E, 0x07, 0xE1, 0xFC, 0xE7, 0x39, 0xCC, 0x63, 0xF1, 0xFC, 0x73,
  0x9C, 0xE6, 0x39, 0x9C, 0xFF, 0x3F, 0x80, 0x07, 0x0F, 0xCF, 0xEE, 0x07,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x4F, 0xE3, 0xF0, 0x1E,
  0x07, 0xE1, 0xFC, 0xE7, 0x38, 0xCE, 0x33, 0x0D, 0xC7, 0x71, 0xDC, 0x76,
  0x39, 0x9C, 0xFF, 0x3F, 0x00, 0x1F, 0x8F, 0xC7, 0xE7, 0x03, 0x81, 0xC0,
  0xFC, 0xFC, 0x70, 0x38, 0x18, 0x0C, 0x0F, 0xE7, 0xE0, 0x1F, 0x8F, 0xC7,
  0xE7, 0x03, 0x81, 0xC0, 0xFC, 0xFC, 0x7E, 0x38, 0x18, 0x0C, 0x0E, 0x07,
  0x00, 0x07, 0x87, 0xF3, 0xFD, 0xE0, 0x70, 0x38, 0x0E, 0x7B, 0x9E, 0xE7,
  0xB8, 0xEE, 0x33, 0x8C, 0x7F, 0x0F, 0xC0, 0x1C, 0x71, 0x86, 0x18, 0xE3,
  0x8E, 0x38, 0xE3, 0x8C, 0x3F, 0xC7, 0xFC, 0x71, 0xC7, 0x1C, 0x61, 0x86,
  0x18, 0xE3, 0x8E, 0x38, 0x1F, 0x8F, 0x83, 0x81, 0xC0, 0xC0, 0x60, 0x70,
  0x38, 0x18, 0x0C, 0x06, 0x07, 0x07, 0xC7, 0xE0, 0x03, 0x81, 0x80, 0xC0,
  0xE0, 0x70, 0x38, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x81, 0x80, 0xC0, 0xE0,
  0x70, 0x70, 0xF8, 0x78, 0x00, 0x1C, 0x63, 0x1C, 0x67, 0x1D, 0xC3, 0xB0,
  0x6E, 0x0F, 0x83, 0xF0, 0x7E, 0x0E, 0xC1, 0x9C, 0x33, 0x8E, 0x71, 0xC7,
  0x00, 0x1C, 0x30, 0x61, 0xC3, 0x86, 0x0C, 0x38, 0x70, 0xE1, 0x83, 0x0F,
  0xFF, 0xC0, 0x1C, 0x1E, 0x38, 0x38, 0x70, 0xF1, 0xE1, 0xE3, 0xC6, 0xC7,
  0xCF, 0x8D, 0xBE, 0x3B, 0x6C, 0x77, 0xD8, 0xCF, 0x71, 0x9E, 0xE3, 0x39,
  0x8E, 0x73, 0x1C, 0xCE, 0x00, 0x1C, 0x31, 0xC3, 0x1C, 0x73, 0xE7, 0x3E,
  0x63, 0x66, 0x36, 0x67, 0x6E, 0x77, 0xE6, 0x3C, 0x63, 0xC6, 0x3C, 0xE3,
  0xCE, 0x38, 0x07, 0x07, 0xE3, 0xFD, 0xC7, 0x71, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0xEE, 0x3B, 0x9C, 0xFF, 0x1F, 0x00, 0x1E, 0x07, 0xE1, 0xFC,
  0xE7, 0x39, 0xCE, 0x73, 0x3D, 0xFE, 0x7F, 0x1C, 0x06, 0x01, 0x80, 0xE0,
  0x38, 0x00, 0x07, 0x07, 0xE3, 0xFD, 0xC7, 0x71, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0xEE, 0x3B, 0x9C, 0xFF, 0x1F, 0x00, 0xE0, 0x38, 0x0F, 0x00,
  0x1E, 0x07, 0xE1, 0xFC, 0xE7, 0x39, 0xCC, 0x63, 0x39, 0xFC, 0x7E, 0x1D,
  0x86, 0x71, 0x9C, 0xE7, 0x38, 0xE0, 0x0F, 0x0F, 0xCF, 0xE7, 0x03, 0x01,
  0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x81, 0x91, 0xCF, 0xE7, 0xE0, 0x7F, 0xBF,
  0xFF, 0xC3, 0x81, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x1C, 0x0E, 0x07,
  0x03, 0x00, 0x38, 0xCC, 0x77, 0x1D, 0xC7, 0x71, 0x98, 0x66, 0x3B, 0x8E,
  0xE3, 0xB8, 0xCE, 0x73, 0x9C, 0xFE, 0x1F, 0x00, 0xC1, 0xE1, 0xF0, 0xD8,
  0xEC, 0x66, 0x73, 0x31, 0x98, 0xDC, 0x6C, 0x3E, 0x1E, 0x0F, 0x07, 0x00,
  0xC3, 0x0F, 0x1C, 0x7C, 0x71, 0xB1, 0xCE, 0xCF, 0x33, 0x3C, 0xCD, 0xB7,
  0x36, 0xD8, 0xFB, 0xE3, 0xCF, 0x0F, 0x3C, 0x38, 0xF0, 0xE3, 0x83, 0x8E,
  0x00, 0x1C, 0x71, 0xCE, 0x1C, 0xC0, 0xDC, 0x0D, 0x80, 0xF0, 0x0F, 0x00,
  0xF0, 0x1F, 0x01, 0xB0, 0x3B, 0x03, 0x38, 0x73, 0x8E, 0x38, 0xC3, 0xE3,
  0xB9, 0x9D, 0xCE, 0xC3, 0xE1, 0xE0, 0xE0, 0x70, 0x30, 0x18, 0x0C, 0x0E,
  0x07, 0x00, 0x1F, 0xC7, 0xF1, 0xFC, 0x0E, 0x03, 0x81, 0xC0, 0xE0, 0x38,
  0x1C, 0x0E, 0x03, 0x81, 0xC0, 0x7F, 0x3F, 0xC0, 0x0F, 0x0F, 0x1C, 0x1C,
  0x18, 0x18, 0x18, 0x38, 0x30, 0x30, 0x30, 0x30, 0x70, 0x60, 0x60, 0x78,
  0xF8, 0xCC, 0xCE, 0x66, 0x66, 0x66, 0x77, 0x33, 0x1E, 0x3C, 0x18, 0x70,
  0xC1, 0x83, 0x06, 0x1C, 0x30, 0x60, 0xC3, 0x87, 0x0C, 0x78, 0xF0, 0x06,
  0x03, 0x03, 0x83, 0xC1, 0xB1, 0x99, 0xCC, 0xC6, 0xC1, 0x80, 0xFE, 0xFD,
  0x80, 0x08, 0x47, 0xE3, 0xF9, 0xCE, 0x73, 0x98, 0xC6, 0x33, 0x9C, 0x67,
  0x1F, 0xC7, 0xE0, 0x1C, 0x0C, 0x0E, 0x07, 0x43, 0x79, 0xFC, 0xCE, 0xE7,
  0x73, 0xB1, 0xD8, 0xCC, 0xEF, 0xE6, 0xE0, 0x08, 0x7D, 0xF7, 0x0E, 0x18,
  0x30, 0x60, 0xC5, 0xF1, 0xE0, 0x00, 0xC0, 0x70, 0x1C, 0x27, 0x1F, 0x8F,
  0xE7, 0x39, 0xCE, 0x63, 0x18, 0xCE, 0x31, 0x9C, 0x7F, 0x1F, 0x80, 0x08,
  0x3E, 0x76, 0xE7, 0xC6, 0xFC, 0xF0, 0xC0, 0xC0, 0xFC, 0x7C, 0x01, 0x80,
  0xF0, 0x78, 0x18, 0x06, 0x07, 0xE1, 0xF0, 0x30, 0x0C, 0x07, 0x01, 0xC0,
  0x70, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x3C, 0x0F, 0x03, 0x00, 0x08,
  0x47, 0xE3, 0xF9, 0xCE, 0x73, 0x98, 0xC6, 0x33, 0x9C, 0xE7, 0x1F, 0xC7,
  0x60, 0x18, 0x0E, 0x3F, 0x8F, 0xC0, 0xC0, 0x1C, 0x0C, 0x0E, 0x07, 0x43,
  0x79, 0xFC, 0xCE, 0xE7, 0x73, 0xB1, 0x98, 0xCC, 0xEE, 0x77, 0x30, 0x18,
  0xC0, 0x03, 0x98, 0xCE, 0x73, 0x98, 0xCE, 0x70, 0x06, 0x0C, 0x00, 0x00,
  0xE1, 0x83, 0x0E, 0x1C, 0x38, 0x60, 0xC3, 0x87, 0x0C, 0x18, 0xF1, 0xC3,
  0x00, 0x1C, 0x06, 0x03, 0x80, 0xE1, 0x33, 0x8C, 0xC3, 0x61, 0xF8, 0x7C,
  0x1F, 0x86, 0xE1, 0x98, 0xE6, 0x39, 0xC0, 0x1C, 0x63, 0x8E, 0x38, 0xC3,
  0x1C, 0x71, 0xC6, 0x18, 0xE3, 0x80, 0x02, 0x10, 0xDF, 0xE3, 0xFF, 0xCC,
  0xE6, 0x73, 0x99, 0xCC, 0x66, 0x33, 0x98, 0xCE, 0x67, 0x33, 0x9C, 0xCE,
  0x67, 0x00, 0x02, 0x1B, 0xCF, 0xE6, 0x77, 0x3B, 0x9D, 0x8C, 0xC6, 0x67,
  0x73, 0xB9, 0x80, 0x08, 0x3E, 0x7E, 0xE7, 0xE7, 0xC7, 0xC6, 0xC6, 0xCE,
  0xFC, 0x78, 0x01, 0x06, 0xF1, 0xFC, 0x67, 0x39, 0xCE, 0x73, 0x1C, 0xC6,
  0x33, 0x9F, 0xC7, 0xE1, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x80, 0x0C, 0x47,
  0xE3, 0xF9, 0xCE, 0x73, 0x98, 0xC6, 0x33, 0x8C, 0xE7, 0x1F, 0xC7, 0xE0,
  0x18, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x03, 0x36, 0x3E, 0x38, 0x70, 0x70,
  0x60, 0x60, 0x60, 0xE0, 0xE0, 0x08, 0x3F, 0x76, 0x70, 0x70, 0x3C, 0x1C,
  0x0C, 0x8C, 0xFC, 0xF8, 0x10, 0xC3, 0x3F, 0xF9, 0x86, 0x38, 0xE3, 0x0C,
  0x3C, 0xF0, 0x73, 0x63, 0x67, 0xE7, 0xE6, 0xC6, 0xCE, 0xCE, 0xFE, 0xFC,
  0xE7, 0xE6, 0xEE, 0xEC, 0xEC, 0xF8, 0xF8, 0x70, 0x70, 0x70, 0xE7, 0x3E,
  0x7B, 0xB3, 0xD9, 0xB6, 0xCD, 0xBE, 0x6D, 0xE3, 0xCB, 0x1E, 0x70, 0xE3,
  0x87, 0x38, 0x00, 0x39, 0xC6, 0xE1, 0xF0, 0x7C, 0x0E, 0x07, 0x83, 0xE0,
  0xDC, 0x77, 0x39, 0xC0, 0x39, 0xCE, 0x63, 0xB8, 0xEC, 0x1B, 0x07, 0xC1,
  0xE0, 0x78, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0xF0, 0x38, 0x0C, 0x00, 0x1F,
  0x9F, 0x81, 0x81, 0xC1, 0xC0, 0xC0, 0xE0, 0xE0, 0x7E, 0x7F, 0x00, 0x03,
  0x0F, 0x0E, 0x1C, 0x1C, 0x18, 0x18, 0x78, 0xE0, 0xF0, 0x30, 0x30, 0x70,
  0x70, 0x70, 0x78, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x10, 0x38, 0x70,
  0x60, 0xC1, 0x87, 0x0E, 0x0E, 0x3C, 0x61, 0xC3, 0x06, 0x1C, 0x78, 0xE0,
  0xF9, 0xFF, 0x8E,
};

const GFXglyph NotoSans_Condensed_BoldItalic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 6, 14, 5, 0, -14 },
  { 12, 7, 5, 8, 2, -14 },
  { 17, 10, 14, 10, 0, -14 },
  { 35, 9, 15, 9, 0, -14 },
  { 52, 13, 14, 14, 1, -14 },
  { 75, 11, 14, 11, 0, -14 },
  { 95, 3, 5, 5, 2, -14 },
  { 97, 7, 17, 6, 0, -14 },
  { 112, 6, 17, 6, -1, -14 },
  { 125, 7, 9, 9, 2, -15 },
  { 133, 8, 9, 9, 1, -11 },
  { 142, 4, 5, 5, -1, -2 },
  { 145, 5, 2, 6, 0, -6 },
  { 147, 3, 3, 5, 0, -3 },
  { 149, 10, 14, 7, -1, -14 },
  { 167, 9, 14, 9, 0, -14 },
  { 183, 6, 14, 9, 2, -14 },
  { 194, 10, 14, 9, -1, -14 },
  { 212, 9, 14, 9, 0, -14 },
  { 228, 9, 14, 9, 0, -14 },
  { 244, 9, 14, 9, 0, -14 },
  { 260, 8, 14, 9, 1, -14 },
  { 274, 9, 14, 9, 1, -14 },
  { 290, 9, 14, 9, 0, -14 },
  { 306, 9, 14, 9, 0, -14 },
  { 322, 5, 11, 5, 0, -11 },
  { 329, 6, 14, 5, -1, -11 },
  { 340, 8, 10, 9, 1, -12 },
  { 350, 8, 6, 9, 1, -10 },
  { 356, 8, 10, 9, 1, -12 },
  { 366, 7, 14, 7, 1, -14 },
  { 379, 12, 16, 13, 1, -14 },
  { 403, 10, 14, 10, -1, -14 },
  { 421, 10, 14, 10, 0, -14 },
  { 439, 9, 14, 9, 1, -14 },
  { 455, 10, 14, 11, 0, -14 },
  { 473, 9, 14, 8, 0, -14 },
  { 489, 9, 14, 8, 0, -14 },
  { 505, 10, 14, 11, 1, -14 },
  { 523, 12, 14, 11, 0, -14 },
  { 544, 9, 14, 6, -1, -14 },
  { 560, 9, 18, 5, -3, -14 },
  { 581, 11, 14, 10, 0, -14 },
  { 601, 7, 14, 8, 0, -14 },
  { 614, 15, 14, 14, 0, -14 },
  { 641, 12, 14, 12, 0, -14 },
  { 662, 10, 14, 11, 1, -14 },
  { 680, 10, 14, 10, 0, -14 },
  { 698, 10, 17, 11, 1, -14 },
  { 720, 10, 14, 10, 0, -14 },
  { 738, 9, 14, 9, 0, -14 },
  { 754, 9, 14, 8, 1, -14 },
  { 770, 10, 14, 11, 1, -14 },
  { 788, 9, 14, 10, 2, -14 },
  { 804, 14, 14, 14, 2, -14 },
  { 829, 12, 14, 9, -1, -14 },
  { 850, 9, 14, 9, 2, -14 },
  { 866, 10, 14, 8, -1, -14 },
  { 884, 8, 17, 6, -1, -14 },
  { 901, 4, 14, 7, 2, -14 },
  { 908, 7, 17, 6, -1, -14 },
  { 923, 9, 9, 9, 0, -14 },
  { 934, 7, 1, 7, -2, 2 },
  { 935, 3, 3, 6, 3, -15 },
  { 937, 10, 11, 10, 0, -11 },
  { 951, 9, 14, 10, 0, -14 },
  { 967, 7, 11, 8, 1, -11 },
  { 977, 10, 14, 10, 0, -14 },
  { 995, 8, 11, 9, 1, -11 },
  { 1006, 10, 20, 6, -2, -15 },
  { 1031, 10, 16, 10, 0, -11 },
  { 1051, 9, 14, 10, 0, -14 },
  { 1067, 5, 14, 5, 0, -14 },
  { 1076, 7, 19, 5, -2, -14 },
  { 1093, 10, 14, 9, 0, -14 },
  { 1111, 6, 14, 5, 0, -14 },
  { 1122, 14, 11, 14, 0, -11 },
  { 1142, 9, 11, 10, 0, -11 },
  { 1155, 8, 11, 9, 1, -11 },
  { 1166, 10, 16, 10, -1, -11 },
  { 1186, 10, 16, 10, 0, -11 },
  { 1206, 8, 11, 7, 0, -11 },
  { 1217, 8, 11, 7, 0, -11 },
  { 1228, 6, 13, 6, 1, -13 },
  { 1238, 8, 10, 9, 1, -10 },
  { 1248, 8, 10, 8, 1, -10 },
  { 1258, 13, 10, 13, 1, -10 },
  { 1275, 10, 10, 8, -1, -10 },
  { 1288, 10, 15, 8, -1, -10 },
  { 1307, 9, 10, 7, -1, -10 },
  { 1319, 8, 17, 7, 0, -14 },
  { 1336, 2, 19, 8, 3, -15 },
  { 1341, 7, 17, 7, -1, -14 },
  { 1356, 8, 3, 9, 1, -8 },
};

const GFXfont NotoSans_Condensed_BoldItalic19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BoldItalic19pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BoldItalic19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_CONDENSED_BOLDITALIC19PT7B_H_
