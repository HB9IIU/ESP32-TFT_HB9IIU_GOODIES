#ifndef _NOTOSANS_CONDENSED_BOLDITALIC10PT7B_H_
#define _NOTOSANS_CONDENSED_BOLDITALIC10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BoldItalic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BoldItalic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0x25, 0x30, 0xFA, 0x28, 0xB7, 0x94, 0xF9, 0x4A, 0x00, 0x11,
  0xDA, 0xC3, 0x1B, 0xCC, 0x40, 0xCE, 0xAD, 0x3B, 0x35, 0x5D, 0x80, 0x39,
  0xE7, 0x1B, 0xFA, 0x4F, 0x80, 0xE0, 0x36, 0x44, 0xC8, 0x8C, 0x40, 0x33,
  0x33, 0x22, 0x24, 0x80, 0x2C, 0x7E, 0xA0, 0x21, 0x3E, 0x42, 0x00, 0x78,
  0xE0, 0xB0, 0x0C, 0x21, 0x0C, 0x21, 0x8C, 0x00, 0x32, 0xD7, 0xAD, 0x79,
  0x80, 0x7E, 0xB4, 0x90, 0x72, 0xC4, 0x66, 0x63, 0xC0, 0x78, 0xC4, 0xE1,
  0x4B, 0x80, 0x19, 0x8C, 0xAF, 0x78, 0x80, 0x7A, 0x18, 0xE1, 0x5B, 0x80,
  0x3B, 0x15, 0xED, 0x69, 0x80, 0x78, 0xC4, 0x62, 0x33, 0x00, 0x7A, 0xDC,
  0xED, 0x4B, 0xC0, 0x72, 0xD6, 0xE1, 0x1B, 0x80, 0x4C, 0x09, 0x80, 0x23,
  0x00, 0x06, 0xC0, 0x09, 0xB0, 0x60, 0x80, 0xF8, 0x3E, 0xC3, 0x86, 0xC8,
  0x00, 0x71, 0x36, 0x40, 0xC0, 0x3C, 0x85, 0x6D, 0x5A, 0xB7, 0x90, 0x1C,
  0x18, 0x63, 0x8A, 0x39, 0x3C, 0xC0, 0x7B, 0x56, 0xE5, 0xEF, 0xC0, 0x3B,
  0x10, 0x8C, 0x21, 0xC0, 0x7B, 0x52, 0x94, 0xEF, 0xC0, 0x7B, 0x10, 0xE4,
  0x63, 0xC0, 0x7B, 0x10, 0xE4, 0x63, 0x00, 0x3D, 0x84, 0x16, 0xC9, 0x27,
  0x80, 0x65, 0xB4, 0xDE, 0x4B, 0x6D, 0x80, 0x72, 0x64, 0x44, 0xE0, 0x18,
  0xC4, 0x21, 0x18, 0xC4, 0xE0, 0x6D, 0xE5, 0x1C, 0x73, 0x49, 0x80, 0x66,
  0x44, 0x4C, 0xF0, 0x63, 0x66, 0x66, 0x6A, 0x7A, 0xF6, 0xB4, 0x65, 0x97,
  0x57, 0x5B, 0x69, 0x80, 0x39, 0xB4, 0xD3, 0xCB, 0x67, 0x00, 0x7B, 0x52,
  0xF4, 0x63, 0x00, 0x39, 0xB4, 0xD3, 0xCB, 0x67, 0x04, 0x18, 0x7B, 0x52,
  0xE7, 0x6A, 0x60, 0x7A, 0x18, 0xE3, 0x5B, 0x80, 0xF4, 0x44, 0xCC, 0x80,
  0x6D, 0xB4, 0x92, 0x4B, 0x67, 0x00, 0x9C, 0xAD, 0x4A, 0x63, 0x00, 0x93,
  0x6E, 0xD5, 0xAD, 0xDB, 0x26, 0x00, 0x36, 0x78, 0x60, 0x83, 0x8D, 0x32,
  0x00, 0x9D, 0xB8, 0x84, 0x62, 0x00, 0x78, 0x8C, 0x44, 0x63, 0xC0, 0x74,
  0x44, 0x4C, 0x88, 0xC0, 0xAD, 0x54, 0x31, 0x13, 0x22, 0x26, 0xC0, 0x31,
  0x95, 0xB0, 0xF0, 0xD0, 0x23, 0xD7, 0xAD, 0x78, 0x23, 0x14, 0xF5, 0xAF,
  0x5E, 0x37, 0x4C, 0xC6, 0x08, 0x4A, 0xF5, 0xEB, 0x4E, 0x27, 0x5E, 0xC7,
  0x18, 0xCE, 0xE2, 0x11, 0x8C, 0x46, 0x00, 0x23, 0xD7, 0xAD, 0x78, 0xDC,
  0x23, 0x14, 0xF5, 0xAB, 0x52, 0x2C, 0xA4, 0xB4, 0x13, 0x12, 0x22, 0x64,
  0x4C, 0x23, 0x12, 0xA7, 0x33, 0xD2, 0x2D, 0xA4, 0xB4, 0x14, 0xFD, 0x6A,
  0x9D, 0x72, 0x80, 0x13, 0xD6, 0xAD, 0x48, 0x23, 0x97, 0xAD, 0x38, 0x08,
  0xF2, 0xCB, 0x69, 0xE4, 0x30, 0x23, 0xD7, 0xAD, 0x78, 0xC6, 0x17, 0x44,
  0xC8, 0x25, 0x46, 0x2E, 0x27, 0xE4, 0x4C, 0xE0, 0x5A, 0xD5, 0xAF, 0x00,
  0xBA, 0xCC, 0xC0, 0xBF, 0x6F, 0xBC, 0xB0, 0x5B, 0x98, 0xCB, 0x00, 0x2C,
  0xA3, 0x0C, 0x30, 0x8E, 0x00, 0x72, 0x4C, 0xE0, 0x32, 0x26, 0xC4, 0x44,
  0x40, 0xFF, 0xC0, 0x31, 0x33, 0x32, 0x6E, 0x80, 0xF8,
};

const GFXglyph NotoSans_Condensed_BoldItalic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 7, 3, 0, -7 },
  { 4, 4, 2, 4, 1, -7 },
  { 5, 6, 7, 5, 0, -7 },
  { 11, 5, 9, 5, 0, -8 },
  { 17, 6, 7, 8, 1, -7 },
  { 23, 6, 7, 6, 0, -7 },
  { 29, 2, 2, 2, 1, -7 },
  { 30, 4, 9, 3, 0, -7 },
  { 35, 4, 9, 3, -1, -7 },
  { 40, 4, 5, 5, 1, -8 },
  { 43, 5, 5, 5, 0, -6 },
  { 47, 3, 2, 3, -1, -1 },
  { 48, 3, 1, 3, 0, -3 },
  { 49, 2, 2, 3, 0, -2 },
  { 50, 6, 7, 4, -1, -7 },
  { 56, 5, 7, 5, 0, -7 },
  { 61, 3, 7, 5, 1, -7 },
  { 64, 5, 7, 5, 0, -7 },
  { 69, 5, 7, 5, 0, -7 },
  { 74, 5, 7, 5, 0, -7 },
  { 79, 5, 7, 5, 0, -7 },
  { 84, 5, 7, 5, 0, -7 },
  { 89, 5, 7, 5, 0, -7 },
  { 94, 5, 7, 5, 0, -7 },
  { 99, 5, 7, 5, 0, -7 },
  { 104, 3, 6, 3, 0, -6 },
  { 107, 4, 7, 3, -1, -6 },
  { 111, 5, 5, 5, 0, -6 },
  { 115, 5, 3, 5, 0, -5 },
  { 117, 5, 5, 5, 0, -6 },
  { 121, 4, 7, 4, 0, -7 },
  { 125, 7, 8, 7, 0, -7 },
  { 132, 6, 7, 5, -1, -7 },
  { 138, 5, 7, 5, 0, -7 },
  { 143, 5, 7, 5, 0, -7 },
  { 148, 5, 7, 6, 0, -7 },
  { 153, 5, 7, 4, 0, -7 },
  { 158, 5, 7, 4, 0, -7 },
  { 163, 6, 7, 6, 0, -7 },
  { 169, 6, 7, 6, 0, -7 },
  { 175, 4, 7, 3, 0, -7 },
  { 179, 5, 9, 3, -2, -7 },
  { 185, 6, 7, 5, 0, -7 },
  { 191, 4, 7, 4, 0, -7 },
  { 195, 8, 7, 8, 0, -7 },
  { 202, 6, 7, 6, 0, -7 },
  { 208, 6, 7, 6, 0, -7 },
  { 214, 5, 7, 5, 0, -7 },
  { 219, 6, 9, 6, 0, -7 },
  { 226, 5, 7, 5, 0, -7 },
  { 231, 5, 7, 4, 0, -7 },
  { 236, 4, 7, 4, 1, -7 },
  { 240, 6, 7, 6, 0, -7 },
  { 246, 5, 7, 5, 1, -7 },
  { 251, 7, 7, 8, 1, -7 },
  { 258, 7, 7, 5, -1, -7 },
  { 265, 5, 7, 5, 1, -7 },
  { 270, 5, 7, 4, 0, -7 },
  { 275, 4, 9, 3, 0, -7 },
  { 280, 2, 7, 4, 1, -7 },
  { 282, 4, 9, 3, -1, -7 },
  { 287, 5, 4, 5, 0, -7 },
  { 290, 4, 1, 3, -1, 1 },
  { 291, 2, 2, 3, 1, -8 },
  { 292, 5, 6, 5, 0, -6 },
  { 296, 5, 8, 5, 0, -8 },
  { 301, 4, 6, 4, 0, -6 },
  { 304, 5, 8, 5, 0, -8 },
  { 309, 4, 6, 5, 0, -6 },
  { 312, 5, 10, 3, -1, -8 },
  { 319, 5, 8, 5, 0, -6 },
  { 324, 5, 8, 5, 0, -8 },
  { 329, 3, 8, 3, 0, -8 },
  { 332, 4, 10, 3, -1, -8 },
  { 337, 5, 8, 5, 0, -8 },
  { 342, 3, 8, 2, 0, -8 },
  { 345, 7, 6, 7, 0, -6 },
  { 351, 5, 6, 5, 0, -6 },
  { 355, 5, 6, 5, 0, -6 },
  { 359, 6, 8, 5, -1, -6 },
  { 365, 5, 8, 5, 0, -6 },
  { 370, 4, 6, 4, 0, -6 },
  { 373, 4, 6, 4, 0, -6 },
  { 376, 4, 7, 3, 0, -7 },
  { 380, 5, 5, 5, 0, -5 },
  { 384, 4, 5, 4, 1, -5 },
  { 387, 6, 5, 7, 1, -5 },
  { 391, 5, 5, 4, 0, -5 },
  { 395, 6, 7, 4, -1, -5 },
  { 401, 4, 5, 4, 0, -5 },
  { 404, 4, 9, 3, 0, -7 },
  { 409, 1, 10, 4, 2, -8 },
  { 411, 4, 9, 3, -1, -7 },
  { 416, 5, 1, 5, 0, -4 },
};

const GFXfont NotoSans_Condensed_BoldItalic10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BoldItalic10pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BoldItalic10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_CONDENSED_BOLDITALIC10PT7B_H_
