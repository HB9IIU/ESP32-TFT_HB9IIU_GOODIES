#ifndef _NOTOSANS_CONDENSED_BOLDITALIC42PT7B_H_
#define _NOTOSANS_CONDENSED_BOLDITALIC42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BoldItalic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BoldItalic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0,
  0x3E, 0x00, 0x3E, 0x7E, 0xFC, 0xFD, 0xF1, 0xF3, 0xE3, 0xE7, 0xC7, 0xCF,
  0x8F, 0x1E, 0x3E, 0x3C, 0x7C, 0xF8, 0xF9, 0xE1, 0xE3, 0xC3, 0xC0, 0x00,
  0x3E, 0x3C, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x03, 0xC3, 0xC0, 0x07,
  0x87, 0x80, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0x78, 0x1F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x1E, 0x3C,
  0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0xC7, 0x80,
  0x0F, 0x0F, 0x11, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFE, 0x03, 0xC7, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x3C, 0x00, 0x3C,
  0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x8F,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x01, 0xF8,
  0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xF9,
  0xC0, 0xFD, 0x84, 0x0F, 0x98, 0x00, 0xF9, 0x80, 0x0F, 0xD8, 0x00, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x06, 0xFC, 0x00, 0x6F, 0xC4,
  0x0C, 0xFC, 0x70, 0xCF, 0x87, 0xEF, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xF0,
  0xFF, 0xFE, 0x03, 0xFF, 0x80, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x07, 0xE0, 0x07, 0x80, 0xFF, 0x00, 0xF0, 0x1F, 0xF8,
  0x0F, 0x03, 0xEF, 0x81, 0xE0, 0x3C, 0x78, 0x3E, 0x03, 0xC7, 0x83, 0xC0,
  0x78, 0x78, 0x78, 0x07, 0x87, 0x87, 0x80, 0x78, 0xF8, 0xF0, 0x0F, 0x8F,
  0x9F, 0x00, 0xF8, 0xF1, 0xE0, 0x0F, 0x0F, 0x3C, 0x00, 0xF1, 0xF3, 0xCF,
  0xCF, 0x1E, 0x79, 0xFE, 0xFB, 0xEF, 0xBF, 0xF7, 0xFC, 0xF3, 0xFF, 0x7F,
  0x9E, 0x7C, 0xF3, 0xF1, 0xE7, 0x8F, 0x00, 0x3C, 0xF8, 0xF0, 0x07, 0xCF,
  0x0F, 0x00, 0x78, 0xF0, 0xF0, 0x0F, 0x0F, 0x0F, 0x00, 0xF0, 0xF1, 0xF0,
  0x1E, 0x0F, 0x1E, 0x03, 0xE0, 0xF1, 0xE0, 0x3C, 0x0F, 0x3C, 0x07, 0x80,
  0xFF, 0xC0, 0xF8, 0x0F, 0xF8, 0x0F, 0x00, 0xFF, 0x81, 0xF0, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x01, 0xF3, 0xF0, 0x03, 0xE1, 0xF0, 0x03, 0xE1, 0xF0, 0x03, 0xE3, 0xE0,
  0x03, 0xE3, 0xE0, 0x03, 0xE7, 0xE0, 0x03, 0xEF, 0xC0, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0x0F, 0xFC, 0x3E,
  0x1F, 0xFE, 0x3E, 0x3F, 0x7E, 0x7E, 0x3F, 0x3F, 0x7C, 0x7E, 0x3F, 0xFC,
  0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF0, 0xFC, 0x1F, 0xF0, 0xFC, 0x0F, 0xE0,
  0xFC, 0x1F, 0xE0, 0xFF, 0x7F, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFB, 0xF8, 0x1F, 0xF1, 0xFC, 0x3E, 0xFD, 0xFB, 0xE7, 0xCF, 0x9F,
  0x3C, 0xF9, 0xF3, 0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07,
  0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x03,
  0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x04, 0x1E,
  0x03, 0x1F, 0x03, 0xEF, 0x01, 0xFF, 0xBF, 0xFF, 0xFF, 0x3F, 0xFF, 0x81,
  0xFF, 0xC1, 0xFC, 0x21, 0xFE, 0x01, 0xF7, 0x83, 0xFB, 0xC0, 0xF9, 0xF0,
  0x38, 0xFC, 0x0C, 0x3C, 0x00, 0x18, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x1F, 0x8F, 0xC7, 0xC7, 0xE3, 0xF1, 0xF1, 0xF8,
  0xF8, 0x7C, 0x7C, 0x3C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xEF, 0xFC,
  0x3C, 0xFF, 0xFF, 0xFF, 0xCF, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x0F, 0xFF,
  0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0x8F, 0x87, 0xE1, 0xF0, 0xFC, 0x3F,
  0x3F, 0x07, 0xE7, 0xE0, 0xF8, 0xF8, 0x1F, 0x3F, 0x03, 0xE7, 0xE0, 0x7C,
  0xFC, 0x1F, 0x9F, 0x03, 0xF3, 0xE0, 0x7E, 0xFC, 0x0F, 0xDF, 0x81, 0xF3,
  0xF0, 0x7E, 0x7E, 0x0F, 0xCF, 0x81, 0xF1, 0xF0, 0x7E, 0x3E, 0x0F, 0xC7,
  0xC3, 0xF0, 0xFC, 0x7E, 0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFC, 0x03,
  0xFF, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0xC1, 0xFF,
  0x0F, 0xF8, 0x7F, 0xE3, 0xFF, 0xBF, 0xFE, 0xFD, 0xF9, 0xE7, 0xC3, 0x1F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x7F,
  0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01,
  0xE1, 0xFC, 0x0C, 0x07, 0xE0, 0x40, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF,
  0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x30, 0x3F, 0x02, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x03,
  0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x80, 0x3F, 0x8F, 0xBF, 0xF0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x7B, 0xE0, 0x07, 0xDF, 0x00, 0x3D,
  0xF8, 0x03, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xE3, 0xE0, 0x1E, 0x3F, 0x01,
  0xF1, 0xF8, 0x1F, 0x0F, 0x80, 0xF0, 0x7C, 0x0F, 0x87, 0xE0, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F,
  0xFE, 0x03, 0xFF, 0xE0, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x08, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x88, 0x03, 0xF8, 0xC0, 0x7F, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xC0, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFC, 0x60, 0x7F, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE7, 0xE0,
  0x3E, 0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xF9, 0xF8, 0x7E, 0x0F,
  0x87, 0xE0, 0xF8, 0xFC, 0x0F, 0x8F, 0xC0, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1,
  0xF8, 0xFC, 0x1F, 0x8F, 0xC3, 0xF0, 0xFC, 0x3F, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xF8,
  0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xE0,
  0x7F, 0xFF, 0x07, 0xE3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF0, 0xF8, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3E, 0x07, 0xC7, 0xE0, 0x7F, 0xFC, 0x03, 0xFF,
  0x80, 0x3F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x03, 0xFB,
  0xF8, 0x3F, 0x1F, 0x87, 0xE0, 0xFC, 0x7C, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC,
  0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x1F, 0x87, 0xE3, 0xF8, 0x7F, 0xFF, 0x07,
  0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x3F, 0xF8,
  0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0x8F, 0xC7, 0xE0, 0xF8,
  0xFC, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0xFC, 0x1F, 0x9F, 0x83, 0xF3,
  0xF0, 0x7E, 0x7E, 0x1F, 0xCF, 0xE7, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xC1,
  0xFE, 0xF8, 0x1F, 0xBF, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0xFE, 0x1E, 0x7F, 0x83, 0xFF, 0xE0, 0x7F,
  0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xC1, 0xF8, 0x3F, 0x87,
  0xE0, 0xFC, 0x1F, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x81, 0xF8, 0x7F, 0x0F, 0xE1,
  0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0xFE, 0x07, 0xE0, 0x3F, 0x01,
  0xF0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x01,
  0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF0,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFF,
  0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x00, 0x3C, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x3C, 0x00, 0x0F, 0xC0,
  0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0xFF, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0E, 0x00,
  0x02, 0x00, 0x00, 0x0F, 0xF8, 0x7F, 0xF8, 0xFF, 0xF9, 0xFF, 0xF3, 0xC7,
  0xE6, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x3C,
  0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x01,
  0xFC, 0x1F, 0x80, 0x1F, 0x80, 0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x1F, 0x00,
  0x03, 0xC1, 0xF0, 0x00, 0x1E, 0x0F, 0x07, 0xF8, 0x70, 0xF0, 0x7F, 0xE3,
  0xC7, 0x87, 0xFF, 0x1E, 0x78, 0x7C, 0xF0, 0xF3, 0xC7, 0xC7, 0x87, 0x9E,
  0x3C, 0x3C, 0x39, 0xE3, 0xC1, 0xE3, 0xCF, 0x1E, 0x1E, 0x1E, 0x78, 0xF0,
  0xF0, 0xF3, 0x87, 0x87, 0x87, 0x3C, 0x78, 0x3C, 0x79, 0xE3, 0xC3, 0xC3,
  0xCF, 0x1E, 0x1E, 0x3C, 0x78, 0xF9, 0xF1, 0xE3, 0xC3, 0xFF, 0xFE, 0x1E,
  0x1F, 0xDF, 0xE0, 0xF0, 0x7C, 0x7E, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x01, 0x00, 0x1F, 0x80, 0x70,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3E,
  0xF8, 0x00, 0xFB, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0xFC, 0xFC,
  0x03, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7C, 0x3F, 0x01, 0xF0, 0xFC, 0x0F,
  0xC3, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0xFC, 0x03, 0xF3,
  0xF0, 0x0F, 0xCF, 0x80, 0x3F, 0x7E, 0x00, 0xFF, 0xF8, 0x03, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xC0, 0xFC,
  0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7C, 0x1F,
  0x81, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3,
  0xE0, 0x7E, 0x0F, 0x81, 0xF8, 0x7E, 0x0F, 0xE1, 0xFF, 0xFF, 0x07, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xF0, 0x30, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x02, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x01,
  0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFC, 0x3F, 0x81, 0xF8,
  0x3F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0x80, 0xFC, 0x3F, 0x01,
  0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xE0, 0x1F,
  0x8F, 0xC0, 0x7F, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF1,
  0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x7F, 0x0F, 0xC1, 0xFC, 0x1F,
  0x07, 0xF0, 0x7E, 0x1F, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x3F,
  0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x81, 0xFF, 0xF8,
  0x1F, 0xFF, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0x03,
  0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xE0,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xF8, 0x0F, 0xFF,
  0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFE, 0x03, 0x07, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC3, 0xFF, 0x3F, 0x07, 0xFE, 0x7E, 0x0F, 0xF8,
  0xFC, 0x1F, 0xF1, 0xF8, 0x7F, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F,
  0xC0, 0x3E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7F, 0x03, 0xF0, 0xFE,
  0x07, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x81, 0xF8, 0x07,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0,
  0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xE0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x7F, 0xFC,
  0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x3F,
  0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x04, 0x7F, 0x00, 0x7F, 0xF0, 0x07, 0xFE,
  0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x1F,
  0x81, 0xF8, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0x7C, 0x1F, 0xC0, 0x3E, 0x0F,
  0xC0, 0x3F, 0x0F, 0xC0, 0x1F, 0x8F, 0xC0, 0x0F, 0xCF, 0xE0, 0x07, 0xC7,
  0xE0, 0x03, 0xE7, 0xE0, 0x03, 0xF7, 0xF0, 0x01, 0xFB, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xEF, 0xC0, 0x07, 0xE7, 0xE0, 0x03,
  0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xF8, 0x7E, 0x00, 0x7C, 0x3F, 0x00,
  0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0x81, 0xF8,
  0x07, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x7F,
  0x80, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0xE0, 0x3F, 0xC0, 0x1F,
  0xF0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x07, 0xFF, 0x03, 0xEF, 0x03,
  0xFF, 0x01, 0xF7, 0x83, 0xEF, 0x80, 0xFB, 0xC1, 0xF7, 0xC0, 0x7D, 0xF0,
  0xF7, 0xE0, 0x3E, 0xF8, 0xFB, 0xE0, 0x3F, 0x7C, 0x79, 0xF0, 0x1F, 0x3E,
  0x7C, 0xF8, 0x0F, 0x9F, 0x3C, 0x7C, 0x07, 0xCF, 0xBE, 0x7E, 0x07, 0xE7,
  0xDE, 0x3E, 0x03, 0xE3, 0xFF, 0x1F, 0x01, 0xF1, 0xFF, 0x8F, 0x80, 0xF8,
  0xFF, 0x8F, 0xC0, 0x7C, 0x7F, 0xC7, 0xE0, 0x7E, 0x3F, 0xC3, 0xE0, 0x3E,
  0x1F, 0xE1, 0xF0, 0x1F, 0x0F, 0xE0, 0xF8, 0x0F, 0x87, 0xF0, 0xFC, 0x07,
  0xC1, 0xF0, 0x7E, 0x07, 0xE0, 0xF8, 0x3E, 0x00, 0x03, 0xF8, 0x03, 0xE0,
  0x7F, 0x00, 0x7C, 0x0F, 0xE0, 0x1F, 0x81, 0xFE, 0x03, 0xE0, 0x3F, 0xC0,
  0x7C, 0x0F, 0xF8, 0x0F, 0x81, 0xFF, 0x03, 0xF0, 0x3F, 0xF0, 0x7C, 0x07,
  0xFE, 0x0F, 0x80, 0xFF, 0xC1, 0xF0, 0x3E, 0xF8, 0x3E, 0x07, 0xDF, 0x0F,
  0xC0, 0xF9, 0xF1, 0xF0, 0x1F, 0x3E, 0x3E, 0x03, 0xE7, 0xC7, 0xC0, 0xFC,
  0xF8, 0xF8, 0x1F, 0x1F, 0xBF, 0x03, 0xE1, 0xF7, 0xC0, 0x7C, 0x3E, 0xF8,
  0x1F, 0x87, 0xDF, 0x03, 0xE0, 0xFB, 0xE0, 0x7C, 0x0F, 0xFC, 0x0F, 0x81,
  0xFF, 0x01, 0xF0, 0x3F, 0xE0, 0x7E, 0x07, 0xFC, 0x0F, 0x80, 0xFF, 0x81,
  0xF0, 0x0F, 0xE0, 0x3E, 0x01, 0xFC, 0x07, 0xC0, 0x3F, 0x81, 0xF8, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFC, 0x3F, 0x87, 0xF0, 0x3F, 0x0F, 0xC0,
  0x7E, 0x3F, 0x80, 0x7E, 0x7E, 0x00, 0xFD, 0xFC, 0x01, 0xFB, 0xF0, 0x07,
  0xF7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0xBF, 0x80, 0x3F, 0x7E, 0x00, 0x7E,
  0xFC, 0x00, 0xFD, 0xF8, 0x03, 0xFB, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF,
  0xC0, 0x3F, 0x9F, 0x80, 0x7E, 0x3F, 0x01, 0xFC, 0x7E, 0x07, 0xF0, 0xFE,
  0x1F, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0x87, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3,
  0xF0, 0x3F, 0x0F, 0xC1, 0xF8, 0x3E, 0x0F, 0xE0, 0xFF, 0xFF, 0x07, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFC, 0x3F, 0x87, 0xF0, 0x3F,
  0x0F, 0xC0, 0x7E, 0x3F, 0x80, 0x7E, 0x7E, 0x00, 0xFD, 0xFC, 0x01, 0xFB,
  0xF0, 0x07, 0xF7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0xBF, 0x00, 0x3F, 0x7E,
  0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x03, 0xFB, 0xF0, 0x07, 0xE7, 0xE0,
  0x0F, 0xCF, 0xC0, 0x3F, 0x9F, 0x80, 0x7E, 0x3F, 0x01, 0xFC, 0x7E, 0x07,
  0xF0, 0xFE, 0x1F, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xF8,
  0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x1F,
  0x07, 0xC0, 0xF8, 0x3E, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0xFC,
  0x3F, 0x07, 0xC7, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x80,
  0xFF, 0xF0, 0x07, 0xCF, 0xC0, 0x7E, 0x7E, 0x03, 0xF1, 0xF0, 0x1F, 0x8F,
  0xC0, 0xF8, 0x7E, 0x07, 0xC3, 0xF0, 0x7E, 0x0F, 0x83, 0xF0, 0x7E, 0x1F,
  0x83, 0xF0, 0xF8, 0x1F, 0x87, 0xC0, 0x7E, 0x7E, 0x03, 0xF0, 0x00, 0x7F,
  0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFE,
  0x0C, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x08, 0x03, 0xF0, 0xE0, 0x7F,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFE,
  0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xEF, 0xFF,
  0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03,
  0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7C,
  0x1F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3,
  0xF0, 0x1F, 0x07, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E,
  0x03, 0xF0, 0xFC, 0x07, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0,
  0x7E, 0x1F, 0x80, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x1F,
  0x81, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xBE, 0x00, 0xFD,
  0xF0, 0x0F, 0xCF, 0x80, 0x7E, 0x7C, 0x03, 0xE3, 0xE0, 0x3F, 0x1F, 0x01,
  0xF0, 0xF8, 0x1F, 0x87, 0xC0, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F,
  0x83, 0xE0, 0x7C, 0x3F, 0x03, 0xE1, 0xF0, 0x1F, 0x1F, 0x80, 0xF8, 0xF8,
  0x07, 0xCF, 0xC0, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0xBE, 0x00, 0x3D,
  0xF0, 0x01, 0xEF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x03, 0xE0, 0x1F, 0xBE, 0x01, 0xF0, 0x1F, 0x9F, 0x01, 0xF8, 0x0F, 0xCF,
  0x80, 0xFC, 0x07, 0xC7, 0xC0, 0xFE, 0x07, 0xE3, 0xE0, 0x7F, 0x03, 0xE1,
  0xF0, 0x3F, 0x83, 0xF0, 0xF8, 0x3F, 0xC1, 0xF8, 0x7C, 0x1F, 0xE0, 0xF8,
  0x3E, 0x1F, 0xF0, 0xFC, 0x1F, 0x0F, 0xF8, 0x7C, 0x0F, 0x8F, 0xFC, 0x7E,
  0x07, 0xC7, 0xFE, 0x3F, 0x03, 0xE3, 0xDF, 0x1F, 0x01, 0xF3, 0xEF, 0x9F,
  0x80, 0xF9, 0xF7, 0xCF, 0x80, 0x7D, 0xF3, 0xEF, 0xC0, 0x3E, 0xF9, 0xF7,
  0xE0, 0x1F, 0x78, 0xFB, 0xE0, 0x0F, 0xFC, 0x7F, 0xF0, 0x07, 0xBE, 0x3F,
  0xF0, 0x07, 0xDE, 0x1F, 0xF8, 0x03, 0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0x07,
  0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF0,
  0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x07, 0xE0, 0x1F, 0x83,
  0xF0, 0x07, 0xE0, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x0F,
  0x8F, 0xC0, 0x03, 0xF7, 0xE0, 0x00, 0xFD, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x01,
  0xFB, 0xF0, 0x00, 0xFC, 0x7C, 0x00, 0x3F, 0x1F, 0x00, 0x1F, 0x87, 0xE0,
  0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x03,
  0xF0, 0x3F, 0x00, 0xFC, 0x00, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x3F,
  0x7E, 0x0F, 0xC7, 0xC1, 0xF8, 0xF8, 0x7E, 0x1F, 0x0F, 0xC3, 0xE3, 0xF0,
  0x7E, 0x7C, 0x0F, 0xDF, 0x80, 0xFB, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x00, 0xF8, 0x3C, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x1E, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x1E, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x0F, 0xFC, 0x03, 0xEF, 0x80, 0x78, 0xF0, 0x1F, 0x1E, 0x07, 0xC3,
  0xE0, 0xF8, 0x7C, 0x3E, 0x07, 0x87, 0x80, 0xF1, 0xF0, 0x1F, 0x7C, 0x03,
  0xFF, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x7E, 0x7E, 0x3E, 0x1F,
  0x1F, 0x0F, 0x01, 0xF1, 0xF0, 0x7F, 0x9F, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE,
  0x1F, 0xFF, 0xE3, 0xF8, 0xFE, 0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x7E, 0x07,
  0xC7, 0xE0, 0x7C, 0x7E, 0x0F, 0xC7, 0xC0, 0xFC, 0xFC, 0x0F, 0x8F, 0xC0,
  0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x3F, 0x8F, 0xC3, 0xF0, 0xFE,
  0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xDF, 0x07, 0xF9, 0xF0, 0x3F, 0x1E, 0x00,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0xFC, 0x07, 0xDF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFE, 0x7F, 0x0F,
  0xC3, 0xF1, 0xF8, 0x3F, 0x1F, 0x83, 0xF1, 0xF0, 0x3F, 0x1F, 0x03, 0xF1,
  0xF0, 0x3F, 0x3F, 0x03, 0xF3, 0xF0, 0x3E, 0x3E, 0x07, 0xE3, 0xE0, 0x7E,
  0x3E, 0x07, 0xC7, 0xE0, 0xFC, 0x7F, 0x1F, 0x87, 0xF3, 0xF8, 0x7F, 0xFF,
  0x07, 0xBF, 0xF0, 0xFB, 0xFE, 0x0F, 0x9F, 0x80, 0x01, 0xFF, 0x01, 0xFF,
  0xC1, 0xFF, 0xC1, 0xFF, 0xE1, 0xFE, 0xE0, 0xFC, 0x10, 0xFC, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x04, 0x3F, 0xDE,
  0x0F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x07, 0xCF,
  0xC0, 0x7F, 0xBF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0x7F, 0x81,
  0xF8, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x1F, 0x07, 0xE0,
  0x7C, 0x1F, 0x03, 0xF0, 0x7C, 0x0F, 0xC3, 0xF0, 0x3E, 0x0F, 0xC0, 0xF8,
  0x3F, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC3, 0xF0, 0x3F,
  0x9F, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFD, 0xF0, 0x0F, 0xE7,
  0x80, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFF, 0x1F, 0x8F,
  0xC7, 0xC1, 0xF3, 0xF0, 0x7C, 0xF8, 0x3F, 0x7E, 0x1F, 0x9F, 0x1F, 0xE7,
  0xFF, 0xF1, 0xFF, 0xF8, 0xFF, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC,
  0x0F, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x7C, 0x07, 0xFD, 0xF0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xF7, 0xF8, 0x1F, 0x8F, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x1F, 0x81, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xC0, 0xFC, 0x3F, 0x03, 0xE0, 0xFC, 0x0F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x0F, 0xE0, 0xFC, 0x3F, 0x03, 0xFB, 0xFC, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xBF, 0x00, 0xFC, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x30, 0x0F, 0xC0, 0xFF,
  0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0xFC, 0x07, 0xDF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0x3E, 0x1F, 0x83,
  0xE1, 0xF0, 0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x3F, 0x07, 0xC3, 0xE0,
  0x7C, 0x3E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xF8, 0x7C,
  0x0F, 0x87, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF0, 0x00, 0xE0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0x00,
  0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xF0, 0x7C, 0x1F, 0x83, 0xF0, 0xFC,
  0x0F, 0xC7, 0xE0, 0x3E, 0x3F, 0x00, 0xF9, 0xF8, 0x03, 0xE7, 0xC0, 0x1F,
  0xBF, 0x00, 0x7D, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xDF, 0x80, 0x3E, 0x7E, 0x01,
  0xF8, 0xF8, 0x07, 0xE3, 0xF0, 0x1F, 0x0F, 0xC0, 0x7C, 0x1F, 0x01, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0x01, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0x07, 0x8F, 0xC3, 0xF0, 0x1E,
  0xFF, 0x9F, 0xE0, 0xFB, 0xFE, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x0F, 0xF7,
  0xFD, 0xFC, 0x3F, 0x0F, 0xE3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC7, 0xE0, 0xFC,
  0x3F, 0x1F, 0x83, 0xE0, 0xF8, 0x7C, 0x1F, 0x83, 0xE1, 0xF0, 0x7E, 0x0F,
  0x8F, 0xC1, 0xF0, 0x7E, 0x3F, 0x07, 0xC1, 0xF8, 0xF8, 0x1F, 0x07, 0xC3,
  0xE0, 0xFC, 0x1F, 0x0F, 0x83, 0xF0, 0x7C, 0x7E, 0x0F, 0x83, 0xF1, 0xF8,
  0x3E, 0x0F, 0xC7, 0xC1, 0xF8, 0x3E, 0x1F, 0x07, 0xE0, 0xF8, 0x7C, 0x1F,
  0x07, 0xE3, 0xF0, 0x7C, 0x1F, 0x8F, 0xC1, 0xF0, 0x7C, 0x00, 0x07, 0x8F,
  0xC0, 0x79, 0xFE, 0x0F, 0xBF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF1, 0xF8, 0x3F, 0x1F, 0x83, 0xE1, 0xF8, 0x3E, 0x1F,
  0x07, 0xE3, 0xF0, 0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0x7C, 0x3E, 0x07, 0xC3,
  0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xF8, 0x7E, 0x0F, 0x87, 0xC0, 0xF8,
  0x7C, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x1F, 0x00, 0x01, 0xFE, 0x00, 0xFF,
  0xC0, 0xFF, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0xCF, 0xE3, 0xF3, 0xF0, 0x7C,
  0xF8, 0x1F, 0x7E, 0x07, 0xDF, 0x81, 0xF7, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFB, 0xF0, 0x7E, 0xFC, 0x1F, 0xBF, 0x0F,
  0xC7, 0xEF, 0xF1, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0x00,
  0x01, 0xE3, 0xF0, 0x07, 0x9F, 0xE0, 0x3E, 0xFF, 0x80, 0xFF, 0xFF, 0x03,
  0xF9, 0xFC, 0x0F, 0xC3, 0xF0, 0x3E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x03, 0xF0, 0x7C, 0x0F, 0xC3, 0xF0, 0x3E, 0x0F, 0xC0, 0xF8,
  0x3E, 0x07, 0xE0, 0xF8, 0x1F, 0x83, 0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x7F,
  0x1F, 0xC1, 0xFE, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFD, 0xFE,
  0x03, 0xF7, 0xF0, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF9, 0xF0, 0x7F, 0xDF,
  0x07, 0xFD, 0xF0, 0xFF, 0xFE, 0x1F, 0xDF, 0xE1, 0xF8, 0xFE, 0x3F, 0x07,
  0xE3, 0xE0, 0x7C, 0x7E, 0x07, 0xC7, 0xE0, 0x7C, 0x7C, 0x0F, 0xC7, 0xC0,
  0xFC, 0xFC, 0x0F, 0x8F, 0xC0, 0xF8, 0xFC, 0x0F, 0x8F, 0xC1, 0xF8, 0xFC,
  0x1F, 0x8F, 0xC3, 0xF0, 0xFE, 0x7F, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x07,
  0xFB, 0xF0, 0x3F, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x8F, 0x83, 0xCF, 0x83, 0xEF,
  0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xD0, 0x7F, 0x80, 0x3F, 0x80, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80,
  0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x03, 0xFE, 0x03, 0xFF, 0xC3,
  0xFF, 0xC3, 0xFF, 0xE1, 0xF8, 0x60, 0xF8, 0x10, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x40, 0x7E, 0x3C, 0x7F, 0x1F,
  0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0x00, 0x03, 0xC0, 0x3C, 0x01,
  0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xF1, 0xF8,
  0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x90, 0xFF,
  0x87, 0xFC, 0x3F, 0xE0, 0xFF, 0x00, 0x0F, 0x83, 0xF1, 0xF8, 0x3F, 0x1F,
  0x83, 0xE1, 0xF0, 0x3E, 0x1F, 0x03, 0xE1, 0xF0, 0x7E, 0x3F, 0x07, 0xE3,
  0xF0, 0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0xFC, 0x3E, 0x0F, 0xC7, 0xE0, 0xF8,
  0x7E, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x1F, 0x87, 0xC1, 0xF8, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFE, 0x7F, 0x0F, 0xFF, 0xF0, 0x7F, 0xDF, 0x07, 0xFD,
  0xE0, 0x3F, 0x1E, 0x00, 0xFC, 0x07, 0xFF, 0x03, 0xF7, 0xC0, 0xF9, 0xF0,
  0x7E, 0x7C, 0x1F, 0x1F, 0x0F, 0xC7, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x7C,
  0x1F, 0x1F, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x7D, 0xF8, 0x1F, 0x7C, 0x07,
  0xDF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x3F, 0x03, 0xFF,
  0x07, 0xE0, 0xFF, 0xE1, 0xFC, 0x1F, 0x7C, 0x3F, 0x87, 0xEF, 0x8F, 0xF0,
  0xF9, 0xF1, 0xFE, 0x1F, 0x3E, 0x3F, 0xC7, 0xC7, 0xCF, 0x78, 0xF8, 0xF9,
  0xEF, 0x3F, 0x1F, 0x7D, 0xE7, 0xC3, 0xEF, 0x3C, 0xF8, 0x7D, 0xE7, 0xBE,
  0x0F, 0x7C, 0xF7, 0xC1, 0xEF, 0x1F, 0xF0, 0x3D, 0xE3, 0xFE, 0x07, 0xF8,
  0x7F, 0xC0, 0xFF, 0x0F, 0xF0, 0x1F, 0xE3, 0xFE, 0x03, 0xF8, 0x7F, 0x80,
  0x7F, 0x0F, 0xF0, 0x0F, 0xE1, 0xFC, 0x01, 0xF8, 0x3F, 0x80, 0x3F, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0xFE, 0x0F, 0xC1, 0xF8, 0x0F, 0x87, 0xE0, 0x1F,
  0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x3E, 0xFC, 0x00, 0x7D, 0xF0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x0F, 0xDF, 0x00, 0x1F, 0x3E, 0x00, 0x7E, 0x7E, 0x01, 0xF8, 0xFC, 0x03,
  0xF0, 0xF8, 0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x3F,
  0x03, 0xE0, 0x7E, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0xFC, 0x03, 0xE0, 0xFC,
  0x03, 0xE1, 0xF8, 0x03, 0xE1, 0xF8, 0x03, 0xE1, 0xF0, 0x03, 0xE3, 0xF0,
  0x03, 0xE3, 0xE0, 0x03, 0xE7, 0xE0, 0x03, 0xE7, 0xC0, 0x03, 0xEF, 0xC0,
  0x01, 0xEF, 0x80, 0x01, 0xEF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F,
  0xFF, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x3F, 0x80, 0x7F, 0xC0, 0x3F, 0x80, 0x1F, 0x00, 0x0F, 0xE0, 0x0F, 0xF8,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x0C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xE0, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x03, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x3F, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xF0, 0x07, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80,
  0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0xE0, 0x00, 0x3F, 0x00, 0x7F, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xE0, 0x1F, 0xE8, 0x00, 0xE0,
};

const GFXglyph NotoSans_Condensed_BoldItalic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 13, 30, 11, 0, -30 },
  { 50, 15, 11, 17, 4, -30 },
  { 71, 23, 30, 22, 0, -30 },
  { 158, 20, 34, 19, 0, -32 },
  { 243, 28, 30, 32, 2, -30 },
  { 348, 24, 30, 24, 0, -30 },
  { 438, 7, 11, 10, 4, -30 },
  { 448, 14, 37, 12, 1, -30 },
  { 513, 14, 38, 12, -3, -31 },
  { 580, 17, 18, 19, 3, -32 },
  { 619, 18, 20, 21, 2, -25 },
  { 664, 9, 11, 11, -2, -5 },
  { 677, 11, 5, 13, 1, -14 },
  { 684, 7, 6, 11, 0, -6 },
  { 690, 22, 30, 16, -2, -30 },
  { 773, 19, 30, 19, 1, -30 },
  { 845, 14, 30, 20, 4, -30 },
  { 898, 21, 30, 19, -1, -30 },
  { 977, 20, 30, 19, 0, -30 },
  { 1052, 21, 30, 20, -1, -30 },
  { 1131, 20, 30, 19, 0, -30 },
  { 1206, 20, 30, 19, 1, -30 },
  { 1281, 21, 30, 19, 1, -30 },
  { 1360, 20, 30, 19, 0, -30 },
  { 1435, 19, 30, 19, 0, -30 },
  { 1507, 11, 23, 11, 0, -23 },
  { 1539, 13, 29, 11, -2, -23 },
  { 1587, 18, 20, 21, 2, -25 },
  { 1632, 18, 13, 21, 2, -21 },
  { 1662, 18, 20, 21, 2, -25 },
  { 1707, 15, 30, 16, 2, -30 },
  { 1764, 29, 33, 30, 1, -30 },
  { 1884, 22, 30, 22, -3, -30 },
  { 1967, 22, 30, 22, 0, -30 },
  { 2050, 21, 30, 21, 2, -30 },
  { 2129, 23, 30, 24, 0, -30 },
  { 2216, 20, 30, 19, 0, -30 },
  { 2291, 20, 30, 18, 0, -30 },
  { 2366, 23, 30, 24, 2, -30 },
  { 2453, 26, 30, 24, 0, -30 },
  { 2551, 19, 30, 14, -2, -30 },
  { 2623, 20, 39, 11, -7, -30 },
  { 2721, 25, 30, 21, 0, -30 },
  { 2815, 15, 30, 18, 0, -30 },
  { 2872, 33, 30, 32, 0, -30 },
  { 2996, 27, 30, 26, 0, -30 },
  { 3098, 23, 30, 25, 2, -30 },
  { 3185, 22, 30, 21, 0, -30 },
  { 3268, 23, 37, 25, 2, -30 },
  { 3375, 21, 30, 21, 0, -30 },
  { 3454, 20, 30, 19, 0, -30 },
  { 3529, 19, 30, 18, 3, -30 },
  { 3601, 23, 30, 24, 2, -30 },
  { 3688, 21, 30, 21, 4, -30 },
  { 3767, 33, 30, 32, 3, -30 },
  { 3891, 26, 30, 21, -2, -30 },
  { 3989, 19, 30, 20, 4, -30 },
  { 4061, 23, 30, 18, -2, -30 },
  { 4148, 17, 37, 13, -1, -30 },
  { 4227, 9, 30, 16, 4, -30 },
  { 4261, 17, 37, 13, -3, -30 },
  { 4340, 19, 18, 20, 0, -30 },
  { 4383, 15, 2, 15, -4, 4 },
  { 4387, 8, 7, 13, 6, -32 },
  { 4394, 20, 23, 21, 1, -23 },
  { 4452, 20, 32, 21, 0, -32 },
  { 4532, 17, 23, 17, 1, -23 },
  { 4581, 22, 32, 21, 1, -32 },
  { 4669, 18, 23, 19, 1, -23 },
  { 4721, 23, 42, 13, -5, -32 },
  { 4842, 22, 33, 21, -1, -23 },
  { 4933, 20, 32, 21, 0, -32 },
  { 5013, 12, 32, 11, 0, -32 },
  { 5061, 17, 42, 11, -5, -32 },
  { 5151, 22, 32, 20, 0, -32 },
  { 5239, 12, 32, 10, 0, -32 },
  { 5287, 30, 23, 31, 0, -23 },
  { 5374, 20, 23, 21, 0, -23 },
  { 5432, 18, 23, 21, 1, -23 },
  { 5484, 22, 33, 21, -2, -23 },
  { 5575, 20, 33, 21, 1, -23 },
  { 5658, 17, 23, 15, 0, -23 },
  { 5707, 17, 23, 17, 0, -23 },
  { 5756, 13, 28, 14, 2, -28 },
  { 5802, 20, 23, 21, 1, -23 },
  { 5860, 18, 23, 18, 2, -23 },
  { 5912, 27, 23, 28, 3, -23 },
  { 5990, 23, 23, 19, -2, -23 },
  { 6057, 24, 33, 18, -3, -23 },
  { 6156, 18, 23, 16, -1, -23 },
  { 6208, 17, 37, 14, 0, -30 },
  { 6287, 5, 42, 18, 6, -32 },
  { 6314, 16, 37, 14, -2, -30 },
  { 6388, 18, 7, 21, 2, -18 },
};

const GFXfont NotoSans_Condensed_BoldItalic42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BoldItalic42pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BoldItalic42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_CONDENSED_BOLDITALIC42PT7B_H_
