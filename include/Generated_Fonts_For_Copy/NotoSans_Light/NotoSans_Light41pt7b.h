#ifndef _NOTOSANS_LIGHT41PT7B_H_
#define _NOTOSANS_LIGHT41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light41pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60,
  0x00, 0x06, 0xFF, 0xF0, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xC0, 0x00, 0x70, 0x30, 0x00, 0x60, 0x30, 0x00, 0x60,
  0x30, 0x00, 0x60, 0x30, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x60, 0x00, 0xC0,
  0x60, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x60, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0x80,
  0xC0, 0x01, 0x81, 0x80, 0x03, 0x01, 0x80, 0x03, 0x01, 0x80, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0x03, 0x01, 0x80, 0x06, 0x03, 0x00, 0x06, 0x03,
  0x00, 0x06, 0x03, 0x00, 0x06, 0x03, 0x00, 0x06, 0x03, 0x00, 0x0C, 0x06,
  0x00, 0x0C, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x01, 0xFF, 0x83, 0xFF, 0xF3, 0xCC, 0x3B, 0x86, 0x01, 0x83, 0x00,
  0xC1, 0x80, 0x60, 0xC0, 0x30, 0x60, 0x18, 0x30, 0x0E, 0x18, 0x03, 0x8C,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x67, 0xC0,
  0x30, 0xE0, 0x18, 0x38, 0x0C, 0x0C, 0x06, 0x06, 0x03, 0x03, 0x01, 0x81,
  0x80, 0xC1, 0xE0, 0x61, 0xDF, 0xB7, 0xCF, 0xFF, 0xC0, 0xFF, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x38, 0x0E, 0x30, 0x01, 0x80, 0xC0, 0xC0, 0x18, 0x06, 0x06, 0x00, 0xC0,
  0x30, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0xE0, 0x18, 0x06, 0x06, 0x00, 0xC0,
  0x30, 0x70, 0x06, 0x01, 0x83, 0x00, 0x30, 0x0C, 0x30, 0x01, 0x80, 0x61,
  0x80, 0x0C, 0x03, 0x18, 0x78, 0x30, 0x38, 0xC7, 0xF1, 0x81, 0x8C, 0x61,
  0xCC, 0x0C, 0xE7, 0x06, 0x39, 0xC6, 0x30, 0x30, 0xFC, 0x71, 0x80, 0xC3,
  0x83, 0x0C, 0x06, 0x00, 0x30, 0xC0, 0x30, 0x01, 0x86, 0x01, 0x80, 0x18,
  0x30, 0x0C, 0x00, 0xC1, 0x80, 0x60, 0x0C, 0x0E, 0x03, 0x00, 0x60, 0x30,
  0x18, 0x06, 0x01, 0x80, 0xC0, 0x70, 0x0C, 0x0C, 0x03, 0x00, 0x30, 0x60,
  0x30, 0x01, 0xEE, 0x03, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xC0, 0x38, 0x00,
  0x38, 0x03, 0x00, 0x07, 0x00, 0x60, 0x00, 0xE0, 0x0C, 0x00, 0x0C, 0x03,
  0x80, 0x01, 0xC0, 0x60, 0x00, 0x18, 0x1C, 0x00, 0x03, 0x8F, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7B, 0x80,
  0x00, 0x1E, 0x38, 0x01, 0x87, 0x03, 0x80, 0x31, 0xC0, 0x38, 0x0E, 0x38,
  0x03, 0x81, 0x86, 0x00, 0x38, 0x71, 0xC0, 0x03, 0x8C, 0x38, 0x00, 0x3B,
  0x87, 0x00, 0x03, 0xE0, 0x60, 0x00, 0x38, 0x0E, 0x00, 0x0F, 0x81, 0xC0,
  0x03, 0xB8, 0x1E, 0x01, 0xE3, 0x81, 0xFF, 0xF8, 0x38, 0x0F, 0xFC, 0x03,
  0xC0, 0xFF, 0xFF, 0xF0, 0x07, 0x0E, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0x70,
  0x60, 0x60, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xE0, 0xE0, 0x60, 0x60, 0x70, 0x30, 0x30, 0x38, 0x18,
  0x0C, 0x0E, 0x07, 0xE0, 0x18, 0x0E, 0x03, 0x01, 0xC0, 0x60, 0x38, 0x0C,
  0x06, 0x03, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x81, 0x80, 0xC0, 0xE0,
  0x60, 0x30, 0x30, 0x38, 0x18, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x20, 0x30, 0x1F, 0x0C, 0x1F, 0xFB,
  0x3F, 0x1F, 0xFE, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0E, 0xC0, 0x03, 0x18,
  0x01, 0x87, 0x00, 0xE0, 0xC0, 0x70, 0x3C, 0x0C, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x39, 0x9C, 0xE6, 0x31,
  0x98, 0xC6, 0x00, 0xFF, 0xFF, 0xF0, 0x6F, 0xFF, 0x00, 0x1C, 0x00, 0x60,
  0x03, 0x80, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0,
  0x03, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0,
  0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80,
  0x06, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0xFF, 0x80, 0x3E, 0x7C, 0x0E, 0x03, 0x83, 0x80, 0x38, 0x60,
  0x03, 0x9C, 0x00, 0x33, 0x80, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x1D, 0x80,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xB0, 0x00, 0x36, 0x00,
  0x0E, 0xC0, 0x01, 0xD8, 0x00, 0x33, 0x80, 0x06, 0x30, 0x01, 0xC7, 0x00,
  0x30, 0x60, 0x0E, 0x0E, 0x03, 0x80, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x01,
  0xC0, 0xF0, 0xEC, 0x73, 0x38, 0xFC, 0x34, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x00, 0xE0, 0x01, 0xFF, 0x80, 0xFC, 0xF8, 0x38, 0x03, 0x82, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x01, 0xF0, 0x03, 0xFF, 0x81, 0xFC, 0xFC, 0x78, 0x03, 0xC4, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x7C, 0x03, 0xFC, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x3A, 0x00, 0x0E, 0x70, 0x03, 0xCF, 0xFF, 0xE0, 0x7F, 0xF8, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x60, 0x00,
  0x19, 0x80, 0x00, 0xE6, 0x00, 0x07, 0x18, 0x00, 0x18, 0x60, 0x00, 0xC1,
  0x80, 0x07, 0x06, 0x00, 0x18, 0x18, 0x00, 0xC0, 0x60, 0x07, 0x01, 0x80,
  0x38, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x60, 0x38, 0x01, 0x80, 0xC0,
  0x06, 0x06, 0x00, 0x18, 0x38, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x3F, 0xFF, 0x0F, 0xFF,
  0xC3, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x9F, 0x80, 0x7F,
  0xFC, 0x1E, 0x1F, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x03, 0xA0, 0x01, 0xCC, 0x00, 0xE3, 0xFF, 0xF0, 0x7F,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0xC0, 0x7C, 0x10, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x00, 0xC3, 0xF8, 0x33, 0xFF, 0x8D, 0xC0, 0x73,
  0xC0, 0x0E, 0xE0, 0x01, 0xB8, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0x60, 0x01, 0xDC, 0x00,
  0x63, 0x80, 0x38, 0x70, 0x1C, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xC0,
  0x7C, 0x7C, 0x1C, 0x01, 0xC3, 0x00, 0x1C, 0xE0, 0x03, 0x9C, 0x00, 0x33,
  0x80, 0x06, 0x70, 0x00, 0xC6, 0x00, 0x38, 0xE0, 0x06, 0x0E, 0x03, 0x80,
  0xF0, 0xE0, 0x0F, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xE0, 0x1E, 0x0F, 0x07,
  0x00, 0x70, 0xC0, 0x07, 0x30, 0x00, 0x66, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0x60, 0x00, 0xEC, 0x00, 0x19, 0xC0, 0x07, 0x1C,
  0x01, 0xC1, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0xE0, 0x01, 0xFF, 0x80,
  0x7C, 0x78, 0x1C, 0x03, 0x87, 0x00, 0x38, 0xC0, 0x03, 0x18, 0x00, 0x77,
  0x00, 0x06, 0xE0, 0x00, 0xDC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0E, 0xC0, 0x01, 0xDC, 0x00, 0x79, 0xC0, 0x1B, 0x3C, 0x0E, 0xE1,
  0xFF, 0x9C, 0x0F, 0x83, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x7F, 0xF6, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x6F, 0xFF, 0x18, 0xF3, 0xC6, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x63, 0x8E, 0x38, 0xC3, 0x1C,
  0x61, 0x8E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1C, 0x00, 0x00,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x03, 0x80, 0xFF, 0xE3, 0xF3, 0xE2, 0x00, 0xE0, 0x00, 0xE0,
  0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xF0, 0x03, 0xE0, 0x03,
  0xC0, 0x00, 0x70, 0x07, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x06, 0x30, 0x03, 0xFC, 0x06, 0x30,
  0x0F, 0xFE, 0x07, 0x70, 0x1C, 0x06, 0x03, 0x60, 0x38, 0x06, 0x03, 0x60,
  0x30, 0x06, 0x03, 0x60, 0x60, 0x06, 0x03, 0xC0, 0x60, 0x06, 0x03, 0xC0,
  0x60, 0x06, 0x03, 0xC0, 0x60, 0x06, 0x03, 0xC0, 0x60, 0x0E, 0x03, 0xC0,
  0x60, 0x0E, 0x03, 0xC0, 0x60, 0x0E, 0x06, 0xE0, 0x60, 0x1E, 0x06, 0x60,
  0x70, 0x1E, 0x0E, 0x60, 0x3C, 0x73, 0x1C, 0x60, 0x1F, 0xE3, 0xF8, 0x30,
  0x01, 0x00, 0x40, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x01, 0x00, 0x03,
  0xE0, 0x0F, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00,
  0x03, 0x70, 0x00, 0x03, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x30, 0x18,
  0x00, 0x38, 0x0E, 0x00, 0x18, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x0E, 0x00,
  0xE0, 0x06, 0x00, 0x30, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0x80,
  0x03, 0x01, 0xC0, 0x01, 0xC0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x70,
  0x00, 0x1C, 0x30, 0x00, 0x06, 0x38, 0x00, 0x03, 0x98, 0x00, 0x01, 0xCC,
  0x00, 0x00, 0x6E, 0x00, 0x00, 0x38, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xC0,
  0x07, 0x8C, 0x00, 0x1C, 0xC0, 0x00, 0xCC, 0x00, 0x0E, 0xC0, 0x00, 0xEC,
  0x00, 0x0E, 0xC0, 0x00, 0xEC, 0x00, 0x0C, 0xC0, 0x01, 0xCC, 0x00, 0x38,
  0xC0, 0x3F, 0x0F, 0xFF, 0x80, 0xFF, 0xFF, 0x0C, 0x00, 0x3C, 0xC0, 0x00,
  0xEC, 0x00, 0x0E, 0xC0, 0x00, 0x6C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x6C, 0x00, 0x0E, 0xC0, 0x00, 0xEC, 0x00, 0x1C, 0xC0,
  0x07, 0x8F, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0xFF,
  0x80, 0xFE, 0xFE, 0x1E, 0x00, 0x31, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x20, 0x7F, 0xFF, 0x00,
  0xFF, 0xF8, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0x00, 0x1F, 0x06, 0x00,
  0x0F, 0x0C, 0x00, 0x07, 0x18, 0x00, 0x07, 0x30, 0x00, 0x0E, 0x60, 0x00,
  0x0E, 0xC0, 0x00, 0x1D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0xEC,
  0x00, 0x01, 0xD8, 0x00, 0x03, 0x30, 0x00, 0x0E, 0x60, 0x00, 0x38, 0xC0,
  0x00, 0xE1, 0x80, 0x07, 0x83, 0x00, 0x7E, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0xFF, 0xFC, 0x03, 0xFD, 0xFE, 0x07, 0x80, 0x06, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x07, 0xFF, 0xC0, 0x07,
  0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x07, 0x70, 0x00, 0x07, 0x38, 0x00,
  0x07, 0x3C, 0x00, 0x07, 0x1E, 0x00, 0x07, 0x0F, 0x80, 0x0F, 0x03, 0xFF,
  0xFF, 0x00, 0xFF, 0xF8, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1C,
  0xFF, 0x9F, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x1F, 0xFF, 0xF8, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x01, 0xC0, 0xEF, 0xFB, 0xF8, 0xC0, 0x00, 0xFC, 0x00, 0x1C, 0xC0,
  0x03, 0x8C, 0x00, 0x70, 0xC0, 0x0E, 0x0C, 0x01, 0xC0, 0xC0, 0x38, 0x0C,
  0x07, 0x00, 0xC0, 0xE0, 0x0C, 0x0C, 0x00, 0xC1, 0xC0, 0x0C, 0x38, 0x00,
  0xC7, 0x00, 0x0C, 0xF8, 0x00, 0xD9, 0xC0, 0x0F, 0x1C, 0x00, 0xE0, 0xE0,
  0x0C, 0x07, 0x00, 0xC0, 0x38, 0x0C, 0x03, 0x80, 0xC0, 0x1C, 0x0C, 0x00,
  0xE0, 0xC0, 0x0E, 0x0C, 0x00, 0x70, 0xC0, 0x03, 0x8C, 0x00, 0x1C, 0xC0,
  0x01, 0xCC, 0x00, 0x0E, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFD, 0x80, 0x00, 0x1F, 0xDC, 0x00, 0x03, 0x7C, 0xC0,
  0x00, 0x37, 0xCC, 0x00, 0x07, 0x7C, 0xE0, 0x00, 0x67, 0xC6, 0x00, 0x06,
  0x7C, 0x70, 0x00, 0xC7, 0xC3, 0x00, 0x0C, 0x7C, 0x30, 0x01, 0xC7, 0xC3,
  0x80, 0x18, 0x7C, 0x18, 0x01, 0x87, 0xC1, 0xC0, 0x30, 0x7C, 0x0C, 0x03,
  0x07, 0xC0, 0xC0, 0x70, 0x7C, 0x0E, 0x06, 0x07, 0xC0, 0x60, 0x60, 0x7C,
  0x07, 0x0E, 0x07, 0xC0, 0x70, 0xC0, 0x7C, 0x03, 0x1C, 0x07, 0xC0, 0x39,
  0x80, 0x7C, 0x01, 0x98, 0x07, 0xC0, 0x1B, 0x80, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x0F, 0x00, 0x7C, 0x00, 0xE0, 0x07, 0xC0, 0x06, 0x00, 0x70, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xDC, 0x00,
  0x0F, 0x30, 0x00, 0x3C, 0xE0, 0x00, 0xF1, 0xC0, 0x03, 0xC3, 0x00, 0x0F,
  0x0E, 0x00, 0x3C, 0x1C, 0x00, 0xF0, 0x30, 0x03, 0xC0, 0xE0, 0x0F, 0x01,
  0xC0, 0x3C, 0x03, 0x00, 0xF0, 0x0E, 0x03, 0xC0, 0x1C, 0x0F, 0x00, 0x30,
  0x3C, 0x00, 0xE0, 0xF0, 0x01, 0xC3, 0xC0, 0x03, 0x0F, 0x00, 0x0E, 0x3C,
  0x00, 0x1C, 0xF0, 0x00, 0x33, 0xC0, 0x00, 0xEF, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1C, 0x00, 0x1F, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x3C, 0x00, 0xF0, 0x1C, 0x00, 0x1E, 0x0E,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x0C, 0x30, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x81, 0xE0, 0x01, 0xC0, 0x3C,
  0x01, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF8, 0x3F,
  0xFF, 0x8C, 0x00, 0xF3, 0x00, 0x0E, 0xC0, 0x01, 0xB0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x06,
  0xC0, 0x03, 0xB0, 0x01, 0xCC, 0x03, 0xE3, 0xFF, 0xF0, 0xFF, 0xE0, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0x3F,
  0x80, 0x3C, 0x00, 0xF0, 0x1C, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x6E,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xB8,
  0x00, 0x00, 0xE6, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x07,
  0x0E, 0x00, 0x03, 0x81, 0xE0, 0x01, 0xC0, 0x3C, 0x01, 0xE0, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xC0, 0x0F, 0x0C,
  0x00, 0x38, 0xC0, 0x01, 0x8C, 0x00, 0x1C, 0xC0, 0x01, 0xCC, 0x00, 0x1C,
  0xC0, 0x01, 0xCC, 0x00, 0x1C, 0xC0, 0x01, 0xCC, 0x00, 0x38, 0xC0, 0x03,
  0x8C, 0x00, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x80, 0xC0, 0x18, 0x0C, 0x01, 0xC0, 0xC0, 0x0E, 0x0C, 0x00, 0xE0, 0xC0,
  0x07, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x8C, 0x00, 0x1C, 0xC0, 0x01, 0xCC,
  0x00, 0x0E, 0xC0, 0x00, 0x70, 0x00, 0xF0, 0x03, 0xFF, 0xF1, 0xFB, 0xF8,
  0xE0, 0x02, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x3B, 0x80, 0x1C, 0xFF, 0xFE, 0x1F, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0x98, 0x00, 0x0E,
  0x70, 0x00, 0x30, 0xE0, 0x01, 0xC1, 0xE0, 0x1E, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0x00, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x06, 0x70, 0x00, 0x0E, 0x70,
  0x00, 0x0C, 0x30, 0x00, 0x0C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x18, 0x18,
  0x00, 0x38, 0x1C, 0x00, 0x38, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x70, 0x0E,
  0x00, 0x70, 0x06, 0x00, 0x60, 0x07, 0x00, 0xE0, 0x07, 0x00, 0xC0, 0x03,
  0x00, 0xC0, 0x03, 0x81, 0xC0, 0x01, 0x81, 0x80, 0x01, 0x83, 0x80, 0x01,
  0xC3, 0x80, 0x00, 0xC3, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x18, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x1C,
  0x00, 0x1D, 0x80, 0x07, 0x80, 0x03, 0x30, 0x00, 0xF8, 0x00, 0xE7, 0x00,
  0x1B, 0x00, 0x1C, 0xE0, 0x07, 0x60, 0x03, 0x0C, 0x00, 0xCE, 0x00, 0x61,
  0x80, 0x18, 0xC0, 0x1C, 0x38, 0x03, 0x18, 0x03, 0x83, 0x00, 0xE3, 0x00,
  0x60, 0x60, 0x18, 0x70, 0x0C, 0x0E, 0x03, 0x06, 0x03, 0x81, 0xC0, 0xE0,
  0xC0, 0x70, 0x18, 0x18, 0x1C, 0x0C, 0x03, 0x03, 0x01, 0x81, 0x80, 0x70,
  0x60, 0x30, 0x70, 0x0E, 0x1C, 0x06, 0x0C, 0x00, 0xC3, 0x00, 0xE1, 0x80,
  0x18, 0x60, 0x0C, 0x70, 0x03, 0x8C, 0x01, 0x8E, 0x00, 0x33, 0x80, 0x39,
  0x80, 0x06, 0x60, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x6E, 0x00, 0x1D, 0x80,
  0x0D, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x70, 0x00, 0x1C, 0xE0, 0x00, 0xE1, 0x80, 0x07, 0x07, 0x00, 0x18, 0x0E,
  0x00, 0xE0, 0x18, 0x07, 0x00, 0x70, 0x18, 0x00, 0xC0, 0xE0, 0x03, 0x83,
  0x00, 0x07, 0x18, 0x00, 0x0C, 0xE0, 0x00, 0x3B, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0xEC, 0x00, 0x07,
  0x38, 0x00, 0x18, 0x70, 0x00, 0xE0, 0xC0, 0x03, 0x03, 0x80, 0x18, 0x07,
  0x00, 0xE0, 0x0C, 0x03, 0x00, 0x38, 0x1C, 0x00, 0x70, 0xE0, 0x00, 0xC3,
  0x00, 0x03, 0x9C, 0x00, 0x06, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1D, 0xC0,
  0x00, 0xE3, 0x00, 0x03, 0x0E, 0x00, 0x1C, 0x18, 0x00, 0x60, 0x70, 0x03,
  0x80, 0xC0, 0x0C, 0x03, 0x80, 0x70, 0x06, 0x01, 0x80, 0x1C, 0x0E, 0x00,
  0x30, 0x30, 0x00, 0xE1, 0xC0, 0x01, 0x86, 0x00, 0x07, 0x38, 0x00, 0x0F,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x7F, 0xFF, 0xE0, 0xE0, 0x01, 0x80,
  0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xE0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80,
  0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C,
  0xFF, 0xFF, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xB0, 0x00,
  0x1B, 0x00, 0x03, 0x18, 0x00, 0x31, 0x80, 0x07, 0x0C, 0x00, 0x60, 0xC0,
  0x0E, 0x06, 0x00, 0xC0, 0x60, 0x1C, 0x03, 0x01, 0x80, 0x30, 0x38, 0x01,
  0x83, 0x00, 0x1C, 0x70, 0x00, 0xC6, 0x00, 0x0E, 0xE0, 0x00, 0x6C, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0,
  0x07, 0xF8, 0x1F, 0xFF, 0x06, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x3F, 0xC3, 0xFF, 0xE7,
  0xE0, 0x77, 0x80, 0x3B, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xF0, 0x03, 0xF8, 0x03, 0xEE, 0x03, 0x37, 0xFF, 0x98, 0xFF, 0x0C, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0xFE, 0x0C, 0xFF, 0xE3,
  0x70, 0x3C, 0xF0, 0x03, 0x38, 0x00, 0xEE, 0x00, 0x1B, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x6E, 0x00, 0x3B,
  0xC0, 0x0C, 0xD8, 0x0F, 0x33, 0xFF, 0x88, 0x7F, 0x80, 0x01, 0xFE, 0x07,
  0xFF, 0x1E, 0x01, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1E,
  0x01, 0x0F, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x7F, 0x0C, 0x3F, 0xF9, 0x8F, 0x03, 0xB3, 0x80, 0x16,
  0x60, 0x03, 0xDC, 0x00, 0x3B, 0x00, 0x07, 0x60, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1B,
  0x00, 0x07, 0x60, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x07, 0x9C, 0x00, 0xB1,
  0xC0, 0x36, 0x1F, 0xFC, 0xC1, 0xFF, 0x18, 0x03, 0xFC, 0x03, 0xFF, 0x81,
  0xE0, 0x70, 0xE0, 0x0E, 0x30, 0x01, 0x9C, 0x00, 0x76, 0x00, 0x0D, 0x80,
  0x03, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x78, 0x02, 0x0F, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xFC, 0x1F,
  0xF0, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x01, 0xFF, 0x8F, 0xFE, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x00, 0x03, 0xF8, 0x61, 0xFF, 0xCC, 0x78, 0x1D, 0x9C,
  0x00, 0xF3, 0x00, 0x1E, 0xE0, 0x01, 0xD8, 0x00, 0x3B, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xD8, 0x00, 0x3B, 0x00, 0x07, 0x70, 0x00, 0xEE, 0x00, 0x3C, 0xE0,
  0x05, 0x8E, 0x03, 0xB0, 0xFF, 0xE6, 0x0F, 0xF8, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE2, 0x00,
  0x38, 0x7C, 0x1F, 0x0F, 0xFF, 0x80, 0x1F, 0xC0, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x61, 0xFC, 0x33, 0xFF, 0x9B, 0x81, 0xEF, 0x00, 0x77,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x06, 0x7F, 0xA0, 0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D,
  0xB6, 0xC0, 0x03, 0x07, 0x07, 0x02, 0x00, 0x00, 0x00, 0x00, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x07, 0x07, 0x8E, 0xFC, 0xF8, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x0E, 0xC0, 0x1C, 0xC0, 0x38, 0xC0, 0x30, 0xC0, 0x70, 0xC0, 0xE0,
  0xC1, 0xC0, 0xC3, 0x80, 0xC7, 0x00, 0xCE, 0x00, 0xDF, 0x00, 0xFB, 0x00,
  0xF3, 0x80, 0xE1, 0xC0, 0xC0, 0xE0, 0xC0, 0x60, 0xC0, 0x70, 0xC0, 0x38,
  0xC0, 0x1C, 0xC0, 0x0C, 0xC0, 0x0E, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xC7, 0xF0, 0x1F, 0xC6, 0x7F, 0xE3, 0xFF, 0x36,
  0x07, 0x38, 0x1D, 0xE0, 0x1F, 0x00, 0x7E, 0x00, 0x78, 0x03, 0xF0, 0x03,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C,
  0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0C,
  0xC3, 0xF8, 0x67, 0xFF, 0x37, 0x03, 0xDE, 0x00, 0xEE, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0C, 0x03,
  0xFC, 0x00, 0xFF, 0xF0, 0x1E, 0x03, 0x83, 0x80, 0x1C, 0x30, 0x00, 0xC7,
  0x00, 0x0E, 0x60, 0x00, 0x66, 0x00, 0x06, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x60, 0x00,
  0x76, 0x00, 0x06, 0x70, 0x00, 0xE3, 0x00, 0x0E, 0x38, 0x01, 0xC1, 0xC0,
  0x38, 0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0xC3, 0xF8, 0x33, 0xFF, 0x8D, 0xC0,
  0xF3, 0xC0, 0x0E, 0xE0, 0x03, 0xB8, 0x00, 0x6E, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xB8, 0x00, 0xEF, 0x00,
  0x33, 0x60, 0x3C, 0xCF, 0xFE, 0x31, 0xFE, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x03, 0xF8, 0x61, 0xFF, 0xCC, 0x78,
  0x1D, 0x9C, 0x01, 0xB3, 0x00, 0x1E, 0xE0, 0x01, 0xD8, 0x00, 0x3B, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x01, 0xD8, 0x00, 0x3B, 0x00, 0x07, 0x70, 0x00, 0xEE, 0x00,
  0x3C, 0xE0, 0x05, 0x8E, 0x03, 0xB1, 0xFF, 0xE6, 0x0F, 0xF0, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC7, 0xFC,
  0xFE, 0xDC, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x0F, 0xF8, 0x7F, 0xFD, 0xC0,
  0x33, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x3E, 0x00, 0xEF, 0xFF, 0x8F, 0xFE,
  0x00, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x07, 0xFF, 0xFF, 0xF1,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0xC0, 0x1C, 0x00, 0xFF, 0x07, 0xF0, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xD8, 0x00, 0xF7, 0x00,
  0x6C, 0xE0, 0x3B, 0x3F, 0xFC, 0xC3, 0xFC, 0x30, 0xE0, 0x00, 0x7C, 0x00,
  0x1D, 0x80, 0x03, 0x38, 0x00, 0x63, 0x00, 0x1C, 0x60, 0x03, 0x0E, 0x00,
  0xE0, 0xC0, 0x18, 0x1C, 0x03, 0x01, 0x80, 0xE0, 0x30, 0x18, 0x07, 0x03,
  0x00, 0x60, 0xE0, 0x0C, 0x18, 0x01, 0xC7, 0x00, 0x18, 0xC0, 0x03, 0x98,
  0x00, 0x37, 0x00, 0x06, 0xC0, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0xC0, 0x07, 0x00, 0x3E, 0x00, 0x38, 0x01, 0xB8, 0x03, 0xC0, 0x0C,
  0xC0, 0x1F, 0x00, 0xE6, 0x00, 0xD8, 0x06, 0x30, 0x0E, 0xC0, 0x31, 0xC0,
  0x66, 0x01, 0x86, 0x03, 0x18, 0x1C, 0x30, 0x38, 0xC0, 0xC1, 0xC1, 0x86,
  0x06, 0x0E, 0x0C, 0x38, 0x70, 0x30, 0xE0, 0xC3, 0x81, 0x86, 0x06, 0x18,
  0x0E, 0x30, 0x38, 0xC0, 0x33, 0x80, 0xCE, 0x01, 0x98, 0x06, 0x60, 0x0C,
  0xC0, 0x3B, 0x00, 0x76, 0x00, 0xD8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0xE0, 0x01, 0xCE,
  0x00, 0x30, 0xE0, 0x0E, 0x0C, 0x03, 0x81, 0xC0, 0x60, 0x1C, 0x18, 0x01,
  0x87, 0x00, 0x39, 0xC0, 0x03, 0xB0, 0x00, 0x3E, 0x00, 0x03, 0x80, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x07, 0x70, 0x01, 0xC6, 0x00, 0x30, 0xE0, 0x0C,
  0x0E, 0x03, 0x80, 0xC0, 0xE0, 0x0C, 0x18, 0x01, 0xC7, 0x00, 0x1D, 0xC0,
  0x01, 0xC0, 0xE0, 0x00, 0x6C, 0x00, 0x1D, 0x80, 0x03, 0x38, 0x00, 0x63,
  0x00, 0x1C, 0x70, 0x03, 0x06, 0x00, 0xE0, 0xC0, 0x18, 0x1C, 0x03, 0x01,
  0x80, 0xE0, 0x30, 0x18, 0x07, 0x03, 0x00, 0x60, 0xE0, 0x0E, 0x18, 0x00,
  0xC7, 0x00, 0x18, 0xC0, 0x03, 0x98, 0x00, 0x37, 0x00, 0x06, 0xC0, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x1E,
  0x00, 0x3F, 0x80, 0x07, 0xC0, 0x00, 0x7F, 0xFE, 0xFF, 0xFC, 0x00, 0x38,
  0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x03,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xF0, 0x1F, 0x03, 0x80, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0,
  0x7C, 0x0E, 0x00, 0xF8, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x70,
  0x03, 0x80, 0x3F, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x07, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xF0, 0x03, 0xC0, 0x7E, 0x07,
  0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x07, 0xE0, 0x3E,
  0x00, 0x1E, 0x00, 0x2F, 0xF8, 0x07, 0x87, 0xC3, 0xC0, 0x3F, 0xE8, 0x00,
  0xF0,
};

const GFXglyph NotoSans_Light41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 4, 29, 10, 3, -29 },
  { 16, 9, 10, 15, 3, -29 },
  { 28, 24, 29, 26, 1, -29 },
  { 115, 17, 33, 23, 3, -31 },
  { 186, 29, 30, 33, 2, -30 },
  { 295, 27, 30, 29, 2, -30 },
  { 397, 2, 10, 8, 3, -29 },
  { 400, 8, 35, 11, 2, -29 },
  { 435, 9, 35, 11, 1, -29 },
  { 475, 18, 17, 23, 2, -31 },
  { 514, 19, 19, 23, 2, -24 },
  { 560, 5, 10, 9, 2, -5 },
  { 567, 10, 2, 13, 2, -12 },
  { 570, 4, 4, 10, 3, -4 },
  { 572, 14, 29, 14, 0, -29 },
  { 623, 19, 30, 23, 2, -30 },
  { 695, 10, 29, 23, 4, -29 },
  { 732, 19, 30, 23, 2, -30 },
  { 804, 19, 30, 23, 2, -30 },
  { 876, 22, 29, 23, 1, -29 },
  { 956, 18, 29, 23, 3, -29 },
  { 1022, 18, 30, 23, 3, -30 },
  { 1090, 19, 29, 23, 2, -29 },
  { 1159, 19, 30, 23, 2, -30 },
  { 1231, 19, 30, 23, 2, -30 },
  { 1303, 4, 22, 10, 3, -22 },
  { 1314, 6, 27, 10, 1, -22 },
  { 1335, 19, 19, 23, 2, -24 },
  { 1381, 19, 11, 23, 2, -20 },
  { 1408, 19, 19, 23, 2, -24 },
  { 1454, 15, 30, 17, 1, -30 },
  { 1511, 32, 33, 36, 2, -29 },
  { 1643, 25, 29, 25, 0, -29 },
  { 1734, 20, 29, 26, 4, -29 },
  { 1807, 21, 30, 26, 3, -30 },
  { 1886, 23, 29, 29, 4, -29 },
  { 1970, 16, 29, 23, 4, -29 },
  { 2028, 16, 29, 21, 4, -29 },
  { 2086, 24, 30, 30, 3, -30 },
  { 2176, 22, 29, 30, 4, -29 },
  { 2256, 9, 29, 13, 2, -29 },
  { 2289, 10, 36, 10, -4, -29 },
  { 2334, 20, 29, 24, 4, -29 },
  { 2407, 16, 29, 21, 4, -29 },
  { 2465, 28, 29, 36, 4, -29 },
  { 2567, 22, 29, 30, 4, -29 },
  { 2647, 26, 30, 31, 3, -30 },
  { 2745, 18, 29, 24, 4, -29 },
  { 2811, 26, 37, 31, 3, -30 },
  { 2932, 20, 29, 25, 4, -29 },
  { 3005, 18, 30, 22, 2, -30 },
  { 3073, 21, 29, 22, 0, -29 },
  { 3150, 22, 29, 30, 4, -29 },
  { 3230, 24, 29, 24, 0, -29 },
  { 3317, 35, 29, 37, 1, -29 },
  { 3444, 22, 29, 22, 0, -29 },
  { 3524, 22, 29, 22, 0, -29 },
  { 3604, 20, 29, 24, 2, -29 },
  { 3677, 9, 35, 13, 3, -29 },
  { 3717, 14, 29, 14, 0, -29 },
  { 3768, 9, 35, 13, 1, -29 },
  { 3808, 20, 18, 23, 2, -29 },
  { 3853, 17, 2, 17, 0, 4 },
  { 3858, 7, 6, 11, 2, -31 },
  { 3864, 17, 22, 22, 2, -22 },
  { 3911, 18, 31, 25, 4, -31 },
  { 3981, 16, 22, 20, 2, -22 },
  { 4025, 19, 31, 25, 2, -31 },
  { 4099, 18, 22, 23, 2, -22 },
  { 4149, 14, 31, 13, 1, -31 },
  { 4204, 19, 32, 25, 2, -22 },
  { 4280, 17, 31, 24, 4, -31 },
  { 4346, 3, 30, 10, 3, -30 },
  { 4358, 8, 40, 10, -2, -30 },
  { 4398, 16, 31, 20, 4, -31 },
  { 4460, 2, 31, 10, 4, -31 },
  { 4468, 29, 22, 37, 4, -22 },
  { 4548, 17, 22, 24, 4, -22 },
  { 4595, 20, 22, 24, 2, -22 },
  { 4650, 18, 32, 25, 4, -22 },
  { 4722, 19, 32, 25, 2, -22 },
  { 4798, 12, 22, 16, 4, -22 },
  { 4831, 15, 22, 19, 2, -22 },
  { 4873, 12, 27, 14, 1, -27 },
  { 4914, 18, 22, 24, 3, -22 },
  { 4964, 19, 22, 19, 0, -22 },
  { 5017, 29, 22, 30, 1, -22 },
  { 5097, 19, 22, 21, 1, -22 },
  { 5150, 19, 32, 19, 0, -22 },
  { 5226, 15, 22, 19, 2, -22 },
  { 5268, 12, 35, 15, 1, -29 },
  { 5321, 2, 41, 22, 10, -31 },
  { 5332, 13, 35, 15, 1, -29 },
  { 5389, 19, 5, 23, 2, -17 },
};

const GFXfont NotoSans_Light41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light41pt7bBitmaps,
  (GFXglyph *)NotoSans_Light41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_LIGHT41PT7B_H_
