#ifndef _NOTOSANS_LIGHT64PT7B_H_
#define _NOTOSANS_LIGHT64PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light64pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x71, 0xC7, 0x1C, 0x71, 0xC3,
  0x0C, 0x30, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x31, 0xEF, 0xFF, 0xFF, 0xE3,
  0x00, 0xF0, 0x1F, 0xE0, 0x3D, 0xC0, 0x7B, 0x80, 0xF7, 0x01, 0xEE, 0x03,
  0xDC, 0x07, 0xB8, 0x0F, 0x70, 0x1E, 0xE0, 0x39, 0xC0, 0x73, 0x80, 0xE7,
  0x00, 0xCE, 0x01, 0x9C, 0x03, 0x38, 0x06, 0x70, 0x0C, 0x00, 0x03, 0xC0,
  0x0F, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x03, 0x80, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x07, 0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x03, 0x80,
  0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x01, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x03, 0x80, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFC, 0x1F, 0xCE, 0x3F, 0x83, 0xE0, 0xE0, 0x38, 0x7C,
  0x0E, 0x00, 0x07, 0x80, 0xE0, 0x00, 0xF0, 0x0E, 0x00, 0x0F, 0x00, 0xE0,
  0x00, 0xF0, 0x0E, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0xF0, 0x0E, 0x00, 0x0F,
  0x00, 0xE0, 0x00, 0xF0, 0x0E, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x7C, 0x0E,
  0x00, 0x03, 0xE0, 0xE0, 0x00, 0x1F, 0x8E, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0E, 0xFF, 0x00, 0x00, 0xE1, 0xF8, 0x00, 0x0E, 0x07,
  0xC0, 0x00, 0xE0, 0x3E, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0xE0, 0x1E, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0xE0, 0x0F, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0xE0,
  0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xE0, 0x1E, 0x00, 0x0E, 0x01, 0xE8,
  0x00, 0xE0, 0x3C, 0xE0, 0x0E, 0x0F, 0x8F, 0xF0, 0xEF, 0xF0, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x38, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x3C, 0x00, 0x3C, 0x03, 0x80, 0x00, 0xE0, 0x00, 0xE0,
  0x0E, 0x00, 0x07, 0x80, 0x07, 0x80, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x78,
  0x03, 0x80, 0x00, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x07, 0x80,
  0x70, 0x00, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x78, 0x0E,
  0x00, 0x00, 0x70, 0x01, 0xE0, 0x70, 0x00, 0x01, 0xC0, 0x07, 0x83, 0xC0,
  0x00, 0x07, 0x00, 0x1C, 0x0E, 0x07, 0xF0, 0x1C, 0x00, 0x70, 0x78, 0x7F,
  0xE0, 0x70, 0x01, 0xC1, 0xC3, 0xFF, 0xC1, 0xE0, 0x0F, 0x0F, 0x0F, 0x07,
  0x83, 0x80, 0x38, 0x38, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xE1, 0xC0, 0x1C,
  0x1E, 0x0F, 0x07, 0x0F, 0x00, 0x70, 0x7E, 0xFC, 0x38, 0x38, 0x00, 0xE0,
  0xFF, 0xE1, 0xE0, 0xE0, 0x03, 0x80, 0xFE, 0x07, 0x03, 0x80, 0x0E, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x78, 0x00, 0xE0, 0x00,
  0x07, 0x81, 0xE0, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x1C, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x70, 0x00, 0xE0, 0x00, 0x1C,
  0x01, 0xE0, 0x03, 0x80, 0x00, 0xF0, 0x07, 0x80, 0x0E, 0x00, 0x03, 0x80,
  0x1E, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0xE0, 0x03, 0x80, 0x03, 0xC0, 0x03, 0x80, 0x1E, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x1C, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0x78,
  0x0E, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x78, 0x00, 0x01, 0xFF,
  0xC0, 0x01, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x00, 0x01,
  0xE0, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x7E, 0x00, 0x00, 0x00, 0x1E, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xEF, 0x80, 0x00, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x1E, 0x0F, 0xC0, 0xF8,
  0x00, 0x0E, 0x0F, 0x80, 0x3E, 0x00, 0x0F, 0x07, 0x80, 0x0F, 0x80, 0x07,
  0x87, 0x80, 0x03, 0xE0, 0x03, 0x87, 0xC0, 0x00, 0xF8, 0x03, 0xC3, 0xC0,
  0x00, 0x3E, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x81, 0xE0, 0xF0, 0x00, 0x03,
  0xE0, 0xF0, 0x78, 0x00, 0x00, 0xF8, 0xF0, 0x3C, 0x00, 0x00, 0x3E, 0xF8,
  0x1E, 0x00, 0x00, 0x0F, 0xF8, 0x0F, 0x00, 0x00, 0x03, 0xF8, 0x07, 0x80,
  0x00, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x7C, 0x00, 0x00, 0xFB, 0xE0, 0x1F, 0x00, 0x01, 0xF8, 0xF8,
  0x07, 0xE0, 0x03, 0xF8, 0x3E, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x7F,
  0xFF, 0xF0, 0x03, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xFF, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x70, 0x00,
  0x78, 0x07, 0x80, 0x78, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0,
  0x0F, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x01, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0,
  0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80,
  0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1F, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0xF0,
  0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x02, 0x00, 0x38,
  0x00, 0x9E, 0x01, 0xC0, 0x3C, 0xFE, 0x0E, 0x0F, 0xEF, 0xFE, 0x73, 0xFF,
  0x8F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x07, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x7C, 0x07, 0xC0, 0x03, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00,
  0xE0, 0x03, 0x80, 0x01, 0x00, 0x10, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1E, 0x3C, 0xF9, 0xE3, 0xC7, 0x8E, 0x3C, 0x78,
  0xE1, 0xC3, 0x8E, 0x1C, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x31, 0xEF, 0xFF, 0xFF, 0xE3, 0x00, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0x80, 0x7E, 0x00, 0xF8, 0x00,
  0xF8, 0x0F, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x38,
  0x3C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x01, 0xE7, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x3B, 0xC0, 0x00,
  0x01, 0xDE, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x07, 0x9C, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x1C, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xEF, 0x0F, 0xCF,
  0x1F, 0x0F, 0x3E, 0x0F, 0xFC, 0x0F, 0x70, 0x0F, 0x20, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0x80, 0x7E, 0x07, 0xE0, 0x00, 0xF8,
  0x1E, 0x00, 0x03, 0xE0, 0x40, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7C, 0x38,
  0x00, 0x01, 0xF0, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x80, 0x00, 0x03, 0xE6, 0x00, 0x00,
  0x3F, 0x3E, 0x00, 0x07, 0xF1, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00,
  0x07, 0x38, 0x00, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x00, 0x1E, 0x3C, 0x00, 0x00, 0x03, 0x87, 0x80, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x01, 0xC0,
  0x78, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x3C, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0xF0, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x78, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFB,
  0xFF, 0x80, 0x60, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x80, 0x00, 0x07, 0xC7, 0x00,
  0x00, 0x7C, 0x3E, 0x00, 0x0F, 0xC1, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x80,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x0F, 0xFE, 0x01, 0xE1, 0xFF, 0xFC, 0x0F, 0x1F, 0xFF,
  0xF8, 0x79, 0xE0, 0x07, 0xE3, 0xDC, 0x00, 0x0F, 0x9F, 0xC0, 0x00, 0x3C,
  0xFC, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x03,
  0xDC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0x38, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x0F, 0x00,
  0x01, 0xE0, 0x7C, 0x00, 0x1E, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0D, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0x01, 0xF0, 0x00, 0x7C, 0x1E,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C, 0x78, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x01,
  0xC7, 0x80, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x07,
  0x80, 0x00, 0x78, 0x1F, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x78, 0x01, 0xF8,
  0x0F, 0x80, 0x07, 0xF1, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0x7F, 0x80, 0x07, 0xE0, 0x7E, 0x00,
  0x7C, 0x00, 0xFC, 0x07, 0xC0, 0x03, 0xF0, 0x78, 0x00, 0x07, 0xC7, 0x80,
  0x00, 0x1E, 0x3C, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3B, 0xC0,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE1, 0xF0, 0x00,
  0x1E, 0x07, 0xC0, 0x03, 0xF0, 0x1F, 0xF3, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x5C, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F,
  0x00, 0x0F, 0x80, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x3D,
  0xC0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x1F, 0x78,
  0x00, 0x00, 0xFC, 0xF0, 0x00, 0x03, 0xF3, 0xC0, 0x00, 0x1F, 0xC7, 0x80,
  0x01, 0xEF, 0x1F, 0x80, 0x0F, 0x38, 0x3F, 0xC7, 0xF8, 0xE0, 0x3F, 0xFF,
  0xC3, 0x80, 0x7F, 0xFC, 0x0E, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x07, 0xEF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x31, 0xEF, 0xFF, 0xFF, 0xE3, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xC7, 0xBF, 0xFF, 0xFF, 0x8C, 0x06, 0x0F, 0x87, 0xE3,
  0xF1, 0xF8, 0xF8, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x0E, 0x0F, 0x07,
  0x83, 0xC1, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xC7, 0xE0, 0x1F, 0xC6, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xF3, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x38, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x1C, 0xF0, 0x00, 0xFC, 0x03, 0xC0, 0x0F, 0x70,
  0x00, 0xF8, 0x00, 0xE0, 0x03, 0xB8, 0x00, 0xF0, 0x00, 0x70, 0x01, 0xFC,
  0x00, 0x70, 0x00, 0x38, 0x00, 0xFE, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x7E,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x3F, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x1F,
  0x80, 0x1C, 0x00, 0x07, 0x80, 0x0F, 0xC0, 0x0E, 0x00, 0x03, 0xC0, 0x07,
  0xE0, 0x07, 0x00, 0x01, 0xE0, 0x03, 0xF0, 0x03, 0x80, 0x00, 0xF0, 0x01,
  0xF8, 0x01, 0xC0, 0x00, 0x70, 0x00, 0xFC, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x7E, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x3F, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x3B, 0x80, 0x1C, 0x00, 0x0F, 0x00, 0x1D, 0xC0, 0x0F, 0x00, 0x07, 0xC0,
  0x1E, 0xE0, 0x03, 0x80, 0x07, 0xE0, 0x0E, 0x70, 0x01, 0xE0, 0x07, 0x70,
  0x0F, 0x3C, 0x00, 0x78, 0x07, 0x1C, 0x0F, 0x0E, 0x00, 0x1F, 0xFF, 0x0F,
  0xFF, 0x07, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x03, 0xC0, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x00,
  0x1D, 0xC0, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x00, 0xF3, 0x80,
  0x00, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x00,
  0x0F, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x70, 0x00, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x01,
  0xE0, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x07, 0x80, 0x00, 0x07, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0x00, 0x03, 0xC0, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0x00,
  0x00, 0xFE, 0x1E, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x3E, 0x78, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0x07, 0x3C, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00,
  0x71, 0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3E,
  0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xE0, 0xF0, 0x00, 0x07, 0xE1, 0xE0, 0x00, 0x03, 0xE3,
  0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0x1F, 0x78, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF9, 0xE0, 0x00,
  0x07, 0xE3, 0xC0, 0x00, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x03, 0x80, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x20, 0x0F, 0xE0, 0x00, 0x78, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x00, 0x0F, 0xF0,
  0x0F, 0x00, 0x00, 0x1F, 0x80, 0xF0, 0x00, 0x00, 0xFC, 0x0F, 0x00, 0x00,
  0x03, 0xE0, 0xF0, 0x00, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x03, 0xEF, 0x00, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00,
  0x0F, 0xC0, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0x00, 0x00, 0xFF, 0x00, 0xF0,
  0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x07, 0x00, 0xFC,
  0x00, 0x00, 0x08, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0x00, 0xEF, 0x00,
  0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x00, 0x01,
  0xCF, 0x00, 0x00, 0x00, 0x0E, 0x7C, 0x00, 0x00, 0x00, 0x71, 0xE0, 0x00,
  0x00, 0x03, 0x8F, 0x80, 0x00, 0x00, 0x1C, 0x3E, 0x00, 0x00, 0x00, 0xE0,
  0xF8, 0x00, 0x00, 0x07, 0x03, 0xF0, 0x00, 0x00, 0x38, 0x0F, 0xC0, 0x00,
  0x01, 0xC0, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x0F, 0xFC, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3E,
  0x80, 0x7C, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0x0F, 0x00, 0xF0, 0x00,
  0x00, 0x3E, 0xF0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0xF8, 0xF0, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01,
  0xF0, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0xF0, 0x0F,
  0x80, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0xF0, 0x7C,
  0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0xF1, 0xF8, 0x00, 0x00, 0xF3, 0xFC,
  0x00, 0x00, 0xF7, 0xFE, 0x00, 0x00, 0xF7, 0x9E, 0x00, 0x00, 0xFF, 0x1F,
  0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0x80, 0x00, 0xF0, 0x03,
  0xC0, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x03, 0xE0, 0xF0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x3E, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x1D, 0xFD, 0xC0, 0x00, 0x00, 0x07, 0xBF, 0xBC, 0x00,
  0x00, 0x00, 0xF7, 0xF3, 0x80, 0x00, 0x00, 0x1C, 0xFE, 0x78, 0x00, 0x00,
  0x07, 0x9F, 0xCF, 0x00, 0x00, 0x00, 0xE3, 0xF8, 0xE0, 0x00, 0x00, 0x3C,
  0x7F, 0x1E, 0x00, 0x00, 0x07, 0x8F, 0xE3, 0xC0, 0x00, 0x00, 0xE1, 0xFC,
  0x3C, 0x00, 0x00, 0x3C, 0x3F, 0x87, 0x80, 0x00, 0x07, 0x07, 0xF0, 0x70,
  0x00, 0x01, 0xE0, 0xFE, 0x0F, 0x00, 0x00, 0x3C, 0x1F, 0xC1, 0xE0, 0x00,
  0x07, 0x03, 0xF8, 0x1E, 0x00, 0x01, 0xE0, 0x7F, 0x03, 0xC0, 0x00, 0x38,
  0x0F, 0xE0, 0x38, 0x00, 0x0F, 0x01, 0xFC, 0x07, 0x80, 0x01, 0xE0, 0x3F,
  0x80, 0xF0, 0x00, 0x38, 0x07, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0xFE, 0x01,
  0xE0, 0x01, 0xC0, 0x1F, 0xC0, 0x1C, 0x00, 0x78, 0x03, 0xF8, 0x03, 0xC0,
  0x0F, 0x00, 0x7F, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0xE0, 0x07, 0x80, 0x78,
  0x01, 0xFC, 0x00, 0xF0, 0x0E, 0x00, 0x3F, 0x80, 0x0E, 0x03, 0xC0, 0x07,
  0xF0, 0x01, 0xE0, 0x78, 0x00, 0xFE, 0x00, 0x3C, 0x0E, 0x00, 0x1F, 0xC0,
  0x03, 0xC3, 0xC0, 0x03, 0xF8, 0x00, 0x78, 0x70, 0x00, 0x7F, 0x00, 0x07,
  0x1E, 0x00, 0x0F, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xFC, 0x00, 0x1E, 0x70,
  0x00, 0x3F, 0x80, 0x01, 0xDE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xDE, 0x00,
  0x00, 0x07, 0xF7, 0xC0, 0x00, 0x01, 0xFC, 0xF0, 0x00, 0x00, 0x7F, 0x1E,
  0x00, 0x00, 0x1F, 0xC7, 0xC0, 0x00, 0x07, 0xF0, 0xF0, 0x00, 0x01, 0xFC,
  0x1E, 0x00, 0x00, 0x7F, 0x07, 0xC0, 0x00, 0x1F, 0xC0, 0xF0, 0x00, 0x07,
  0xF0, 0x1E, 0x00, 0x01, 0xFC, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0xF0, 0x00,
  0x1F, 0xC0, 0x1E, 0x00, 0x07, 0xF0, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0xF0,
  0x00, 0x7F, 0x00, 0x1E, 0x00, 0x1F, 0xC0, 0x07, 0xC0, 0x07, 0xF0, 0x00,
  0xF0, 0x01, 0xFC, 0x00, 0x1E, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x1F, 0xC0,
  0x00, 0xF0, 0x07, 0xF0, 0x00, 0x1E, 0x01, 0xFC, 0x00, 0x07, 0xC0, 0x7F,
  0x00, 0x00, 0xF0, 0x1F, 0xC0, 0x00, 0x1E, 0x07, 0xF0, 0x00, 0x07, 0xC1,
  0xFC, 0x00, 0x00, 0xF0, 0x7F, 0x00, 0x00, 0x1E, 0x1F, 0xC0, 0x00, 0x07,
  0xC7, 0xF0, 0x00, 0x00, 0xF1, 0xFC, 0x00, 0x00, 0x1E, 0x7F, 0x00, 0x00,
  0x07, 0xDF, 0xC0, 0x00, 0x00, 0xF7, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xE0, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x80, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x00, 0x01, 0xF3, 0xC0, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x0F, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xF0,
  0x00, 0x3F, 0x8F, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x03, 0xEF, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xEF, 0x00,
  0x00, 0x7C, 0xF0, 0x00, 0x1F, 0x8F, 0x00, 0x0F, 0xF0, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x00, 0x1E,
  0x70, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0x80,
  0x00, 0x01, 0xE0, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0x00,
  0x01, 0xFC, 0x1E, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0xF8, 0x78, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1F,
  0x0F, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x1F, 0xC0,
  0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x03,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x7C, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0xF8, 0x78, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xF1, 0xE0, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x03, 0xEF, 0x00, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x1F, 0xC0, 0x0F, 0xC1, 0xF8, 0x00, 0x0E,
  0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE6, 0x00,
  0x00, 0x3E, 0x3F, 0x00, 0x07, 0xE1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0xF0, 0xF8,
  0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x01,
  0xC1, 0xE0, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x00, 0x01, 0xC7, 0x80, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE3, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x77, 0x80, 0x00,
  0x3C, 0x1C, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xCE,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xC0, 0xF0, 0x00,
  0x0E, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3C, 0x38, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x70, 0x70, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xE0, 0xF0, 0x00,
  0x38, 0x03, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0x07, 0x81,
  0xC0, 0x01, 0xE0, 0x0F, 0x00, 0x0E, 0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x00,
  0x1C, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x07, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0xF0, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xC0, 0x1E, 0x00,
  0x70, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x00, 0xE0, 0x0F, 0x00,
  0x38, 0x03, 0xC0, 0x01, 0xE0, 0x1C, 0x00, 0x78, 0x07, 0x80, 0x03, 0xC0,
  0x38, 0x00, 0xF0, 0x0E, 0x00, 0x03, 0x80, 0xF0, 0x00, 0xE0, 0x3C, 0x00,
  0x07, 0x81, 0xE0, 0x01, 0xC0, 0x78, 0x00, 0x0F, 0x03, 0x80, 0x03, 0xC0,
  0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1C, 0x1E, 0x00,
  0x07, 0x07, 0x80, 0x00, 0x3C, 0x38, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78,
  0x70, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1C, 0x78, 0x00,
  0x00, 0xE3, 0xC0, 0x00, 0x38, 0xF0, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0xEF, 0x00, 0x00, 0x07, 0x78, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x78, 0x07, 0x00,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x0F, 0x0E,
  0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0xF8, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x1F, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x00, 0x3E, 0x3C, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3C, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00,
  0x1C, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x38,
  0x78, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x07, 0x80,
  0xE0, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x70, 0x03,
  0xC0, 0x01, 0xE0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x07,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x1F, 0x01, 0xF0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xF7, 0xFC, 0x0F, 0x00,
  0x1F, 0x03, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x07,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0x80, 0x3C, 0x7E,
  0x00, 0x0F, 0x3E, 0x00, 0x03, 0xDF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0x77, 0x80,
  0x03, 0xDD, 0xF8, 0x01, 0xE7, 0x3F, 0xEF, 0xF1, 0xC7, 0xFF, 0xF8, 0x70,
  0x7F, 0xF8, 0x1C, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x1E, 0x00,
  0x1C, 0x0F, 0xFF, 0x00, 0xE1, 0xFF, 0xFE, 0x07, 0x1F, 0xEF, 0xF8, 0x39,
  0xE0, 0x07, 0xE1, 0xDC, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x3C, 0x7E, 0x00,
  0x00, 0xF3, 0xE0, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xE7, 0xC0,
  0x00, 0x0F, 0x3E, 0x00, 0x00, 0xF1, 0xF8, 0x00, 0x0F, 0x8E, 0xE0, 0x00,
  0xF8, 0x73, 0xC0, 0x0F, 0x83, 0x8F, 0xFF, 0xF8, 0x1C, 0x3F, 0xFF, 0x80,
  0xC0, 0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x7F, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xE0, 0x03, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x3C, 0x01, 0xE0, 0x1F, 0xFE, 0x0F, 0x03, 0xFF, 0xFC, 0x78, 0x3F, 0xEF,
  0xF3, 0xC3, 0xF0, 0x03, 0xDE, 0x3E, 0x00, 0x0E, 0xF3, 0xE0, 0x00, 0x3F,
  0x9E, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x07, 0xEF, 0x00, 0x00, 0x1F, 0x78,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00,
  0xFB, 0xC0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x07, 0xF1,
  0xF0, 0x00, 0x77, 0x87, 0xC0, 0x07, 0x9C, 0x1F, 0xFF, 0xF8, 0xE0, 0x7F,
  0xFF, 0x07, 0x00, 0xFF, 0xF0, 0x38, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0x9F, 0xE0,
  0x0F, 0xC0, 0x1F, 0x01, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0xC3, 0xC0,
  0x00, 0x3C, 0x3C, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x40, 0xFC,
  0x00, 0x1C, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x3F, 0x07, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0xFF, 0x81, 0xC0, 0xFF, 0xFF, 0x0E, 0x0F, 0xFB, 0xFC, 0xF0, 0xFC, 0x00,
  0xF7, 0x8F, 0x80, 0x03, 0xFC, 0xF8, 0x00, 0x0F, 0xE7, 0x80, 0x00, 0x3F,
  0x7C, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7B, 0x80, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x01,
  0xF3, 0xC0, 0x00, 0x1F, 0x9F, 0x00, 0x01, 0xFC, 0x7C, 0x00, 0x1D, 0xE1,
  0xF0, 0x03, 0xEF, 0x07, 0xFF, 0xFE, 0x78, 0x1F, 0xFF, 0xC3, 0xC0, 0x3F,
  0xFC, 0x1E, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3E, 0x18, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x7E, 0x07, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x03, 0xF0, 0x07,
  0x03, 0xFF, 0xC0, 0xE1, 0xFF, 0xFE, 0x1C, 0x7F, 0xBF, 0xE3, 0x9E, 0x00,
  0x7E, 0x77, 0x00, 0x03, 0xCF, 0xC0, 0x00, 0x3D, 0xF8, 0x00, 0x07, 0xBE,
  0x00, 0x00, 0x77, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xE0, 0x67, 0xFF, 0xFF, 0xB8, 0x00,
  0x00, 0x00, 0x00, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C,
  0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39,
  0xC0, 0x00, 0x60, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0xF9, 0xFF, 0xCF, 0xFC, 0x7F, 0x80, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0xE0, 0x00, 0x1E, 0x70,
  0x00, 0x1E, 0x38, 0x00, 0x1E, 0x1C, 0x00, 0x1E, 0x0E, 0x00, 0x1E, 0x07,
  0x00, 0x1E, 0x03, 0x80, 0x1E, 0x01, 0xC0, 0x1F, 0x00, 0xE0, 0x1F, 0x00,
  0x70, 0x1F, 0x00, 0x38, 0x1F, 0x00, 0x1C, 0x1F, 0x00, 0x0E, 0x0F, 0x00,
  0x07, 0x0F, 0x00, 0x03, 0x8F, 0xC0, 0x01, 0xCF, 0xE0, 0x00, 0xEF, 0x78,
  0x00, 0x7F, 0x1E, 0x00, 0x3F, 0x0F, 0x80, 0x1F, 0x03, 0xC0, 0x0F, 0x00,
  0xF0, 0x07, 0x00, 0x3C, 0x03, 0x80, 0x1F, 0x01, 0xC0, 0x07, 0x80, 0xE0,
  0x01, 0xE0, 0x70, 0x00, 0x78, 0x38, 0x00, 0x3E, 0x1C, 0x00, 0x0F, 0x0E,
  0x00, 0x03, 0xC7, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x7D, 0xC0, 0x00, 0x1E,
  0xE0, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x03, 0x83, 0xFF, 0x80, 0x1F, 0xFE, 0x0E, 0x1F,
  0xFF, 0x80, 0xFF, 0xFC, 0x39, 0xFE, 0xFF, 0x0F, 0xF7, 0xF8, 0xE7, 0x00,
  0x7E, 0x7C, 0x01, 0xF3, 0xB8, 0x00, 0x79, 0xC0, 0x03, 0xEF, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xBE, 0x00, 0x03, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0,
  0x1C, 0x0F, 0xFF, 0x03, 0x87, 0xFF, 0xF8, 0x71, 0xFE, 0xFF, 0x8E, 0x78,
  0x01, 0xF9, 0xDC, 0x00, 0x0F, 0x3B, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x1E,
  0xF8, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0x7F, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x7C, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0x3C, 0x7C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07,
  0x81, 0xF0, 0x00, 0x3C, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x07, 0x03, 0xFF, 0xC0, 0x38, 0x7F, 0xFF, 0x81, 0xC7, 0xFB,
  0xFE, 0x0E, 0x78, 0x01, 0xF8, 0x77, 0x80, 0x03, 0xE3, 0xB8, 0x00, 0x0F,
  0x1F, 0x80, 0x00, 0x3C, 0xF8, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xDE, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0xBE, 0x00, 0x00,
  0x79, 0xF0, 0x00, 0x03, 0xCF, 0xC0, 0x00, 0x3E, 0x7E, 0x00, 0x03, 0xE3,
  0xBC, 0x00, 0x3E, 0x1C, 0xF0, 0x03, 0xF0, 0xE3, 0xFF, 0xFF, 0x07, 0x0F,
  0xFF, 0xE0, 0x38, 0x1F, 0xFC, 0x01, 0xC0, 0x0F, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xFF, 0x81, 0xC0, 0xFF, 0xFE, 0x0E,
  0x0F, 0xFB, 0xFC, 0xF0, 0xF8, 0x00, 0xF7, 0x8F, 0x80, 0x03, 0xBC, 0xF8,
  0x00, 0x0F, 0xE7, 0x80, 0x00, 0x3F, 0x78, 0x00, 0x01, 0xFB, 0xC0, 0x00,
  0x07, 0xDE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xDE,
  0x00, 0x00, 0x3E, 0xF0, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x1F, 0x9F, 0x00,
  0x01, 0xFC, 0x7C, 0x00, 0x1D, 0xE3, 0xF0, 0x03, 0xCF, 0x0F, 0xFF, 0xFC,
  0x78, 0x1F, 0xFF, 0xC3, 0xC0, 0x7F, 0xF8, 0x1E, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x38, 0x1F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF,
  0xE7, 0xC0, 0x3B, 0xC0, 0x0E, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x1F, 0xE3, 0xFE, 0x3E, 0x00,
  0x1C, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0E, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x7C, 0xFF, 0xCF,
  0xF8, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x83, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xE0,
  0x0F, 0xFC, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x0F,
  0xBC, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7E, 0x78, 0x00, 0x1D, 0xCF, 0xC0,
  0x0F, 0x38, 0xFF, 0xFF, 0xC7, 0x0F, 0xFF, 0xF0, 0xE0, 0x7F, 0xF8, 0x1C,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0xE7,
  0x80, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x03, 0xC1, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00,
  0x01, 0xE0, 0x38, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0xF0, 0x07, 0x80, 0x07, 0x80, 0x1E, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x07, 0x38,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xDC,
  0x00, 0x03, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xE7, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0x3C, 0x00, 0x0E, 0xE0, 0x00, 0x78, 0xF0, 0x00,
  0x77, 0x80, 0x03, 0x87, 0x80, 0x03, 0x9C, 0x00, 0x3C, 0x3C, 0x00, 0x3C,
  0xE0, 0x01, 0xE0, 0xE0, 0x01, 0xC7, 0x80, 0x0F, 0x07, 0x80, 0x0E, 0x1C,
  0x00, 0x70, 0x3C, 0x00, 0xF0, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0x07, 0x80,
  0x3C, 0x07, 0x00, 0x38, 0x3C, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0xE0, 0x0E,
  0x01, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80,
  0x3C, 0x0F, 0x00, 0xE0, 0x38, 0x01, 0xE0, 0x70, 0x07, 0x81, 0xC0, 0x0F,
  0x03, 0x80, 0x3C, 0x1E, 0x00, 0x38, 0x3C, 0x00, 0xE0, 0xF0, 0x01, 0xE1,
  0xC0, 0x07, 0x87, 0x00, 0x0F, 0x0E, 0x00, 0x3C, 0x38, 0x00, 0x38, 0xF0,
  0x00, 0xE3, 0xC0, 0x01, 0xC7, 0x80, 0x07, 0x1E, 0x00, 0x0F, 0x38, 0x00,
  0x3C, 0xE0, 0x00, 0x79, 0xC0, 0x00, 0xE7, 0x00, 0x01, 0xDE, 0x00, 0x07,
  0x78, 0x00, 0x0E, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x77, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0xF8, 0x0F, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0xF8, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x07,
  0x87, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x80,
  0x3C, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x0F, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C,
  0x7C, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x00, 0xF0, 0x00,
  0x3C, 0x01, 0xC0, 0x00, 0xF0, 0x07, 0x80, 0x07, 0x80, 0x1E, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xC0, 0x0F, 0x00,
  0x07, 0x80, 0x38, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x38, 0x07, 0x80, 0x00,
  0xF0, 0x3C, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xE0, 0x01, 0xFC, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x01, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0x00, 0x1F, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x0F, 0x80, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x04, 0xFF, 0xF8, 0x00, 0x17, 0xFF, 0xF8, 0x01, 0xFE, 0x07, 0xFC, 0x1F,
  0xE0, 0x03, 0xFF, 0xFB, 0x00, 0x03, 0xFF, 0xC8, 0x00, 0x01, 0xFC, 0x00,
};

const GFXglyph NotoSans_Light64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 6, 47, 16, 5, -46 },
  { 37, 15, 17, 23, 4, -46 },
  { 69, 38, 46, 41, 2, -46 },
  { 288, 28, 53, 37, 4, -49 },
  { 474, 46, 47, 52, 3, -46 },
  { 745, 41, 47, 46, 4, -46 },
  { 986, 4, 17, 13, 4, -46 },
  { 995, 13, 56, 18, 3, -46 },
  { 1086, 13, 56, 18, 2, -46 },
  { 1177, 29, 28, 35, 3, -49 },
  { 1279, 30, 31, 37, 3, -38 },
  { 1396, 7, 15, 14, 3, -7 },
  { 1410, 15, 3, 21, 3, -19 },
  { 1416, 6, 7, 16, 5, -6 },
  { 1422, 21, 46, 22, 1, -46 },
  { 1543, 29, 47, 37, 4, -46 },
  { 1714, 16, 46, 37, 6, -46 },
  { 1806, 29, 46, 37, 3, -46 },
  { 1973, 29, 47, 37, 3, -46 },
  { 2144, 35, 46, 37, 1, -46 },
  { 2346, 29, 47, 37, 4, -46 },
  { 2517, 29, 47, 37, 4, -46 },
  { 2688, 30, 46, 37, 3, -46 },
  { 2861, 29, 47, 37, 4, -46 },
  { 3032, 30, 47, 37, 3, -46 },
  { 3209, 6, 36, 16, 5, -35 },
  { 3236, 9, 43, 16, 2, -35 },
  { 3285, 30, 30, 37, 3, -38 },
  { 3398, 29, 16, 37, 4, -31 },
  { 3456, 30, 30, 37, 3, -38 },
  { 3569, 23, 47, 27, 2, -46 },
  { 3705, 49, 51, 57, 4, -45 },
  { 4018, 39, 46, 39, 0, -46 },
  { 4243, 31, 46, 40, 6, -46 },
  { 4422, 34, 47, 40, 4, -46 },
  { 4622, 36, 46, 46, 6, -46 },
  { 4829, 25, 46, 35, 6, -46 },
  { 4973, 26, 46, 32, 6, -46 },
  { 5123, 37, 47, 46, 4, -46 },
  { 5341, 34, 46, 46, 6, -46 },
  { 5537, 14, 46, 20, 3, -46 },
  { 5618, 16, 58, 16, -6, -46 },
  { 5734, 32, 46, 38, 6, -46 },
  { 5918, 26, 46, 33, 6, -46 },
  { 6068, 43, 46, 56, 6, -46 },
  { 6316, 34, 46, 47, 6, -46 },
  { 6512, 41, 47, 49, 4, -46 },
  { 6753, 28, 46, 38, 6, -46 },
  { 6914, 41, 57, 49, 4, -46 },
  { 7207, 31, 46, 38, 6, -46 },
  { 7386, 29, 47, 35, 3, -46 },
  { 7557, 34, 46, 34, 0, -46 },
  { 7753, 34, 47, 46, 6, -46 },
  { 7953, 37, 46, 37, 0, -46 },
  { 8166, 55, 46, 58, 1, -46 },
  { 8483, 35, 46, 35, 0, -46 },
  { 8685, 34, 46, 34, 0, -46 },
  { 8881, 32, 46, 37, 2, -46 },
  { 9065, 14, 56, 21, 5, -46 },
  { 9163, 21, 46, 22, 1, -46 },
  { 9284, 13, 56, 21, 2, -46 },
  { 9375, 31, 29, 37, 3, -46 },
  { 9488, 27, 3, 27, 0, 6 },
  { 9499, 11, 10, 17, 3, -49 },
  { 9513, 26, 36, 34, 3, -35 },
  { 9630, 29, 50, 38, 6, -49 },
  { 9812, 24, 36, 30, 4, -35 },
  { 9920, 29, 50, 38, 4, -49 },
  { 10102, 28, 36, 35, 4, -35 },
  { 10228, 22, 49, 20, 1, -49 },
  { 10363, 29, 50, 38, 4, -35 },
  { 10545, 27, 49, 38, 6, -49 },
  { 10711, 5, 47, 15, 5, -47 },
  { 10741, 13, 62, 15, -3, -47 },
  { 10842, 25, 49, 32, 6, -49 },
  { 10996, 3, 49, 15, 6, -49 },
  { 11015, 46, 35, 57, 6, -35 },
  { 11217, 27, 35, 38, 6, -35 },
  { 11336, 30, 36, 38, 4, -35 },
  { 11471, 29, 50, 38, 6, -35 },
  { 11653, 29, 50, 38, 4, -35 },
  { 11835, 18, 35, 25, 6, -35 },
  { 11914, 24, 36, 30, 3, -35 },
  { 12022, 19, 43, 22, 1, -42 },
  { 12125, 27, 35, 38, 5, -34 },
  { 12244, 30, 34, 30, 0, -34 },
  { 12372, 45, 34, 47, 1, -34 },
  { 12564, 30, 34, 32, 1, -34 },
  { 12692, 30, 49, 30, 0, -34 },
  { 12876, 24, 34, 30, 3, -34 },
  { 12978, 19, 56, 23, 2, -46 },
  { 13111, 3, 65, 35, 16, -49 },
  { 13136, 19, 56, 23, 2, -46 },
  { 13269, 30, 7, 37, 3, -26 },
};

const GFXfont NotoSans_Light64pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light64pt7bBitmaps,
  (GFXglyph *)NotoSans_Light64pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _NOTOSANS_LIGHT64PT7B_H_
