#ifndef _NOTOSANS_LIGHT23PT7B_H_
#define _NOTOSANS_LIGHT23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light23pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xEA, 0xAA, 0x0F, 0x9C, 0xE3, 0x18, 0xC4, 0x04, 0x20, 0x21,
  0x02, 0x10, 0x10, 0x80, 0x84, 0x7F, 0xFC, 0x21, 0x03, 0x18, 0x10, 0x80,
  0x84, 0x3F, 0xFC, 0x21, 0x03, 0x18, 0x10, 0x80, 0x84, 0x04, 0x20, 0x04,
  0x07, 0xC7, 0x5D, 0x10, 0xC4, 0x31, 0x04, 0x40, 0xD0, 0x1E, 0x01, 0xE0,
  0x4C, 0x11, 0x04, 0x41, 0x18, 0x4F, 0xFE, 0x04, 0x01, 0x00, 0x38, 0x04,
  0x6C, 0x08, 0x44, 0x10, 0xC6, 0x10, 0x82, 0x20, 0x82, 0x20, 0x82, 0x40,
  0xC6, 0xDE, 0x44, 0x93, 0x6D, 0xA1, 0x19, 0x21, 0x02, 0x21, 0x02, 0x21,
  0x04, 0x21, 0x04, 0x21, 0x08, 0x11, 0x18, 0x1E, 0x06, 0x00, 0x33, 0x00,
  0xC3, 0x01, 0x06, 0x02, 0x0C, 0x06, 0x10, 0x06, 0x60, 0x07, 0x00, 0x1E,
  0x00, 0x66, 0x09, 0x86, 0x16, 0x06, 0x6C, 0x06, 0x98, 0x06, 0x10, 0x0E,
  0x30, 0x66, 0x3F, 0x86, 0xFC, 0x19, 0x18, 0x84, 0x63, 0x10, 0x84, 0x21,
  0x0C, 0x61, 0x08, 0x61, 0x0C, 0x30, 0xC4, 0x22, 0x31, 0x11, 0x11, 0x11,
  0x11, 0x32, 0x26, 0x48, 0x04, 0x01, 0x00, 0x43, 0x93, 0x3F, 0x03, 0x01,
  0xA0, 0x44, 0x31, 0x80, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x41, 0xFF,
  0xC1, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x00, 0x69, 0x29, 0x00, 0xF8,
  0xF0, 0x03, 0x02, 0x06, 0x04, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x10, 0x30,
  0x20, 0x20, 0x60, 0x40, 0xC0, 0x0E, 0x07, 0x70, 0x83, 0x20, 0x24, 0x04,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x34, 0x06, 0x80,
  0x98, 0x31, 0x84, 0x1F, 0x00, 0x1C, 0xD6, 0xF3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0E, 0x0F, 0xF1, 0x02, 0x00, 0x60, 0x04,
  0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x60, 0x18, 0x06, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0xFF, 0xE0, 0x0E, 0x0F, 0x73, 0x03, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x30, 0x0C, 0x1E, 0x00, 0x30, 0x01, 0x00, 0x30, 0x06, 0x00,
  0x80, 0x14, 0x06, 0x7F, 0x00, 0x00, 0x80, 0x18, 0x02, 0x80, 0x28, 0x04,
  0x80, 0x88, 0x18, 0x81, 0x08, 0x20, 0x86, 0x08, 0xC0, 0x88, 0x08, 0xFF,
  0xF0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x7F, 0x90, 0x0C, 0x03, 0x00,
  0xC0, 0x20, 0x0F, 0xE2, 0x0C, 0x00, 0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x28, 0x33, 0xF8, 0x03, 0x81, 0xC8, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x10,
  0x02, 0xFC, 0xF0, 0xD8, 0x0F, 0x01, 0xA0, 0x14, 0x02, 0x80, 0xD8, 0x11,
  0x86, 0x1F, 0x80, 0xFF, 0xE0, 0x08, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00,
  0x40, 0x18, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x00,
  0x80, 0x0E, 0x07, 0x71, 0x83, 0x20, 0x24, 0x04, 0x80, 0x88, 0x20, 0xD8,
  0x0E, 0x06, 0x31, 0x83, 0x20, 0x3C, 0x07, 0x80, 0xD0, 0x13, 0x06, 0x3F,
  0x80, 0x0E, 0x07, 0x71, 0x82, 0x20, 0x2C, 0x05, 0x80, 0xF0, 0x1E, 0x03,
  0x40, 0xE6, 0x2C, 0x79, 0x80, 0x20, 0x04, 0x01, 0x80, 0x20, 0x18, 0x7E,
  0x00, 0xF0, 0x00, 0x0F, 0x6C, 0x00, 0x00, 0x0D, 0x2D, 0x20, 0x00, 0x20,
  0x1C, 0x0E, 0x07, 0x03, 0x01, 0x80, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x00, 0x80, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x80,
  0x1C, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x30, 0x18, 0x1C, 0x0E,
  0x02, 0x00, 0x00, 0x38, 0xFE, 0x03, 0x01, 0x01, 0x01, 0x02, 0x06, 0x0C,
  0x10, 0x30, 0x20, 0x20, 0x00, 0x00, 0x30, 0x30, 0x03, 0xFC, 0x03, 0x00,
  0x81, 0x00, 0x10, 0x80, 0x02, 0x60, 0xF0, 0xD0, 0xC2, 0x14, 0x20, 0x87,
  0x10, 0x21, 0x84, 0x08, 0x61, 0x02, 0x18, 0x41, 0x87, 0x18, 0x62, 0x43,
  0xEF, 0x90, 0x20, 0x82, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x04, 0x01, 0xFE,
  0x00, 0x03, 0x00, 0x0C, 0x00, 0x68, 0x01, 0x20, 0x04, 0xC0, 0x21, 0x00,
  0x84, 0x06, 0x18, 0x10, 0x20, 0x7F, 0xC3, 0x03, 0x08, 0x04, 0x60, 0x19,
  0x00, 0x24, 0x00, 0xB0, 0x03, 0xFF, 0x98, 0x1B, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xB0, 0x27, 0xF8, 0xC0, 0xD8, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0xF0, 0x37, 0xFC, 0x01, 0xC0, 0x7F, 0xC6, 0x00, 0x60, 0x06, 0x00, 0x20,
  0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x02, 0x0F, 0xF0, 0xFF, 0x86, 0x07, 0x30, 0x0D,
  0x80, 0x2C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0xF0,
  0x07, 0x80, 0x2C, 0x03, 0x60, 0x33, 0x07, 0x1F, 0xE0, 0xFF, 0xE0, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0xFF, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0xFF, 0xFF, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xFF, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x01, 0xE0, 0x3F,
  0xF1, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x03, 0xF4, 0x00, 0x50, 0x01, 0x40, 0x05, 0x80, 0x13, 0x00, 0x47,
  0x03, 0x07, 0xF8, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1F, 0xFF, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10,
  0x9F, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x21, 0xBC, 0xC0, 0x6C, 0x0C, 0xC1, 0x8C, 0x30, 0xC6, 0x0C,
  0xC0, 0xD8, 0x0F, 0x80, 0xEC, 0x0C, 0x60, 0xC3, 0x0C, 0x10, 0xC1, 0x8C,
  0x0C, 0xC0, 0x4C, 0x03, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xFF, 0xE0, 0x07,
  0xE0, 0x05, 0xE0, 0x07, 0xD0, 0x0B, 0xD0, 0x0B, 0xD8, 0x1B, 0xC8, 0x13,
  0xC8, 0x13, 0xCC, 0x23, 0xC4, 0x23, 0xC6, 0x63, 0xC2, 0x43, 0xC2, 0x43,
  0xC3, 0xC3, 0xC1, 0x83, 0xC1, 0x83, 0xC0, 0x1E, 0x01, 0xB0, 0x1D, 0x01,
  0xD8, 0x1C, 0xC1, 0xC4, 0x1C, 0x61, 0xC3, 0x1C, 0x11, 0xC1, 0x9C, 0x0D,
  0xC0, 0x5C, 0x07, 0xC0, 0x3C, 0x01, 0x03, 0xC0, 0x1F, 0xE0, 0xC0, 0x61,
  0x00, 0x66, 0x00, 0x48, 0x00, 0xD0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x05, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x6C, 0x00, 0x8C, 0x03, 0x0C, 0x0C,
  0x0F, 0xE0, 0xFF, 0xB0, 0x3C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0F, 0x06,
  0xFF, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x03, 0xC0,
  0x1F, 0xE0, 0xC0, 0x61, 0x00, 0x66, 0x00, 0x48, 0x00, 0xD0, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x05, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x6C, 0x00,
  0x8C, 0x03, 0x0C, 0x0C, 0x0F, 0xE0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x01, 0xC0, 0xFF, 0x98, 0x1B, 0x01, 0x60, 0x2C, 0x05, 0x80, 0xB0, 0x36,
  0x0C, 0xFE, 0x18, 0x43, 0x0C, 0x60, 0xCC, 0x09, 0x81, 0xB0, 0x16, 0x03,
  0x0F, 0x0F, 0xF6, 0x01, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x1E, 0x00,
  0xE0, 0x0C, 0x01, 0x00, 0x40, 0x10, 0x06, 0x06, 0xFF, 0x00, 0xFF, 0xF0,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x1C, 0x01, 0xC0, 0x14, 0x03, 0x30, 0x61, 0xFC, 0xC0, 0x0A,
  0x00, 0xD0, 0x04, 0xC0, 0x22, 0x03, 0x18, 0x10, 0x41, 0x82, 0x08, 0x18,
  0x40, 0x46, 0x02, 0x20, 0x19, 0x00, 0x58, 0x02, 0x80, 0x1C, 0x00, 0x60,
  0x80, 0xC0, 0x30, 0x1C, 0x0F, 0x02, 0x81, 0x20, 0xD0, 0x24, 0x12, 0x0C,
  0x82, 0x61, 0x98, 0x44, 0x21, 0x18, 0x84, 0x22, 0x19, 0x86, 0x41, 0x20,
  0xC8, 0x24, 0x0B, 0x04, 0x81, 0x40, 0xF0, 0x38, 0x0C, 0x03, 0x01, 0x80,
  0x40, 0x30, 0xE0, 0x31, 0x01, 0x0C, 0x10, 0x21, 0x80, 0x88, 0x06, 0x80,
  0x1C, 0x00, 0xC0, 0x07, 0x00, 0x68, 0x02, 0x20, 0x21, 0x83, 0x04, 0x10,
  0x31, 0x00, 0xD8, 0x03, 0xC0, 0x34, 0x02, 0x20, 0x63, 0x04, 0x10, 0xC1,
  0x88, 0x09, 0x80, 0xD0, 0x06, 0x00, 0x60, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0xFF, 0xE0, 0x08, 0x03, 0x00, 0x40, 0x10, 0x06,
  0x00, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x40, 0x18, 0x02, 0x00, 0x80, 0x30,
  0x07, 0xFF, 0xFC, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x3F, 0xF0, 0xC0, 0x40, 0x60, 0x20, 0x20, 0x30, 0x10, 0x18, 0x08,
  0x08, 0x0C, 0x04, 0x04, 0x06, 0x02, 0x03, 0xF1, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x11, 0xFF, 0x04, 0x00, 0x80, 0x28, 0x05, 0x81, 0x10,
  0x23, 0x08, 0x21, 0x06, 0x40, 0x48, 0x0E, 0x00, 0x80, 0xFF, 0xC0, 0xC4,
  0x21, 0x7F, 0x20, 0x40, 0x20, 0x10, 0x08, 0xFD, 0x83, 0x81, 0x80, 0xE0,
  0xF0, 0x6F, 0xD0, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x2F, 0xEA, 0x0B,
  0x03, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x70, 0x1C, 0x0E, 0x86, 0x9F,
  0x00, 0x1F, 0x90, 0x18, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x40, 0x30,
  0x0C, 0x23, 0xF0, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x7E, 0xD8,
  0x2A, 0x03, 0x40, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x06, 0x80, 0xD0, 0x19,
  0x05, 0x1F, 0x20, 0x1F, 0x88, 0x24, 0x05, 0x01, 0xC0, 0x7F, 0xFC, 0x03,
  0x00, 0x40, 0x18, 0x03, 0x04, 0x7F, 0x06, 0x1F, 0x10, 0x10, 0x10, 0x10,
  0xFE, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x3F, 0x2C, 0x15, 0x01, 0xA0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x40,
  0x68, 0x0C, 0x83, 0x8F, 0xB0, 0x06, 0x00, 0xC0, 0x12, 0x06, 0x7F, 0x80,
  0x80, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x2F, 0xEA, 0x0B, 0x03, 0xC0,
  0xE0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0xB0,
  0x2A, 0xAA, 0xAA, 0x80, 0x10, 0xC0, 0x00, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x79, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x0E, 0x09, 0x08, 0x88, 0x4C, 0x2C, 0x1D, 0x0C, 0xC4, 0x32, 0x09,
  0x02, 0x81, 0x80, 0xFF, 0xFF, 0x80, 0xBF, 0x3F, 0x70, 0xE0, 0xB0, 0x20,
  0x70, 0x10, 0x38, 0x08, 0x1C, 0x04, 0x0E, 0x02, 0x07, 0x01, 0x03, 0x80,
  0x81, 0xC0, 0x40, 0xE0, 0x20, 0x70, 0x10, 0x30, 0xBF, 0xA8, 0x2C, 0x0F,
  0x03, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x1F,
  0x84, 0x19, 0x01, 0xA0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x40, 0x2C,
  0x08, 0xC3, 0x0F, 0xC0, 0x9F, 0xA8, 0x2C, 0x0F, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0xC0, 0x70, 0x3A, 0x1A, 0x7C, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x00, 0x3F, 0x2C, 0x15, 0x01, 0xA0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0x40, 0x68, 0x0D, 0x83, 0x8F, 0xB0, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0xBF, 0x43, 0x06, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x00, 0x7F, 0x60, 0x30, 0x18, 0x06, 0x01, 0xE0, 0x1C, 0x02, 0x01, 0x80,
  0xE0, 0x5F, 0xC0, 0x20, 0x40, 0x87, 0xF2, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x03, 0x06, 0x07, 0x80, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3C, 0x1D, 0xF9, 0xC0, 0x68, 0x09, 0x03,
  0x30, 0x42, 0x08, 0x63, 0x04, 0x40, 0x88, 0x1A, 0x01, 0x40, 0x38, 0x06,
  0x00, 0xC0, 0x81, 0xA0, 0xA0, 0x90, 0x50, 0x4C, 0x28, 0x62, 0x36, 0x21,
  0x11, 0x10, 0xC8, 0x98, 0x2C, 0x68, 0x14, 0x14, 0x0A, 0x0A, 0x07, 0x07,
  0x01, 0x01, 0x00, 0x60, 0x64, 0x18, 0x46, 0x0C, 0x80, 0xE0, 0x0C, 0x03,
  0x80, 0x58, 0x11, 0x86, 0x10, 0x83, 0x60, 0x30, 0xC0, 0x68, 0x09, 0x03,
  0x30, 0x42, 0x08, 0x63, 0x04, 0x40, 0x88, 0x1A, 0x01, 0x40, 0x38, 0x02,
  0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0xF0, 0x08, 0x00, 0xFF, 0x80, 0x80,
  0x80, 0xC0, 0x40, 0x40, 0x60, 0x60, 0x20, 0x20, 0x30, 0x1F, 0xF0, 0x1C,
  0x43, 0x0C, 0x30, 0xC3, 0x0C, 0x23, 0x06, 0x08, 0x30, 0xC3, 0x0C, 0x30,
  0xC1, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0x60, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x18, 0x0C, 0x60, 0x81, 0x02, 0x04, 0x08, 0x10, 0x63, 0x84, 0x00, 0x7C,
  0x30, 0x78,
};

const GFXglyph NotoSans_Light23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 16, 6, 2, -16 },
  { 5, 5, 6, 8, 2, -16 },
  { 9, 13, 16, 15, 1, -16 },
  { 35, 10, 18, 13, 1, -17 },
  { 58, 16, 17, 19, 1, -17 },
  { 92, 15, 17, 16, 1, -17 },
  { 124, 1, 6, 5, 2, -16 },
  { 125, 5, 20, 6, 1, -16 },
  { 138, 4, 20, 6, 1, -16 },
  { 148, 10, 9, 13, 1, -17 },
  { 160, 11, 11, 13, 1, -14 },
  { 176, 3, 6, 5, 1, -3 },
  { 179, 5, 1, 7, 1, -7 },
  { 180, 2, 2, 6, 2, -2 },
  { 181, 8, 16, 8, 0, -16 },
  { 197, 11, 17, 13, 1, -17 },
  { 221, 6, 16, 13, 2, -16 },
  { 233, 11, 17, 13, 1, -17 },
  { 257, 11, 17, 13, 1, -17 },
  { 281, 12, 17, 13, 1, -17 },
  { 307, 10, 16, 13, 2, -16 },
  { 327, 11, 17, 13, 1, -17 },
  { 351, 11, 16, 13, 1, -16 },
  { 373, 11, 17, 13, 1, -17 },
  { 397, 11, 17, 13, 1, -17 },
  { 421, 2, 12, 6, 2, -12 },
  { 424, 3, 15, 6, 1, -12 },
  { 430, 11, 11, 13, 1, -14 },
  { 446, 11, 6, 13, 1, -11 },
  { 455, 11, 11, 13, 1, -14 },
  { 471, 8, 17, 10, 1, -17 },
  { 488, 18, 18, 20, 1, -16 },
  { 529, 14, 16, 14, 0, -16 },
  { 557, 11, 16, 15, 2, -16 },
  { 579, 13, 17, 14, 1, -17 },
  { 607, 13, 16, 16, 2, -16 },
  { 633, 9, 16, 13, 2, -16 },
  { 651, 9, 16, 12, 2, -16 },
  { 669, 14, 17, 17, 1, -17 },
  { 699, 12, 16, 17, 2, -16 },
  { 723, 5, 16, 7, 1, -16 },
  { 733, 6, 20, 6, -2, -16 },
  { 748, 12, 16, 14, 2, -16 },
  { 772, 9, 16, 12, 2, -16 },
  { 790, 16, 16, 20, 2, -16 },
  { 822, 12, 16, 17, 2, -16 },
  { 846, 15, 17, 18, 1, -17 },
  { 878, 10, 16, 14, 2, -16 },
  { 898, 15, 21, 18, 1, -17 },
  { 938, 11, 16, 14, 2, -16 },
  { 960, 10, 17, 13, 1, -17 },
  { 982, 12, 16, 12, 0, -16 },
  { 1006, 12, 16, 17, 2, -16 },
  { 1030, 13, 16, 13, 0, -16 },
  { 1056, 19, 16, 21, 1, -16 },
  { 1094, 13, 16, 13, 0, -16 },
  { 1120, 12, 16, 12, 0, -16 },
  { 1144, 11, 16, 13, 1, -16 },
  { 1166, 5, 20, 7, 2, -16 },
  { 1179, 8, 16, 8, 0, -16 },
  { 1195, 4, 20, 7, 1, -16 },
  { 1205, 11, 11, 13, 1, -17 },
  { 1221, 10, 1, 10, 0, 2 },
  { 1223, 4, 4, 6, 1, -18 },
  { 1225, 9, 12, 12, 1, -12 },
  { 1239, 10, 17, 14, 2, -17 },
  { 1261, 9, 12, 11, 1, -12 },
  { 1275, 11, 17, 14, 1, -17 },
  { 1299, 10, 12, 13, 1, -12 },
  { 1314, 8, 18, 7, 0, -18 },
  { 1332, 11, 18, 14, 1, -12 },
  { 1357, 10, 17, 14, 2, -17 },
  { 1379, 2, 17, 5, 2, -17 },
  { 1384, 5, 23, 5, -1, -17 },
  { 1399, 9, 17, 11, 2, -17 },
  { 1419, 1, 17, 5, 2, -17 },
  { 1422, 17, 12, 21, 2, -12 },
  { 1448, 10, 12, 14, 2, -12 },
  { 1463, 11, 12, 14, 1, -12 },
  { 1480, 10, 17, 14, 2, -12 },
  { 1502, 11, 17, 14, 1, -12 },
  { 1526, 7, 12, 9, 2, -12 },
  { 1537, 9, 12, 11, 1, -12 },
  { 1551, 7, 15, 8, 0, -15 },
  { 1565, 10, 12, 14, 2, -12 },
  { 1580, 11, 12, 11, 0, -12 },
  { 1597, 17, 12, 17, 0, -12 },
  { 1623, 11, 12, 12, 0, -12 },
  { 1640, 11, 18, 11, 0, -12 },
  { 1665, 9, 12, 11, 1, -12 },
  { 1679, 6, 20, 8, 1, -16 },
  { 1694, 1, 24, 12, 6, -18 },
  { 1697, 7, 20, 8, 1, -16 },
  { 1715, 11, 2, 13, 1, -9 },
};

const GFXfont NotoSans_Light23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light23pt7bBitmaps,
  (GFXglyph *)NotoSans_Light23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_LIGHT23PT7B_H_
