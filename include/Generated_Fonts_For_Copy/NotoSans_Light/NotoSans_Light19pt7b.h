#ifndef _NOTOSANS_LIGHT19PT7B_H_
#define _NOTOSANS_LIGHT19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light19pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x50, 0x70, 0x9C, 0x63, 0x18, 0x80, 0x08, 0x81, 0x10,
  0x42, 0x08, 0x81, 0x11, 0xFF, 0xC4, 0x41, 0x08, 0x22, 0x1F, 0xF8, 0x88,
  0x11, 0x02, 0x20, 0x88, 0x00, 0x08, 0x3F, 0x49, 0x88, 0x88, 0x48, 0x38,
  0x0E, 0x0B, 0x09, 0x09, 0x09, 0xFE, 0x08, 0x08, 0x30, 0x22, 0x42, 0x22,
  0x11, 0x11, 0x08, 0x88, 0x44, 0x82, 0x25, 0xE9, 0x51, 0x32, 0x88, 0x24,
  0x42, 0x22, 0x11, 0x11, 0x08, 0x98, 0x38, 0x1C, 0x02, 0x20, 0x21, 0x06,
  0x10, 0x23, 0x03, 0x60, 0x18, 0x02, 0xC1, 0x46, 0x28, 0x32, 0x81, 0xC8,
  0x0C, 0x41, 0xE3, 0xE3, 0xF8, 0x32, 0x44, 0xC8, 0x88, 0x88, 0x88, 0x84,
  0x42, 0x30, 0x8C, 0x46, 0x22, 0x22, 0x32, 0x22, 0x22, 0x44, 0x80, 0x08,
  0x08, 0x89, 0x7E, 0x18, 0x34, 0x66, 0x22, 0x08, 0x04, 0x02, 0x01, 0x0F,
  0xF8, 0x40, 0x20, 0x10, 0x08, 0x00, 0x7A, 0xF0, 0x70, 0x04, 0x10, 0x42,
  0x08, 0x41, 0x04, 0x20, 0x82, 0x10, 0x42, 0x00, 0x1C, 0x31, 0x10, 0x58,
  0x28, 0x1C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x48, 0x24, 0x31, 0xF0,
  0x13, 0x59, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1C, 0x71, 0x00, 0x40, 0x20,
  0x10, 0x08, 0x08, 0x0C, 0x0C, 0x0C, 0x04, 0x04, 0x04, 0x07, 0xFC, 0x3C,
  0x61, 0x00, 0x40, 0x20, 0x10, 0x18, 0xF0, 0x1C, 0x01, 0x00, 0xC0, 0x60,
  0x28, 0x37, 0xF0, 0x01, 0x00, 0x60, 0x0C, 0x02, 0x80, 0x90, 0x32, 0x04,
  0x41, 0x08, 0x41, 0x08, 0x23, 0xFF, 0x80, 0x80, 0x10, 0x02, 0x00, 0x7F,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0xF8, 0x02, 0x01, 0x80, 0x40, 0x20,
  0x28, 0x37, 0xF0, 0x0F, 0x18, 0x08, 0x08, 0x04, 0x04, 0x02, 0xFD, 0x82,
  0x80, 0xC0, 0x60, 0x28, 0x36, 0x11, 0xF0, 0xFF, 0x80, 0x40, 0x40, 0x20,
  0x20, 0x10, 0x18, 0x08, 0x0C, 0x04, 0x02, 0x02, 0x01, 0x01, 0x00, 0x1C,
  0x31, 0x90, 0x48, 0x24, 0x13, 0x10, 0x70, 0x6C, 0x41, 0x40, 0xE0, 0x30,
  0x14, 0x11, 0xF0, 0x1C, 0x31, 0x30, 0x50, 0x28, 0x1C, 0x06, 0x06, 0x85,
  0x3D, 0x80, 0x80, 0x40, 0x60, 0x63, 0xE0, 0xD0, 0x00, 0x70, 0xD0, 0x00,
  0x7A, 0x01, 0x83, 0x06, 0x0C, 0x0C, 0x01, 0x80, 0x30, 0x07, 0x00, 0x80,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x18,
  0x30, 0xE1, 0x80, 0x80, 0x00, 0x39, 0x8C, 0x08, 0x10, 0x20, 0x41, 0x0C,
  0x10, 0x20, 0x00, 0x01, 0x06, 0x00, 0x0F, 0xF0, 0x60, 0x10, 0x80, 0x12,
  0x1E, 0x24, 0x42, 0x31, 0x04, 0x62, 0x10, 0xC4, 0x21, 0x88, 0x43, 0x10,
  0xCA, 0x1E, 0xE2, 0x00, 0x02, 0x00, 0x03, 0x04, 0x01, 0xF0, 0x00, 0x04,
  0x00, 0x60, 0x06, 0x00, 0xB0, 0x09, 0x01, 0x10, 0x10, 0x81, 0x08, 0x3F,
  0x82, 0x04, 0x60, 0x44, 0x06, 0x40, 0x28, 0x03, 0xF8, 0x43, 0xA0, 0x50,
  0x38, 0x14, 0x0B, 0xF9, 0x0E, 0x81, 0xC0, 0x60, 0x30, 0x38, 0x17, 0xF0,
  0x07, 0x86, 0x12, 0x01, 0x00, 0x40, 0x30, 0x08, 0x02, 0x00, 0x80, 0x30,
  0x04, 0x01, 0x80, 0x30, 0x07, 0xF0, 0xF8, 0x21, 0xC8, 0x1A, 0x03, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x02, 0x83, 0x3F, 0x00,
  0xFF, 0x02, 0x04, 0x08, 0x10, 0x3F, 0xC0, 0x81, 0x02, 0x04, 0x08, 0x1F,
  0xC0, 0xFF, 0x02, 0x04, 0x08, 0x10, 0x20, 0x7F, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x00, 0x07, 0xC3, 0x0C, 0x80, 0x20, 0x04, 0x01, 0x80, 0x20, 0x04,
  0x1F, 0x80, 0x38, 0x05, 0x00, 0xB0, 0x13, 0x02, 0x3F, 0xC0, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x1F, 0xFE, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x10, 0xF6, 0x66, 0x66, 0x66, 0x66, 0x66, 0x6F, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0xF0, 0x80, 0xC0,
  0xA0, 0x90, 0x88, 0x84, 0x82, 0xC1, 0xA0, 0x88, 0x42, 0x21, 0x90, 0x48,
  0x14, 0x0C, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x1F, 0xC0, 0xC0, 0x1E, 0x00, 0xF0, 0x0B, 0x40, 0x5A, 0x04, 0xD8,
  0x26, 0x41, 0x32, 0x11, 0x88, 0x8C, 0x48, 0x63, 0x43, 0x0A, 0x18, 0x60,
  0xC1, 0x04, 0x80, 0x70, 0x1C, 0x06, 0x81, 0xB0, 0x64, 0x18, 0x86, 0x31,
  0x84, 0x60, 0x98, 0x36, 0x05, 0x80, 0xE0, 0x30, 0x0F, 0x03, 0x0C, 0x60,
  0x24, 0x03, 0x40, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x01, 0x40,
  0x16, 0x02, 0x30, 0x61, 0xF8, 0xF0, 0x8E, 0x83, 0x81, 0x81, 0x81, 0x83,
  0xFE, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x0F, 0x03, 0x0C, 0x60, 0x24,
  0x03, 0x40, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x01, 0x40, 0x16,
  0x02, 0x30, 0x61, 0xF8, 0x01, 0x80, 0x08, 0x00, 0x60, 0xF8, 0x43, 0x20,
  0x50, 0x28, 0x14, 0x0A, 0x09, 0xF8, 0x8C, 0x42, 0x20, 0x90, 0x48, 0x14,
  0x0C, 0x1E, 0x63, 0xC0, 0x80, 0x80, 0x40, 0x30, 0x0E, 0x03, 0x01, 0x01,
  0x01, 0x83, 0xFE, 0xFF, 0xC3, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03,
  0x41, 0x8F, 0xC0, 0x80, 0x38, 0x0D, 0x01, 0x20, 0x26, 0x0C, 0x41, 0x08,
  0x20, 0x88, 0x11, 0x02, 0x20, 0x28, 0x05, 0x00, 0xA0, 0x08, 0x00, 0xC0,
  0x80, 0xA0, 0x40, 0x90, 0x50, 0x48, 0x28, 0x22, 0x14, 0x31, 0x0B, 0x10,
  0x88, 0x88, 0x44, 0x44, 0x12, 0x24, 0x0A, 0x0A, 0x05, 0x05, 0x02, 0x82,
  0x80, 0xC1, 0x80, 0x40, 0x40, 0xC0, 0x50, 0x22, 0x08, 0xC4, 0x12, 0x02,
  0x80, 0xC0, 0x30, 0x0A, 0x04, 0xC2, 0x10, 0x82, 0x40, 0xB0, 0x10, 0x80,
  0x50, 0x34, 0x08, 0x86, 0x21, 0x04, 0x81, 0x20, 0x30, 0x0C, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0xFF, 0x80, 0x40, 0x40, 0x40, 0x20, 0x20,
  0x20, 0x10, 0x10, 0x10, 0x08, 0x08, 0x08, 0x07, 0xFC, 0xF8, 0x88, 0x88,
  0x88, 0x88, 0x88, 0x88, 0x88, 0xF0, 0x81, 0x04, 0x10, 0x20, 0x83, 0x04,
  0x10, 0x20, 0x82, 0x04, 0x10, 0xF8, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x8C, 0x63, 0xF8, 0x08, 0x0C, 0x05, 0x04, 0x82, 0x22, 0x11, 0x05,
  0x02, 0x80, 0x80, 0xFF, 0x99, 0x80, 0x7E, 0x02, 0x03, 0x01, 0x3F, 0x41,
  0x81, 0x83, 0x85, 0x79, 0x80, 0x80, 0x80, 0x80, 0xBE, 0xC3, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0xC2, 0xBC, 0x3E, 0x81, 0x04, 0x08, 0x10, 0x20,
  0x60, 0x40, 0x7C, 0x00, 0x80, 0x40, 0x20, 0x13, 0xEA, 0x0F, 0x07, 0x01,
  0x80, 0xC0, 0x60, 0x38, 0x34, 0x19, 0xF4, 0x3E, 0x41, 0x41, 0x81, 0xFF,
  0x80, 0x80, 0x40, 0x40, 0x3F, 0x0C, 0x24, 0x81, 0x02, 0x1F, 0x88, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x00, 0x3E, 0xA0, 0xF0, 0x70, 0x18,
  0x0C, 0x06, 0x03, 0x83, 0x41, 0x9F, 0x40, 0x20, 0x10, 0x13, 0x18, 0x70,
  0x80, 0x80, 0x80, 0x80, 0xBE, 0xC2, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0xD0, 0x55, 0x55, 0x50, 0x31, 0x00, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x1A, 0x40, 0x81, 0x02, 0x04, 0x08, 0x71, 0xA6, 0x58, 0xA1,
  0xA2, 0x64, 0x48, 0x50, 0x40, 0xFF, 0xFC, 0xBC, 0xFE, 0x18, 0x60, 0x83,
  0x04, 0x18, 0x20, 0xC1, 0x06, 0x08, 0x30, 0x41, 0x82, 0x0C, 0x10, 0x40,
  0xBE, 0xC2, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x3E, 0x20,
  0xB0, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x81, 0x41, 0x1F, 0x00, 0xBE, 0xC3,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xC2, 0xBC, 0x80, 0x80, 0x80, 0x80,
  0x3E, 0xA0, 0xF0, 0x70, 0x18, 0x0C, 0x06, 0x03, 0x83, 0x42, 0x9F, 0x40,
  0x20, 0x10, 0x08, 0x04, 0xBE, 0x21, 0x08, 0x42, 0x10, 0x84, 0x00, 0x7F,
  0x02, 0x06, 0x07, 0x01, 0x80, 0x81, 0x83, 0xF8, 0x20, 0x82, 0x3F, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x3C, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x83, 0x83, 0x85, 0x79, 0x80, 0xA0, 0x90, 0x4C, 0x62, 0x21, 0x10, 0x50,
  0x28, 0x14, 0x04, 0x00, 0xC3, 0x0D, 0x0C, 0x24, 0x30, 0x91, 0x22, 0x24,
  0x90, 0x92, 0x42, 0x85, 0x0A, 0x14, 0x18, 0x60, 0x40, 0x80, 0x41, 0x90,
  0x8C, 0x82, 0x80, 0xC0, 0x60, 0x58, 0x44, 0x61, 0x60, 0x40, 0x80, 0xA0,
  0x90, 0x4C, 0x62, 0x21, 0x10, 0x50, 0x28, 0x14, 0x04, 0x02, 0x02, 0x01,
  0x05, 0x03, 0x00, 0xFE, 0x08, 0x30, 0x41, 0x06, 0x08, 0x20, 0xC1, 0xFC,
  0x09, 0x88, 0x42, 0x10, 0x8C, 0xC2, 0x08, 0x42, 0x10, 0x84, 0x18, 0xFF,
  0xFF, 0xE0, 0x83, 0x08, 0x42, 0x10, 0x84, 0x19, 0x88, 0x42, 0x10, 0x84,
  0xC0, 0x70, 0xC7, 0xC0,
};

const GFXglyph NotoSans_Light19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 14, 5, 1, -14 },
  { 5, 5, 5, 7, 1, -14 },
  { 9, 11, 14, 12, 1, -14 },
  { 29, 8, 15, 11, 1, -14 },
  { 44, 13, 14, 15, 1, -14 },
  { 67, 12, 14, 14, 1, -14 },
  { 88, 1, 5, 4, 1, -14 },
  { 89, 4, 17, 5, 1, -14 },
  { 98, 4, 17, 5, 1, -14 },
  { 107, 8, 8, 10, 1, -14 },
  { 115, 9, 9, 11, 1, -11 },
  { 126, 2, 4, 4, 1, -2 },
  { 127, 4, 1, 6, 1, -6 },
  { 128, 2, 2, 5, 1, -2 },
  { 129, 6, 14, 7, 0, -14 },
  { 140, 9, 14, 11, 1, -14 },
  { 156, 4, 14, 11, 2, -14 },
  { 163, 9, 14, 11, 1, -14 },
  { 179, 9, 14, 11, 1, -14 },
  { 195, 11, 14, 11, 0, -14 },
  { 215, 9, 14, 11, 1, -14 },
  { 231, 9, 14, 11, 1, -14 },
  { 247, 9, 14, 11, 1, -14 },
  { 263, 9, 14, 11, 1, -14 },
  { 279, 9, 14, 11, 1, -14 },
  { 295, 2, 10, 5, 1, -10 },
  { 298, 2, 12, 5, 1, -10 },
  { 301, 9, 9, 11, 1, -11 },
  { 312, 9, 5, 11, 1, -9 },
  { 318, 9, 9, 11, 1, -11 },
  { 329, 7, 14, 8, 0, -14 },
  { 342, 15, 15, 17, 1, -13 },
  { 371, 12, 14, 12, 0, -14 },
  { 392, 9, 14, 12, 2, -14 },
  { 408, 10, 14, 12, 1, -14 },
  { 426, 10, 14, 14, 2, -14 },
  { 444, 7, 14, 11, 2, -14 },
  { 457, 7, 14, 10, 2, -14 },
  { 470, 11, 14, 14, 1, -14 },
  { 490, 10, 14, 14, 2, -14 },
  { 508, 4, 14, 6, 1, -14 },
  { 515, 5, 17, 5, -2, -14 },
  { 526, 9, 14, 11, 2, -14 },
  { 542, 7, 14, 10, 2, -14 },
  { 555, 13, 14, 17, 2, -14 },
  { 578, 10, 14, 14, 2, -14 },
  { 596, 12, 14, 15, 1, -14 },
  { 617, 8, 14, 11, 2, -14 },
  { 631, 12, 17, 15, 1, -14 },
  { 657, 9, 14, 11, 2, -14 },
  { 673, 8, 14, 10, 1, -14 },
  { 687, 10, 14, 10, 0, -14 },
  { 705, 10, 14, 14, 2, -14 },
  { 723, 11, 14, 11, 0, -14 },
  { 743, 17, 14, 17, 0, -14 },
  { 773, 10, 14, 10, 0, -14 },
  { 791, 10, 14, 10, 0, -14 },
  { 809, 9, 14, 11, 1, -14 },
  { 825, 4, 17, 6, 2, -14 },
  { 834, 6, 14, 7, 0, -14 },
  { 845, 5, 17, 6, 0, -14 },
  { 856, 9, 9, 11, 1, -14 },
  { 867, 8, 1, 8, 0, 2 },
  { 868, 3, 3, 5, 1, -15 },
  { 870, 8, 10, 10, 1, -10 },
  { 880, 8, 14, 11, 2, -14 },
  { 894, 7, 10, 9, 1, -10 },
  { 903, 9, 14, 11, 1, -14 },
  { 919, 8, 10, 10, 1, -10 },
  { 929, 7, 15, 6, 0, -15 },
  { 943, 9, 15, 11, 1, -10 },
  { 960, 8, 14, 11, 2, -14 },
  { 974, 2, 14, 4, 1, -14 },
  { 978, 4, 19, 4, -1, -14 },
  { 988, 7, 14, 9, 2, -14 },
  { 1001, 1, 14, 4, 2, -14 },
  { 1003, 13, 10, 17, 2, -10 },
  { 1020, 8, 10, 11, 2, -10 },
  { 1030, 9, 10, 11, 1, -10 },
  { 1042, 8, 14, 11, 2, -10 },
  { 1056, 9, 14, 11, 1, -10 },
  { 1072, 5, 10, 7, 2, -10 },
  { 1079, 7, 10, 9, 1, -10 },
  { 1088, 6, 13, 6, 0, -13 },
  { 1098, 8, 10, 11, 2, -10 },
  { 1108, 9, 10, 9, 0, -10 },
  { 1120, 14, 10, 14, 0, -10 },
  { 1138, 9, 10, 10, 0, -10 },
  { 1150, 9, 15, 9, 0, -10 },
  { 1167, 7, 10, 9, 1, -10 },
  { 1176, 5, 17, 7, 1, -14 },
  { 1187, 1, 19, 10, 5, -14 },
  { 1190, 5, 17, 7, 1, -14 },
  { 1201, 9, 2, 11, 1, -8 },
};

const GFXfont NotoSans_Light19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light19pt7bBitmaps,
  (GFXglyph *)NotoSans_Light19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_LIGHT19PT7B_H_
