#ifndef _NOTOSANS_LIGHT69PT7B_H_
#define _NOTOSANS_LIGHT69PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light69pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE3,
  0xC7, 0x8F, 0x1E, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xC7, 0xDF, 0xBF, 0xBE, 0x7C, 0x70, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xB0, 0x07, 0x60, 0x0E, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x01, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x0F, 0x00,
  0x00, 0x03, 0x80, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x80, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00,
  0x01, 0xC0, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x07, 0x00, 0x00, 0x03, 0xC0,
  0x07, 0x80, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFC, 0x1F, 0xC7, 0x87, 0xF0, 0xFC, 0x1E, 0x03, 0x83, 0xC0, 0x78, 0x00,
  0x1F, 0x01, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0x03, 0xC0,
  0x1E, 0x00, 0x07, 0x80, 0x78, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x7C, 0x07,
  0x80, 0x00, 0xF8, 0x1E, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x07, 0xF9, 0xE0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x79, 0xFE, 0x00, 0x01, 0xE1, 0xFC, 0x00, 0x07, 0x81, 0xF8, 0x00,
  0x1E, 0x03, 0xE0, 0x00, 0x78, 0x07, 0xC0, 0x01, 0xE0, 0x0F, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0x01, 0xE0,
  0x0F, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x78, 0x07,
  0x80, 0x01, 0xE0, 0x3E, 0xC0, 0x07, 0x81, 0xF3, 0xF0, 0x1E, 0x1F, 0x8F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1E,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x38, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x78, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x70, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0xF0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0xE0, 0x07, 0x80, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0xE0, 0x78, 0x1F, 0xC0, 0xF0, 0x01, 0xE0, 0xF0, 0x7F,
  0xF0, 0xF0, 0x01, 0xE0, 0xE0, 0xFF, 0xF8, 0x70, 0x01, 0xC1, 0xE1, 0xF0,
  0x7C, 0x78, 0x03, 0xC1, 0xC1, 0xE0, 0x3C, 0x78, 0x03, 0xC3, 0xC3, 0xC0,
  0x1E, 0x3C, 0x07, 0x83, 0x83, 0x80, 0x0E, 0x1E, 0x0F, 0x07, 0x87, 0x80,
  0x0E, 0x1F, 0xFF, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0xFE, 0x0F, 0x07, 0x80,
  0x0F, 0x01, 0xF8, 0x1E, 0x07, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x07, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x07, 0x00, 0x00, 0x38, 0x07, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x07, 0x00, 0x07, 0x00, 0x00, 0x70, 0x07, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x07, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x07, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x0E, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x1C, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0xF8,
  0xF8, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xE3, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x03, 0xC0,
  0xFC, 0x0F, 0xC0, 0x00, 0x3C, 0x1F, 0x80, 0x7E, 0x00, 0x07, 0xC3, 0xE0,
  0x03, 0xF0, 0x00, 0x78, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0x87, 0xC0, 0x00,
  0xFC, 0x00, 0xF8, 0x78, 0x00, 0x07, 0xE0, 0x0F, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0xF0, 0xF0, 0x00, 0x01, 0xF8, 0x1E, 0x0F, 0x00, 0x00, 0x0F, 0xC1,
  0xE0, 0xF0, 0x00, 0x00, 0x7E, 0x3C, 0x0F, 0x00, 0x00, 0x03, 0xF7, 0xC0,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0xF8, 0x07, 0xC0, 0x00, 0x01, 0xF7, 0xC0, 0x3E, 0x00, 0x00,
  0x7E, 0x3E, 0x01, 0xF8, 0x00, 0x0F, 0xC1, 0xF0, 0x1F, 0xE0, 0x07, 0xF8,
  0x1F, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEE, 0xE6, 0x66, 0x00, 0x7C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F,
  0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0xF8, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x1C, 0x00, 0x3F, 0x80, 0x70, 0x07, 0xFF, 0xC1, 0xC0, 0xFF,
  0xFF, 0xE3, 0x1F, 0xFD, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x03, 0xC1,
  0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x03, 0xE0, 0x1F,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xE0, 0x01, 0xC0,
  0x01, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x1F, 0x1F, 0x1F, 0x1E, 0x1E, 0x3E, 0x3C, 0x3C,
  0x3C, 0x3C, 0x78, 0x78, 0x70, 0x70, 0xF0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x38, 0xFB, 0xF7, 0xF7, 0xCF, 0x8E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x03, 0xFE, 0x7F, 0x80, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x03,
  0xE0, 0x0F, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x3C, 0x78, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x01,
  0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xF7, 0x07,
  0xE7, 0x0F, 0xCF, 0x1F, 0x0F, 0x7E, 0x0F, 0xFC, 0x0F, 0xF0, 0x0F, 0x60,
  0x0F, 0x40, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xF8, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0xFC, 0x0E, 0x00, 0x00, 0xF8, 0x18, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFC, 0x7F, 0xE0, 0x7F, 0x80, 0x07,
  0xF0, 0x7E, 0x00, 0x01, 0xF0, 0x38, 0x00, 0x00, 0xF8, 0x20, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x7C, 0x80, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x0F,
  0xF0, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x00, 0x0E, 0xF0,
  0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFE, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF8, 0x06, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x20, 0x00, 0x00, 0xF8, 0xE0,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F,
  0xF0, 0x70, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x40, 0x00, 0x78, 0x1F, 0xFF, 0x00, 0x78, 0x7F,
  0xFF, 0xC0, 0x70, 0xFF, 0xFF, 0xE0, 0xF1, 0xF0, 0x03, 0xF0, 0xF3, 0xC0,
  0x00, 0xF8, 0xF7, 0x00, 0x00, 0x7C, 0xFE, 0x00, 0x00, 0x3C, 0xFC, 0x00,
  0x00, 0x3E, 0xFC, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x1E, 0xF8, 0x00,
  0x00, 0x1E, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0x70, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3E, 0x1E, 0x00,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xC0,
  0x01, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0xFC, 0x00, 0x7E, 0x03, 0xE0, 0x00,
  0x3E, 0x07, 0x80, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x01,
  0xE3, 0x80, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xE0,
  0x3E, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x3F, 0x8F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0x3E, 0x3E, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00,
  0xF3, 0xE0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x07, 0x87, 0xE0, 0x00, 0x3F,
  0x07, 0xF0, 0x01, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xE7, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xDE, 0x00, 0x00,
  0x0F, 0xBC, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0xFE, 0x7C, 0x00, 0x03,
  0xBC, 0x7C, 0x00, 0x1E, 0x78, 0x7E, 0x00, 0xF8, 0xF0, 0x7F, 0xFF, 0xE1,
  0xE0, 0x7F, 0xFF, 0x83, 0xC0, 0x3F, 0xF8, 0x07, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x08, 0x00, 0x3F, 0x80, 0x0F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7C, 0xFB, 0xF7, 0xF7, 0xCF, 0x84, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x7D, 0xFB, 0xFB, 0xE7, 0xC7, 0x00,
  0x0F, 0x87, 0xC7, 0xE3, 0xF0, 0xF8, 0x7C, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x3C, 0x1E,
  0x1F, 0x0F, 0x87, 0x83, 0xC1, 0xE1, 0xF0, 0xF0, 0x78, 0x3C, 0x1C, 0x1E,
  0x0E, 0x07, 0x07, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0x80, 0x07, 0xE3, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x1C, 0x3C, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x78, 0xE0, 0x00, 0xFC, 0x00, 0x70, 0x01, 0xE7, 0x80, 0x07,
  0xC0, 0x01, 0xC0, 0x03, 0x9E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0E, 0x70,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x39, 0xC0, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0xEF, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x03, 0xBC, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x0F, 0xF0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x3F, 0x80, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0xFE, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x03, 0xB8, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x0E, 0xE0, 0x03, 0x80, 0x00, 0x38, 0x00, 0x3B,
  0x80, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0xEE, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x03, 0xB8, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x1E, 0xE0, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x73, 0x80, 0x0F, 0x00, 0x01, 0xF0, 0x01, 0xCF, 0x00, 0x1C,
  0x00, 0x0F, 0xC0, 0x0F, 0x3C, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x38, 0xF0,
  0x01, 0xF0, 0x01, 0xDC, 0x01, 0xE1, 0xC0, 0x03, 0xE0, 0x1E, 0x38, 0x0F,
  0x07, 0x80, 0x07, 0xFF, 0xF0, 0xFF, 0xF8, 0x1E, 0x00, 0x0F, 0xFF, 0x81,
  0xFF, 0xC0, 0x38, 0x00, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xF0, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x1E, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x38,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x78, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE7, 0x80, 0x00,
  0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x1E, 0x00, 0x07, 0xFE, 0x0F, 0x00, 0x00, 0x3F, 0x87, 0x80,
  0x00, 0x07, 0xE3, 0xC0, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x00, 0x7C, 0xF0,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1F,
  0x0F, 0x00, 0x00, 0x3E, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x78, 0x00, 0x03,
  0xF8, 0x3C, 0x00, 0x00, 0x3F, 0x1E, 0x00, 0x00, 0x0F, 0xCF, 0x00, 0x00,
  0x03, 0xE7, 0x80, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x00, 0x3D, 0xE0, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x0F, 0x9E,
  0x00, 0x00, 0x1F, 0x8F, 0x00, 0x00, 0x3F, 0x87, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x1F,
  0x00, 0x7F, 0x00, 0x00, 0x18, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x10, 0x01, 0xFF,
  0x00, 0x0F, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3C,
  0x00, 0x1F, 0xFE, 0x00, 0xF0, 0x00, 0x03, 0xFC, 0x03, 0xC0, 0x00, 0x03,
  0xF8, 0x0F, 0x00, 0x00, 0x03, 0xF0, 0x3C, 0x00, 0x00, 0x07, 0xE0, 0xF0,
  0x00, 0x00, 0x0F, 0xC3, 0xC0, 0x00, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x00,
  0x3E, 0x3C, 0x00, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x01, 0xF3, 0xC0,
  0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x00,
  0x3E, 0xF0, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x00, 0xFB, 0xC0, 0x00,
  0x00, 0x03, 0xEF, 0x00, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x00, 0x7C,
  0xF0, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0x0F, 0x8F, 0x00, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0x0F, 0x83,
  0xC0, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x07, 0xE0, 0x3C, 0x00, 0x00,
  0x7F, 0x00, 0xF0, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xDE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x07, 0xE0,
  0x03, 0xF8, 0x00, 0x00, 0x70, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0x87, 0xE0, 0x00, 0x00, 0x03, 0xC1, 0xF8, 0x00,
  0x00, 0x01, 0xE0, 0x7E, 0x00, 0x00, 0x00, 0xF0, 0x1F, 0x80, 0x00, 0x00,
  0x78, 0x07, 0xF8, 0x00, 0x00, 0x7C, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x3E, 0x60, 0x7E, 0x3F, 0xFF, 0x1F, 0xFE, 0x0F, 0xFE,
  0x00, 0xA0, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xBC, 0x00, 0x00, 0x0F, 0x8F,
  0x00, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0xF0, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x03,
  0xE0, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0xF0,
  0x0F, 0x80, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x03,
  0xC1, 0xF0, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0x3C, 0x7F, 0x00, 0x00,
  0x0F, 0x3F, 0xC0, 0x00, 0x03, 0xCF, 0xF8, 0x00, 0x00, 0xF7, 0x9F, 0x00,
  0x00, 0x3F, 0xC3, 0xE0, 0x00, 0x0F, 0xE0, 0xF8, 0x00, 0x03, 0xF0, 0x1F,
  0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x7C,
  0x03, 0xC0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00,
  0x7C, 0x0F, 0x00, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x01, 0xF0, 0xF0, 0x00,
  0x00, 0x7C, 0x3C, 0x00, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x01, 0xF3, 0xC0,
  0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xEF, 0x00, 0x00, 0x00, 0x03, 0xDF, 0xBC,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x78, 0x00, 0x00, 0x00, 0x3B, 0xFD, 0xE0,
  0x00, 0x00, 0x01, 0xEF, 0xF7, 0x80, 0x00, 0x00, 0x07, 0xBF, 0xCF, 0x00,
  0x00, 0x00, 0x3C, 0xFF, 0x3C, 0x00, 0x00, 0x00, 0xF3, 0xFC, 0x78, 0x00,
  0x00, 0x03, 0x8F, 0xF1, 0xE0, 0x00, 0x00, 0x1E, 0x3F, 0xC7, 0x80, 0x00,
  0x00, 0x78, 0xFF, 0x0F, 0x00, 0x00, 0x03, 0xC3, 0xFC, 0x3C, 0x00, 0x00,
  0x0F, 0x0F, 0xF0, 0x78, 0x00, 0x00, 0x38, 0x3F, 0xC1, 0xE0, 0x00, 0x01,
  0xE0, 0xFF, 0x07, 0x80, 0x00, 0x07, 0x83, 0xFC, 0x0F, 0x00, 0x00, 0x3C,
  0x0F, 0xF0, 0x3C, 0x00, 0x00, 0xF0, 0x3F, 0xC0, 0x78, 0x00, 0x03, 0x80,
  0xFF, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xFC, 0x07, 0x80, 0x00, 0x78, 0x0F,
  0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x3F, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0xFF,
  0x00, 0xF8, 0x00, 0x38, 0x03, 0xFC, 0x01, 0xE0, 0x01, 0xE0, 0x0F, 0xF0,
  0x07, 0x80, 0x07, 0x80, 0x3F, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xFF, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xFC, 0x00, 0xF0, 0x03, 0x80, 0x0F, 0xF0, 0x01,
  0xE0, 0x1E, 0x00, 0x3F, 0xC0, 0x07, 0x80, 0x78, 0x00, 0xFF, 0x00, 0x0F,
  0x03, 0xC0, 0x03, 0xFC, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0xF0, 0x00, 0xF0,
  0x38, 0x00, 0x3F, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0x87,
  0x80, 0x03, 0xFC, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xF3, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x00, 0x7E, 0x78, 0x00, 0x00, 0x07,
  0xE7, 0xC0, 0x00, 0x00, 0x7F, 0x3E, 0x00, 0x00, 0x07, 0xF1, 0xE0, 0x00,
  0x00, 0x7F, 0x1F, 0x00, 0x00, 0x07, 0xF0, 0xF8, 0x00, 0x00, 0x7F, 0x07,
  0x80, 0x00, 0x07, 0xF0, 0x7C, 0x00, 0x00, 0x7F, 0x03, 0xE0, 0x00, 0x07,
  0xF0, 0x1E, 0x00, 0x00, 0x7F, 0x01, 0xF0, 0x00, 0x07, 0xF0, 0x0F, 0x80,
  0x00, 0x7F, 0x00, 0x78, 0x00, 0x07, 0xF0, 0x07, 0xC0, 0x00, 0x7F, 0x00,
  0x3E, 0x00, 0x07, 0xF0, 0x01, 0xE0, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x07,
  0xF0, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0x80, 0x07, 0xF0, 0x00, 0x7C,
  0x00, 0x7F, 0x00, 0x03, 0xE0, 0x07, 0xF0, 0x00, 0x1E, 0x00, 0x7F, 0x00,
  0x01, 0xF0, 0x07, 0xF0, 0x00, 0x0F, 0x80, 0x7F, 0x00, 0x00, 0x78, 0x07,
  0xF0, 0x00, 0x07, 0xC0, 0x7F, 0x00, 0x00, 0x3E, 0x07, 0xF0, 0x00, 0x03,
  0xE0, 0x7F, 0x00, 0x00, 0x1F, 0x07, 0xF0, 0x00, 0x00, 0xF8, 0x7F, 0x00,
  0x00, 0x07, 0x87, 0xF0, 0x00, 0x00, 0x7C, 0x7F, 0x00, 0x00, 0x03, 0xE7,
  0xF0, 0x00, 0x00, 0x3E, 0x7F, 0x00, 0x00, 0x01, 0xF7, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0x81, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x7C,
  0x00, 0x00, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x78, 0x00,
  0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x1F, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF8, 0x3C, 0x00, 0x3F, 0xF0, 0xF0, 0x00, 0x0F, 0xE3, 0xC0,
  0x00, 0x0F, 0xCF, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x3E, 0xF0, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xFB, 0xC0,
  0x00, 0x07, 0xCF, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x01, 0xF8, 0xF0, 0x00,
  0x3F, 0xC3, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x00,
  0x00, 0x3C, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7B,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x00, 0x1E,
  0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x1E, 0x00, 0x1F,
  0xF8, 0x0F, 0x00, 0x00, 0xFE, 0x07, 0x80, 0x00, 0x1F, 0x83, 0xC0, 0x00,
  0x07, 0xE1, 0xE0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x00, 0x3E, 0x3C, 0x00, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x1F, 0x07,
  0x80, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x1F, 0x81, 0xE0, 0x00, 0x3F, 0x80,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xC0, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x01,
  0xF0, 0x0F, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x3E, 0x03, 0xC0, 0x00,
  0x0F, 0x81, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xF0, 0x78, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x0F, 0x8F, 0x00,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x1F,
  0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x00, 0xC3, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF3, 0x80, 0x00, 0x1F,
  0x8F, 0xE0, 0x01, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xE8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0xF0,
  0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x01, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x0F, 0x80, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00,
  0x1F, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x01, 0xE7, 0xC0,
  0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x1D, 0xE0, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0xF3, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE0,
  0xF8, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0xE0,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x70, 0x78, 0x00, 0x0F,
  0x80, 0x78, 0x00, 0x1E, 0x07, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x80, 0x1E,
  0x00, 0x0E, 0x01, 0xC0, 0x01, 0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x3C, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x78, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0E,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x3C, 0x01, 0xC0, 0x03, 0x80, 0x3E, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x78, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x1E, 0x01, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x1E, 0x07, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x07, 0x03,
  0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x01, 0xE7,
  0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01, 0xCF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x00, 0x07, 0x81, 0xF0, 0x00,
  0x00, 0x3E, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x07, 0x80,
  0x1F, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x00, 0x07, 0xC3, 0xC0, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x00, 0x3E,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x00, 0xFB, 0xC0, 0x00,
  0x00, 0x07, 0x9F, 0x00, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00,
  0x1E, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00,
  0x3E, 0x3E, 0x00, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x07, 0xDF, 0x00,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x00, 0x38, 0xF0, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x07, 0x07, 0x80,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x0F, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0xF0, 0x01,
  0xC0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x38, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0xFE, 0x01,
  0xFC, 0x07, 0x00, 0x07, 0xE0, 0x40, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0xF0, 0xFF, 0x00, 0x0F, 0x1F, 0x80, 0x00,
  0xF3, 0xE0, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0x78, 0x00, 0x03, 0xF7,
  0xC0, 0x00, 0x77, 0x7C, 0x00, 0x0E, 0x73, 0xF0, 0x03, 0xC7, 0x1F, 0xFF,
  0xF8, 0x70, 0xFF, 0xFF, 0x07, 0x03, 0xFF, 0xC0, 0x70, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x0F,
  0xFE, 0x00, 0xF0, 0x7F, 0xFF, 0x01, 0xE3, 0xFF, 0xFF, 0x83, 0xCF, 0xC0,
  0x3F, 0x87, 0xBE, 0x00, 0x1F, 0x8F, 0x70, 0x00, 0x1F, 0x1F, 0xC0, 0x00,
  0x1F, 0x3F, 0x00, 0x00, 0x1E, 0x7E, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00,
  0x3D, 0xF0, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00, 0xF7, 0xE0,
  0x00, 0x03, 0xEF, 0xC0, 0x00, 0x07, 0x9F, 0xC0, 0x00, 0x1F, 0x3F, 0xC0,
  0x00, 0x7C, 0x7B, 0xC0, 0x01, 0xF0, 0xE3, 0xE0, 0x0F, 0xE1, 0xC3, 0xFF,
  0xFF, 0x83, 0x83, 0xFF, 0xFC, 0x07, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x01, 0xFE, 0x03, 0xE0, 0x7E, 0x00, 0x04, 0x1F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x40, 0xFE, 0x00, 0x78, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x1F, 0xFC,
  0x0F, 0x00, 0xFF, 0xFE, 0x1E, 0x07, 0xFF, 0xFE, 0x3C, 0x1F, 0xC0, 0x3E,
  0x38, 0x7E, 0x00, 0x1E, 0x71, 0xF8, 0x00, 0x0E, 0xE3, 0xE0, 0x00, 0x1D,
  0xCF, 0x80, 0x00, 0x1F, 0x9E, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x3E,
  0xF0, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x01, 0xF3, 0xC0, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x0F, 0xC7, 0xC0, 0x00,
  0x3B, 0x87, 0xC0, 0x00, 0xE7, 0x0F, 0xE0, 0x07, 0x8E, 0x0F, 0xFF, 0xFE,
  0x1C, 0x07, 0xFF, 0xF8, 0x38, 0x03, 0xFF, 0xC0, 0x70, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0x81,
  0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x18, 0x1F, 0xC0, 0x03, 0xE0, 0x3F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0xFC, 0x01, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x0E, 0x01, 0xFF, 0xFC, 0x1C, 0x0F,
  0xFF, 0xFC, 0x38, 0x3F, 0x80, 0x7E, 0x70, 0xFC, 0x00, 0x3C, 0xE3, 0xF0,
  0x00, 0x1D, 0xC7, 0xC0, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x3F, 0x3C, 0x00,
  0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x0F, 0xCF,
  0x80, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x7F, 0x0F, 0x80, 0x01, 0xDE, 0x0F,
  0xC0, 0x0F, 0x3C, 0x0F, 0xFF, 0xFE, 0x78, 0x0F, 0xFF, 0xF0, 0xF0, 0x07,
  0xFF, 0x81, 0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1F, 0x10, 0x00, 0x00, 0x7C, 0x38, 0x00, 0x01,
  0xF0, 0x7F, 0x00, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0x60, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x03, 0xFF, 0x80, 0xF0, 0x7F, 0xFF, 0x07, 0x8F,
  0xFF, 0xFE, 0x3C, 0xFC, 0x03, 0xF9, 0xEF, 0x00, 0x07, 0xCF, 0x70, 0x00,
  0x1F, 0x7F, 0x00, 0x00, 0x7B, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x70, 0x79, 0xFF, 0xFF, 0x78, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E,
  0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E,
  0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE0, 0x00, 0x3C, 0x00, 0x7C,
  0x01, 0xF8, 0x03, 0xF0, 0x03, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x07, 0xC0, 0x0F, 0x20, 0x3E, 0x7F, 0xF8, 0xFF, 0xE1, 0xFF, 0x80,
  0x78, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0xF0, 0x00,
  0x07, 0xCF, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x03, 0xE0,
  0xF0, 0x00, 0x7C, 0x0F, 0x00, 0x0F, 0x80, 0xF0, 0x01, 0xF0, 0x0F, 0x00,
  0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x00, 0xF0, 0x0F, 0x00,
  0x0F, 0x01, 0xF0, 0x00, 0xF0, 0x3E, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0xF0,
  0xF8, 0x00, 0x0F, 0x1F, 0x80, 0x00, 0xF3, 0xF8, 0x00, 0x0F, 0x3F, 0xC0,
  0x00, 0xF7, 0xBE, 0x00, 0x0F, 0xF1, 0xF0, 0x00, 0xFE, 0x0F, 0x00, 0x0F,
  0xC0, 0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xF0, 0x01,
  0xE0, 0x0F, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0xF8, 0x0F, 0x00, 0x07, 0xC0,
  0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x1F, 0x0F, 0x00,
  0x00, 0xF8, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x03,
  0xEF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x38, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x0E, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xE3, 0xCF, 0x80, 0xFE, 0x3F, 0x01, 0xFC, 0xF7, 0x80, 0x0F, 0x9F, 0x00,
  0x1F, 0x3F, 0xC0, 0x01, 0xF7, 0x00, 0x03, 0xEF, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x7B, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0xE0, 0x1F,
  0xFC, 0x07, 0x03, 0xFF, 0xF8, 0x38, 0x7F, 0xFF, 0xF1, 0xE7, 0xE0, 0x1F,
  0xCF, 0x78, 0x00, 0x3E, 0x7B, 0x80, 0x00, 0xFB, 0xF8, 0x00, 0x03, 0xDF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0x1E, 0x3E, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x07, 0xCF, 0x00,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x01,
  0xE1, 0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x01,
  0xF0, 0x0F, 0xC0, 0x01, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x1F, 0xFC, 0x01, 0xC0, 0xFF, 0xFE, 0x03, 0x83, 0xFF,
  0xFF, 0x07, 0x9F, 0x80, 0x7F, 0x0F, 0x3C, 0x00, 0x3F, 0x1E, 0xE0, 0x00,
  0x3E, 0x3F, 0x80, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x3C, 0xFC, 0x00, 0x00,
  0x7D, 0xF0, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xF7, 0xC0,
  0x00, 0x01, 0xEF, 0xC0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x0F, 0x3F, 0x80,
  0x00, 0x3E, 0x7F, 0x80, 0x00, 0xF8, 0xF7, 0x80, 0x03, 0xF1, 0xE7, 0xC0,
  0x1F, 0xC3, 0xC7, 0xFF, 0xFF, 0x07, 0x87, 0xFF, 0xF8, 0x0F, 0x03, 0xFF,
  0xC0, 0x1E, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x0E, 0x01, 0xFF, 0xFC, 0x1C,
  0x0F, 0xFF, 0xFC, 0x38, 0x3F, 0x80, 0x7C, 0x70, 0xFC, 0x00, 0x3C, 0xE3,
  0xE0, 0x00, 0x3D, 0xC7, 0x80, 0x00, 0x3F, 0x9F, 0x00, 0x00, 0x3F, 0x3C,
  0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00, 0xFB, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00,
  0xFB, 0xC0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x0F,
  0xCF, 0x80, 0x00, 0x3F, 0x8F, 0x80, 0x00, 0x7F, 0x1F, 0x80, 0x03, 0xDE,
  0x1F, 0xC0, 0x1F, 0x3C, 0x1F, 0xFF, 0xFC, 0x78, 0x0F, 0xFF, 0xF0, 0xF0,
  0x0F, 0xFF, 0x81, 0xE0, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xF1,
  0xFF, 0xFF, 0x3F, 0x83, 0xF3, 0xC0, 0x0F, 0x70, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF8, 0x7E, 0x00, 0x7E, 0x3E, 0x00, 0x03, 0x1F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0xC0,
  0x00, 0x0F, 0xBF, 0x00, 0x0F, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x40, 0x7F, 0xFE,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x07, 0xE0, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xEF, 0x80, 0x00, 0xFF, 0x7E, 0x00, 0x0F, 0x79, 0xF8, 0x01, 0xF3, 0xC7,
  0xFF, 0xFF, 0x0E, 0x1F, 0xFF, 0xF0, 0x70, 0x3F, 0xFE, 0x03, 0x80, 0x3F,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x1F, 0x78, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0x3C, 0x3E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00,
  0x00, 0xF0, 0x07, 0x80, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x07, 0xC0,
  0x01, 0xE0, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0,
  0x03, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x00, 0xF0,
  0x07, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x78,
  0x0E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xF3, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1D, 0xE0, 0x00,
  0x78, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x38, 0x00,
  0x1E, 0x0F, 0x00, 0x07, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x8F, 0x00,
  0x0F, 0x03, 0xC0, 0x03, 0xC3, 0x80, 0x07, 0x81, 0xE0, 0x01, 0xC1, 0xE0,
  0x03, 0x80, 0x78, 0x01, 0xE0, 0xF0, 0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x78,
  0x01, 0xE0, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x0F,
  0x00, 0xF0, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x01, 0xE0, 0x1E, 0x01,
  0xC0, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x0F, 0x00,
  0x78, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x1C, 0x0F, 0x00, 0x0F, 0x07, 0x80,
  0x0F, 0x07, 0x80, 0x03, 0x83, 0xC0, 0x07, 0x83, 0x80, 0x01, 0xE1, 0xE0,
  0x01, 0xC3, 0xC0, 0x00, 0xF0, 0xE0, 0x00, 0xF1, 0xE0, 0x00, 0x78, 0xF0,
  0x00, 0x78, 0xF0, 0x00, 0x1C, 0x78, 0x00, 0x1C, 0x70, 0x00, 0x0F, 0x38,
  0x00, 0x0F, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00,
  0xF8, 0xF0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0xF0, 0x03, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x0F, 0x80, 0x03, 0xC0, 0x3E, 0x00, 0x07, 0xC0, 0x78, 0x00,
  0x07, 0xC1, 0xE0, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x0F, 0xBC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x3C,
  0x3E, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x80,
  0x7C, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0xF8, 0x03, 0xE0, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x01,
  0xF0, 0x78, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0xF0, 0x07, 0x80, 0x00, 0xF0, 0x07, 0x80, 0x01,
  0xE0, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x00, 0xF0, 0x07,
  0x80, 0x00, 0xF0, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x70,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0x00,
  0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x3F,
  0xC0, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0x3F, 0xFE, 0x00,
  0x03, 0x7F, 0xFF, 0x80, 0x07, 0xF8, 0x3F, 0xF0, 0x1F, 0xE0, 0x03, 0xFF,
  0xFE, 0xC0, 0x00, 0xFF, 0xFC, 0x80, 0x00, 0x3F, 0xF0,
};

const GFXglyph NotoSans_Light69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 7, 50, 17, 5, -49 },
  { 45, 15, 18, 25, 5, -49 },
  { 79, 41, 49, 45, 2, -49 },
  { 331, 30, 56, 39, 4, -52 },
  { 541, 48, 51, 56, 4, -50 },
  { 847, 44, 51, 49, 4, -50 },
  { 1128, 4, 18, 14, 5, -49 },
  { 1137, 14, 60, 19, 3, -49 },
  { 1242, 14, 60, 19, 2, -49 },
  { 1347, 30, 29, 38, 4, -52 },
  { 1456, 32, 33, 39, 4, -41 },
  { 1588, 8, 17, 16, 3, -8 },
  { 1605, 16, 3, 22, 3, -20 },
  { 1611, 7, 7, 17, 5, -6 },
  { 1618, 22, 49, 24, 1, -49 },
  { 1753, 32, 51, 39, 4, -50 },
  { 1957, 16, 49, 39, 7, -49 },
  { 2055, 31, 50, 39, 4, -50 },
  { 2249, 32, 51, 39, 3, -50 },
  { 2453, 36, 50, 39, 2, -50 },
  { 2678, 30, 50, 39, 5, -49 },
  { 2866, 32, 51, 39, 4, -50 },
  { 3070, 32, 49, 39, 4, -49 },
  { 3266, 31, 51, 39, 4, -50 },
  { 3464, 31, 51, 39, 4, -50 },
  { 3662, 7, 38, 17, 5, -37 },
  { 3696, 9, 46, 17, 2, -37 },
  { 3748, 32, 32, 39, 4, -41 },
  { 3876, 32, 17, 39, 4, -33 },
  { 3944, 32, 32, 39, 4, -41 },
  { 4072, 25, 51, 29, 2, -50 },
  { 4232, 54, 55, 61, 4, -49 },
  { 4604, 42, 49, 42, 0, -49 },
  { 4862, 33, 49, 44, 7, -49 },
  { 5065, 37, 51, 43, 4, -50 },
  { 5301, 38, 49, 49, 7, -49 },
  { 5534, 27, 49, 38, 7, -49 },
  { 5700, 27, 49, 35, 7, -49 },
  { 5866, 41, 51, 50, 4, -50 },
  { 6128, 36, 49, 50, 7, -49 },
  { 6349, 14, 49, 21, 4, -49 },
  { 6435, 17, 62, 17, -6, -49 },
  { 6567, 34, 49, 41, 7, -49 },
  { 6776, 27, 49, 36, 7, -49 },
  { 6942, 46, 49, 60, 7, -49 },
  { 7224, 36, 49, 50, 7, -49 },
  { 7445, 45, 51, 53, 4, -50 },
  { 7732, 30, 49, 41, 7, -49 },
  { 7916, 45, 62, 53, 4, -50 },
  { 8265, 33, 49, 41, 7, -49 },
  { 8468, 30, 51, 38, 4, -50 },
  { 8660, 36, 49, 37, 0, -49 },
  { 8881, 37, 50, 50, 6, -49 },
  { 9113, 40, 49, 40, 0, -49 },
  { 9358, 59, 49, 62, 2, -49 },
  { 9720, 38, 49, 38, 0, -49 },
  { 9953, 37, 49, 37, 0, -49 },
  { 10180, 34, 49, 40, 3, -49 },
  { 10389, 14, 60, 22, 6, -49 },
  { 10494, 22, 49, 24, 1, -49 },
  { 10629, 14, 60, 22, 2, -49 },
  { 10734, 34, 31, 39, 3, -50 },
  { 10866, 29, 3, 29, 0, 6 },
  { 10877, 13, 11, 18, 3, -53 },
  { 10895, 28, 38, 37, 3, -37 },
  { 11028, 31, 53, 41, 6, -52 },
  { 11234, 27, 38, 33, 4, -37 },
  { 11363, 31, 53, 41, 4, -52 },
  { 11569, 30, 38, 38, 4, -37 },
  { 11712, 24, 53, 21, 1, -53 },
  { 11871, 31, 54, 41, 4, -37 },
  { 12081, 29, 52, 41, 6, -52 },
  { 12270, 6, 50, 16, 5, -50 },
  { 12308, 15, 67, 16, -4, -50 },
  { 12434, 28, 52, 34, 6, -52 },
  { 12616, 4, 52, 16, 6, -52 },
  { 12642, 50, 37, 62, 6, -37 },
  { 12874, 29, 37, 41, 6, -37 },
  { 13009, 33, 38, 41, 4, -37 },
  { 13166, 31, 53, 41, 6, -37 },
  { 13372, 31, 53, 41, 4, -37 },
  { 13578, 20, 37, 27, 6, -37 },
  { 13671, 26, 38, 32, 3, -37 },
  { 13795, 21, 46, 23, 1, -45 },
  { 13916, 29, 38, 41, 6, -37 },
  { 14054, 32, 37, 32, 0, -37 },
  { 14202, 49, 37, 51, 1, -37 },
  { 14429, 31, 37, 35, 2, -37 },
  { 14573, 32, 54, 32, 0, -37 },
  { 14789, 26, 37, 32, 3, -37 },
  { 14910, 20, 60, 25, 2, -49 },
  { 15060, 3, 70, 37, 17, -53 },
  { 15087, 21, 60, 25, 2, -49 },
  { 15245, 32, 7, 39, 4, -28 },
};

const GFXfont NotoSans_Light69pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light69pt7bBitmaps,
  (GFXglyph *)NotoSans_Light69pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _NOTOSANS_LIGHT69PT7B_H_
