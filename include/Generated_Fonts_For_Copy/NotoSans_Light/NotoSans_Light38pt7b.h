#ifndef _NOTOSANS_LIGHT38PT7B_H_
#define _NOTOSANS_LIGHT38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light38pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xA0, 0x00, 0xFF, 0x80,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x00, 0x60,
  0x60, 0x01, 0x80, 0xC0, 0x03, 0x01, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x0C,
  0x00, 0x18, 0x18, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x40, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFC, 0x06, 0x06, 0x00, 0x08, 0x0C, 0x00, 0x30, 0x18, 0x00,
  0x60, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80, 0x02, 0x03, 0x01, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xE0, 0x30, 0x30, 0x00, 0x60, 0x60, 0x00, 0x80,
  0xC0, 0x03, 0x01, 0x80, 0x06, 0x02, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18,
  0x00, 0x30, 0x30, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x01, 0xFF,
  0x81, 0xFF, 0xF1, 0xC4, 0x31, 0x82, 0x00, 0xC1, 0x00, 0xE0, 0x80, 0x70,
  0x40, 0x38, 0x20, 0x0C, 0x10, 0x07, 0x08, 0x01, 0xF4, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x47, 0x00, 0x21, 0xC0, 0x10, 0x70, 0x08,
  0x38, 0x04, 0x0C, 0x02, 0x0E, 0x01, 0x06, 0x00, 0x87, 0x78, 0x4F, 0x3F,
  0xFF, 0x03, 0xFC, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x00, 0x07, 0xF0, 0x01, 0x81, 0xC6, 0x00, 0x60, 0x30, 0x60, 0x0C, 0x06,
  0x0C, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x30, 0x18, 0x18, 0x06, 0x03, 0x06,
  0x00, 0xC0, 0x60, 0xC0, 0x18, 0x0C, 0x30, 0x03, 0x01, 0x86, 0x00, 0x60,
  0x31, 0x87, 0x0C, 0x06, 0x33, 0xF8, 0xC1, 0x8C, 0xE3, 0x18, 0x33, 0x18,
  0x31, 0x8C, 0x66, 0x06, 0x3F, 0x18, 0xC0, 0x60, 0x83, 0x18, 0x0C, 0x00,
  0xC3, 0x01, 0x80, 0x18, 0x60, 0x30, 0x06, 0x0C, 0x06, 0x00, 0xC1, 0x80,
  0xC0, 0x30, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x01, 0x80, 0x60, 0xC0, 0x60,
  0x0C, 0x18, 0x0C, 0x00, 0xEE, 0x03, 0x00, 0x0F, 0x80, 0x00, 0x60, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xC7, 0x80, 0x01, 0x80, 0xC0, 0x01, 0x80, 0x70,
  0x00, 0xC0, 0x18, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x0E, 0x00, 0x1C, 0x06,
  0x00, 0x06, 0x07, 0x00, 0x03, 0x87, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x38, 0xE0, 0x0C, 0x38,
  0x38, 0x06, 0x38, 0x0E, 0x07, 0x18, 0x03, 0x83, 0x1C, 0x00, 0xE3, 0x8E,
  0x00, 0x39, 0x86, 0x00, 0x0F, 0xC3, 0x80, 0x03, 0xC0, 0xC0, 0x01, 0xE0,
  0x70, 0x01, 0xF8, 0x1C, 0x03, 0xCE, 0x07, 0xFF, 0xC3, 0x81, 0xFF, 0x80,
  0xF0, 0xFF, 0xFF, 0xF0, 0x06, 0x18, 0x60, 0xC3, 0x06, 0x1C, 0x30, 0x61,
  0xC3, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x70, 0x60, 0xC1, 0xC1, 0x83, 0x03, 0x07, 0x06, 0x06, 0xE0, 0x70, 0x30,
  0x18, 0x18, 0x0C, 0x0C, 0x0E, 0x06, 0x06, 0x06, 0x07, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x07, 0x07, 0x06, 0x06, 0x06, 0x0E, 0x0C,
  0x0C, 0x18, 0x18, 0x30, 0x70, 0xE0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x04, 0x04, 0x07, 0xC2, 0x1F, 0xFD, 0x7F, 0x0F,
  0xF0, 0x00, 0xE0, 0x00, 0xD8, 0x00, 0xCE, 0x00, 0x63, 0x00, 0x60, 0xC0,
  0x70, 0x70, 0x30, 0x18, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x77, 0x66, 0x6C,
  0xCC, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x38, 0x01, 0x80, 0x0C,
  0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00,
  0x60, 0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03,
  0x00, 0x38, 0x00, 0x00, 0x80, 0x01, 0xFE, 0x01, 0xF3, 0xC0, 0x60, 0x38,
  0x30, 0x07, 0x1C, 0x00, 0xC6, 0x00, 0x39, 0x80, 0x06, 0x60, 0x01, 0xB8,
  0x00, 0x6C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xB0, 0x00, 0x6E, 0x00, 0x1B, 0x80, 0x06,
  0x60, 0x01, 0x98, 0x00, 0x66, 0x00, 0x30, 0xC0, 0x0C, 0x38, 0x07, 0x07,
  0x03, 0x80, 0xFF, 0xC0, 0x1F, 0xE0, 0x03, 0x83, 0xC3, 0x67, 0x37, 0x1F,
  0x0E, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x00, 0x80, 0x07, 0xFC, 0x0F, 0x9F, 0x0E, 0x01, 0xC4, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x80, 0x0F, 0xFC, 0x1F, 0x8F, 0x1C, 0x01, 0xC4, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x01, 0xC0, 0x03, 0xC0, 0x7F, 0x80, 0x3F, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x60, 0x07, 0x3F, 0xFF, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1B, 0x00, 0x01, 0xB0, 0x00,
  0x33, 0x00, 0x06, 0x30, 0x00, 0xE3, 0x00, 0x0C, 0x30, 0x01, 0x83, 0x00,
  0x38, 0x30, 0x03, 0x03, 0x00, 0x60, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x30,
  0x18, 0x03, 0x03, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x30, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x7F, 0xFE, 0x7F,
  0xFE, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xFF, 0xF0, 0x7D, 0xFC, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x80, 0x1C, 0xFF,
  0xF8, 0x7F, 0xE0, 0x00, 0x0C, 0x00, 0x7F, 0xC0, 0x7C, 0x10, 0x38, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x87, 0xC0, 0x67, 0xFE, 0x3B, 0x83, 0xCF, 0x80,
  0x33, 0xC0, 0x06, 0xE0, 0x01, 0xB8, 0x00, 0x7E, 0x00, 0x0D, 0x80, 0x03,
  0x60, 0x01, 0xD8, 0x00, 0x76, 0x00, 0x18, 0xC0, 0x06, 0x38, 0x03, 0x87,
  0x01, 0xC0, 0xFF, 0xE0, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x03, 0xFE, 0x01,
  0xE3, 0xE0, 0xE0, 0x1C, 0x70, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x39, 0x80,
  0x0E, 0x60, 0x03, 0x0C, 0x00, 0xC3, 0x80, 0x60, 0x70, 0x70, 0x0F, 0x78,
  0x00, 0xF8, 0x00, 0x7F, 0x80, 0x70, 0x78, 0x38, 0x07, 0x1C, 0x00, 0xC6,
  0x00, 0x1B, 0x80, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x7C, 0x00, 0x1B, 0x80,
  0x06, 0x60, 0x03, 0x8E, 0x01, 0xC1, 0xF7, 0xE0, 0x3F, 0xE0, 0x00, 0x80,
  0x07, 0xFC, 0x07, 0xCF, 0x07, 0x01, 0xC7, 0x00, 0x73, 0x00, 0x1B, 0x80,
  0x0D, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x3B, 0x00, 0x1D, 0xC0, 0x1E, 0x78, 0x3B, 0x1F, 0xF9, 0x81, 0xE0,
  0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x1C, 0x0E, 0xFC, 0x07, 0xF8, 0x00, 0x5F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x11, 0xCE, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xCC, 0x63, 0x39, 0x8C, 0x66, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x80, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x30, 0x00, 0x00, 0x02, 0x01, 0xFF, 0x8F, 0xDF, 0x10,
  0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0x80, 0x0C, 0x00, 0x70, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x01, 0x81, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x40,
  0x06, 0x30, 0x0F, 0xF8, 0x19, 0x80, 0xF0, 0x60, 0x66, 0x07, 0x01, 0x80,
  0x98, 0x18, 0x06, 0x03, 0xC0, 0xE0, 0x18, 0x0F, 0x03, 0x00, 0x60, 0x3C,
  0x0C, 0x01, 0x80, 0xF0, 0x30, 0x06, 0x03, 0xC0, 0xC0, 0x18, 0x0B, 0x03,
  0x00, 0x60, 0x6C, 0x0C, 0x03, 0x81, 0xB0, 0x38, 0x0E, 0x0C, 0x40, 0x60,
  0x6C, 0x31, 0x80, 0xFF, 0x3F, 0x86, 0x00, 0xF0, 0x3C, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x01, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x31, 0x80,
  0x00, 0x63, 0x80, 0x01, 0x83, 0x00, 0x03, 0x06, 0x00, 0x0E, 0x06, 0x00,
  0x18, 0x0C, 0x00, 0x30, 0x1C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x07,
  0x00, 0x70, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x70, 0x01, 0xC0, 0xC0,
  0x01, 0x81, 0x80, 0x03, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x38, 0x00,
  0x0E, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x18, 0xFF, 0xF0,
  0x3F, 0xFF, 0x8C, 0x00, 0xF3, 0x00, 0x0E, 0xC0, 0x03, 0xB0, 0x00, 0x6C,
  0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0xCC, 0x00, 0x73, 0x00,
  0x78, 0xFF, 0xF8, 0x3F, 0xFF, 0x0C, 0x00, 0x73, 0x00, 0x0E, 0xC0, 0x01,
  0xB0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1B, 0x00, 0x0E, 0xC0, 0x0F, 0x3F, 0xFF, 0x8F, 0xFF, 0x00, 0x00,
  0x04, 0x00, 0x07, 0xFF, 0x40, 0xFE, 0xFC, 0x0F, 0x00, 0x20, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x80, 0xFF, 0xFC, 0x01, 0xFF,
  0xC0, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x30, 0x03, 0xC1, 0x80, 0x07, 0x0C,
  0x00, 0x1C, 0x60, 0x00, 0x73, 0x00, 0x01, 0x98, 0x00, 0x0E, 0xC0, 0x00,
  0x36, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x36, 0x00, 0x01,
  0xB0, 0x00, 0x0D, 0x80, 0x00, 0xEC, 0x00, 0x06, 0x60, 0x00, 0x73, 0x00,
  0x07, 0x18, 0x00, 0xF0, 0xC0, 0x1F, 0x07, 0xFF, 0xE0, 0x3F, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0F, 0xFF,
  0xDF, 0xFF, 0xB0, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x1F, 0xFF, 0xBF, 0xFF, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x01, 0xFF, 0xF0,
  0x0F, 0xE7, 0xF0, 0x3C, 0x00, 0x60, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x0E, 0xC0, 0x00, 0x1D, 0x80, 0x00,
  0x3B, 0x00, 0x00, 0x77, 0x00, 0x00, 0xE6, 0x00, 0x01, 0xCE, 0x00, 0x03,
  0x8E, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x0F, 0x00, 0x1C, 0x0F, 0xFF, 0xF8,
  0x07, 0xFF, 0x80, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x70, 0xFF,
  0x3C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x7E, 0xFF, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x1C,
  0x0D, 0x1E, 0xFE, 0x7C, 0x00, 0xC0, 0x01, 0xF0, 0x00, 0xEC, 0x00, 0x73,
  0x00, 0x38, 0xC0, 0x1C, 0x30, 0x0E, 0x0C, 0x07, 0x03, 0x03, 0x80, 0xC1,
  0xC0, 0x30, 0xE0, 0x0C, 0x70, 0x03, 0x38, 0x00, 0xDF, 0x00, 0x3E, 0xE0,
  0x0F, 0x18, 0x03, 0x87, 0x00, 0xC0, 0xE0, 0x30, 0x18, 0x0C, 0x07, 0x03,
  0x00, 0xE0, 0xC0, 0x1C, 0x30, 0x03, 0x0C, 0x00, 0xE3, 0x00, 0x1C, 0xC0,
  0x03, 0xB0, 0x00, 0x6C, 0x00, 0x1C, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFD, 0x80, 0x00,
  0xDE, 0xC0, 0x00, 0x6F, 0x30, 0x00, 0x67, 0x98, 0x00, 0x33, 0xCE, 0x00,
  0x19, 0xE3, 0x00, 0x18, 0xF1, 0x80, 0x0C, 0x78, 0xE0, 0x0E, 0x3C, 0x30,
  0x06, 0x1E, 0x1C, 0x03, 0x0F, 0x06, 0x03, 0x07, 0x83, 0x01, 0x83, 0xC1,
  0xC1, 0xC1, 0xE0, 0x60, 0xC0, 0xF0, 0x30, 0x60, 0x78, 0x0C, 0x60, 0x3C,
  0x06, 0x30, 0x1E, 0x03, 0xB8, 0x0F, 0x00, 0xD8, 0x07, 0x80, 0x6C, 0x03,
  0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x60, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xD8, 0x00, 0x3D, 0xC0,
  0x03, 0xCE, 0x00, 0x3C, 0x60, 0x03, 0xC7, 0x00, 0x3C, 0x38, 0x03, 0xC1,
  0x80, 0x3C, 0x1C, 0x03, 0xC0, 0xE0, 0x3C, 0x06, 0x03, 0xC0, 0x70, 0x3C,
  0x03, 0x83, 0xC0, 0x18, 0x3C, 0x01, 0xC3, 0xC0, 0x0E, 0x3C, 0x00, 0x63,
  0xC0, 0x07, 0x3C, 0x00, 0x3B, 0xC0, 0x01, 0xBC, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x70, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xE0,
  0x01, 0xFC, 0xFC, 0x01, 0xE0, 0x0F, 0x01, 0xC0, 0x01, 0xC0, 0xC0, 0x00,
  0x70, 0xE0, 0x00, 0x18, 0x60, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x30, 0x00,
  0x01, 0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xB0,
  0x00, 0x01, 0xD8, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x67, 0x00, 0x00, 0x71,
  0x80, 0x00, 0x30, 0xE0, 0x00, 0x38, 0x30, 0x00, 0x18, 0x1C, 0x00, 0x1C,
  0x07, 0x80, 0x3C, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0,
  0xFF, 0xFC, 0xC0, 0x1E, 0xC0, 0x0E, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x06, 0xC0, 0x0E,
  0xC0, 0x3C, 0xFF, 0xF8, 0xFF, 0xC0, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFC,
  0xFC, 0x01, 0xE0, 0x0F, 0x01, 0xC0, 0x01, 0xC0, 0xC0, 0x00, 0x70, 0xE0,
  0x00, 0x18, 0x60, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x30, 0x00, 0x01, 0x98,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xB0, 0x00, 0x01,
  0xD8, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x67, 0x00, 0x00, 0x71, 0x80, 0x00,
  0x38, 0xE0, 0x00, 0x38, 0x30, 0x00, 0x18, 0x1C, 0x00, 0x1C, 0x07, 0x80,
  0x3C, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1E, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x0C, 0x01, 0xE3, 0x00, 0x1C,
  0xC0, 0x07, 0x30, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x03, 0x30,
  0x00, 0xCC, 0x00, 0x73, 0x00, 0x18, 0xC0, 0x1C, 0x3F, 0xFE, 0x0F, 0xFE,
  0x03, 0x01, 0x80, 0xC0, 0x70, 0x30, 0x0C, 0x0C, 0x03, 0x83, 0x00, 0x60,
  0xC0, 0x0C, 0x30, 0x03, 0x8C, 0x00, 0x63, 0x00, 0x1C, 0xC0, 0x03, 0x30,
  0x00, 0xEC, 0x00, 0x1C, 0x00, 0xC0, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0x00,
  0x27, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x60, 0x07, 0x3F,
  0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x06, 0x60, 0x00, 0xE7, 0x00, 0x1C,
  0x38, 0x03, 0x81, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0xE0, 0x00, 0x0D, 0x80,
  0x00, 0x76, 0x00, 0x01, 0x9C, 0x00, 0x0E, 0x30, 0x00, 0x30, 0xC0, 0x00,
  0xC3, 0x80, 0x07, 0x06, 0x00, 0x18, 0x18, 0x00, 0x60, 0x30, 0x03, 0x80,
  0xC0, 0x0C, 0x03, 0x80, 0x30, 0x06, 0x01, 0x80, 0x18, 0x06, 0x00, 0x70,
  0x38, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x0E, 0x1C, 0x00, 0x18, 0x60,
  0x00, 0x71, 0x80, 0x00, 0xCE, 0x00, 0x03, 0x30, 0x00, 0x0E, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0x60, 0x03, 0xC0, 0x07, 0x60,
  0x03, 0xC0, 0x06, 0x60, 0x03, 0xC0, 0x06, 0x70, 0x06, 0x60, 0x06, 0x30,
  0x06, 0x60, 0x0E, 0x30, 0x06, 0x60, 0x0C, 0x30, 0x0E, 0x30, 0x0C, 0x38,
  0x0C, 0x30, 0x1C, 0x18, 0x0C, 0x30, 0x18, 0x18, 0x0C, 0x30, 0x18, 0x1C,
  0x18, 0x18, 0x18, 0x0C, 0x18, 0x18, 0x38, 0x0C, 0x18, 0x18, 0x30, 0x0C,
  0x38, 0x0C, 0x30, 0x0E, 0x30, 0x0C, 0x30, 0x06, 0x30, 0x0C, 0x70, 0x06,
  0x30, 0x0E, 0x60, 0x06, 0x60, 0x06, 0x60, 0x07, 0x60, 0x06, 0x60, 0x03,
  0x60, 0x06, 0xC0, 0x03, 0x60, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x70,
  0x00, 0x71, 0x80, 0x03, 0x0E, 0x00, 0x30, 0x38, 0x03, 0x80, 0xC0, 0x18,
  0x07, 0x01, 0xC0, 0x18, 0x0C, 0x00, 0x60, 0xC0, 0x03, 0x8E, 0x00, 0x0C,
  0x60, 0x00, 0x36, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x03, 0xE0, 0x00, 0x3B, 0x00, 0x01, 0x8C, 0x00, 0x18, 0x70, 0x00, 0xC1,
  0x80, 0x0C, 0x06, 0x00, 0xE0, 0x38, 0x06, 0x00, 0xC0, 0x60, 0x07, 0x07,
  0x00, 0x1C, 0x30, 0x00, 0x63, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00,
  0x36, 0x00, 0x07, 0x70, 0x00, 0x63, 0x00, 0x0C, 0x18, 0x01, 0xC1, 0x80,
  0x18, 0x0C, 0x03, 0x80, 0xE0, 0x30, 0x06, 0x07, 0x00, 0x70, 0x60, 0x03,
  0x0E, 0x00, 0x38, 0xC0, 0x01, 0x9C, 0x00, 0x1D, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xE0, 0x03, 0x00, 0x1C,
  0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60,
  0x03, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x80,
  0x0C, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x30, 0x01, 0x80, 0x0E, 0xFF, 0xFF, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0xFF,
  0xFF, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x0C, 0x80, 0x03, 0x30,
  0x01, 0x84, 0x00, 0x61, 0x80, 0x30, 0x20, 0x0C, 0x0C, 0x06, 0x01, 0x81,
  0x80, 0x60, 0xC0, 0x0C, 0x30, 0x03, 0x18, 0x00, 0x66, 0x00, 0x1B, 0x00,
  0x03, 0xC0, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC1, 0xC1, 0xC1,
  0xC1, 0xC0, 0x00, 0x80, 0x3F, 0xF0, 0xF8, 0xF1, 0x00, 0x70, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x01, 0xFC, 0x7F, 0xF9, 0xE0,
  0x37, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F,
  0x80, 0xDB, 0xEF, 0xB3, 0xFC, 0x20, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x40, 0x31, 0xFF, 0x0C, 0xE1, 0xE3, 0x60, 0x1C, 0xF0, 0x03, 0x38,
  0x00, 0xEE, 0x00, 0x1B, 0x80, 0x06, 0xE0, 0x01, 0xB8, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x6E, 0x00, 0x1B, 0x80, 0x06,
  0xE0, 0x03, 0xBC, 0x01, 0xCD, 0x80, 0xE3, 0x3F, 0xF0, 0xC7, 0xF8, 0x00,
  0x00, 0x70, 0x0F, 0xFC, 0x3C, 0x78, 0xE0, 0x03, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xF0, 0x08,
  0xFF, 0xF0, 0x7F, 0xC0, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x01, 0xC1, 0x87,
  0xFC, 0xC7, 0x87, 0x67, 0x00, 0xF3, 0x00, 0x3B, 0x80, 0x1D, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x03, 0xB8, 0x01, 0xCE,
  0x01, 0xE3, 0xFF, 0x90, 0x7F, 0x08, 0x00, 0xC0, 0x03, 0xFC, 0x07, 0xC7,
  0x07, 0x00, 0xC3, 0x00, 0x73, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x07, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0F, 0x00, 0x41, 0xFF,
  0xE0, 0x7F, 0xE0, 0x01, 0xFC, 0x0F, 0xF0, 0x70, 0x01, 0x80, 0x0E, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x03, 0xFF, 0x8F, 0xFE, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x07, 0xFC, 0x47, 0x87,
  0x67, 0x00, 0xF3, 0x00, 0x3B, 0x80, 0x0D, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x06, 0xC0, 0x03, 0x60, 0x03, 0x98, 0x01, 0xCE, 0x01, 0xE3, 0xFF,
  0xB0, 0x7F, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xCE, 0x01, 0xE7, 0xFF, 0xE0, 0x7F, 0xC0, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0xC0, 0x73, 0xFE, 0x33, 0x87, 0x9B, 0x00, 0xEF,
  0x00, 0x37, 0x00, 0x1B, 0x80, 0x0D, 0xC0, 0x06, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x38,
  0x5F, 0xA0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x02,
  0x07, 0x07, 0x02, 0x00, 0x00, 0x00, 0x00, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x06, 0x06, 0x0E, 0xFC, 0xF8,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x0E, 0xC0, 0x18, 0xC0, 0x38,
  0xC0, 0x70, 0xC0, 0xE0, 0xC1, 0xC0, 0xC3, 0x80, 0xC7, 0x00, 0xCE, 0x00,
  0xCF, 0x00, 0xDB, 0x80, 0xF1, 0x80, 0xE0, 0xC0, 0xC0, 0xE0, 0xC0, 0x70,
  0xC0, 0x30, 0xC0, 0x38, 0xC0, 0x1C, 0xC0, 0x0E, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xC0, 0x04,
  0x0C, 0x7F, 0x87, 0xF8, 0xCE, 0x3C, 0xF1, 0xED, 0x80, 0xD8, 0x0E, 0xF0,
  0x0F, 0x00, 0x6E, 0x00, 0x70, 0x07, 0xE0, 0x06, 0x00, 0x3E, 0x00, 0x60,
  0x03, 0xE0, 0x06, 0x00, 0x3E, 0x00, 0x60, 0x03, 0xE0, 0x06, 0x00, 0x3E,
  0x00, 0x60, 0x03, 0xE0, 0x06, 0x00, 0x3E, 0x00, 0x60, 0x03, 0xE0, 0x06,
  0x00, 0x3E, 0x00, 0x60, 0x03, 0xE0, 0x06, 0x00, 0x3E, 0x00, 0x60, 0x03,
  0xE0, 0x06, 0x00, 0x3E, 0x00, 0x60, 0x03, 0xE0, 0x06, 0x00, 0x30, 0x00,
  0xC0, 0x63, 0xFE, 0x33, 0xC7, 0x9B, 0x00, 0xEF, 0x00, 0x37, 0x00, 0x1B,
  0x80, 0x0D, 0xC0, 0x06, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x38, 0x00, 0x40, 0x01, 0xFF,
  0x01, 0xE1, 0xE0, 0xE0, 0x1C, 0x30, 0x03, 0x9C, 0x00, 0x66, 0x00, 0x1F,
  0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x07, 0x70, 0x01, 0x8C, 0x00,
  0xE1, 0xC0, 0x70, 0x3F, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0xE0, 0x31, 0xFF,
  0x0C, 0xE1, 0xE3, 0x60, 0x1C, 0xD0, 0x03, 0x38, 0x00, 0xEE, 0x00, 0x1B,
  0x80, 0x06, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x6E, 0x00, 0x1B, 0x80, 0x06, 0xF0, 0x03, 0xBC, 0x01,
  0xCD, 0x80, 0xF3, 0x3F, 0xF8, 0xC7, 0xF8, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x80, 0x07, 0xFC, 0x47, 0x87, 0x67, 0x00,
  0xF7, 0x00, 0x3B, 0x00, 0x1D, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x06,
  0xC0, 0x03, 0x60, 0x03, 0xB8, 0x01, 0xCE, 0x01, 0xE3, 0xEF, 0xB0, 0xFF,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0xD8, 0xFF, 0x3C,
  0xEC, 0x0D, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x00, 0x03, 0x00, 0xFF, 0xF7, 0x87, 0xB8, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x01, 0xBF, 0x7C,
  0x7F, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x0F, 0xFF, 0xFF,
  0xF1, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x0E,
  0x00, 0x7F, 0x07, 0xF0, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x07,
  0x60, 0x0F, 0x70, 0x1B, 0x3E, 0xFB, 0x1F, 0xE3, 0xE0, 0x01, 0xD8, 0x00,
  0x66, 0x00, 0x19, 0xC0, 0x0C, 0x30, 0x03, 0x0C, 0x01, 0xC1, 0x80, 0x60,
  0x60, 0x18, 0x1C, 0x0C, 0x03, 0x03, 0x00, 0xC0, 0xC0, 0x38, 0x60, 0x06,
  0x18, 0x01, 0x8E, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x03, 0x60, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x03, 0x00, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3E,
  0x01, 0xE0, 0x0D, 0x80, 0x78, 0x06, 0x60, 0x1B, 0x01, 0x98, 0x0C, 0xC0,
  0x67, 0x03, 0x30, 0x38, 0xC0, 0xC6, 0x0C, 0x30, 0x61, 0x83, 0x0C, 0x18,
  0x60, 0xC1, 0x86, 0x0C, 0x70, 0x63, 0x03, 0x18, 0x18, 0xC0, 0xC6, 0x07,
  0x30, 0x19, 0x80, 0xD8, 0x06, 0xC0, 0x36, 0x01, 0xB0, 0x0D, 0x80, 0x6C,
  0x01, 0xC0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0xE0, 0x03,
  0xB8, 0x03, 0x8E, 0x03, 0x83, 0x01, 0x80, 0xC1, 0x80, 0x71, 0xC0, 0x18,
  0xC0, 0x06, 0xC0, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x6C, 0x00,
  0x73, 0x00, 0x71, 0xC0, 0x30, 0x60, 0x30, 0x18, 0x38, 0x0E, 0x18, 0x03,
  0x18, 0x00, 0xDC, 0x00, 0x70, 0xE0, 0x01, 0xD8, 0x00, 0x66, 0x00, 0x19,
  0xC0, 0x0C, 0x30, 0x03, 0x0E, 0x01, 0xC1, 0x80, 0x60, 0x60, 0x18, 0x1C,
  0x0E, 0x03, 0x03, 0x00, 0xC0, 0xC0, 0x18, 0x60, 0x06, 0x18, 0x01, 0xCE,
  0x00, 0x33, 0x00, 0x0C, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00,
  0x70, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xE0,
  0x7C, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x07, 0xC0, 0xE0, 0x0F, 0x00, 0x30,
  0x06, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0x60, 0x0C, 0x01, 0xC0, 0x1F, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0F, 0xC0, 0x0C, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x03, 0x00, 0x3F, 0x00, 0x70, 0x3E, 0x03, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0xE0, 0x1C, 0x0F, 0x80, 0xF0, 0x00, 0x08, 0x00, 0x1F, 0xE0,
  0x1E, 0x3E, 0x1E, 0x01, 0xFE, 0x00, 0x0E, 0x00,
};

const GFXglyph NotoSans_Light38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 3, 27, 9, 3, -27 },
  { 12, 8, 10, 14, 3, -27 },
  { 22, 23, 27, 25, 1, -27 },
  { 100, 17, 31, 22, 2, -29 },
  { 166, 27, 28, 31, 2, -28 },
  { 261, 25, 28, 27, 2, -28 },
  { 349, 2, 10, 8, 3, -27 },
  { 352, 7, 33, 11, 2, -27 },
  { 381, 8, 33, 11, 1, -27 },
  { 414, 17, 16, 21, 2, -29 },
  { 448, 18, 18, 22, 2, -22 },
  { 489, 4, 9, 9, 2, -4 },
  { 494, 9, 2, 12, 2, -11 },
  { 497, 3, 3, 9, 3, -3 },
  { 499, 13, 27, 13, 0, -27 },
  { 543, 18, 28, 22, 2, -28 },
  { 606, 9, 27, 22, 4, -27 },
  { 637, 17, 28, 22, 2, -28 },
  { 697, 17, 28, 22, 2, -28 },
  { 757, 20, 27, 22, 1, -27 },
  { 825, 16, 27, 22, 3, -27 },
  { 879, 18, 28, 22, 2, -28 },
  { 942, 18, 27, 22, 2, -27 },
  { 1003, 18, 28, 22, 2, -28 },
  { 1066, 17, 28, 22, 2, -28 },
  { 1126, 3, 21, 9, 3, -21 },
  { 1134, 5, 26, 9, 1, -21 },
  { 1151, 18, 18, 22, 2, -23 },
  { 1192, 18, 9, 22, 2, -18 },
  { 1213, 18, 18, 22, 2, -23 },
  { 1254, 14, 28, 16, 1, -28 },
  { 1303, 30, 31, 34, 2, -27 },
  { 1420, 23, 27, 23, 0, -27 },
  { 1498, 18, 27, 24, 4, -27 },
  { 1559, 21, 28, 24, 2, -28 },
  { 1633, 21, 27, 27, 4, -27 },
  { 1704, 15, 27, 21, 4, -27 },
  { 1755, 15, 27, 19, 4, -27 },
  { 1806, 23, 28, 28, 2, -28 },
  { 1887, 20, 27, 28, 4, -27 },
  { 1955, 8, 27, 12, 2, -27 },
  { 1982, 9, 34, 10, -3, -27 },
  { 2021, 18, 27, 22, 4, -27 },
  { 2082, 15, 27, 20, 4, -27 },
  { 2133, 25, 27, 33, 4, -27 },
  { 2218, 20, 27, 28, 4, -27 },
  { 2286, 25, 28, 29, 2, -28 },
  { 2374, 16, 27, 22, 4, -27 },
  { 2428, 25, 34, 29, 2, -28 },
  { 2535, 18, 27, 23, 4, -27 },
  { 2596, 17, 28, 21, 2, -28 },
  { 2656, 20, 27, 20, 0, -27 },
  { 2724, 20, 27, 27, 4, -27 },
  { 2792, 22, 27, 22, 0, -27 },
  { 2867, 32, 27, 34, 1, -27 },
  { 2975, 21, 27, 21, 0, -27 },
  { 3046, 20, 27, 20, 0, -27 },
  { 3114, 19, 27, 22, 1, -27 },
  { 3179, 8, 33, 12, 3, -27 },
  { 3212, 13, 27, 13, 0, -27 },
  { 3256, 8, 33, 12, 1, -27 },
  { 3289, 18, 17, 22, 2, -27 },
  { 3328, 16, 2, 16, 0, 3 },
  { 3332, 7, 6, 10, 2, -29 },
  { 3338, 15, 21, 20, 2, -21 },
  { 3378, 18, 29, 23, 3, -29 },
  { 3444, 15, 21, 18, 2, -21 },
  { 3484, 17, 29, 23, 2, -29 },
  { 3546, 17, 21, 21, 2, -21 },
  { 3591, 14, 29, 12, 0, -29 },
  { 3642, 17, 30, 23, 2, -21 },
  { 3706, 17, 29, 23, 3, -29 },
  { 3768, 3, 28, 9, 3, -28 },
  { 3779, 8, 37, 9, -2, -28 },
  { 3816, 16, 29, 19, 3, -29 },
  { 3874, 3, 29, 9, 3, -29 },
  { 3885, 28, 21, 34, 3, -21 },
  { 3959, 17, 21, 23, 3, -21 },
  { 4004, 18, 21, 22, 2, -21 },
  { 4052, 18, 30, 23, 3, -21 },
  { 4120, 17, 30, 23, 2, -21 },
  { 4184, 11, 21, 15, 3, -21 },
  { 4213, 14, 21, 18, 2, -21 },
  { 4250, 12, 25, 13, 0, -25 },
  { 4288, 16, 20, 23, 3, -20 },
  { 4328, 18, 20, 18, 0, -20 },
  { 4373, 26, 20, 28, 1, -20 },
  { 4438, 17, 20, 19, 1, -20 },
  { 4481, 18, 29, 18, 0, -20 },
  { 4547, 14, 20, 18, 2, -20 },
  { 4582, 11, 33, 14, 1, -27 },
  { 4628, 2, 38, 21, 9, -29 },
  { 4638, 12, 33, 14, 1, -27 },
  { 4688, 18, 5, 22, 2, -16 },
};

const GFXfont NotoSans_Light38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light38pt7bBitmaps,
  (GFXglyph *)NotoSans_Light38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_LIGHT38PT7B_H_
