#ifndef _NOTOSANS_LIGHT30PT7B_H_
#define _NOTOSANS_LIGHT30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light30pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x69, 0x24, 0x90, 0x01, 0x7E, 0xC7, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0x80, 0x01, 0x06, 0x00, 0xC1, 0x00, 0x30, 0x40, 0x08,
  0x10, 0x02, 0x0C, 0x00, 0x83, 0x07, 0xFF, 0xFD, 0xFF, 0xFF, 0x04, 0x08,
  0x01, 0x06, 0x00, 0x41, 0x80, 0x30, 0x40, 0x0C, 0x10, 0x3F, 0xFF, 0xC0,
  0x83, 0x00, 0x20, 0xC0, 0x18, 0x20, 0x06, 0x08, 0x01, 0x82, 0x00, 0x41,
  0x80, 0x10, 0x60, 0x00, 0x02, 0x00, 0x10, 0x03, 0xC0, 0x7F, 0xE6, 0x23,
  0x61, 0x03, 0x08, 0x18, 0x40, 0xC2, 0x07, 0x10, 0x1C, 0x80, 0x7C, 0x00,
  0x78, 0x01, 0x70, 0x08, 0xC0, 0x43, 0x02, 0x18, 0x10, 0xC0, 0x87, 0x04,
  0x6F, 0xBE, 0x3F, 0xE0, 0x08, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x83,
  0xF0, 0x08, 0x30, 0x80, 0xC1, 0x86, 0x04, 0x08, 0x30, 0x60, 0x40, 0x82,
  0x02, 0x04, 0x30, 0x10, 0x23, 0x00, 0x81, 0x18, 0x04, 0x19, 0x9F, 0x30,
  0xC9, 0x8D, 0x84, 0xC8, 0x27, 0xE4, 0xC1, 0x1C, 0x66, 0x0C, 0x02, 0x30,
  0x60, 0x31, 0x83, 0x03, 0x0C, 0x18, 0x18, 0x60, 0xC1, 0x83, 0x04, 0x08,
  0x08, 0x20, 0xC0, 0x63, 0x0C, 0x01, 0xF0, 0x07, 0x80, 0x03, 0xFC, 0x00,
  0xE1, 0xC0, 0x18, 0x18, 0x03, 0x03, 0x00, 0x60, 0x60, 0x0C, 0x0C, 0x00,
  0xC3, 0x00, 0x18, 0xC0, 0x01, 0xF0, 0x00, 0x38, 0x00, 0x0D, 0x80, 0x07,
  0x18, 0x0D, 0xC1, 0x81, 0xB0, 0x18, 0x66, 0x01, 0xCC, 0xC0, 0x1F, 0x18,
  0x01, 0xC3, 0x00, 0x38, 0x70, 0x0F, 0x87, 0x87, 0x18, 0x3F, 0x81, 0xC0,
  0xFF, 0xFC, 0x0C, 0x61, 0x0C, 0x31, 0x86, 0x18, 0x43, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0x41, 0x06, 0x18, 0x20, 0xC3, 0x06, 0x08, 0x30, 0xC1, 0x83,
  0x0C, 0x18, 0x60, 0x83, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0x86, 0x18, 0x43, 0x08, 0x63, 0x00, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x08, 0x20, 0xF9, 0x3D, 0xFF, 0x80, 0xC0, 0x0D, 0x00, 0x4C, 0x06, 0x30,
  0x61, 0xC3, 0x04, 0x00, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x3F, 0xFF, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x36, 0x66, 0x44, 0xC0, 0xFF, 0xFC, 0x5F,
  0x80, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x18, 0x06,
  0x01, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x08, 0x06,
  0x01, 0x80, 0xC0, 0x00, 0x07, 0x00, 0xFE, 0x0C, 0x18, 0xC0, 0x64, 0x01,
  0x60, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1A, 0x00, 0xD8, 0x0C, 0xC0,
  0x63, 0x8E, 0x0F, 0xE0, 0x0E, 0x3C, 0xDF, 0x3C, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x0F,
  0x01, 0xFE, 0x38, 0x18, 0x80, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x00, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x01,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07,
  0x80, 0xFF, 0xC7, 0x03, 0x90, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x06, 0x00, 0x18, 0x01, 0xC0, 0xFC, 0x03, 0xF8, 0x00, 0x38, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x06, 0xF0, 0x71,
  0xFF, 0x80, 0x00, 0x30, 0x00, 0x30, 0x00, 0x50, 0x00, 0xF0, 0x01, 0xB0,
  0x01, 0x30, 0x03, 0x30, 0x06, 0x30, 0x04, 0x30, 0x0C, 0x30, 0x18, 0x30,
  0x30, 0x30, 0x20, 0x30, 0x60, 0x30, 0xC0, 0x30, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x7F, 0xF3,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x7F,
  0x83, 0xFF, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x03,
  0x00, 0x18, 0x00, 0xE0, 0x0D, 0xC1, 0xC7, 0xFC, 0x00, 0x01, 0xF0, 0x3F,
  0xC1, 0xC0, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x3F, 0x8D, 0x87, 0x38, 0x06, 0xC0, 0x1B, 0x00, 0x2C, 0x00, 0xF0,
  0x03, 0xC0, 0x09, 0x00, 0x26, 0x01, 0x8C, 0x0C, 0x38, 0x70, 0x3F, 0x00,
  0xFF, 0xFC, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x06,
  0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C,
  0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0x07, 0x81, 0xFF, 0x1C, 0x0C, 0xC0, 0x2C, 0x01, 0xE0, 0x0D, 0x00,
  0x6C, 0x06, 0x30, 0x60, 0xE6, 0x03, 0xC0, 0x3B, 0x83, 0x07, 0x30, 0x1B,
  0x00, 0x78, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x07, 0xC0, 0x77, 0x07, 0x0F,
  0xE0, 0x0F, 0x01, 0xFE, 0x18, 0x19, 0x80, 0x6C, 0x01, 0x40, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x06, 0xC0, 0xD3, 0xFD, 0x8F, 0x8C,
  0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x18, 0x01, 0xC4, 0x3C, 0x3F,
  0x80, 0xFD, 0x00, 0x00, 0x00, 0x00, 0xBF, 0x77, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x16, 0x66, 0x64, 0xCC, 0x00, 0x04, 0x00, 0x70, 0x07, 0x00, 0xF0,
  0x0F, 0x00, 0xE0, 0x0E, 0x00, 0x30, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x70, 0x07, 0x00,
  0xF0, 0x0F, 0x00, 0xE0, 0x02, 0x00, 0x00, 0x1E, 0x1F, 0xF2, 0x03, 0x00,
  0x20, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x04, 0x01, 0x80,
  0x30, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0x03, 0xC0, 0x30, 0x00, 0xC0, 0xC0,
  0x00, 0xC3, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x90, 0x1F, 0xC1, 0x60, 0xE0,
  0x83, 0xC1, 0x81, 0x07, 0x06, 0x02, 0x06, 0x0C, 0x04, 0x0C, 0x10, 0x08,
  0x38, 0x20, 0x30, 0x70, 0x40, 0x60, 0xE0, 0xC0, 0xC1, 0x41, 0x83, 0x86,
  0xC1, 0xFD, 0xF9, 0x80, 0xE0, 0xC1, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x80, 0x10, 0x01, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x06, 0x80, 0x01, 0xB0, 0x00, 0xCC,
  0x00, 0x31, 0x00, 0x08, 0x60, 0x06, 0x18, 0x01, 0x82, 0x00, 0x40, 0xC0,
  0x30, 0x30, 0x08, 0x06, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x40, 0x0C, 0x30,
  0x03, 0x0C, 0x00, 0x66, 0x00, 0x19, 0x80, 0x06, 0x40, 0x00, 0xF0, 0x00,
  0x30, 0xFF, 0xE3, 0x01, 0xEC, 0x01, 0xB0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xB0, 0x06, 0xC0, 0x33, 0xFF, 0x0F, 0xFF, 0x30, 0x06, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xBF, 0xFC,
  0xFF, 0xC0, 0x00, 0xF0, 0x07, 0xFF, 0x1E, 0x02, 0x38, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0F, 0x06, 0x07, 0xFE, 0xFF, 0xE0,
  0xC0, 0x78, 0xC0, 0x1C, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x06, 0xC0, 0x0C, 0xC0, 0x38,
  0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xFE, 0xFF, 0xEC, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFC, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xFF, 0xEF, 0xFE, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x78, 0x03, 0xFF,
  0xC3, 0x80, 0x63, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x07, 0xFC, 0x03, 0xFE,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x60, 0x00, 0xB0, 0x00, 0x4C, 0x00,
  0x23, 0x00, 0x10, 0xF0, 0x38, 0x1F, 0xF8, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xFC, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0xFC, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x06, 0x0E, 0xFC, 0xC0, 0x1D, 0x80, 0x73, 0x01,
  0xC6, 0x03, 0x0C, 0x0C, 0x18, 0x30, 0x30, 0xC0, 0x63, 0x00, 0xCC, 0x01,
  0xB8, 0x03, 0xD8, 0x07, 0x18, 0x0C, 0x30, 0x18, 0x30, 0x30, 0x30, 0x60,
  0x30, 0xC0, 0x61, 0x80, 0x63, 0x00, 0x66, 0x00, 0xEC, 0x00, 0xE0, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x7E, 0x00, 0x05,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xD8, 0x00, 0xBD, 0x80, 0x1B, 0xC8, 0x01,
  0x3C, 0xC0, 0x33, 0xCC, 0x03, 0x3C, 0x60, 0x23, 0xC6, 0x06, 0x3C, 0x20,
  0x43, 0xC3, 0x0C, 0x3C, 0x30, 0xC3, 0xC1, 0x88, 0x3C, 0x19, 0x83, 0xC0,
  0x90, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x06, 0x03, 0xC0, 0x60, 0x30,
  0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xD8, 0x03, 0xCC, 0x03,
  0xCC, 0x03, 0xC6, 0x03, 0xC3, 0x03, 0xC3, 0x03, 0xC1, 0x83, 0xC0, 0xC3,
  0xC0, 0xC3, 0xC0, 0x63, 0xC0, 0x33, 0xC0, 0x33, 0xC0, 0x1B, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0x00, 0xF0, 0x01, 0xFF, 0xC0, 0x70,
  0x1C, 0x18, 0x00, 0xC7, 0x00, 0x1C, 0xC0, 0x01, 0x90, 0x00, 0x16, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x60, 0x00, 0xCC, 0x00,
  0x18, 0xC0, 0x06, 0x1C, 0x01, 0xC0, 0xF0, 0xE0, 0x0F, 0xF8, 0x00, 0xFF,
  0xC6, 0x07, 0xB0, 0x0D, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x01, 0xB0, 0xF9, 0xFF, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x00, 0xF0,
  0x01, 0xFF, 0xC0, 0x70, 0x1C, 0x18, 0x00, 0xC7, 0x00, 0x1C, 0xC0, 0x01,
  0x90, 0x00, 0x16, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0x60, 0x00, 0xCC, 0x00, 0x18, 0xC0, 0x06, 0x1C, 0x01, 0xC0, 0xF0, 0xE0,
  0x0F, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0xFF, 0xC3, 0x03, 0xCC, 0x03, 0x30, 0x06, 0xC0, 0x1B,
  0x00, 0x6C, 0x01, 0xB0, 0x06, 0xC0, 0x33, 0x01, 0xCF, 0xFC, 0x3F, 0xE0,
  0xC1, 0x83, 0x03, 0x0C, 0x0C, 0x30, 0x18, 0xC0, 0x33, 0x00, 0xCC, 0x01,
  0xB0, 0x06, 0xC0, 0x0C, 0x07, 0x81, 0xFF, 0x9C, 0x05, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x6E, 0x1E, 0x7F, 0xE0, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x02, 0x60, 0x06, 0x70, 0x0C,
  0x3C, 0x38, 0x0F, 0xF0, 0xC0, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x4C, 0x00,
  0x63, 0x00, 0x31, 0x80, 0x30, 0x40, 0x18, 0x30, 0x0C, 0x18, 0x0C, 0x04,
  0x06, 0x03, 0x02, 0x01, 0x83, 0x00, 0x61, 0x80, 0x30, 0x80, 0x18, 0xC0,
  0x06, 0x60, 0x03, 0x60, 0x00, 0xB0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x05, 0x00, 0x6C, 0x06,
  0x80, 0x66, 0x03, 0x60, 0x33, 0x01, 0x30, 0x18, 0x80, 0x88, 0x08, 0x60,
  0xC6, 0x0C, 0x30, 0x63, 0x06, 0x18, 0x20, 0x83, 0x04, 0x30, 0x41, 0x03,
  0x18, 0x31, 0x81, 0x8C, 0x18, 0xC0, 0xC4, 0x04, 0x60, 0x26, 0x03, 0x20,
  0x1B, 0x01, 0xB0, 0x0D, 0x00, 0x58, 0x02, 0x80, 0x28, 0x01, 0xC0, 0x1C,
  0x00, 0xE0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x60, 0x07, 0x30, 0x06, 0x30,
  0x0C, 0x18, 0x08, 0x0C, 0x18, 0x0C, 0x30, 0x06, 0x20, 0x03, 0x60, 0x03,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x02, 0x60, 0x06, 0x30, 0x0C,
  0x30, 0x08, 0x18, 0x18, 0x0C, 0x30, 0x0C, 0x30, 0x06, 0x60, 0x06, 0xC0,
  0x03, 0xC0, 0x03, 0x60, 0x06, 0x20, 0x06, 0x30, 0x0C, 0x18, 0x08, 0x18,
  0x18, 0x0C, 0x30, 0x0C, 0x30, 0x06, 0x60, 0x06, 0x60, 0x03, 0xC0, 0x03,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x7F, 0xFE, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0xFF, 0xF0, 0xC0, 0x18, 0x06, 0x00, 0xC0,
  0x30, 0x04, 0x01, 0x80, 0x60, 0x08, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00,
  0x80, 0x30, 0x0C, 0x01, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0xFC, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0xFF, 0xF0, 0x01, 0x00, 0x07, 0x00, 0x0A, 0x00,
  0x36, 0x00, 0x44, 0x01, 0x8C, 0x02, 0x08, 0x0C, 0x18, 0x10, 0x10, 0x60,
  0x30, 0xC0, 0x23, 0x00, 0x66, 0x00, 0x58, 0x00, 0xC0, 0xFF, 0xF8, 0xE1,
  0x83, 0x06, 0x0C, 0x1F, 0xE1, 0xC3, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x80,
  0x0C, 0x00, 0x61, 0xFF, 0x38, 0x1B, 0x00, 0xD0, 0x07, 0x80, 0x3C, 0x03,
  0xB0, 0x3D, 0xC3, 0x67, 0xF3, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x11, 0xF8, 0xB8, 0xE5, 0x01, 0xB0, 0x07, 0x80,
  0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x07,
  0x80, 0x2E, 0x03, 0x5C, 0x72, 0x7F, 0x00, 0x0F, 0xE7, 0x8D, 0xC0, 0x30,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x18, 0x03, 0x00, 0x60, 0x06,
  0x00, 0xC0, 0x0E, 0x18, 0xFF, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x23, 0xF9, 0x38, 0xEB, 0x01, 0xD0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x07, 0x00, 0x30, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07,
  0x80, 0x36, 0x03, 0x9C, 0x74, 0x7F, 0x20, 0x1F, 0xC1, 0xC7, 0x18, 0x0C,
  0x80, 0x6C, 0x01, 0xE0, 0x0F, 0x00, 0x7F, 0xFF, 0x80, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xE0, 0xC3, 0xFE, 0x03, 0xE1, 0xFC,
  0x30, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x07, 0xFC, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0x1F, 0xC9, 0xC3, 0x58, 0x0E, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x07, 0x80,
  0x3C, 0x01, 0xB0, 0x14, 0xE3, 0xA3, 0xF9, 0x00, 0x08, 0x00, 0x40, 0x06,
  0x00, 0x38, 0x03, 0x38, 0x78, 0xFF, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0xFC, 0xB8, 0xEE, 0x03, 0xC0, 0x3C,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x5D, 0x00, 0x12, 0x49, 0x24, 0x92,
  0x49, 0x24, 0x80, 0x04, 0x1C, 0x10, 0x00, 0x00, 0x01, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x34, 0xEF, 0x80, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x06, 0x80, 0xC8, 0x18, 0x83, 0x08, 0x60, 0x8C,
  0x09, 0x80, 0xB8, 0x0A, 0xC0, 0xC6, 0x08, 0x30, 0x83, 0x08, 0x18, 0x80,
  0xC8, 0x06, 0x80, 0x70, 0xFF, 0xFF, 0xFE, 0x9F, 0x87, 0xE5, 0x8E, 0x61,
  0xB8, 0x1E, 0x07, 0x80, 0xE0, 0x3C, 0x03, 0x00, 0xC0, 0x10, 0x06, 0x00,
  0x80, 0x30, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x03,
  0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x04,
  0x01, 0x8F, 0xCB, 0x8E, 0xA0, 0x3C, 0x03, 0xC0, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x1F, 0xC0, 0xE1, 0xC6, 0x03, 0x98, 0x06, 0xC0, 0x0B, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x02, 0x60, 0x19,
  0x80, 0xE3, 0x87, 0x07, 0xF0, 0x8F, 0xC5, 0xC7, 0x28, 0x0D, 0x80, 0x3C,
  0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x03, 0x70, 0x1A, 0xC3, 0x93, 0xF8, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x00, 0x1F, 0xC9, 0xC7, 0x58, 0x0A,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x70,
  0x07, 0x80, 0x3C, 0x01, 0xB0, 0x14, 0xE3, 0xA3, 0xF1, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x8F, 0xB9, 0xA0,
  0xC0, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x1F, 0xE7, 0x06, 0x60, 0x04, 0x00, 0x40, 0x06, 0x00, 0x38, 0x01,
  0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x30, 0x03, 0x00, 0x30, 0x06, 0xE0, 0xE7,
  0xF8, 0x10, 0x08, 0x04, 0x02, 0x0F, 0xF8, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x18, 0x0C, 0x07, 0x21, 0xF0,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x34, 0x01, 0xB0, 0x14, 0xC3,
  0xA3, 0xF1, 0xC0, 0x0D, 0x00, 0x36, 0x01, 0x98, 0x06, 0x30, 0x10, 0xC0,
  0xC3, 0x03, 0x06, 0x18, 0x18, 0x60, 0x21, 0x00, 0xCC, 0x03, 0x30, 0x04,
  0x80, 0x1E, 0x00, 0x38, 0x00, 0xC0, 0xC0, 0x30, 0x0D, 0x80, 0xE0, 0x26,
  0x07, 0x81, 0x98, 0x1A, 0x06, 0x20, 0x48, 0x10, 0xC1, 0x30, 0xC3, 0x0C,
  0xC3, 0x04, 0x31, 0x0C, 0x18, 0x86, 0x20, 0x66, 0x19, 0x81, 0x98, 0x26,
  0x02, 0x40, 0xD8, 0x0F, 0x03, 0x40, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x01,
  0x80, 0x60, 0xC0, 0x1B, 0x01, 0x8C, 0x18, 0x60, 0xC1, 0x8C, 0x06, 0xC0,
  0x14, 0x00, 0xE0, 0x07, 0x00, 0x6C, 0x02, 0x20, 0x31, 0x83, 0x06, 0x30,
  0x19, 0x80, 0xD8, 0x03, 0xC0, 0x0D, 0x00, 0x36, 0x01, 0x98, 0x06, 0x30,
  0x10, 0xC0, 0xC1, 0x03, 0x06, 0x18, 0x18, 0x60, 0x21, 0x00, 0xCC, 0x01,
  0x30, 0x06, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00,
  0x60, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x7F, 0xF0, 0x06,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0,
  0x18, 0x01, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x0F, 0xFF, 0x07, 0x86, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x06, 0x0E, 0x03,
  0x80, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x18,
  0x07, 0x80, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0,
  0x1C, 0x06, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x03, 0x00,
  0xC0, 0x38, 0x38, 0x30, 0x18, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x60, 0x30, 0xF0, 0x40, 0x00, 0x7C, 0x07, 0x1E, 0x78, 0x1F, 0x00,
};

const GFXglyph NotoSans_Light30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 3, 21, 7, 2, -21 },
  { 9, 7, 7, 11, 2, -21 },
  { 16, 18, 21, 19, 1, -21 },
  { 64, 13, 25, 17, 2, -23 },
  { 105, 21, 22, 24, 2, -22 },
  { 163, 19, 22, 22, 2, -22 },
  { 216, 2, 7, 6, 2, -21 },
  { 218, 6, 26, 8, 1, -21 },
  { 238, 6, 26, 8, 1, -21 },
  { 258, 13, 13, 17, 2, -23 },
  { 280, 14, 14, 17, 2, -18 },
  { 305, 4, 7, 7, 1, -3 },
  { 309, 7, 2, 10, 1, -9 },
  { 311, 3, 3, 7, 2, -3 },
  { 313, 10, 21, 10, 0, -21 },
  { 340, 13, 22, 17, 2, -22 },
  { 376, 7, 21, 17, 3, -21 },
  { 395, 13, 22, 17, 2, -22 },
  { 431, 14, 22, 17, 1, -22 },
  { 470, 16, 22, 17, 1, -22 },
  { 514, 13, 21, 17, 2, -21 },
  { 549, 14, 22, 17, 2, -22 },
  { 588, 14, 21, 17, 2, -21 },
  { 625, 13, 22, 17, 2, -22 },
  { 661, 13, 22, 17, 2, -22 },
  { 697, 3, 16, 7, 2, -16 },
  { 703, 4, 20, 7, 1, -16 },
  { 713, 14, 14, 17, 2, -18 },
  { 738, 13, 7, 17, 2, -14 },
  { 750, 14, 14, 17, 2, -18 },
  { 775, 11, 22, 13, 1, -22 },
  { 806, 23, 24, 27, 2, -21 },
  { 875, 18, 22, 18, 0, -22 },
  { 925, 14, 21, 19, 3, -21 },
  { 962, 16, 22, 19, 2, -22 },
  { 1006, 16, 21, 21, 3, -21 },
  { 1048, 12, 21, 17, 3, -21 },
  { 1080, 12, 21, 15, 3, -21 },
  { 1112, 17, 22, 22, 2, -22 },
  { 1159, 16, 21, 22, 3, -21 },
  { 1201, 6, 21, 9, 2, -21 },
  { 1217, 8, 26, 8, -3, -21 },
  { 1243, 15, 21, 18, 3, -21 },
  { 1283, 12, 21, 15, 3, -21 },
  { 1315, 20, 21, 26, 3, -21 },
  { 1368, 16, 21, 22, 3, -21 },
  { 1410, 19, 22, 23, 2, -22 },
  { 1463, 13, 21, 18, 3, -21 },
  { 1498, 19, 27, 23, 2, -22 },
  { 1563, 14, 21, 18, 3, -21 },
  { 1600, 13, 22, 16, 2, -22 },
  { 1636, 16, 21, 16, 0, -21 },
  { 1678, 16, 21, 22, 3, -21 },
  { 1720, 17, 21, 17, 0, -21 },
  { 1765, 25, 21, 27, 1, -21 },
  { 1831, 16, 21, 16, 0, -21 },
  { 1873, 16, 21, 16, 0, -21 },
  { 1915, 15, 21, 17, 1, -21 },
  { 1955, 6, 26, 10, 3, -21 },
  { 1975, 10, 21, 10, 0, -21 },
  { 2002, 6, 26, 10, 1, -21 },
  { 2022, 15, 14, 17, 1, -22 },
  { 2049, 13, 1, 13, 0, 3 },
  { 2051, 6, 5, 8, 1, -23 },
  { 2055, 13, 16, 16, 1, -16 },
  { 2081, 13, 23, 18, 3, -23 },
  { 2119, 11, 16, 14, 2, -16 },
  { 2141, 13, 23, 18, 2, -23 },
  { 2179, 13, 16, 17, 2, -16 },
  { 2205, 11, 23, 9, 0, -23 },
  { 2237, 13, 23, 18, 2, -16 },
  { 2275, 12, 23, 18, 3, -23 },
  { 2310, 3, 22, 7, 2, -22 },
  { 2319, 7, 29, 7, -2, -22 },
  { 2345, 12, 23, 15, 3, -23 },
  { 2380, 1, 23, 7, 3, -23 },
  { 2383, 21, 16, 27, 3, -16 },
  { 2425, 12, 16, 18, 3, -16 },
  { 2449, 14, 16, 18, 2, -16 },
  { 2477, 13, 23, 18, 3, -16 },
  { 2515, 13, 23, 18, 2, -16 },
  { 2553, 8, 16, 12, 3, -16 },
  { 2569, 12, 16, 14, 1, -16 },
  { 2593, 9, 20, 10, 0, -20 },
  { 2616, 13, 16, 18, 2, -16 },
  { 2642, 14, 16, 14, 0, -16 },
  { 2670, 22, 16, 22, 0, -16 },
  { 2714, 13, 16, 15, 1, -16 },
  { 2740, 14, 23, 14, 0, -16 },
  { 2781, 12, 16, 14, 1, -16 },
  { 2805, 9, 26, 11, 1, -21 },
  { 2835, 2, 30, 16, 7, -23 },
  { 2843, 9, 26, 11, 1, -21 },
  { 2873, 14, 3, 17, 2, -12 },
};

const GFXfont NotoSans_Light30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light30pt7bBitmaps,
  (GFXglyph *)NotoSans_Light30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_LIGHT30PT7B_H_
