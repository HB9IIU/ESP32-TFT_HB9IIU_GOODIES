#ifndef _NOTOSANS_LIGHT58PT7B_H_
#define _NOTOSANS_LIGHT58PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light58pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBC, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x18, 0xC6, 0x30, 0x00, 0x00, 0x00, 0x0F,
  0x7F, 0xFF, 0xF3, 0x00, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xD8, 0x0E, 0xC0, 0x76,
  0x03, 0xB0, 0x19, 0x80, 0xC0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x1C, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x18, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00,
  0x70, 0x03, 0x80, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x0C, 0x00, 0x00, 0x60, 0x07, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x06,
  0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x06, 0x00, 0x70, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00,
  0xE0, 0x07, 0x00, 0x00, 0x38, 0x01, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x70, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x01, 0x80, 0x1C,
  0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x18, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x70,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x7E, 0x30,
  0xFC, 0x7C, 0x18, 0x04, 0x38, 0x0C, 0x00, 0x3C, 0x06, 0x00, 0x1C, 0x03,
  0x00, 0x0E, 0x01, 0x80, 0x07, 0x00, 0xC0, 0x03, 0x80, 0x60, 0x01, 0xC0,
  0x30, 0x00, 0xF0, 0x18, 0x00, 0x78, 0x0C, 0x00, 0x1E, 0x06, 0x00, 0x07,
  0xC3, 0x00, 0x01, 0xF9, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x0D, 0xFC, 0x00, 0x06, 0x1F,
  0x80, 0x03, 0x03, 0xC0, 0x01, 0x80, 0xF0, 0x00, 0xC0, 0x38, 0x00, 0x60,
  0x1C, 0x00, 0x30, 0x0F, 0x00, 0x18, 0x07, 0x80, 0x0C, 0x03, 0xC0, 0x06,
  0x01, 0xC0, 0x03, 0x00, 0xE0, 0x01, 0x80, 0xF4, 0x00, 0xC0, 0xF3, 0xC0,
  0x61, 0xF1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x40, 0x07, 0xFC, 0x00, 0x01,
  0xC0, 0x07, 0xFF, 0x00, 0x01, 0xE0, 0x07, 0x83, 0xC0, 0x00, 0xE0, 0x03,
  0x80, 0xE0, 0x00, 0xE0, 0x03, 0x80, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x1C,
  0x00, 0x70, 0x00, 0xE0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x00, 0x70, 0x01, 0x80, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x1C, 0x00, 0x1C,
  0x00, 0x70, 0x1E, 0x00, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x00, 0x1C,
  0x0E, 0x00, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0x07, 0x07, 0x00,
  0x00, 0xE0, 0x03, 0x03, 0x80, 0x00, 0x70, 0x03, 0x83, 0x83, 0xF8, 0x1C,
  0x01, 0xC1, 0xC3, 0xFF, 0x0E, 0x00, 0xE1, 0xC3, 0xC7, 0xC7, 0x00, 0x71,
  0xE3, 0xC0, 0xE1, 0xC0, 0x70, 0xE1, 0xC0, 0x38, 0xF0, 0x78, 0xE1, 0xC0,
  0x1C, 0x3F, 0xF8, 0x70, 0xE0, 0x0E, 0x0F, 0xF8, 0x70, 0x70, 0x03, 0x81,
  0xF0, 0x38, 0x38, 0x01, 0xC0, 0x00, 0x38, 0x18, 0x00, 0xE0, 0x00, 0x1C,
  0x1C, 0x00, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x00, 0x1E, 0x07, 0x00,
  0x1C, 0x00, 0x0E, 0x03, 0x80, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x07, 0x00,
  0x07, 0x00, 0x60, 0x03, 0x80, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00,
  0x70, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x01, 0xE0, 0x00, 0xE0, 0x38, 0x00,
  0xE0, 0x00, 0x3C, 0x3C, 0x00, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x70, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00,
  0x00, 0xF1, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xDE, 0x00, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x78,
  0x00, 0x38, 0x1E, 0x00, 0xF0, 0x00, 0xE0, 0xF0, 0x01, 0xE0, 0x07, 0x87,
  0x80, 0x03, 0xC0, 0x1C, 0x1E, 0x00, 0x07, 0x80, 0x70, 0x70, 0x00, 0x0F,
  0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x0E, 0x0F, 0x00, 0x00, 0x3C, 0x78, 0x3C,
  0x00, 0x00, 0x7B, 0xC0, 0xF0, 0x00, 0x00, 0xFE, 0x03, 0xC0, 0x00, 0x01,
  0xF8, 0x07, 0x00, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0x3F, 0x80, 0x7C,
  0x00, 0x01, 0xFF, 0x00, 0xF8, 0x00, 0x0F, 0x9E, 0x01, 0xF0, 0x00, 0xF8,
  0x3C, 0x03, 0xFC, 0xFF, 0xC0, 0x78, 0x07, 0xFF, 0xFC, 0x00, 0xF0, 0x07,
  0xFF, 0xC0, 0x01, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xEE, 0xEE,
  0xEE, 0xEE, 0x66, 0x66, 0x60, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x07,
  0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C,
  0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x80, 0x78, 0x03, 0x80, 0x38,
  0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07,
  0x80, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0xF0, 0x07, 0x80, 0x38,
  0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03,
  0x80, 0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01,
  0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07,
  0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x60, 0x0C, 0x01, 0xBF, 0x03, 0x03, 0xEF, 0xF8, 0xC7, 0xFD, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x73, 0x80, 0x00, 0x38, 0xF0, 0x00, 0x1E, 0x1E,
  0x00, 0x0F, 0x03, 0x80, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0xF0,
  0x07, 0xC0, 0x1C, 0x00, 0xE0, 0x01, 0x00, 0x20, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x3C, 0x78, 0xF1, 0xC7, 0x8F, 0x1C,
  0x38, 0x71, 0xC3, 0x87, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF7, 0xFF, 0xFF, 0x30, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03,
  0xE0, 0x3E, 0x00, 0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x07, 0x00, 0x01,
  0xC1, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x71, 0xE0,
  0x00, 0x0F, 0x38, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xB8, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x73, 0xC0, 0x00,
  0x1E, 0x38, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x1E, 0x0E,
  0x00, 0x03, 0x81, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x01, 0xE0, 0x0F,
  0x80, 0x3F, 0x8F, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x3C, 0x03, 0xF0, 0x1F, 0xC0, 0xFF, 0x0F, 0xBC,
  0x7C, 0xF3, 0xC3, 0xFE, 0x0F, 0xF0, 0x3D, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x80, 0xFE, 0x03, 0xF0, 0x7C, 0x00, 0x3E, 0x0E, 0x00, 0x07, 0x82, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x81, 0xFC, 0x01, 0xF8, 0xF8, 0x00, 0x1E,
  0x18, 0x00, 0x03, 0xC4, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xA0, 0x00, 0x03, 0xCE,
  0x00, 0x03, 0xE3, 0xFC, 0x0F, 0xF0, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xF8,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x78, 0x07, 0x00, 0x00, 0xE0,
  0x0E, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0x80, 0x03,
  0x80, 0x0E, 0x00, 0x07, 0x00, 0x38, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1C,
  0x03, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x00, 0x70, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x1F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x7B, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x80, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x80, 0x00, 0x3E, 0x38,
  0x00, 0x1F, 0x0F, 0xF0, 0x7F, 0x83, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x80,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x0F,
  0xFF, 0xE0, 0x07, 0xE0, 0x04, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x1F, 0x00, 0x38,
  0x3F, 0xFC, 0x0E, 0x3F, 0xFF, 0x83, 0x9F, 0x01, 0xF8, 0xEF, 0x00, 0x1F,
  0x3F, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x0E, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0x70, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x38, 0xE0, 0x00,
  0x1E, 0x3C, 0x00, 0x07, 0x07, 0x80, 0x03, 0xC0, 0xF8, 0x03, 0xE0, 0x1F,
  0xC7, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x40, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xC0, 0x1F, 0x01, 0xE0, 0x00, 0xF0,
  0x38, 0x00, 0x0E, 0x0F, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x38, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00,
  0xF0, 0x0F, 0x80, 0x3C, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xF8, 0x3F,
  0x00, 0x7C, 0x01, 0xF0, 0x1E, 0x00, 0x1F, 0x07, 0x80, 0x00, 0xF1, 0xE0,
  0x00, 0x0F, 0x3C, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3D, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3C,
  0x78, 0x00, 0x0F, 0x07, 0x80, 0x07, 0xC0, 0x7E, 0x07, 0xF0, 0x07, 0xFF,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x50, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xC0, 0x3E, 0x01, 0xE0,
  0x03, 0xE0, 0x78, 0x00, 0x3C, 0x0E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C,
  0x70, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x0F, 0x70, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x0E, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3D, 0xC0, 0x00,
  0x0F, 0xBC, 0x00, 0x03, 0xF3, 0x80, 0x00, 0x7E, 0x78, 0x00, 0x3B, 0x87,
  0xC0, 0x0E, 0x70, 0x7F, 0xBF, 0xCE, 0x07, 0xFF, 0xE1, 0xC0, 0x3F, 0xF0,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0xC0, 0x7F, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF7,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3D, 0xFF, 0xFF, 0xCC, 0x1E, 0x1F, 0x1F, 0x1F, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C,
  0x3C, 0x38, 0x38, 0x38, 0x70, 0x70, 0x70, 0x60, 0xE0, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x7F, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0x00, 0xFC, 0x60, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xCF,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x78, 0x00, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x07, 0xE0, 0x00, 0xE1, 0xC0, 0x01, 0xFF, 0xF0, 0x07, 0x1C, 0x00,
  0x3F, 0xFF, 0x80, 0x38, 0xE0, 0x03, 0xC0, 0x1C, 0x00, 0xEF, 0x00, 0x3C,
  0x00, 0xE0, 0x07, 0x70, 0x03, 0xC0, 0x07, 0x00, 0x3B, 0x80, 0x3C, 0x00,
  0x38, 0x01, 0xDC, 0x01, 0xC0, 0x01, 0xC0, 0x0E, 0xC0, 0x0E, 0x00, 0x0E,
  0x00, 0x3E, 0x00, 0xF0, 0x00, 0x70, 0x01, 0xF0, 0x07, 0x00, 0x03, 0x80,
  0x1F, 0x80, 0x38, 0x00, 0x1C, 0x00, 0xFC, 0x01, 0xC0, 0x00, 0xE0, 0x07,
  0xE0, 0x0E, 0x00, 0x07, 0x00, 0x3F, 0x00, 0x70, 0x00, 0x38, 0x01, 0xF8,
  0x03, 0x80, 0x03, 0xC0, 0x0F, 0xC0, 0x1C, 0x00, 0x1E, 0x00, 0xEE, 0x00,
  0x70, 0x00, 0xF0, 0x07, 0x30, 0x03, 0x80, 0x0D, 0x80, 0x79, 0xC0, 0x1E,
  0x00, 0xEE, 0x03, 0x8E, 0x00, 0x78, 0x0E, 0x78, 0x38, 0x70, 0x01, 0xFF,
  0xE1, 0xFF, 0x81, 0xC0, 0x07, 0xFE, 0x07, 0xF8, 0x0E, 0x00, 0x07, 0x80,
  0x0F, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x02, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x00, 0x3C, 0x38, 0x00, 0x00, 0x07, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x1C, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x07, 0x00, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x0E,
  0x00, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x70,
  0x0E, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1C, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x70, 0x00, 0x1F, 0x8E, 0x00, 0x00,
  0xF9, 0xC0, 0x00, 0x0F, 0xB8, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x1E, 0xE0,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x07, 0xB8, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x1F, 0x1C, 0x00, 0x1F, 0x83, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC1, 0xC0, 0x00, 0x7E, 0x38, 0x00,
  0x01, 0xE7, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0x70, 0x00, 0x03, 0xEE, 0x00, 0x00,
  0xF9, 0xC0, 0x00, 0x7E, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0x3F, 0x03, 0xF0, 0x00, 0x18, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x01, 0x80, 0x7F, 0xF3, 0xFE, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x00, 0x3F,
  0x80, 0xE0, 0x00, 0x0F, 0xC0, 0xE0, 0x00, 0x03, 0xE0, 0xE0, 0x00, 0x01,
  0xF0, 0xE0, 0x00, 0x00, 0xF8, 0xE0, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00,
  0x3C, 0xE0, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00,
  0x1E, 0xE0, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00,
  0x1E, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00,
  0x3C, 0xE0, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0xF8, 0xE0, 0x00, 0x00,
  0xF0, 0xE0, 0x00, 0x03, 0xE0, 0xE0, 0x00, 0x07, 0xC0, 0xE0, 0x00, 0x1F,
  0x80, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x07, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x0F, 0x0F, 0x80,
  0x00, 0x03, 0xC1, 0xF8, 0x00, 0x00, 0xF0, 0x3F, 0x80, 0x00, 0x7C, 0x03,
  0xFF, 0x9F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F,
  0x8F, 0xFF, 0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xE0, 0x07, 0x80, 0x3C, 0xFF, 0xF3, 0xFF, 0x8F, 0xF8, 0x02, 0x00, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x07, 0x8E, 0x00, 0x00,
  0xF0, 0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x78, 0x0E,
  0x00, 0x0F, 0x00, 0xE0, 0x01, 0xE0, 0x0E, 0x00, 0x3C, 0x00, 0xE0, 0x07,
  0x80, 0x0E, 0x00, 0xF0, 0x00, 0xE0, 0x1E, 0x00, 0x0E, 0x03, 0xC0, 0x00,
  0xE0, 0x78, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0xE1, 0xF0, 0x00, 0x0E, 0x3E,
  0x00, 0x00, 0xE3, 0xF0, 0x00, 0x0E, 0x7F, 0x00, 0x00, 0xEE, 0x78, 0x00,
  0x0F, 0xC3, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xE0,
  0x0F, 0x00, 0x0E, 0x00, 0x78, 0x00, 0xE0, 0x07, 0xC0, 0x0E, 0x00, 0x3C,
  0x00, 0xE0, 0x01, 0xE0, 0x0E, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0xF0, 0x0E,
  0x00, 0x07, 0x80, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x01, 0xE0, 0xE0, 0x00,
  0x1E, 0x0E, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x3C,
  0xE0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0xF0, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0x7F, 0xE0, 0x00, 0x00, 0x0E, 0xFD, 0xC0, 0x00,
  0x00, 0x3D, 0xFB, 0xC0, 0x00, 0x00, 0x77, 0xF3, 0x80, 0x00, 0x00, 0xEF,
  0xE7, 0x00, 0x00, 0x03, 0x9F, 0xCF, 0x00, 0x00, 0x07, 0x3F, 0x8E, 0x00,
  0x00, 0x1E, 0x7F, 0x1E, 0x00, 0x00, 0x38, 0xFE, 0x1C, 0x00, 0x00, 0x71,
  0xFC, 0x38, 0x00, 0x01, 0xC3, 0xF8, 0x78, 0x00, 0x03, 0x87, 0xF0, 0x70,
  0x00, 0x0F, 0x0F, 0xE0, 0xF0, 0x00, 0x1C, 0x1F, 0xC0, 0xE0, 0x00, 0x38,
  0x3F, 0x81, 0xC0, 0x00, 0xE0, 0x7F, 0x03, 0xC0, 0x01, 0xC0, 0xFE, 0x03,
  0x80, 0x07, 0x81, 0xFC, 0x07, 0x80, 0x0E, 0x03, 0xF8, 0x07, 0x00, 0x1C,
  0x07, 0xF0, 0x0E, 0x00, 0x70, 0x0F, 0xE0, 0x1E, 0x00, 0xE0, 0x1F, 0xC0,
  0x1C, 0x03, 0xC0, 0x3F, 0x80, 0x38, 0x07, 0x00, 0x7F, 0x00, 0x78, 0x0E,
  0x00, 0xFE, 0x00, 0x70, 0x38, 0x01, 0xFC, 0x00, 0xF0, 0x70, 0x03, 0xF8,
  0x00, 0xE1, 0xE0, 0x07, 0xF0, 0x01, 0xC3, 0x80, 0x0F, 0xE0, 0x03, 0xC7,
  0x00, 0x1F, 0xC0, 0x03, 0x9C, 0x00, 0x3F, 0x80, 0x07, 0xB8, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0xE0, 0x00, 0x38, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7E, 0xF0, 0x00, 0x01, 0xF9, 0xE0, 0x00, 0x07, 0xE7,
  0x80, 0x00, 0x1F, 0x8F, 0x00, 0x00, 0x7E, 0x1E, 0x00, 0x01, 0xF8, 0x78,
  0x00, 0x07, 0xE0, 0xF0, 0x00, 0x1F, 0x81, 0xE0, 0x00, 0x7E, 0x07, 0x80,
  0x01, 0xF8, 0x0F, 0x00, 0x07, 0xE0, 0x1E, 0x00, 0x1F, 0x80, 0x78, 0x00,
  0x7E, 0x00, 0xF0, 0x01, 0xF8, 0x01, 0xE0, 0x07, 0xE0, 0x07, 0x80, 0x1F,
  0x80, 0x0F, 0x00, 0x7E, 0x00, 0x1E, 0x01, 0xF8, 0x00, 0x78, 0x07, 0xE0,
  0x00, 0xF0, 0x1F, 0x80, 0x01, 0xE0, 0x7E, 0x00, 0x07, 0x81, 0xF8, 0x00,
  0x0F, 0x07, 0xE0, 0x00, 0x1E, 0x1F, 0x80, 0x00, 0x78, 0x7E, 0x00, 0x00,
  0xF1, 0xF8, 0x00, 0x01, 0xE7, 0xE0, 0x00, 0x07, 0x9F, 0x80, 0x00, 0x0F,
  0x7E, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x00, 0x3E, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00,
  0x0F, 0x0E, 0x00, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x01,
  0xDE, 0x00, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00,
  0x0F, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x1C, 0x00, 0x1F, 0x8E, 0x00,
  0x03, 0xE7, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x3D, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0E,
  0xE0, 0x00, 0x0F, 0x70, 0x00, 0x07, 0xB8, 0x00, 0x07, 0x9C, 0x00, 0x0F,
  0x8E, 0x00, 0x1F, 0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x01, 0xFF, 0xFC,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xF8, 0x03,
  0xF8, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x3C,
  0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1D,
  0xE0, 0x00, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x3F, 0xF3, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x07, 0xE0, 0xE0, 0x00,
  0x1E, 0x0E, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x78,
  0xE0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x07,
  0x8E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0F, 0x0E, 0x00, 0x01, 0xE0, 0xE0,
  0x00, 0x3C, 0x0E, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x0E,
  0x00, 0x3C, 0x00, 0xE0, 0x01, 0xE0, 0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0xF0, 0x0E, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x78, 0x0E, 0x00, 0x03, 0xC0,
  0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x0F, 0x0E, 0x00,
  0x00, 0xF0, 0xE0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x03,
  0xCE, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x7F, 0x00, 0xFC, 0x1E, 0x00, 0x03,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xA0, 0x00, 0x07, 0xCF,
  0x00, 0x03, 0xE3, 0xFF, 0x3F, 0xF0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x03, 0xBC, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x1E, 0x70, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC1, 0xF0, 0x00,
  0x0F, 0x01, 0xF8, 0x00, 0x7C, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xDC, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x03, 0xC1, 0xC0,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x1E, 0x03,
  0x80, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x0E, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x07, 0x00, 0x00, 0xE0,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x1E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x07, 0x87, 0x80, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x00, 0x38, 0x70,
  0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xDC, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x39, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1E, 0x38, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x8E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x73, 0x80, 0x00, 0x70,
  0xF0, 0x00, 0x1C, 0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x07, 0x38, 0x00, 0x0F,
  0x07, 0x00, 0x03, 0xCF, 0x00, 0x03, 0x81, 0xE0, 0x00, 0xE1, 0xC0, 0x01,
  0xE0, 0x38, 0x00, 0x38, 0x70, 0x00, 0x78, 0x0E, 0x00, 0x0E, 0x1C, 0x00,
  0x1C, 0x03, 0x80, 0x07, 0x03, 0x80, 0x07, 0x00, 0xF0, 0x01, 0xC0, 0xE0,
  0x03, 0xC0, 0x1C, 0x00, 0x70, 0x38, 0x00, 0xF0, 0x07, 0x00, 0x3C, 0x0F,
  0x00, 0x38, 0x01, 0xE0, 0x0E, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0x80,
  0x70, 0x07, 0x80, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xE0, 0x03, 0x80, 0x78,
  0x03, 0x80, 0x70, 0x00, 0xF0, 0x1C, 0x00, 0xE0, 0x1C, 0x00, 0x3C, 0x07,
  0x00, 0x38, 0x0F, 0x00, 0x07, 0x03, 0xC0, 0x0F, 0x03, 0x80, 0x01, 0xC0,
  0xE0, 0x01, 0xC0, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x70, 0x78, 0x00, 0x0E,
  0x0E, 0x00, 0x1C, 0x1E, 0x00, 0x03, 0x87, 0x80, 0x03, 0x87, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0xE1, 0xC0, 0x00, 0x3C, 0x70, 0x00, 0x38, 0xF0, 0x00,
  0x07, 0x1C, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xCE, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x73, 0x80, 0x00, 0x1E, 0xE0, 0x00, 0x1D, 0xE0,
  0x00, 0x03, 0xB8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00,
  0x70, 0x0F, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x03, 0x80, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x00, 0xE0, 0x07,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x78, 0x1C,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1E, 0x70,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x70, 0x1E,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x01, 0xC0, 0x07,
  0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x07, 0x80, 0x01,
  0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x78, 0xE0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x07,
  0x03, 0xC0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x38, 0x07, 0x80, 0x00, 0xF0,
  0x07, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1C, 0x01, 0xE0, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x38, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xE0,
  0x0E, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x07,
  0x00, 0x38, 0x00, 0x38, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x1C, 0x70, 0x00, 0x00, 0x77, 0x80, 0x00, 0x03, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x01, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x7F, 0x9F, 0xE0, 0xF0, 0x03, 0xE0, 0x80, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x03, 0xFF,
  0xC0, 0xFF, 0xFF, 0x87, 0xFF, 0xE7, 0x1F, 0x80, 0x0E, 0x78, 0x00, 0x1D,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0,
  0x01, 0xFB, 0xC0, 0x0F, 0x77, 0xF0, 0x7C, 0x67, 0xFF, 0xF0, 0xC3, 0xFF,
  0x81, 0x80, 0x60, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x1F,
  0xF8, 0x0E, 0x1F, 0xFF, 0x83, 0x8F, 0xEF, 0xF0, 0xE7, 0x00, 0x3E, 0x3B,
  0x80, 0x03, 0xCF, 0xC0, 0x00, 0xF3, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x03,
  0xBC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0E, 0xF8, 0x00, 0x03, 0xBE, 0x00, 0x01, 0xEF, 0xC0, 0x00, 0xF3, 0xB0,
  0x00, 0x7C, 0xEF, 0x00, 0x3E, 0x39, 0xF8, 0x7F, 0x0E, 0x3F, 0xFF, 0x83,
  0x83, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3E, 0x00, 0x20, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x20, 0x7F, 0x8F, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0x05, 0x40, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x01,
  0xFF, 0x83, 0xC0, 0xFF, 0xFC, 0x78, 0x3F, 0xCF, 0xCF, 0x0F, 0x80, 0x1C,
  0xE3, 0xE0, 0x01, 0xDC, 0x78, 0x00, 0x1F, 0x9E, 0x00, 0x01, 0xF3, 0x80,
  0x00, 0x3E, 0xF0, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x0F,
  0x70, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0x70, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x3D, 0xC0, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3E, 0x78, 0x00, 0x07, 0xCF,
  0x00, 0x01, 0xF8, 0xF0, 0x00, 0x77, 0x0F, 0x00, 0x1C, 0xE1, 0xFC, 0x1F,
  0x1C, 0x0F, 0xFF, 0xC3, 0x80, 0xFF, 0xF0, 0x70, 0x01, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x3E, 0x00, 0xF8,
  0x0F, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC3, 0xC0, 0x00, 0x70, 0xE0, 0x00,
  0x1E, 0x78, 0x00, 0x03, 0x9E, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x3D, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x0C, 0x07, 0xF8, 0x3F, 0x00, 0x7F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xF0, 0x0F, 0xFF,
  0x01, 0xFC, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x01, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xE0,
  0xE0, 0x7F, 0xFE, 0x1C, 0x1F, 0xE7, 0xE3, 0x87, 0xC0, 0x0E, 0x71, 0xF0,
  0x00, 0xEE, 0x3C, 0x00, 0x0F, 0xCF, 0x00, 0x00, 0xF9, 0xC0, 0x00, 0x1F,
  0x78, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x07, 0xB8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xB8, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1F, 0x3C, 0x00, 0x03, 0xE7, 0x80, 0x00,
  0xFC, 0x78, 0x00, 0x3F, 0x87, 0xC0, 0x0E, 0xF0, 0x7E, 0x0F, 0x9E, 0x07,
  0xFF, 0xE3, 0xC0, 0x3F, 0xF0, 0x78, 0x00, 0x60, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C,
  0x30, 0x00, 0x0F, 0x07, 0xE0, 0x07, 0xC0, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x03, 0xFF,
  0x03, 0x87, 0xFF, 0xE1, 0xC7, 0xF3, 0xF8, 0xE7, 0x00, 0x3E, 0x77, 0x00,
  0x0F, 0xBF, 0x00, 0x03, 0xDF, 0x00, 0x00, 0xEF, 0x80, 0x00, 0x77, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF0, 0xFF,
  0xFF, 0x60, 0x00, 0x00, 0x0E, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x1E, 0x83, 0xCF, 0xFC, 0xFF, 0x87, 0xE0, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x3E, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0xF0, 0xE0, 0x01, 0xE0, 0xE0,
  0x01, 0xE0, 0xE0, 0x03, 0xC0, 0xE0, 0x07, 0x80, 0xE0, 0x0F, 0x00, 0xE0,
  0x1E, 0x00, 0xE0, 0x3C, 0x00, 0xE0, 0x78, 0x00, 0xE0, 0xF0, 0x00, 0xE1,
  0xE0, 0x00, 0xE3, 0xC0, 0x00, 0xE7, 0xE0, 0x00, 0xE7, 0xF0, 0x00, 0xEE,
  0x78, 0x00, 0xFC, 0x38, 0x00, 0xF8, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0xE0,
  0x0F, 0x00, 0xE0, 0x0F, 0x00, 0xE0, 0x07, 0x80, 0xE0, 0x03, 0xC0, 0xE0,
  0x01, 0xE0, 0xE0, 0x01, 0xE0, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0x78, 0xE0,
  0x00, 0x3C, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xE0, 0xFF, 0xC0, 0x1F, 0xF8, 0x38, 0xFF, 0xF8, 0x1F, 0xFF, 0x8E,
  0x7F, 0x7F, 0x0F, 0xE7, 0xF3, 0xBC, 0x01, 0xE7, 0x80, 0x3E, 0xEC, 0x00,
  0x3D, 0xC0, 0x07, 0xBF, 0x00, 0x0F, 0xE0, 0x00, 0xEF, 0x80, 0x01, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x78, 0x00, 0x07, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x78, 0x00,
  0x07, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x78, 0x00, 0x07, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0xE0, 0x7F, 0xE0, 0x70,
  0xFF, 0xFC, 0x38, 0xFC, 0x7F, 0x1C, 0xE0, 0x07, 0xCE, 0xE0, 0x01, 0xF7,
  0xE0, 0x00, 0x7B, 0xE0, 0x00, 0x1D, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1E, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xF9, 0xFE, 0x00, 0xF8, 0x01, 0xF0, 0x1F,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC3, 0x80, 0x00,
  0x1C, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xE7, 0x80,
  0x00, 0x0E, 0x78, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x3C, 0x1F, 0x00, 0x07, 0x80, 0xF8, 0x01, 0xF0, 0x07,
  0xF0, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x60,
  0x00, 0xE0, 0x7F, 0xE0, 0x1C, 0x3F, 0xFF, 0x03, 0x8F, 0xEF, 0xF0, 0x73,
  0xC0, 0x1F, 0x0E, 0xE0, 0x00, 0xF1, 0xD8, 0x00, 0x1E, 0x3E, 0x00, 0x01,
  0xE7, 0xC0, 0x00, 0x1C, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x07, 0x78, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x3B, 0xC0, 0x00, 0x07, 0x78, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x1D,
  0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x3C, 0xF8, 0x00,
  0x07, 0x9F, 0x80, 0x01, 0xE3, 0xB8, 0x00, 0x7C, 0x73, 0x80, 0x1F, 0x0E,
  0x7E, 0x1F, 0xC1, 0xC3, 0xFF, 0xF0, 0x38, 0x3F, 0xF8, 0x07, 0x00, 0x20,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0xE0, 0x7F, 0xFE, 0x1C, 0x1F, 0xE7, 0xE3, 0x87, 0xC0, 0x0E, 0x71, 0xE0,
  0x00, 0xEE, 0x3C, 0x00, 0x0F, 0xCF, 0x00, 0x00, 0xF9, 0xC0, 0x00, 0x1F,
  0x78, 0x00, 0x03, 0xEE, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x07, 0xB8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0xFB, 0xC0, 0x00, 0x1F, 0x38, 0x00, 0x03, 0xE7, 0x80, 0x00,
  0xFC, 0x78, 0x00, 0x3F, 0x8F, 0x80, 0x0E, 0xF0, 0xFE, 0x1F, 0x9E, 0x07,
  0xFF, 0xE3, 0xC0, 0x7F, 0xF0, 0x78, 0x00, 0x40, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0xE0, 0x7F, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC,
  0xF0, 0x0E, 0xE0, 0x07, 0x60, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x07,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE3, 0xF8, 0x7F, 0x1F, 0x00, 0x0C, 0x70, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE8, 0x00,
  0x07, 0xB0, 0x00, 0x3C, 0xFC, 0x07, 0xE3, 0xFF, 0xFF, 0x03, 0xFF, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC3, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x7E, 0x30, 0x1F, 0xF8, 0x07, 0xFC,
  0x00, 0x20, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0x78, 0x00, 0x3F, 0x7C,
  0x00, 0xF7, 0x3F, 0x87, 0xE7, 0x1F, 0xFF, 0xC3, 0x07, 0xFF, 0x03, 0x00,
  0xB0, 0x00, 0xF0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x07,
  0x3C, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x0F, 0x00,
  0x01, 0xE0, 0xE0, 0x00, 0x38, 0x1E, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xE0,
  0x38, 0x00, 0x38, 0x07, 0x80, 0x0F, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00,
  0x38, 0x01, 0xE0, 0x0F, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0xC0, 0x38, 0x00,
  0x38, 0x0F, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x0E, 0x0E,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x78, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x79, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0x80, 0x01, 0xCE, 0x00, 0x07, 0xC0, 0x00, 0xE7, 0x00, 0x03, 0x70, 0x00,
  0xF3, 0xC0, 0x03, 0xB8, 0x00, 0x70, 0xE0, 0x01, 0xDC, 0x00, 0x38, 0x70,
  0x00, 0xEF, 0x00, 0x1C, 0x3C, 0x00, 0xE3, 0x80, 0x1E, 0x1E, 0x00, 0x71,
  0xC0, 0x0E, 0x07, 0x00, 0x38, 0xF0, 0x07, 0x03, 0x80, 0x38, 0x38, 0x07,
  0x81, 0xE0, 0x1C, 0x1C, 0x03, 0xC0, 0x70, 0x0E, 0x0F, 0x01, 0xC0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x0F, 0x03, 0x80,
  0xE0, 0x70, 0x03, 0x83, 0x80, 0x38, 0x38, 0x01, 0xC1, 0xC0, 0x1C, 0x1C,
  0x00, 0xF0, 0xE0, 0x0E, 0x1E, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x1C,
  0x70, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x07, 0xB8, 0x00,
  0x3B, 0xC0, 0x01, 0xDC, 0x00, 0x1D, 0xC0, 0x00, 0xEE, 0x00, 0x0E, 0xE0,
  0x00, 0x77, 0x00, 0x07, 0x70, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x78, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1E,
  0x0F, 0x00, 0x07, 0x80, 0xF0, 0x01, 0xE0, 0x0E, 0x00, 0x38, 0x01, 0xE0,
  0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x3C, 0x1E, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x3C, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x0E, 0x0E,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x1C, 0x01, 0xC0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x03, 0xC0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x03,
  0x83, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x07, 0x3C, 0x00, 0x01,
  0xE3, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x07, 0x00, 0x01, 0xE0, 0xE0,
  0x00, 0x38, 0x1E, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x38,
  0x03, 0x80, 0x0F, 0x00, 0x70, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x00, 0xE0,
  0x0F, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0xC0, 0x38, 0x00, 0x38, 0x0F, 0x00,
  0x07, 0x81, 0xC0, 0x00, 0x70, 0x78, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xE1,
  0xC0, 0x00, 0x1C, 0x78, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x07, 0x78, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x80,
  0x3F, 0xC0, 0x3F, 0x80, 0x3E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x01, 0xFC, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x1F, 0x80, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x3E, 0x01, 0xFE, 0x00,
  0xFE, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x05,
  0xFF, 0xF8, 0x01, 0xFC, 0x1F, 0xE0, 0xFE, 0x00, 0xFF, 0xFD, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0x00,
};

const GFXglyph NotoSans_Light58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 5, 42, 14, 5, -41 },
  { 28, 13, 15, 21, 4, -41 },
  { 53, 34, 41, 37, 2, -41 },
  { 228, 25, 47, 33, 4, -44 },
  { 375, 41, 43, 47, 3, -42 },
  { 596, 38, 43, 42, 3, -42 },
  { 801, 4, 15, 12, 4, -41 },
  { 809, 12, 50, 16, 2, -41 },
  { 884, 12, 50, 16, 2, -41 },
  { 959, 26, 25, 32, 3, -44 },
  { 1041, 27, 27, 33, 3, -34 },
  { 1133, 7, 14, 13, 2, -7 },
  { 1146, 14, 3, 19, 2, -17 },
  { 1152, 5, 6, 14, 5, -5 },
  { 1156, 18, 41, 20, 1, -41 },
  { 1249, 27, 43, 33, 3, -42 },
  { 1395, 14, 41, 33, 6, -41 },
  { 1467, 26, 42, 33, 3, -42 },
  { 1604, 26, 43, 33, 3, -42 },
  { 1744, 31, 42, 33, 1, -42 },
  { 1907, 26, 42, 33, 4, -41 },
  { 2044, 26, 43, 33, 4, -42 },
  { 2184, 27, 41, 33, 3, -41 },
  { 2323, 27, 43, 33, 3, -42 },
  { 2469, 27, 43, 33, 3, -42 },
  { 2615, 5, 32, 14, 5, -31 },
  { 2635, 8, 38, 14, 2, -31 },
  { 2673, 27, 28, 33, 3, -35 },
  { 2768, 27, 15, 33, 3, -28 },
  { 2819, 27, 28, 33, 3, -35 },
  { 2914, 22, 43, 25, 1, -42 },
  { 3033, 45, 46, 52, 3, -41 },
  { 3292, 35, 42, 35, 0, -42 },
  { 3476, 27, 41, 37, 6, -41 },
  { 3615, 30, 43, 36, 4, -42 },
  { 3777, 32, 41, 41, 6, -41 },
  { 3941, 23, 41, 32, 6, -41 },
  { 4059, 23, 41, 29, 6, -41 },
  { 4177, 34, 43, 42, 4, -42 },
  { 4360, 30, 41, 42, 6, -41 },
  { 4514, 12, 41, 18, 3, -41 },
  { 4576, 14, 52, 15, -5, -41 },
  { 4667, 28, 41, 34, 6, -41 },
  { 4811, 23, 41, 30, 6, -41 },
  { 4929, 39, 41, 51, 6, -41 },
  { 5129, 30, 41, 42, 6, -41 },
  { 5283, 37, 43, 45, 4, -42 },
  { 5482, 25, 41, 34, 6, -41 },
  { 5611, 37, 52, 45, 4, -42 },
  { 5852, 28, 41, 35, 6, -41 },
  { 5996, 26, 43, 32, 3, -42 },
  { 6136, 30, 41, 31, 0, -41 },
  { 6290, 31, 42, 42, 5, -41 },
  { 6453, 34, 41, 34, 0, -41 },
  { 6628, 50, 41, 52, 1, -41 },
  { 6885, 32, 41, 32, 0, -41 },
  { 7049, 31, 41, 31, 0, -41 },
  { 7208, 29, 41, 33, 2, -41 },
  { 7357, 12, 50, 19, 5, -41 },
  { 7432, 18, 41, 20, 1, -41 },
  { 7525, 13, 50, 19, 1, -41 },
  { 7607, 29, 26, 33, 2, -42 },
  { 7702, 24, 3, 24, 0, 5 },
  { 7711, 11, 9, 15, 2, -44 },
  { 7724, 23, 32, 31, 3, -31 },
  { 7816, 26, 45, 35, 5, -44 },
  { 7963, 23, 32, 28, 3, -31 },
  { 8055, 27, 45, 35, 3, -44 },
  { 8207, 26, 32, 32, 3, -31 },
  { 8311, 20, 44, 18, 1, -44 },
  { 8421, 27, 45, 35, 3, -31 },
  { 8573, 25, 44, 35, 5, -44 },
  { 8711, 4, 42, 14, 5, -42 },
  { 8732, 12, 56, 14, -3, -42 },
  { 8816, 24, 44, 29, 5, -44 },
  { 8948, 3, 44, 14, 5, -44 },
  { 8965, 42, 31, 52, 5, -31 },
  { 9128, 25, 31, 35, 5, -31 },
  { 9225, 28, 32, 34, 3, -31 },
  { 9337, 27, 45, 35, 5, -31 },
  { 9489, 27, 45, 35, 3, -31 },
  { 9641, 17, 31, 23, 5, -31 },
  { 9707, 22, 32, 27, 3, -31 },
  { 9795, 17, 39, 20, 1, -38 },
  { 9878, 24, 32, 35, 5, -31 },
  { 9974, 27, 31, 27, 0, -31 },
  { 10079, 41, 31, 43, 1, -31 },
  { 10238, 27, 31, 29, 1, -31 },
  { 10343, 27, 45, 27, 0, -31 },
  { 10495, 22, 31, 27, 2, -31 },
  { 10581, 17, 50, 21, 2, -41 },
  { 10688, 3, 58, 32, 14, -44 },
  { 10710, 17, 50, 21, 2, -41 },
  { 10817, 27, 7, 33, 3, -24 },
};

const GFXfont NotoSans_Light58pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light58pt7bBitmaps,
  (GFXglyph *)NotoSans_Light58pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _NOTOSANS_LIGHT58PT7B_H_
