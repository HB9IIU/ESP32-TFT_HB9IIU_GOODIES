#ifndef _NOTOSANS_LIGHT32PT7B_H_
#define _NOTOSANS_LIGHT32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light32pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0xC7, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xA1, 0x01, 0x83, 0x00, 0x30, 0x60, 0x04, 0x08, 0x00, 0x81, 0x00,
  0x30, 0x60, 0x06, 0x0C, 0x00, 0xC1, 0x83, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0,
  0xC1, 0x80, 0x18, 0x30, 0x03, 0x06, 0x00, 0x40, 0x80, 0x08, 0x10, 0x03,
  0x06, 0x07, 0xFF, 0xFE, 0x0C, 0x18, 0x01, 0x02, 0x00, 0x20, 0x40, 0x04,
  0x08, 0x01, 0x83, 0x00, 0x30, 0x60, 0x06, 0x08, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0xFE, 0x0F, 0xFE, 0x63, 0x0B, 0x0C, 0x0C, 0x30, 0x30, 0xC0, 0xC3,
  0x03, 0x8C, 0x07, 0x30, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x33, 0x80,
  0xC6, 0x03, 0x0C, 0x0C, 0x30, 0x30, 0xC0, 0xC6, 0x83, 0x3B, 0xFF, 0xC3,
  0xFC, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3E, 0x00, 0xC1, 0x9C, 0x02,
  0x0C, 0x30, 0x18, 0x30, 0x40, 0x40, 0xC1, 0x83, 0x02, 0x06, 0x08, 0x08,
  0x18, 0x60, 0x20, 0x63, 0x00, 0x81, 0x8C, 0x03, 0x06, 0x63, 0xCC, 0x11,
  0x3B, 0xB0, 0xCC, 0xC2, 0x67, 0x22, 0x0C, 0xF9, 0x98, 0x30, 0x04, 0x60,
  0x40, 0x31, 0x81, 0x01, 0x86, 0x04, 0x06, 0x18, 0x10, 0x30, 0x60, 0xC0,
  0x81, 0x83, 0x06, 0x03, 0x0C, 0x10, 0x0C, 0x60, 0xC0, 0x1F, 0x00, 0x07,
  0xE0, 0x01, 0xE7, 0x00, 0x18, 0x38, 0x03, 0x01, 0x80, 0x30, 0x18, 0x03,
  0x01, 0x80, 0x30, 0x18, 0x01, 0x83, 0x00, 0x0C, 0x60, 0x00, 0xFC, 0x00,
  0x07, 0x00, 0x01, 0xF8, 0x00, 0x39, 0xC0, 0x66, 0x0E, 0x06, 0xC0, 0x70,
  0x6C, 0x03, 0x8C, 0xC0, 0x1C, 0xCC, 0x00, 0xF8, 0xC0, 0x07, 0x0C, 0x00,
  0x78, 0x60, 0x0D, 0xC3, 0xC7, 0x8E, 0x1F, 0xE0, 0x70, 0xFF, 0xFD, 0x06,
  0x18, 0x60, 0xC3, 0x06, 0x18, 0x30, 0x60, 0xC1, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x81, 0x83, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x30,
  0xC0, 0xC0, 0xC1, 0x81, 0x83, 0x02, 0x06, 0x0C, 0x18, 0x30, 0x20, 0x60,
  0xC1, 0x83, 0x04, 0x18, 0x30, 0x60, 0xC1, 0x06, 0x0C, 0x30, 0x61, 0x86,
  0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x82, 0x0F, 0xC9, 0xF3,
  0xFE, 0x01, 0xC0, 0x05, 0x80, 0x33, 0x01, 0x8C, 0x0E, 0x18, 0x30, 0x70,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x7F, 0xFF, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0x33, 0x36, 0x66, 0x4C, 0xFF, 0xFC, 0x00,
  0x60, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x06, 0x00,
  0xC0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x00, 0x0F, 0xC0, 0x7B, 0xC3, 0x03,
  0x18, 0x06, 0x60, 0x0B, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x36, 0x00, 0xD8, 0x06, 0x30, 0x38, 0x71, 0xC0, 0xFC, 0x00,
  0x03, 0x0F, 0x1F, 0x33, 0xE3, 0x43, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x1F,
  0xC1, 0xF7, 0x8E, 0x03, 0x10, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0, 0x7D, 0xF1, 0x80, 0x70, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x3F,
  0x80, 0x7F, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x78, 0x01, 0xDF, 0x0F, 0x0F, 0xF8, 0x00,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0B, 0x00, 0x0D, 0x80, 0x0C,
  0xC0, 0x0C, 0x60, 0x06, 0x30, 0x06, 0x18, 0x06, 0x0C, 0x02, 0x06, 0x03,
  0x03, 0x03, 0x01, 0x83, 0x00, 0xC1, 0x80, 0x61, 0x80, 0x30, 0xFF, 0xFF,
  0x80, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x3F, 0xF8, 0xFF, 0xE2, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0xBE, 0x07, 0xFF, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07,
  0x80, 0x3B, 0xC3, 0xC7, 0xFC, 0x00, 0x03, 0xF8, 0x1E, 0x10, 0x70, 0x01,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x8F,
  0xC3, 0x71, 0xE7, 0x80, 0xCE, 0x00, 0xD8, 0x01, 0xB0, 0x01, 0xE0, 0x03,
  0xC0, 0x06, 0x80, 0x09, 0x80, 0x33, 0x00, 0x63, 0x01, 0x83, 0x8F, 0x03,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80,
  0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x00, 0x0F, 0xE0,
  0xF3, 0xC7, 0x01, 0x98, 0x06, 0x40, 0x0D, 0x00, 0x36, 0x00, 0x98, 0x06,
  0x30, 0x30, 0x71, 0x80, 0xFC, 0x03, 0xF0, 0x38, 0x71, 0x80, 0x6E, 0x00,
  0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x60, 0x18, 0xE1,
  0xE1, 0xFE, 0x00, 0x1F, 0xC0, 0xF3, 0x86, 0x03, 0x30, 0x06, 0xC0, 0x0B,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xD8, 0x07,
  0x78, 0x6C, 0x7F, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01,
  0x80, 0x0C, 0x00, 0x61, 0x07, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x37, 0x30, 0x00, 0x00, 0x00, 0x00, 0x03, 0x36, 0x66, 0x64, 0xC0,
  0x00, 0x06, 0x00, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0x60, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0x80, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x3C,
  0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x1C, 0x00, 0x20, 0x00, 0x00,
  0x7F, 0x8F, 0xFC, 0x80, 0x60, 0x06, 0x00, 0x20, 0x03, 0x00, 0x20, 0x06,
  0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xC0, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x1C, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xE0, 0x0E, 0x01, 0x80, 0x03, 0x81,
  0x80, 0x00, 0x61, 0x80, 0x00, 0x30, 0x80, 0x00, 0x0C, 0xC0, 0xFF, 0x86,
  0x40, 0xE0, 0x81, 0x60, 0xC0, 0x40, 0xF0, 0x60, 0x20, 0x78, 0x20, 0x10,
  0x38, 0x30, 0x08, 0x1C, 0x18, 0x04, 0x0E, 0x0C, 0x06, 0x05, 0x06, 0x03,
  0x02, 0xC1, 0x01, 0x83, 0x60, 0xC1, 0x63, 0x30, 0x3F, 0x1F, 0x08, 0x02,
  0x02, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x80, 0x07, 0xEF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x58, 0x00, 0x19, 0x00, 0x03, 0x30, 0x00,
  0xC6, 0x00, 0x18, 0x60, 0x03, 0x0C, 0x00, 0xC1, 0x80, 0x18, 0x18, 0x06,
  0x03, 0x00, 0xC0, 0x20, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0xC0, 0x0C, 0x10,
  0x01, 0x86, 0x00, 0x30, 0xC0, 0x03, 0x30, 0x00, 0x66, 0x00, 0x06, 0xC0,
  0x00, 0xF0, 0x00, 0x18, 0xFF, 0xC1, 0xFF, 0xF3, 0x00, 0x76, 0x00, 0x6C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0D, 0x80, 0x33, 0xFF,
  0xC7, 0xFF, 0x8C, 0x01, 0xD8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x01, 0xDF, 0xFF, 0x3F, 0xF8, 0x00,
  0x01, 0xFE, 0x03, 0xFF, 0xC7, 0x80, 0x23, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x7C, 0x38, 0x0F,
  0xFC, 0xFF, 0xC0, 0x3F, 0xFE, 0x0C, 0x01, 0xC3, 0x00, 0x18, 0xC0, 0x03,
  0x30, 0x00, 0xEC, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1B, 0x00,
  0x06, 0xC0, 0x01, 0xB0, 0x00, 0xEC, 0x00, 0x33, 0x00, 0x18, 0xC0, 0x1C,
  0x3F, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x3F, 0xFD, 0xFF,
  0xEC, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0xFF, 0xEF, 0xFF, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0xFD, 0xF8, 0x38, 0x01, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x60,
  0x00, 0x6C, 0x00, 0x0C, 0xC0, 0x01, 0x9C, 0x00, 0x31, 0xC0, 0x06, 0x1F,
  0x87, 0xC0, 0xFF, 0xE0, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x06, 0xFD, 0xE3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xCF, 0xC0, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x06, 0xFC, 0x78, 0xC0, 0x07, 0xC0, 0x0C, 0xC0, 0x18, 0xC0, 0x30,
  0xC0, 0x60, 0xC0, 0xC0, 0xC1, 0xC0, 0xC3, 0x80, 0xC7, 0x00, 0xCE, 0x00,
  0xDE, 0x00, 0xDE, 0x00, 0xF3, 0x00, 0xC1, 0x80, 0xC1, 0xC0, 0xC0, 0xC0,
  0xC0, 0x60, 0xC0, 0x30, 0xC0, 0x38, 0xC0, 0x18, 0xC0, 0x0C, 0xC0, 0x0E,
  0xC0, 0x07, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0B, 0xD8, 0x00, 0x6F, 0x60, 0x01, 0xBC, 0xC0, 0x0C, 0xF3,
  0x00, 0x33, 0xCC, 0x00, 0x8F, 0x18, 0x06, 0x3C, 0x60, 0x18, 0xF0, 0x80,
  0xC3, 0xC3, 0x03, 0x0F, 0x0C, 0x08, 0x3C, 0x18, 0x60, 0xF0, 0x61, 0x83,
  0xC0, 0x8C, 0x0F, 0x03, 0x30, 0x3C, 0x0C, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x00, 0xC0, 0x3C, 0x03, 0x00, 0xC0, 0xC0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3D, 0x80, 0x1E, 0x60, 0x0F, 0x30, 0x07, 0x8C,
  0x03, 0xC3, 0x01, 0xE1, 0x80, 0xF0, 0x60, 0x78, 0x18, 0x3C, 0x0C, 0x1E,
  0x03, 0x0F, 0x01, 0xC7, 0x80, 0x63, 0xC0, 0x19, 0xE0, 0x0E, 0xF0, 0x03,
  0x78, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x06, 0x03, 0xFE, 0x00,
  0x7E, 0xF8, 0x07, 0x00, 0x70, 0x70, 0x01, 0x83, 0x00, 0x06, 0x30, 0x00,
  0x31, 0x80, 0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x36, 0x00, 0x01, 0xB0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1B, 0x00, 0x00,
  0xD8, 0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x03, 0x0C, 0x00, 0x18, 0x70,
  0x01, 0x81, 0xC0, 0x1C, 0x07, 0xC7, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x83,
  0xFF, 0xCC, 0x03, 0xB0, 0x06, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xB0, 0x1C, 0xFF, 0xE3, 0xF8, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x7E, 0xF8, 0x07, 0x00, 0x70, 0x70,
  0x01, 0x83, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80, 0x00, 0xD8, 0x00, 0x06,
  0xC0, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00, 0x06, 0x60, 0x00, 0x33,
  0x00, 0x03, 0x0C, 0x00, 0x18, 0x70, 0x01, 0x81, 0xC0, 0x1C, 0x07, 0xC7,
  0x80, 0x0F, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0xFF, 0x80, 0xFF, 0xF0, 0xC0, 0x38, 0xC0,
  0x1C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0,
  0x18, 0xC0, 0x38, 0xC1, 0xF0, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0x60, 0xC0, 0x70, 0xC0, 0x30, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x0C, 0xC0,
  0x0E, 0xC0, 0x07, 0x0F, 0xF0, 0xFF, 0xE6, 0x00, 0xB0, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0,
  0x01, 0xE0, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x06, 0x80, 0x3B, 0xC3, 0xCF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xD8,
  0x00, 0x6C, 0x00, 0x63, 0x00, 0x60, 0xF9, 0xE0, 0x3F, 0xE0, 0xC0, 0x00,
  0xF8, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x03,
  0x0C, 0x00, 0xC0, 0xC0, 0x18, 0x18, 0x03, 0x03, 0x00, 0xC0, 0x30, 0x18,
  0x06, 0x06, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x01, 0x86, 0x00, 0x18, 0xC0,
  0x03, 0x18, 0x00, 0x66, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x78, 0x01, 0xC0, 0x0F,
  0x00, 0x38, 0x01, 0x30, 0x0D, 0x00, 0x66, 0x01, 0xB0, 0x0C, 0xC0, 0x36,
  0x01, 0x98, 0x04, 0xC0, 0x61, 0x81, 0x88, 0x0C, 0x30, 0x31, 0x81, 0x86,
  0x04, 0x30, 0x30, 0x41, 0x86, 0x0C, 0x0C, 0x30, 0x61, 0x81, 0x86, 0x0C,
  0x30, 0x30, 0x81, 0x84, 0x02, 0x30, 0x11, 0x80, 0x66, 0x03, 0x30, 0x0C,
  0xC0, 0x66, 0x01, 0xB0, 0x0D, 0x80, 0x16, 0x00, 0xB0, 0x03, 0xC0, 0x1E,
  0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x60,
  0x01, 0x8C, 0x00, 0xC3, 0x00, 0x60, 0x60, 0x18, 0x18, 0x0C, 0x03, 0x03,
  0x00, 0x61, 0x80, 0x18, 0xC0, 0x03, 0x30, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0xD8, 0x00, 0x23, 0x00, 0x18, 0x60, 0x0C,
  0x18, 0x03, 0x03, 0x01, 0x80, 0x60, 0xC0, 0x18, 0x30, 0x03, 0x18, 0x00,
  0xEC, 0x00, 0x1C, 0xC0, 0x01, 0xB0, 0x01, 0x98, 0x00, 0xC6, 0x00, 0xC3,
  0x00, 0x60, 0xC0, 0x60, 0x60, 0x30, 0x18, 0x30, 0x06, 0x18, 0x03, 0x18,
  0x00, 0xCC, 0x00, 0x6C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x0F, 0xFF, 0xC0,
  0x0C, 0x01, 0x80, 0x10, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x18, 0x01,
  0x80, 0x30, 0x02, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x30,
  0x06, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x18, 0xFF, 0xFC, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0F, 0xFF, 0xF0, 0x01, 0x80, 0x01, 0x80,
  0x03, 0xC0, 0x02, 0x40, 0x06, 0x60, 0x04, 0x20, 0x0C, 0x30, 0x08, 0x18,
  0x18, 0x18, 0x10, 0x0C, 0x30, 0x0C, 0x20, 0x06, 0x60, 0x06, 0xC0, 0x03,
  0xFF, 0xF8, 0xC1, 0x83, 0x06, 0x08, 0x10, 0x0F, 0xE0, 0xF1, 0xC2, 0x01,
  0x80, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0xFF, 0x1F, 0x8C, 0xC0,
  0x36, 0x00, 0xD8, 0x03, 0xC0, 0x1D, 0x80, 0x76, 0x02, 0xDC, 0x3B, 0x3F,
  0x8C, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x33, 0xF8, 0xD8, 0x73, 0x80, 0x6E, 0x01, 0xB0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xE0, 0x1A, 0x80, 0xE9, 0xCF, 0x23, 0xF8, 0x0F, 0xF1, 0xC3, 0x30, 0x06,
  0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0xC7, 0x0F, 0xF0, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x43, 0xF1, 0x3C,
  0x75, 0xC0, 0x56, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x60, 0x0D, 0xC0, 0x53,
  0xC7, 0x47, 0xF1, 0x0F, 0xE0, 0xF1, 0xC3, 0x03, 0x98, 0x06, 0xC0, 0x0B,
  0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x80, 0x07, 0x00, 0x0F, 0x8E, 0x0F, 0xF0, 0x07, 0xF0, 0xE1,
  0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x0F, 0xF8, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0F, 0xE4, 0xE1,
  0xD7, 0x01, 0x58, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0D, 0x80, 0x37, 0x01, 0x4F,
  0x3D, 0x1F, 0xC4, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x76,
  0x03, 0x9F, 0xFC, 0x07, 0x80, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x19, 0xFC, 0xD8, 0x77, 0x00, 0xF8, 0x07, 0x80,
  0x3C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x7C, 0x00, 0x1B, 0x6D,
  0xB6, 0xDB, 0x6D, 0xB6, 0xD8, 0x06, 0x1C, 0x00, 0x00, 0x00, 0x01, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0xDF, 0x9C, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x0E, 0xC0, 0x66,
  0x06, 0x30, 0x61, 0x86, 0x0C, 0x60, 0x66, 0x03, 0x70, 0x1F, 0x80, 0xE6,
  0x06, 0x18, 0x30, 0xE1, 0x83, 0x0C, 0x0C, 0x60, 0x33, 0x01, 0xD8, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xC3, 0xF9, 0x71, 0xCE, 0x3B,
  0x80, 0xF0, 0x36, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x06, 0x00, 0xF0,
  0x0C, 0x01, 0xE0, 0x18, 0x03, 0xC0, 0x30, 0x07, 0x80, 0x60, 0x0F, 0x00,
  0xC0, 0x1E, 0x01, 0x80, 0x3C, 0x03, 0x00, 0x78, 0x06, 0x00, 0xF0, 0x0C,
  0x01, 0xE0, 0x18, 0x03, 0xC0, 0x30, 0x06, 0x8F, 0xE4, 0xE3, 0xB8, 0x07,
  0xC0, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x08, 0x0F,
  0xE0, 0x78, 0xF1, 0xC0, 0x63, 0x00, 0x6C, 0x00, 0xD8, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xCC,
  0x01, 0x8C, 0x06, 0x1E, 0x3C, 0x0F, 0xE0, 0x8F, 0xE2, 0x61, 0xCF, 0x01,
  0xB8, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x6E, 0x03, 0xB6, 0x1C, 0xCF,
  0xE3, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0x1F, 0xC4, 0xF1, 0xD7, 0x01, 0x58, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0D, 0x80, 0x77, 0x01, 0x4F, 0x19, 0x1F, 0xC4, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x8F,
  0xCE, 0x7C, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x00, 0x1F, 0xF1, 0xC3, 0x98, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x00,
  0x0C, 0x00, 0x60, 0x01, 0x80, 0x0A, 0x00, 0xDE, 0x1C, 0x7F, 0xC0, 0x18,
  0x06, 0x01, 0x80, 0x60, 0xFF, 0xC6, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x31,
  0x07, 0xC0, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0,
  0x1F, 0x00, 0xAE, 0x19, 0x3F, 0x88, 0xC0, 0x06, 0xC0, 0x19, 0x80, 0x33,
  0x00, 0x63, 0x01, 0x86, 0x03, 0x0C, 0x06, 0x0C, 0x18, 0x18, 0x30, 0x18,
  0xC0, 0x31, 0x80, 0x63, 0x00, 0x6C, 0x00, 0xD8, 0x00, 0xA0, 0x01, 0xC0,
  0x03, 0x80, 0xE0, 0x18, 0x06, 0xC0, 0x70, 0x0D, 0x80, 0xF0, 0x13, 0x01,
  0x60, 0x63, 0x02, 0x40, 0xC6, 0x0C, 0xC1, 0x8C, 0x19, 0x86, 0x08, 0x23,
  0x0C, 0x18, 0xC3, 0x18, 0x31, 0x86, 0x30, 0x62, 0x0C, 0xC0, 0x4C, 0x09,
  0x80, 0xD8, 0x1B, 0x01, 0xA0, 0x34, 0x01, 0xC0, 0x28, 0x03, 0x80, 0x70,
  0x06, 0x00, 0xE0, 0xC0, 0x0D, 0x80, 0x63, 0x03, 0x0E, 0x1C, 0x18, 0x60,
  0x33, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x00, 0x1E, 0x00, 0xCC, 0x03, 0x30,
  0x18, 0x60, 0xC0, 0xC7, 0x03, 0x98, 0x06, 0xC0, 0x0C, 0xC0, 0x06, 0xC0,
  0x09, 0x80, 0x33, 0x00, 0x63, 0x01, 0x86, 0x03, 0x04, 0x06, 0x0C, 0x18,
  0x18, 0x30, 0x18, 0x40, 0x31, 0x80, 0x23, 0x00, 0x6C, 0x00, 0xD8, 0x00,
  0xA0, 0x01, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x7F, 0xF0, 0x01, 0x80,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1F, 0xFF, 0xFF, 0xF8,
  0x01, 0x83, 0xC3, 0x01, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x03, 0x01, 0x87, 0x83, 0x80, 0x70, 0x18, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x0C, 0x06, 0x01, 0xE0, 0x70, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3E, 0x01, 0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x06, 0x00, 0xF0, 0x3C, 0x18, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x0F, 0x83, 0x80, 0x7C,
  0x03, 0xFF, 0x0E, 0x07, 0xF0,
};

const GFXglyph NotoSans_Light32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 23, 8, 3, -23 },
  { 7, 7, 8, 12, 2, -23 },
  { 14, 19, 23, 21, 1, -23 },
  { 69, 14, 26, 18, 2, -24 },
  { 115, 22, 23, 26, 2, -23 },
  { 179, 20, 23, 23, 2, -23 },
  { 237, 2, 8, 6, 2, -23 },
  { 239, 7, 28, 9, 1, -23 },
  { 264, 7, 28, 9, 1, -23 },
  { 289, 14, 13, 18, 2, -24 },
  { 312, 15, 15, 18, 2, -19 },
  { 341, 4, 8, 7, 1, -4 },
  { 345, 8, 1, 10, 1, -9 },
  { 346, 2, 3, 8, 3, -3 },
  { 347, 11, 23, 11, 0, -23 },
  { 379, 14, 23, 18, 2, -23 },
  { 420, 8, 23, 18, 3, -23 },
  { 443, 14, 23, 18, 2, -23 },
  { 484, 15, 23, 18, 1, -23 },
  { 528, 17, 23, 18, 1, -23 },
  { 577, 14, 23, 18, 2, -23 },
  { 618, 15, 23, 18, 2, -23 },
  { 662, 15, 23, 18, 2, -23 },
  { 706, 14, 23, 18, 2, -23 },
  { 747, 14, 23, 18, 2, -23 },
  { 788, 2, 17, 8, 3, -17 },
  { 793, 4, 21, 8, 1, -17 },
  { 804, 15, 15, 18, 2, -19 },
  { 833, 14, 8, 18, 2, -15 },
  { 847, 15, 15, 18, 2, -19 },
  { 876, 12, 23, 14, 1, -23 },
  { 911, 25, 26, 28, 2, -23 },
  { 993, 19, 23, 19, 0, -23 },
  { 1048, 15, 23, 20, 3, -23 },
  { 1092, 17, 23, 20, 2, -23 },
  { 1141, 18, 23, 23, 3, -23 },
  { 1193, 13, 23, 18, 3, -23 },
  { 1231, 13, 23, 16, 3, -23 },
  { 1269, 19, 23, 23, 2, -23 },
  { 1324, 17, 23, 23, 3, -23 },
  { 1373, 6, 23, 10, 2, -23 },
  { 1391, 8, 29, 8, -3, -23 },
  { 1420, 16, 23, 19, 3, -23 },
  { 1466, 13, 23, 16, 3, -23 },
  { 1504, 22, 23, 28, 3, -23 },
  { 1568, 17, 23, 23, 3, -23 },
  { 1617, 21, 23, 25, 2, -23 },
  { 1678, 14, 23, 19, 3, -23 },
  { 1719, 21, 28, 25, 2, -23 },
  { 1793, 16, 23, 19, 3, -23 },
  { 1839, 14, 23, 17, 2, -23 },
  { 1880, 17, 23, 17, 0, -23 },
  { 1929, 17, 23, 23, 3, -23 },
  { 1978, 19, 23, 19, 0, -23 },
  { 2033, 27, 23, 29, 1, -23 },
  { 2111, 18, 23, 18, 0, -23 },
  { 2163, 17, 23, 17, 0, -23 },
  { 2212, 16, 23, 18, 1, -23 },
  { 2258, 6, 28, 10, 3, -23 },
  { 2279, 11, 23, 11, 0, -23 },
  { 2311, 7, 28, 10, 1, -23 },
  { 2336, 16, 14, 18, 1, -23 },
  { 2364, 13, 1, 13, 0, 3 },
  { 2366, 6, 6, 8, 1, -25 },
  { 2371, 14, 17, 17, 1, -17 },
  { 2401, 14, 24, 19, 3, -24 },
  { 2443, 12, 17, 15, 2, -17 },
  { 2469, 14, 24, 19, 2, -24 },
  { 2511, 14, 17, 18, 2, -17 },
  { 2541, 12, 24, 10, 0, -24 },
  { 2577, 14, 25, 19, 2, -17 },
  { 2621, 13, 24, 19, 3, -24 },
  { 2660, 3, 23, 7, 2, -23 },
  { 2669, 7, 31, 7, -2, -23 },
  { 2697, 13, 24, 16, 3, -24 },
  { 2736, 2, 24, 7, 3, -24 },
  { 2742, 23, 17, 29, 3, -17 },
  { 2791, 13, 17, 19, 3, -17 },
  { 2819, 15, 17, 19, 2, -17 },
  { 2851, 14, 25, 19, 3, -17 },
  { 2895, 14, 25, 19, 2, -17 },
  { 2939, 9, 17, 13, 3, -17 },
  { 2959, 13, 17, 15, 1, -17 },
  { 2987, 10, 21, 11, 0, -21 },
  { 3014, 13, 17, 19, 3, -17 },
  { 3042, 15, 17, 15, 0, -17 },
  { 3074, 23, 17, 24, 0, -17 },
  { 3123, 14, 17, 16, 1, -17 },
  { 3153, 15, 25, 15, 0, -17 },
  { 3200, 13, 17, 15, 1, -17 },
  { 3228, 9, 28, 11, 1, -23 },
  { 3260, 1, 32, 17, 8, -24 },
  { 3264, 10, 28, 11, 1, -23 },
  { 3299, 15, 3, 18, 2, -13 },
};

const GFXfont NotoSans_Light32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light32pt7bBitmaps,
  (GFXglyph *)NotoSans_Light32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_LIGHT32PT7B_H_
