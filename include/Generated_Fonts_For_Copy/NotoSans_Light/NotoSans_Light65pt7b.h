#ifndef _NOTOSANS_LIGHT65PT7B_H_
#define _NOTOSANS_LIGHT65PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light65pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE3, 0x8E, 0x38, 0xC3,
  0x0C, 0x30, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x31, 0xEF, 0xFF, 0xFD, 0xE3,
  0x00, 0xF8, 0x1E, 0xE0, 0x3D, 0xC0, 0x7B, 0x80, 0xF7, 0x01, 0xEE, 0x03,
  0xDC, 0x03, 0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x1D, 0xC0, 0x3B, 0x80, 0x77,
  0x00, 0xEE, 0x01, 0xDC, 0x03, 0x38, 0x06, 0x00, 0x01, 0xC0, 0x07, 0x00,
  0x00, 0x0F, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x00, 0xE0,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x00, 0x07, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00,
  0x03, 0xC0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x3C,
  0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x0F, 0x00,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x03, 0x80, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0x00, 0x70, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x00,
  0x03, 0x80, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFC, 0x3F, 0x0E, 0x07, 0xC3, 0xC0, 0xE0, 0x08, 0x78, 0x0E, 0x00,
  0x07, 0x80, 0xE0, 0x00, 0xF0, 0x0E, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0xF0,
  0x0E, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0xF0, 0x0E, 0x00, 0x0F, 0x00, 0xE0,
  0x00, 0x78, 0x0E, 0x00, 0x07, 0xC0, 0xE0, 0x00, 0x3E, 0x0E, 0x00, 0x03,
  0xF0, 0xE0, 0x00, 0x1F, 0xEE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x0E, 0x7F, 0x80, 0x00, 0xE0, 0xFC, 0x00, 0x0E, 0x07, 0xE0, 0x00,
  0xE0, 0x1E, 0x00, 0x0E, 0x01, 0xF0, 0x00, 0xE0, 0x0F, 0x00, 0x0E, 0x00,
  0xF0, 0x00, 0xE0, 0x0F, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0xE0, 0x0F, 0x00,
  0x0E, 0x00, 0xF0, 0x00, 0xE0, 0x0E, 0x00, 0x0E, 0x01, 0xE8, 0x00, 0xE0,
  0x3C, 0xF0, 0x0E, 0x0F, 0xCF, 0xF8, 0xEF, 0xF8, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x78, 0x3E, 0x00,
  0x01, 0xC0, 0x07, 0x80, 0x70, 0x00, 0x1E, 0x00, 0x38, 0x03, 0xC0, 0x00,
  0xE0, 0x01, 0xC0, 0x0E, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0x38, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0x0E,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x70, 0x00, 0xE0, 0x1E, 0x00, 0x03, 0x80,
  0x07, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x38, 0x0F, 0x00, 0x00, 0xE0, 0x01,
  0xC0, 0x70, 0x00, 0x07, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x38, 0x00, 0x70,
  0x38, 0x00, 0x01, 0xC0, 0x07, 0x83, 0xC1, 0xFE, 0x0E, 0x00, 0x38, 0x1C,
  0x3F, 0xF8, 0x78, 0x01, 0xC1, 0xC1, 0xF3, 0xE1, 0xC0, 0x0E, 0x1E, 0x1E,
  0x07, 0x8E, 0x00, 0xF0, 0xE1, 0xE0, 0x1E, 0x78, 0x0F, 0x0F, 0x0E, 0x00,
  0x71, 0xE0, 0xF8, 0x70, 0x70, 0x03, 0x87, 0xFF, 0x87, 0x87, 0x80, 0x1E,
  0x1F, 0xF8, 0x38, 0x38, 0x00, 0x70, 0x3F, 0x03, 0xC1, 0xC0, 0x03, 0x80,
  0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0x00,
  0x1E, 0x03, 0x80, 0x07, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0xE0, 0x01, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x38, 0x00, 0x70, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x80, 0x03, 0xC0, 0x0E,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0,
  0x0F, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x70, 0x03,
  0x80, 0x0F, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x70, 0x00, 0x0F, 0x03, 0xC0,
  0x07, 0x80, 0x00, 0x3C, 0x3E, 0x00, 0x38, 0x00, 0x01, 0xFF, 0xE0, 0x03,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xF3, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x0F, 0x07,
  0xC0, 0x3E, 0x00, 0x07, 0x87, 0xC0, 0x0F, 0x80, 0x03, 0xC7, 0xC0, 0x03,
  0xE0, 0x01, 0xC3, 0xC0, 0x00, 0xF8, 0x01, 0xE3, 0xE0, 0x00, 0x3E, 0x00,
  0xF1, 0xE0, 0x00, 0x0F, 0x80, 0xF0, 0xF0, 0x00, 0x03, 0xE0, 0x78, 0x78,
  0x00, 0x00, 0xF8, 0x78, 0x3C, 0x00, 0x00, 0x3E, 0x3C, 0x1E, 0x00, 0x00,
  0x0F, 0xBC, 0x0F, 0x00, 0x00, 0x03, 0xFC, 0x07, 0x80, 0x00, 0x00, 0xFE,
  0x03, 0xC0, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x78,
  0x00, 0x00, 0x3F, 0xE0, 0x3E, 0x00, 0x00, 0x7E, 0xF8, 0x0F, 0xC0, 0x00,
  0x7E, 0x3E, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0x80, 0xFF, 0xFF, 0xFC, 0x03,
  0xE0, 0x3F, 0xFF, 0xF8, 0x00, 0xF8, 0x07, 0xFF, 0xF0, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xFB, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7,
  0x39, 0xCE, 0x00, 0xF8, 0x07, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0,
  0x1C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01,
  0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xF8, 0x01, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0x80,
  0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0,
  0x0F, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E,
  0x00, 0xE0, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x38, 0x01, 0xDF, 0x81, 0xC0, 0xFE, 0xFF, 0x86, 0x3F, 0xFF,
  0xFF, 0xBF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x3C,
  0x00, 0x00, 0xF0, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00,
  0x07, 0x80, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x60, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1E, 0x3C, 0x78, 0xF3, 0xC7, 0x8F, 0x1E, 0x38, 0xF1,
  0xE3, 0x87, 0x1E, 0x38, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x31,
  0xEF, 0xFF, 0xFD, 0xE3, 0x00, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0xF8, 0x00, 0xF8,
  0x07, 0x80, 0x03, 0xE0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x3C,
  0x00, 0x01, 0xE1, 0xC0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x01, 0xE7, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xDC, 0x00, 0x00,
  0x1C, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC0, 0xF8,
  0x00, 0x1E, 0x03, 0xE0, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFF, 0x03, 0xEF, 0x07, 0xCF,
  0x0F, 0x8F, 0x3F, 0x0F, 0x7C, 0x0F, 0xF8, 0x0F, 0x70, 0x0F, 0x20, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xC1, 0xFE, 0x0F, 0xE0,
  0x01, 0xF0, 0x3C, 0x00, 0x07, 0xC0, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8,
  0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x0F, 0x83, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF2, 0x00, 0x00, 0x07,
  0xCE, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x03, 0xC3, 0x80, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x07, 0x81, 0xC0,
  0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x0F, 0x00,
  0xE0, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x01, 0xE0, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x07, 0x80, 0x00,
  0x70, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x0F, 0x00,
  0x00, 0x38, 0x03, 0xC0, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x3F, 0xF8, 0x00, 0x7F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3C, 0x80, 0x00, 0x03, 0xE7, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x0F,
  0xE1, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xC0, 0x10, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x7E, 0x00, 0x1C, 0x0F, 0xFF, 0x80, 0xF0, 0xFF, 0xFF, 0x03, 0xCF,
  0xE0, 0xFF, 0x0F, 0x7C, 0x00, 0x7E, 0x3D, 0xC0, 0x00, 0x78, 0xFE, 0x00,
  0x00, 0xF3, 0xF0, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x07, 0xBE, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x3E, 0x01, 0xF8, 0x03,
  0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xC0, 0x7F, 0x01, 0xF0, 0x00, 0x7C, 0x0F, 0x00, 0x01,
  0xF0, 0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x3C, 0x1E, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x3C, 0x03, 0xF0, 0x07, 0xC0,
  0x07, 0xE0, 0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x3F, 0x01,
  0xF8, 0x03, 0xE0, 0x03, 0xE0, 0x3C, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0xF8, 0x3F, 0x00, 0x1F, 0x80, 0xFF, 0xDF, 0xF8, 0x03, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFC, 0x0F, 0xC0,
  0x0F, 0x80, 0x0F, 0x80, 0x7C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01, 0xC7, 0x80,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x3B, 0xC0, 0x00,
  0x00, 0xEF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3D, 0xC0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x0F, 0xCF,
  0x80, 0x00, 0x7F, 0x1F, 0x00, 0x07, 0xBC, 0x3F, 0x00, 0x7C, 0xF0, 0x7F,
  0xFF, 0xE3, 0xC0, 0xFF, 0xFF, 0x0F, 0x00, 0xFF, 0xE0, 0x3C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xBF, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7B, 0xFF, 0xFF,
  0xFD, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC7, 0xBF, 0xFF, 0xF7, 0x8C,
  0x0F, 0x0F, 0xC7, 0xE3, 0xF1, 0xF8, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0xF0, 0xF8, 0x78, 0x3C,
  0x1E, 0x0F, 0x0F, 0x07, 0x83, 0xC1, 0xC0, 0xE0, 0xF0, 0x70, 0x38, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0x83, 0xFF, 0xFF, 0xC7, 0xF8, 0x3F,
  0xCF, 0x00, 0x0F, 0xC8, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xE3, 0xC0,
  0x01, 0xFF, 0xFF, 0x00, 0x38, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x0E, 0x78,
  0x00, 0x7C, 0x00, 0xF0, 0x03, 0xDC, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0xF7,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x1F, 0xC0, 0x07, 0x00, 0x03, 0x80, 0x07,
  0xF0, 0x03, 0xC0, 0x00, 0xE0, 0x01, 0xF8, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x7E, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x1F, 0x80, 0x1E, 0x00, 0x03, 0x80,
  0x07, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x01, 0xF8, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x7E, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x1F, 0x80, 0x1C, 0x00, 0x03,
  0x80, 0x07, 0xE0, 0x07, 0x00, 0x01, 0xE0, 0x03, 0xF8, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0xEE, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x3B, 0x80, 0x1E, 0x00,
  0x07, 0x80, 0x0E, 0xE0, 0x03, 0x80, 0x03, 0xE0, 0x07, 0x38, 0x00, 0xF0,
  0x01, 0xDC, 0x03, 0xCF, 0x00, 0x3E, 0x00, 0xF7, 0x00, 0xE3, 0xC0, 0x07,
  0xC0, 0x79, 0xE0, 0xF8, 0x70, 0x00, 0xFF, 0xFC, 0x3F, 0xFC, 0x1C, 0x00,
  0x1F, 0xFE, 0x07, 0xFC, 0x07, 0x80, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x01, 0xE7, 0x00, 0x00,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x0F, 0xF0, 0xF0, 0x00, 0x01, 0xF0, 0xF0,
  0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x7C, 0xF0,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x0F, 0xC0, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xF0,
  0x00, 0x7F, 0xE0, 0xF0, 0x00, 0x03, 0xF0, 0xF0, 0x00, 0x00, 0xF8, 0xF0,
  0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3E, 0xF0,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0xF8, 0xF0,
  0x00, 0x03, 0xF0, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xC1, 0xFF,
  0x00, 0xFE, 0x00, 0x03, 0xC0, 0x7E, 0x00, 0x00, 0x20, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x04, 0x03, 0xFC,
  0x00, 0x1E, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x01, 0xFF,
  0x00, 0xF0, 0x00, 0x03, 0xF8, 0x0F, 0x00, 0x00, 0x0F, 0xC0, 0xF0, 0x00,
  0x00, 0x3E, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0x0F, 0x8F,
  0x00, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x03, 0xEF,
  0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x01, 0xF0, 0xF0, 0x00,
  0x00, 0x3E, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x01, 0xF8, 0x0F,
  0x00, 0x00, 0xFF, 0x00, 0xF0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFB, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xBC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0xF8, 0x07, 0xF0,
  0x00, 0x00, 0x40, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00, 0x3D, 0xF0,
  0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00,
  0x0F, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x00, 0x0F, 0x07, 0xE0, 0x00, 0x00,
  0x3C, 0x0F, 0xC0, 0x00, 0x00, 0xF0, 0x1F, 0xC0, 0x00, 0x03, 0xC0, 0x3F,
  0xE0, 0x00, 0x7F, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFC, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x1F,
  0xFE, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x7C, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0x3F,
  0x80, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00,
  0xF8, 0xF0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x07,
  0xC0, 0xF0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x01, 0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0xF0, 0x07, 0x80,
  0x00, 0xF0, 0x0F, 0x80, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0xF0, 0x3E, 0x00,
  0x00, 0xF0, 0x7C, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0xF1, 0xFC, 0x00,
  0x00, 0xF3, 0xFC, 0x00, 0x00, 0xF7, 0xBE, 0x00, 0x00, 0xFF, 0x1F, 0x00,
  0x00, 0xFE, 0x0F, 0x80, 0x00, 0xFC, 0x07, 0x80, 0x00, 0xF8, 0x07, 0xC0,
  0x00, 0xF0, 0x03, 0xE0, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x03,
  0xE0, 0xF0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00,
  0xF8, 0xF0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0x7F, 0x78, 0x00, 0x00, 0x00, 0xF7, 0xF7, 0x80, 0x00, 0x00,
  0x0E, 0x7F, 0x38, 0x00, 0x00, 0x01, 0xEF, 0xF3, 0xC0, 0x00, 0x00, 0x1E,
  0xFF, 0x3C, 0x00, 0x00, 0x01, 0xCF, 0xF1, 0xE0, 0x00, 0x00, 0x3C, 0xFF,
  0x1E, 0x00, 0x00, 0x03, 0x8F, 0xF0, 0xE0, 0x00, 0x00, 0x78, 0xFF, 0x0F,
  0x00, 0x00, 0x07, 0x8F, 0xF0, 0xF0, 0x00, 0x00, 0x70, 0xFF, 0x07, 0x00,
  0x00, 0x0F, 0x0F, 0xF0, 0x78, 0x00, 0x00, 0xE0, 0xFF, 0x07, 0x80, 0x00,
  0x1E, 0x0F, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0xFF, 0x03, 0xC0, 0x00, 0x1C,
  0x0F, 0xF0, 0x1C, 0x00, 0x03, 0xC0, 0xFF, 0x01, 0xE0, 0x00, 0x38, 0x0F,
  0xF0, 0x1E, 0x00, 0x07, 0x80, 0xFF, 0x00, 0xF0, 0x00, 0x78, 0x0F, 0xF0,
  0x0F, 0x00, 0x07, 0x00, 0xFF, 0x00, 0x70, 0x00, 0xF0, 0x0F, 0xF0, 0x07,
  0x80, 0x0E, 0x00, 0xFF, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0xF0, 0x03, 0xC0,
  0x1E, 0x00, 0xFF, 0x00, 0x3C, 0x01, 0xC0, 0x0F, 0xF0, 0x01, 0xC0, 0x3C,
  0x00, 0xFF, 0x00, 0x1E, 0x03, 0x80, 0x0F, 0xF0, 0x01, 0xE0, 0x78, 0x00,
  0xFF, 0x00, 0x0F, 0x07, 0x80, 0x0F, 0xF0, 0x00, 0xF0, 0x70, 0x00, 0xFF,
  0x00, 0x07, 0x0F, 0x00, 0x0F, 0xF0, 0x00, 0x78, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0x9E, 0x00, 0x0F, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0xFF, 0x00, 0x03,
  0xDC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x03, 0xFD, 0xE0, 0x00, 0x00, 0x7F, 0xBE, 0x00, 0x00, 0x0F, 0xF3,
  0xC0, 0x00, 0x01, 0xFE, 0x3C, 0x00, 0x00, 0x3F, 0xC7, 0xC0, 0x00, 0x07,
  0xF8, 0x78, 0x00, 0x00, 0xFF, 0x07, 0x80, 0x00, 0x1F, 0xE0, 0xF8, 0x00,
  0x03, 0xFC, 0x0F, 0x00, 0x00, 0x7F, 0x80, 0xF0, 0x00, 0x0F, 0xF0, 0x1F,
  0x00, 0x01, 0xFE, 0x01, 0xE0, 0x00, 0x3F, 0xC0, 0x1E, 0x00, 0x07, 0xF8,
  0x03, 0xE0, 0x00, 0xFF, 0x00, 0x3C, 0x00, 0x1F, 0xE0, 0x03, 0xC0, 0x03,
  0xFC, 0x00, 0x7C, 0x00, 0x7F, 0x80, 0x07, 0x80, 0x0F, 0xF0, 0x00, 0x78,
  0x01, 0xFE, 0x00, 0x0F, 0x80, 0x3F, 0xC0, 0x00, 0xF0, 0x07, 0xF8, 0x00,
  0x0F, 0x00, 0xFF, 0x00, 0x01, 0xF0, 0x1F, 0xE0, 0x00, 0x1E, 0x03, 0xFC,
  0x00, 0x01, 0xE0, 0x7F, 0x80, 0x00, 0x3E, 0x0F, 0xF0, 0x00, 0x03, 0xC1,
  0xFE, 0x00, 0x00, 0x3C, 0x3F, 0xC0, 0x00, 0x07, 0xC7, 0xF8, 0x00, 0x00,
  0x78, 0xFF, 0x00, 0x00, 0x07, 0x9F, 0xE0, 0x00, 0x00, 0xFB, 0xFC, 0x00,
  0x00, 0x0F, 0x7F, 0x80, 0x00, 0x00, 0xF7, 0xF0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x81, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC1, 0xE0, 0x00, 0xFF,
  0x0F, 0x00, 0x00, 0xFC, 0x78, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x07, 0xDE,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x3E, 0x78, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x7E, 0x1E, 0x00, 0x7F,
  0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x81, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0xF0, 0x00, 0x3F, 0xC0, 0xF0, 0x00, 0x07, 0xE0, 0xF0, 0x00,
  0x03, 0xE0, 0xF0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xE0, 0xF0, 0x00,
  0x07, 0xC0, 0xF0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0xF0, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0xE0, 0xF0, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x00, 0xF8, 0xF0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x00, 0x3E, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0x03, 0xFE, 0x1F, 0x80, 0x01, 0xC3,
  0xE0, 0x00, 0x04, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x80, 0x00, 0x0F,
  0xCF, 0x80, 0x03, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x01,
  0xE1, 0xF0, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x1F, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x00, 0x77, 0x80, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1E,
  0x38, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1E, 0x3C, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00,
  0xF7, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0xE7, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x78, 0x1E, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x78, 0x0F, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xF0,
  0x07, 0x80, 0x03, 0x81, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0x07, 0x81, 0xE0,
  0x00, 0xE0, 0x07, 0x80, 0x07, 0x80, 0xE0, 0x01, 0xE0, 0x03, 0x80, 0x07,
  0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x0F, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x70, 0x03,
  0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00,
  0x78, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x38, 0x07, 0x80, 0x01, 0xE0,
  0x1C, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x1C, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x07, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x1C,
  0x0F, 0x00, 0x00, 0x70, 0x38, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0x78, 0x70, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x38, 0x70, 0x00, 0x0F, 0x1E,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xBC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x38, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x3C,
  0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x0F, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x3C, 0x00,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x03, 0xEF,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x1E, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x01, 0xE0, 0xE0, 0x00,
  0x00, 0x1E, 0x3C, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x70, 0x01, 0xC0, 0x00, 0xE0, 0x03, 0x80,
  0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x1C, 0x07,
  0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x38, 0x70,
  0x00, 0x00, 0x71, 0xE0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xE0, 0x00, 0xF8,
  0x10, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x7F,
  0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0x80, 0x07, 0x8F,
  0x80, 0x00, 0xF3, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7E, 0xF0, 0x00, 0x1F,
  0xDF, 0x00, 0x07, 0x79, 0xF0, 0x03, 0xCF, 0x3F, 0xEF, 0xF1, 0xE3, 0xFF,
  0xFC, 0x1C, 0x1F, 0xFE, 0x03, 0x80, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0xFF, 0xC0, 0x1C, 0x1F, 0xFF, 0x80, 0xE1, 0xFF, 0xFF, 0x07, 0x3F,
  0x01, 0xFC, 0x39, 0xC0, 0x03, 0xF1, 0xDC, 0x00, 0x07, 0x8F, 0xC0, 0x00,
  0x1E, 0x7E, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x77, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1E, 0xF8, 0x00,
  0x00, 0xF7, 0xC0, 0x00, 0x0F, 0x3F, 0x00, 0x00, 0x79, 0xF8, 0x00, 0x07,
  0x8E, 0xE0, 0x00, 0x7C, 0x73, 0xC0, 0x0F, 0xC3, 0x8F, 0xFF, 0xFC, 0x1C,
  0x3F, 0xFF, 0xC0, 0xE0, 0x7F, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0xFF, 0x01, 0xE0,
  0xFC, 0x00, 0x10, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0xC0, 0x06, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0x80, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x01, 0xFF, 0x80, 0xE0, 0x3F,
  0xFF, 0x07, 0x03, 0xFF, 0xFE, 0x38, 0x7F, 0x00, 0xF9, 0xC3, 0xE0, 0x01,
  0xCE, 0x3E, 0x00, 0x07, 0x73, 0xE0, 0x00, 0x1F, 0x9E, 0x00, 0x00, 0x7D,
  0xE0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x07,
  0xCF, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x03, 0x71, 0xF0, 0x00, 0x3B, 0x87,
  0xE0, 0x07, 0x9C, 0x1F, 0xFF, 0xF8, 0xE0, 0x7F, 0xFF, 0x87, 0x00, 0xFF,
  0xF0, 0x38, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x0F, 0x81,
  0xF0, 0x00, 0x7C, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x38, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x0E, 0x78, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x20, 0xFE, 0x00, 0x1E, 0x03, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xF9, 0xE0,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x7F, 0xE0, 0x38, 0x0F, 0xFF, 0xC1, 0xC0, 0xFF, 0xFF, 0x8E, 0x0F,
  0xC0, 0x3E, 0x70, 0xF8, 0x00, 0x7B, 0x8F, 0x80, 0x01, 0xDC, 0xF8, 0x00,
  0x07, 0xE7, 0x80, 0x00, 0x1F, 0x78, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x3E, 0xF8, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x1F, 0x9F, 0x00, 0x01,
  0xDC, 0x7C, 0x00, 0x1E, 0xE1, 0xF8, 0x01, 0xE7, 0x07, 0xFF, 0xFE, 0x38,
  0x1F, 0xFF, 0xE1, 0xC0, 0x3F, 0xFC, 0x0E, 0x00, 0x3D, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x18, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x3F, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x0F, 0xFC, 0x07, 0x07, 0xFF, 0xF0, 0xE1,
  0xFF, 0xFF, 0x1C, 0xFC, 0x07, 0xF3, 0x9C, 0x00, 0x3F, 0x77, 0x00, 0x01,
  0xEF, 0xC0, 0x00, 0x3D, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xE0, 0x7F, 0xFF, 0xF7, 0x80, 0x00, 0x00, 0x00, 0x07, 0x39,
  0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xC0, 0x00, 0x78, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x79, 0xFF, 0xCF, 0xFC,
  0x7F, 0xC0, 0x60, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0xFB, 0x80, 0x00, 0x7C, 0xE0, 0x00, 0x3E, 0x38,
  0x00, 0x0F, 0x0E, 0x00, 0x07, 0x83, 0x80, 0x03, 0xC0, 0xE0, 0x01, 0xE0,
  0x38, 0x00, 0xF0, 0x0E, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x00, 0xE0, 0x1F,
  0x00, 0x38, 0x0F, 0x80, 0x0E, 0x07, 0xC0, 0x03, 0x83, 0xE0, 0x00, 0xE1,
  0xF0, 0x00, 0x38, 0x78, 0x00, 0x0E, 0x3F, 0x00, 0x03, 0x9F, 0xE0, 0x00,
  0xEF, 0x7C, 0x00, 0x3F, 0x8F, 0x00, 0x0F, 0xC1, 0xE0, 0x03, 0xE0, 0x7C,
  0x00, 0xF0, 0x0F, 0x80, 0x38, 0x01, 0xE0, 0x0E, 0x00, 0x3C, 0x03, 0x80,
  0x0F, 0x80, 0xE0, 0x01, 0xF0, 0x38, 0x00, 0x3C, 0x0E, 0x00, 0x07, 0x83,
  0x80, 0x01, 0xF0, 0xE0, 0x00, 0x3E, 0x38, 0x00, 0x07, 0x8E, 0x00, 0x00,
  0xF3, 0x80, 0x00, 0x3E, 0xE0, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x01, 0xC3, 0xFF, 0xF0,
  0x0F, 0xFF, 0x83, 0x8F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0x3E, 0x03, 0xF1,
  0xF0, 0x0F, 0xCE, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x9D, 0xC0, 0x01, 0xEE,
  0x00, 0x0F, 0xBF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x1E, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0xE0, 0x3F, 0xF0, 0x1C, 0x1F, 0xFF, 0xC3,
  0x87, 0xFF, 0xFC, 0x71, 0xF0, 0x1F, 0xCE, 0x70, 0x00, 0xFD, 0xDC, 0x00,
  0x07, 0xBF, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x7E, 0x03,
  0xE0, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x7C, 0x78,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0x07, 0x78, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x1E, 0x70, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3E,
  0x03, 0xC0, 0x00, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x3F, 0xF0, 0x07, 0x07, 0xFF, 0xE0, 0x38, 0x7F, 0xFF, 0xC1, 0xC7,
  0xC0, 0x7F, 0x0E, 0x78, 0x00, 0x7C, 0x77, 0x00, 0x01, 0xF3, 0xB0, 0x00,
  0x07, 0x9F, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xBE, 0x00,
  0x00, 0x3D, 0xF0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x1E, 0x77, 0x00, 0x01,
  0xE3, 0xBC, 0x00, 0x1F, 0x1C, 0xF8, 0x03, 0xF0, 0xE3, 0xFF, 0xFF, 0x07,
  0x0F, 0xFF, 0xF0, 0x38, 0x1F, 0xFE, 0x01, 0xC0, 0x0F, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x38, 0x0F, 0xFF, 0xC1, 0xC0, 0xFF, 0xFF,
  0x8E, 0x1F, 0xC0, 0x3E, 0x70, 0xF8, 0x00, 0x73, 0x8F, 0x80, 0x01, 0xDC,
  0xF8, 0x00, 0x07, 0xE7, 0x80, 0x00, 0x3F, 0x78, 0x00, 0x00, 0xFB, 0xC0,
  0x00, 0x07, 0xDC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x1F, 0x9F,
  0x00, 0x01, 0xDC, 0x7C, 0x00, 0x1C, 0xE1, 0xF0, 0x03, 0xE7, 0x07, 0xFF,
  0xFE, 0x38, 0x1F, 0xFF, 0xC1, 0xC0, 0x3F, 0xFC, 0x0E, 0x00, 0x1E, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0xE0, 0x3F, 0xFC, 0x1F, 0xFB, 0x87, 0xFF, 0x71,
  0xF0, 0x2E, 0x78, 0x01, 0xDC, 0x00, 0x3B, 0x00, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xC7, 0xE0, 0x07, 0xC3, 0xC0, 0x00, 0x63, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x7A, 0x00, 0x00, 0x79, 0xE0, 0x00, 0xFC, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xE0, 0x1F,
  0xFC, 0x01, 0xFF, 0x80, 0x07, 0x80, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0x70, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x3F, 0x78, 0x00, 0x03, 0xF7,
  0xC0, 0x00, 0x7F, 0x3E, 0x00, 0x0E, 0x73, 0xF0, 0x03, 0xE7, 0x1F, 0xFF,
  0xFC, 0x70, 0xFF, 0xFF, 0x07, 0x03, 0xFF, 0xC0, 0x70, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xE0, 0x78, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x07, 0x00, 0x03,
  0xC0, 0x1E, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x78, 0x07, 0x80, 0x00, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0xE1,
  0xE0, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x1C, 0xF0,
  0x00, 0x00, 0x7B, 0x80, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0x9E, 0x00, 0x03, 0xF0, 0x00, 0x1E, 0x78,
  0x00, 0x0F, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xE3, 0x80,
  0x01, 0xEE, 0x00, 0x07, 0x0F, 0x00, 0x07, 0x38, 0x00, 0x3C, 0x3C, 0x00,
  0x1C, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0x81, 0xE0, 0x03,
  0xC7, 0x00, 0x1E, 0x07, 0x80, 0x0E, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x78,
  0x78, 0x01, 0xE0, 0x38, 0x01, 0xE0, 0xE0, 0x07, 0x00, 0xF0, 0x07, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1C,
  0x03, 0xC0, 0x1C, 0x03, 0x80, 0x78, 0x0E, 0x00, 0x78, 0x1E, 0x01, 0xE0,
  0x78, 0x01, 0xE0, 0x78, 0x03, 0x81, 0xE0, 0x03, 0x81, 0xC0, 0x0E, 0x07,
  0x00, 0x0F, 0x0F, 0x00, 0x3C, 0x1C, 0x00, 0x3C, 0x3C, 0x00, 0x70, 0xF0,
  0x00, 0xF0, 0xE0, 0x01, 0xC3, 0xC0, 0x01, 0xC3, 0x80, 0x07, 0x8E, 0x00,
  0x07, 0x9E, 0x00, 0x1E, 0x38, 0x00, 0x1E, 0x70, 0x00, 0x39, 0xE0, 0x00,
  0x39, 0xC0, 0x00, 0xF7, 0x80, 0x00, 0xEF, 0x00, 0x03, 0xDC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0x70, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x78, 0x0F, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0xF0, 0x03, 0xC0, 0x01, 0xE0, 0x0F, 0x00, 0x07, 0xC0, 0x78, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x3E, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x07, 0xC0, 0x3E,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x7C, 0x3C, 0x00,
  0x00, 0xF1, 0xF0, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x07, 0x80, 0x78, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x07, 0x00, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0x80, 0x00,
  0x1C, 0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x77, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x01, 0xF0, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xC0, 0x07, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x04, 0xFF, 0xFC, 0x00, 0x1B, 0xFF,
  0xFF, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0xDC, 0x00, 0x3F, 0xFF, 0x20, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x03, 0x80,
};

const GFXglyph NotoSans_Light65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 6, 47, 16, 5, -46 },
  { 37, 15, 16, 24, 4, -46 },
  { 67, 38, 46, 42, 2, -46 },
  { 286, 28, 53, 37, 4, -49 },
  { 472, 45, 48, 53, 4, -47 },
  { 742, 41, 48, 47, 4, -47 },
  { 988, 5, 16, 13, 4, -46 },
  { 998, 13, 56, 18, 3, -46 },
  { 1089, 13, 56, 18, 2, -46 },
  { 1180, 29, 27, 36, 3, -49 },
  { 1278, 31, 30, 37, 3, -38 },
  { 1395, 7, 16, 15, 3, -8 },
  { 1409, 15, 3, 21, 3, -19 },
  { 1415, 6, 7, 16, 5, -6 },
  { 1421, 21, 46, 23, 1, -46 },
  { 1542, 29, 48, 37, 4, -47 },
  { 1716, 16, 46, 37, 6, -46 },
  { 1808, 29, 47, 37, 4, -47 },
  { 1979, 30, 48, 37, 3, -47 },
  { 2159, 35, 47, 37, 1, -47 },
  { 2365, 29, 47, 37, 4, -46 },
  { 2536, 30, 48, 37, 4, -47 },
  { 2716, 31, 46, 37, 3, -46 },
  { 2895, 29, 48, 37, 4, -47 },
  { 3069, 30, 48, 37, 3, -47 },
  { 3249, 6, 36, 16, 5, -35 },
  { 3276, 9, 43, 16, 2, -35 },
  { 3325, 31, 31, 37, 3, -39 },
  { 3446, 29, 16, 37, 4, -31 },
  { 3504, 31, 31, 37, 3, -39 },
  { 3625, 23, 48, 28, 2, -47 },
  { 3763, 50, 52, 58, 4, -46 },
  { 4088, 40, 47, 40, 0, -47 },
  { 4323, 32, 46, 41, 6, -46 },
  { 4507, 34, 48, 41, 4, -47 },
  { 4711, 36, 46, 46, 6, -46 },
  { 4918, 26, 46, 36, 6, -46 },
  { 5068, 26, 46, 33, 6, -46 },
  { 5218, 38, 48, 47, 4, -47 },
  { 5446, 35, 46, 47, 6, -46 },
  { 5648, 14, 46, 20, 3, -46 },
  { 5729, 16, 58, 16, -6, -46 },
  { 5845, 32, 46, 38, 6, -46 },
  { 6029, 26, 46, 33, 6, -46 },
  { 6179, 44, 46, 57, 6, -46 },
  { 6432, 35, 46, 47, 6, -46 },
  { 6634, 42, 48, 50, 4, -47 },
  { 6886, 29, 46, 38, 6, -46 },
  { 7053, 42, 58, 50, 4, -47 },
  { 7358, 32, 46, 39, 6, -46 },
  { 7542, 28, 48, 35, 4, -47 },
  { 7710, 34, 46, 35, 0, -46 },
  { 7906, 35, 47, 47, 6, -46 },
  { 8112, 38, 46, 38, 0, -46 },
  { 8331, 56, 46, 59, 1, -46 },
  { 8653, 36, 46, 36, 0, -46 },
  { 8860, 35, 46, 35, 0, -46 },
  { 9062, 33, 46, 37, 2, -46 },
  { 9252, 14, 56, 21, 5, -46 },
  { 9350, 21, 46, 23, 1, -46 },
  { 9471, 13, 56, 21, 2, -46 },
  { 9562, 31, 29, 37, 3, -47 },
  { 9675, 27, 3, 27, 0, 6 },
  { 9686, 12, 11, 17, 3, -50 },
  { 9703, 27, 36, 35, 3, -35 },
  { 9825, 29, 50, 39, 6, -49 },
  { 10007, 25, 36, 31, 4, -35 },
  { 10120, 29, 50, 39, 4, -49 },
  { 10302, 28, 36, 36, 4, -35 },
  { 10428, 23, 50, 20, 1, -50 },
  { 10572, 29, 51, 39, 4, -35 },
  { 10757, 27, 49, 39, 6, -49 },
  { 10923, 5, 47, 15, 5, -47 },
  { 10953, 13, 63, 15, -3, -47 },
  { 11056, 26, 49, 32, 6, -49 },
  { 11216, 3, 49, 15, 6, -49 },
  { 11235, 47, 35, 58, 6, -35 },
  { 11441, 27, 35, 39, 6, -35 },
  { 11560, 31, 36, 38, 4, -35 },
  { 11700, 29, 50, 39, 6, -35 },
  { 11882, 29, 50, 39, 4, -35 },
  { 12064, 19, 35, 26, 6, -35 },
  { 12148, 25, 36, 30, 3, -35 },
  { 12261, 19, 44, 22, 1, -43 },
  { 12366, 28, 36, 39, 5, -35 },
  { 12492, 30, 35, 30, 0, -35 },
  { 12624, 46, 35, 48, 1, -35 },
  { 12826, 30, 35, 33, 1, -35 },
  { 12958, 31, 51, 30, 0, -35 },
  { 13156, 24, 35, 30, 3, -35 },
  { 13261, 19, 56, 23, 2, -46 },
  { 13394, 3, 66, 35, 16, -50 },
  { 13419, 20, 56, 23, 2, -46 },
  { 13559, 31, 8, 37, 3, -27 },
};

const GFXfont NotoSans_Light65pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light65pt7bBitmaps,
  (GFXglyph *)NotoSans_Light65pt7bGlyphs,
  0x20, 0x7E, 89
};

#endif // _NOTOSANS_LIGHT65PT7B_H_
