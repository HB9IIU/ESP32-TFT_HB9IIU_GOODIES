#ifndef _NOTOSANS_LIGHT17PT7B_H_
#define _NOTOSANS_LIGHT17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light17pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x47, 0x99, 0x99, 0x08, 0x81, 0x10, 0x24, 0x37, 0xF1,
  0x10, 0x22, 0x04, 0x47, 0xEE, 0x12, 0x04, 0x40, 0x88, 0x11, 0x00, 0x10,
  0x79, 0x4C, 0x89, 0x1A, 0x0C, 0x0E, 0x12, 0x24, 0x4E, 0xF3, 0x02, 0x00,
  0x70, 0xC8, 0x88, 0x89, 0x08, 0x90, 0x8A, 0x48, 0xAA, 0x75, 0x10, 0x51,
  0x09, 0x11, 0x11, 0x11, 0x12, 0x0E, 0x3C, 0x08, 0x41, 0x08, 0x31, 0x02,
  0xC0, 0x60, 0x12, 0x14, 0x22, 0x82, 0x90, 0x33, 0x0E, 0x3F, 0x30, 0xF0,
  0x29, 0x49, 0x24, 0x92, 0x44, 0x88, 0x89, 0x22, 0x49, 0x24, 0xA5, 0x20,
  0x10, 0x22, 0x4F, 0xF1, 0x85, 0x11, 0x00, 0x10, 0x10, 0x10, 0x10, 0xFF,
  0x10, 0x10, 0x10, 0x6A, 0xF0, 0x70, 0x0C, 0x20, 0x84, 0x10, 0x42, 0x08,
  0x41, 0x04, 0x20, 0x3C, 0x42, 0x82, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x82, 0x42, 0x3C, 0x35, 0x91, 0x11, 0x11, 0x11, 0x11, 0x7C, 0x82, 0x02,
  0x02, 0x02, 0x04, 0x0C, 0x18, 0x10, 0x20, 0x40, 0xFF, 0x7C, 0x82, 0x02,
  0x02, 0x06, 0x38, 0x06, 0x02, 0x01, 0x02, 0x02, 0xFC, 0x02, 0x03, 0x02,
  0x81, 0x41, 0x21, 0x10, 0x88, 0x84, 0xFF, 0x81, 0x00, 0x80, 0x40, 0x7E,
  0x40, 0x40, 0x40, 0x40, 0x7E, 0x02, 0x01, 0x01, 0x02, 0x02, 0xFC, 0x3E,
  0x60, 0x40, 0x80, 0x98, 0xA6, 0xC1, 0x81, 0x81, 0x81, 0x42, 0x3C, 0xFF,
  0x02, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x7C,
  0x42, 0x82, 0x42, 0x64, 0x18, 0x66, 0x82, 0x81, 0x81, 0x82, 0x7C, 0x7C,
  0x82, 0x82, 0x81, 0x81, 0x83, 0x7D, 0x02, 0x02, 0x02, 0x04, 0x78, 0xC0,
  0x01, 0xC0, 0xC0, 0x03, 0xA8, 0x03, 0x0C, 0x30, 0xC0, 0xC0, 0x38, 0x06,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x60, 0x1C, 0x03, 0x06, 0x18, 0x60,
  0x80, 0xFC, 0x08, 0x08, 0x10, 0x41, 0x04, 0x10, 0x20, 0x00, 0x81, 0x80,
  0x0F, 0xC1, 0x81, 0x10, 0x04, 0x87, 0x18, 0xC8, 0xC4, 0x46, 0x42, 0x32,
  0x11, 0x88, 0x8C, 0x7B, 0x90, 0x00, 0x80, 0x03, 0x0C, 0x07, 0x80, 0x04,
  0x03, 0x00, 0xA0, 0x48, 0x12, 0x04, 0x42, 0x10, 0xFE, 0x40, 0x90, 0x24,
  0x06, 0x01, 0xFC, 0x82, 0x82, 0x82, 0x82, 0xFC, 0x86, 0x81, 0x81, 0x81,
  0x82, 0xFC, 0x1F, 0x90, 0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xC0,
  0x20, 0x18, 0x03, 0xF0, 0xFC, 0x41, 0xA0, 0x50, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0xA0, 0x9F, 0x80, 0xFE, 0x08, 0x20, 0x83, 0xF8, 0x20,
  0x82, 0x08, 0x3F, 0xFE, 0x08, 0x20, 0x82, 0x0F, 0xE0, 0x82, 0x08, 0x20,
  0x1F, 0xC8, 0x04, 0x03, 0x00, 0x80, 0x20, 0x08, 0x3E, 0x01, 0xC0, 0x50,
  0x12, 0x04, 0x7F, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0F, 0xFE, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x10, 0xE9, 0x24, 0x92, 0x49, 0x70, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x8B, 0xC0, 0x83, 0x84, 0x88, 0x90,
  0xA0, 0xE0, 0x90, 0x88, 0x88, 0x84, 0x82, 0x83, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x3F, 0x80, 0x78, 0x0F, 0x01, 0xD0, 0x5A, 0x0B,
  0x42, 0x64, 0x4C, 0x89, 0x8A, 0x31, 0x46, 0x30, 0xC2, 0x10, 0x80, 0xE0,
  0x78, 0x34, 0x19, 0x0C, 0x86, 0x23, 0x09, 0x84, 0xC1, 0x60, 0x70, 0x30,
  0x3F, 0x8C, 0x19, 0x01, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x28, 0x09, 0x83, 0x0F, 0x80, 0xFD, 0x0E, 0x0C, 0x18, 0x30, 0xBE, 0x40,
  0x81, 0x02, 0x04, 0x00, 0x3F, 0x8C, 0x19, 0x01, 0x40, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x28, 0x09, 0x83, 0x0F, 0x80, 0x30, 0x03, 0x00,
  0x30, 0xFC, 0x86, 0x82, 0x82, 0x82, 0x84, 0xF8, 0x88, 0x84, 0x84, 0x82,
  0x83, 0x7F, 0x02, 0x04, 0x04, 0x06, 0x03, 0x01, 0x02, 0x04, 0x0F, 0xE0,
  0xFF, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0xB0, 0x4F, 0xC0, 0x80, 0x50, 0x24, 0x09, 0x02, 0x21, 0x08, 0x42,
  0x20, 0x48, 0x12, 0x03, 0x00, 0xC0, 0x30, 0xC1, 0x02, 0x83, 0x09, 0x0A,
  0x12, 0x14, 0x22, 0x28, 0x44, 0x89, 0x09, 0x12, 0x12, 0x24, 0x14, 0x28,
  0x30, 0x60, 0x60, 0xC0, 0x40, 0x80, 0xC0, 0xA0, 0x88, 0x82, 0x41, 0x40,
  0x40, 0x30, 0x28, 0x22, 0x10, 0x90, 0x50, 0x10, 0x80, 0xA0, 0x98, 0x44,
  0x41, 0x20, 0xA0, 0x30, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xFF, 0x02,
  0x02, 0x04, 0x08, 0x18, 0x10, 0x20, 0x60, 0x40, 0x80, 0xFF, 0xF8, 0x88,
  0x88, 0x88, 0x88, 0x88, 0x88, 0xF0, 0x81, 0x04, 0x08, 0x20, 0x81, 0x04,
  0x10, 0x20, 0x81, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0xF0, 0x18,
  0x18, 0x24, 0x24, 0x42, 0x42, 0x81, 0xFE, 0x88, 0x80, 0x7C, 0x0C, 0x08,
  0x17, 0xF0, 0x60, 0xC3, 0x7A, 0x80, 0x80, 0x80, 0x80, 0xBE, 0xC3, 0xC1,
  0xC1, 0x81, 0x81, 0xC1, 0xC3, 0xBE, 0x3E, 0x82, 0x04, 0x08, 0x10, 0x20,
  0x20, 0x3C, 0x01, 0x01, 0x01, 0x01, 0x3D, 0x43, 0x83, 0x81, 0x81, 0x81,
  0x81, 0x43, 0x7D, 0x3C, 0x86, 0x0C, 0x1F, 0xF0, 0x20, 0x20, 0x3E, 0x1C,
  0x82, 0x08, 0xF8, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x3D, 0x43, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x43, 0x7D, 0x01, 0x01, 0x02, 0x7C, 0x80, 0x80,
  0x80, 0x80, 0xBE, 0xC2, 0xC1, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xC2,
  0xAA, 0xAA, 0x30, 0x02, 0x22, 0x22, 0x22, 0x22, 0x22, 0x2E, 0x81, 0x02,
  0x04, 0x08, 0x71, 0xA2, 0x48, 0xB1, 0x92, 0x24, 0x28, 0x20, 0xFF, 0xF8,
  0xBC, 0xF6, 0x18, 0x70, 0x83, 0x04, 0x18, 0x20, 0xC1, 0x06, 0x08, 0x30,
  0x41, 0x82, 0x08, 0xBE, 0xC2, 0xC1, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x3C, 0x42, 0x81, 0x81, 0x81, 0x81, 0x81, 0x42, 0x3C, 0xBE, 0xC3, 0xC1,
  0xC1, 0x81, 0xC1, 0xC1, 0xC3, 0xBE, 0x80, 0x80, 0x80, 0x80, 0x7D, 0x43,
  0x83, 0x81, 0x81, 0x81, 0x83, 0x43, 0x7D, 0x01, 0x01, 0x01, 0x01, 0xBE,
  0x31, 0x08, 0x42, 0x10, 0x80, 0x7E, 0x08, 0x30, 0x38, 0x10, 0x41, 0xF8,
  0x21, 0x3E, 0x42, 0x10, 0x84, 0x21, 0x0E, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x83, 0x43, 0x7D, 0x81, 0x42, 0x42, 0x42, 0x24, 0x24, 0x28, 0x18,
  0x18, 0x82, 0x14, 0x61, 0x45, 0x14, 0x52, 0x49, 0x22, 0x8A, 0x28, 0xA3,
  0x0C, 0x10, 0x40, 0x43, 0x22, 0x24, 0x18, 0x08, 0x14, 0x24, 0x62, 0xC1,
  0x81, 0x42, 0x42, 0x42, 0x24, 0x24, 0x18, 0x18, 0x18, 0x10, 0x10, 0x30,
  0xE0, 0xFC, 0x30, 0x84, 0x20, 0x84, 0x20, 0xFC, 0x1C, 0x42, 0x08, 0x20,
  0x82, 0x30, 0x20, 0x82, 0x08, 0x20, 0x40, 0xC0, 0xFF, 0xFF, 0x80, 0xC3,
  0x08, 0x42, 0x10, 0x83, 0x21, 0x08, 0x42, 0x22, 0x00, 0xF1, 0x8E,
};

const GFXglyph NotoSans_Light17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 12, 4, 1, -12 },
  { 4, 4, 4, 6, 1, -12 },
  { 6, 11, 12, 11, 0, -12 },
  { 23, 7, 14, 10, 1, -13 },
  { 36, 12, 12, 14, 1, -12 },
  { 54, 11, 12, 12, 1, -12 },
  { 71, 1, 4, 3, 1, -12 },
  { 72, 3, 15, 5, 1, -12 },
  { 78, 3, 15, 5, 1, -12 },
  { 84, 7, 7, 9, 1, -13 },
  { 91, 8, 8, 10, 1, -10 },
  { 99, 2, 4, 4, 1, -2 },
  { 100, 4, 1, 5, 1, -5 },
  { 101, 2, 2, 4, 1, -2 },
  { 102, 6, 12, 6, 0, -12 },
  { 111, 8, 12, 10, 1, -12 },
  { 123, 4, 12, 10, 2, -12 },
  { 129, 8, 12, 10, 1, -12 },
  { 141, 8, 12, 10, 1, -12 },
  { 153, 9, 12, 10, 0, -12 },
  { 167, 8, 12, 10, 1, -12 },
  { 179, 8, 12, 10, 1, -12 },
  { 191, 8, 12, 10, 1, -12 },
  { 203, 8, 12, 10, 1, -12 },
  { 215, 8, 12, 10, 1, -12 },
  { 227, 2, 9, 4, 1, -9 },
  { 230, 2, 11, 4, 1, -9 },
  { 233, 8, 8, 10, 1, -10 },
  { 241, 8, 4, 10, 1, -8 },
  { 245, 8, 8, 10, 1, -10 },
  { 253, 7, 12, 7, 0, -12 },
  { 264, 13, 14, 15, 1, -12 },
  { 287, 10, 12, 10, 0, -12 },
  { 302, 8, 12, 11, 2, -12 },
  { 314, 9, 12, 11, 1, -12 },
  { 328, 9, 12, 12, 2, -12 },
  { 342, 6, 12, 9, 2, -12 },
  { 351, 6, 12, 9, 2, -12 },
  { 360, 10, 12, 12, 1, -12 },
  { 375, 9, 12, 12, 2, -12 },
  { 389, 3, 12, 5, 1, -12 },
  { 394, 5, 15, 4, -2, -12 },
  { 404, 8, 12, 10, 2, -12 },
  { 416, 6, 12, 9, 2, -12 },
  { 425, 11, 12, 15, 2, -12 },
  { 442, 9, 12, 12, 2, -12 },
  { 456, 11, 12, 13, 1, -12 },
  { 473, 7, 12, 10, 2, -12 },
  { 484, 11, 15, 13, 1, -12 },
  { 505, 8, 12, 10, 2, -12 },
  { 517, 7, 12, 9, 1, -12 },
  { 528, 9, 12, 9, 0, -12 },
  { 542, 9, 12, 12, 2, -12 },
  { 556, 10, 12, 10, 0, -12 },
  { 571, 15, 12, 15, 0, -12 },
  { 594, 9, 12, 9, 0, -12 },
  { 608, 9, 12, 9, 0, -12 },
  { 622, 8, 12, 10, 1, -12 },
  { 634, 4, 15, 5, 1, -12 },
  { 642, 6, 12, 6, 0, -12 },
  { 651, 4, 15, 5, 0, -12 },
  { 659, 8, 7, 10, 1, -12 },
  { 666, 7, 1, 7, 0, 1 },
  { 667, 3, 3, 5, 1, -13 },
  { 669, 7, 9, 9, 1, -9 },
  { 677, 8, 13, 10, 1, -13 },
  { 690, 7, 9, 8, 1, -9 },
  { 698, 8, 13, 10, 1, -13 },
  { 711, 7, 9, 9, 1, -9 },
  { 719, 6, 13, 5, 0, -13 },
  { 729, 8, 13, 10, 1, -9 },
  { 742, 8, 13, 10, 1, -13 },
  { 755, 2, 12, 4, 1, -12 },
  { 758, 4, 16, 4, -1, -12 },
  { 766, 7, 13, 8, 1, -13 },
  { 778, 1, 13, 4, 1, -13 },
  { 780, 13, 9, 15, 1, -9 },
  { 795, 8, 9, 10, 1, -9 },
  { 804, 8, 9, 10, 1, -9 },
  { 813, 8, 13, 10, 1, -9 },
  { 826, 8, 13, 10, 1, -9 },
  { 839, 5, 9, 7, 1, -9 },
  { 845, 6, 9, 8, 1, -9 },
  { 852, 5, 11, 6, 0, -11 },
  { 859, 8, 9, 10, 1, -9 },
  { 868, 8, 9, 8, 0, -9 },
  { 877, 12, 9, 13, 0, -9 },
  { 891, 8, 9, 9, 0, -9 },
  { 900, 8, 13, 8, 0, -9 },
  { 913, 6, 9, 8, 1, -9 },
  { 920, 6, 15, 6, 0, -12 },
  { 932, 1, 17, 9, 4, -13 },
  { 935, 5, 15, 6, 1, -12 },
  { 945, 8, 2, 10, 1, -7 },
};

const GFXfont NotoSans_Light17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light17pt7bBitmaps,
  (GFXglyph *)NotoSans_Light17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_LIGHT17PT7B_H_
