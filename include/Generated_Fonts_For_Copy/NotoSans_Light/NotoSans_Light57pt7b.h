#ifndef _NOTOSANS_LIGHT57PT7B_H_
#define _NOTOSANS_LIGHT57PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light57pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x8E, 0x38, 0xE3, 0x8E, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x79, 0xEF, 0xDE, 0x78, 0xC0, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x06, 0xE0, 0x37,
  0x01, 0xB8, 0x0D, 0xC0, 0x6E, 0x03, 0x30, 0x19, 0x80, 0xC0, 0x00, 0x06,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x38, 0x00, 0x03, 0x80, 0x18, 0x00, 0x01,
  0xC0, 0x0C, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00,
  0x70, 0x03, 0x80, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x1C, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x70, 0x07, 0x00, 0x00, 0x30, 0x03, 0x80, 0x00, 0x38, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x38, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x01, 0xC0, 0x0C,
  0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x70, 0x07, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x70, 0x00, 0x03, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x1C, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x70,
  0x07, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3E, 0x38, 0x3C,
  0x78, 0x38, 0x04, 0xF0, 0x38, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x38, 0x00,
  0xE0, 0x38, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x38, 0x00,
  0xF0, 0x38, 0x00, 0x78, 0x38, 0x00, 0x7C, 0x38, 0x00, 0x3F, 0x38, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x38, 0xFC, 0x00, 0x38, 0x3E, 0x00, 0x38, 0x1E,
  0x00, 0x38, 0x0F, 0x00, 0x38, 0x07, 0x00, 0x38, 0x07, 0x00, 0x38, 0x07,
  0x00, 0x38, 0x07, 0x00, 0x38, 0x07, 0x00, 0x38, 0x0F, 0x00, 0x38, 0x0E,
  0x80, 0x38, 0x3E, 0xF0, 0x38, 0x7C, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x07, 0xF0, 0x00, 0x03, 0x80, 0x1F,
  0xF8, 0x00, 0x07, 0x00, 0x3E, 0x3C, 0x00, 0x07, 0x00, 0x38, 0x1E, 0x00,
  0x0E, 0x00, 0x70, 0x0E, 0x00, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x00,
  0x70, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07,
  0x00, 0x70, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x07, 0x00, 0xE0,
  0x00, 0xE0, 0x07, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0x01, 0xC0, 0x00, 0xE0,
  0x07, 0x01, 0xC0, 0x00, 0xE0, 0x07, 0x03, 0x80, 0x00, 0xE0, 0x07, 0x03,
  0x80, 0x00, 0xE0, 0x07, 0x07, 0x07, 0xE0, 0xE0, 0x07, 0x0E, 0x0F, 0xF8,
  0x70, 0x07, 0x0E, 0x1F, 0xFC, 0x70, 0x0E, 0x1C, 0x38, 0x1C, 0x70, 0x0E,
  0x1C, 0x78, 0x0E, 0x38, 0x1E, 0x38, 0x70, 0x0E, 0x1E, 0x3C, 0x38, 0x70,
  0x06, 0x1F, 0xF8, 0x70, 0xE0, 0x07, 0x07, 0xF0, 0x70, 0xE0, 0x07, 0x00,
  0x00, 0xE0, 0xE0, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x07, 0x00, 0x01, 0xC0,
  0xE0, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x07,
  0x00, 0x07, 0x00, 0xE0, 0x07, 0x00, 0x07, 0x00, 0xE0, 0x07, 0x00, 0x0E,
  0x00, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x60,
  0x07, 0x00, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x0E, 0x00,
  0x70, 0x00, 0x38, 0x1E, 0x00, 0x70, 0x00, 0x3C, 0x3C, 0x00, 0xE0, 0x00,
  0x1F, 0xF8, 0x01, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x7F,
  0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x01, 0xC0,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x1E, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x3E,
  0x00, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x03, 0xE3, 0xC0, 0x00, 0x70, 0x3C, 0x0F, 0x00, 0x07, 0x83, 0xC0,
  0x3C, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0x01, 0xC3, 0xC0, 0x03, 0xC0, 0x0E,
  0x1E, 0x00, 0x0F, 0x00, 0xE0, 0xE0, 0x00, 0x3C, 0x07, 0x0F, 0x00, 0x00,
  0xF0, 0x78, 0x78, 0x00, 0x03, 0xC3, 0x83, 0xC0, 0x00, 0x0F, 0x38, 0x1E,
  0x00, 0x00, 0x3F, 0xC0, 0xF0, 0x00, 0x00, 0xFC, 0x03, 0x80, 0x00, 0x03,
  0xC0, 0x1E, 0x00, 0x00, 0x3F, 0x00, 0xF0, 0x00, 0x03, 0xFC, 0x03, 0xC0,
  0x00, 0x7C, 0xF0, 0x0F, 0x80, 0x0F, 0xC3, 0xC0, 0x3F, 0x8F, 0xFC, 0x0F,
  0x00, 0xFF, 0xFF, 0x80, 0x3C, 0x01, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xD8, 0x00, 0xF0, 0x0E,
  0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xE0,
  0x1C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x78, 0x07, 0x80, 0x38, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x01, 0xE0,
  0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F,
  0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0,
  0x07, 0x00, 0x78, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38,
  0x07, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80,
  0x70, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0xF0, 0x1C, 0x03, 0xFF, 0x0E, 0x0F, 0xFF, 0xF7,
  0x7F, 0xE3, 0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xE3, 0x80, 0x00, 0xF1, 0xE0, 0x00,
  0x70, 0x78, 0x00, 0x78, 0x1C, 0x00, 0x78, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1C, 0x01, 0xE0, 0x04, 0x00, 0x40, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1E, 0x3C, 0x78, 0xE1, 0xC7, 0x8F, 0x1C, 0x38, 0x71, 0xC3,
  0x86, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x79, 0xEF, 0xDE,
  0x78, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3E, 0x00, 0xF0,
  0x0F, 0x00, 0x1E, 0x07, 0x80, 0x03, 0x81, 0xC0, 0x00, 0x70, 0xF0, 0x00,
  0x1C, 0x38, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x0F, 0x70, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xDC, 0x00, 0x00,
  0xF7, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x8E, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x70, 0x78, 0x00, 0x3C, 0x0E, 0x00, 0x1E, 0x03,
  0xE0, 0x0F, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x07, 0xC0, 0x7F, 0x03,
  0xDC, 0x1E, 0x71, 0xF1, 0xCF, 0x87, 0xF8, 0x1D, 0xC0, 0x72, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0xFC, 0x01, 0xF0, 0x78, 0x00, 0x3C, 0x0C, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x81, 0xF8, 0x01, 0xF0, 0xF0, 0x00, 0x1E, 0x18, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x80, 0x00, 0x1F, 0x38, 0x00, 0x0F, 0x8F, 0xF0, 0x3F,
  0xC3, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x00, 0x2C, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x3C, 0x03,
  0x80, 0x00, 0x70, 0x07, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x07, 0x80, 0x1C,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0,
  0x03, 0xC0, 0x01, 0xC0, 0x07, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x07, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x38, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x38, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x07, 0xC0, 0x7F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC8, 0x00, 0x03, 0xC7, 0x00, 0x07,
  0xE3, 0xF8, 0x1F, 0xE1, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xF1, 0xE0,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x7F, 0xC0, 0x38, 0x7F, 0xFC,
  0x0E, 0x7F, 0x3F, 0xC3, 0xBC, 0x00, 0xF8, 0xEE, 0x00, 0x0F, 0x3E, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x0E, 0x70, 0x00,
  0x03, 0x9E, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x70, 0xF0, 0x00, 0x3C, 0x1E,
  0x00, 0x1E, 0x03, 0xC0, 0x0F, 0x80, 0x7E, 0x1F, 0xC0, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x3C, 0x00, 0xF8, 0x1E, 0x00,
  0x0F, 0x0F, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x78, 0xE0, 0x00, 0x1E, 0x38,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x1E,
  0x38, 0x00, 0x07, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0x3C, 0x00,
  0xF0, 0x07, 0xC0, 0x78, 0x00, 0xFC, 0x7C, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xF8, 0xFE, 0x00, 0xF8, 0x07, 0xC0,
  0x7C, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x0E, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x39, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x87, 0x80, 0x07,
  0xC0, 0xFC, 0x0F, 0xE0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80,
  0x7C, 0x01, 0xF0, 0x3E, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x00,
  0xF1, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xDC, 0x00, 0x00,
  0xF7, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x3F, 0x3C, 0x00, 0x1D, 0xCF, 0x80,
  0x0E, 0x71, 0xF8, 0x1F, 0x1C, 0x1F, 0xFF, 0x87, 0x03, 0xFF, 0x83, 0xC0,
  0x04, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x01, 0x80, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x31, 0xEF, 0xDE, 0x78, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x9E, 0xFD, 0xE7, 0x8C, 0x0C, 0x3C, 0xF9, 0xF1, 0xE1,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x3C, 0x71, 0xE3, 0xC7, 0x8E, 0x1C, 0x78,
  0xE1, 0xC3, 0x8E, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF8, 0xF0, 0x03, 0xC4, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x03, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x3F, 0xF8, 0x01, 0xC3, 0x80, 0x07, 0xFF, 0xF0, 0x06, 0x1C,
  0x00, 0x7E, 0x0F, 0x80, 0x38, 0xE0, 0x07, 0x80, 0x1C, 0x01, 0xCE, 0x00,
  0x78, 0x00, 0xE0, 0x0E, 0x70, 0x07, 0x80, 0x07, 0x00, 0x33, 0x80, 0x38,
  0x00, 0x38, 0x01, 0x98, 0x03, 0xC0, 0x01, 0xC0, 0x0D, 0xC0, 0x1C, 0x00,
  0x0C, 0x00, 0x7E, 0x00, 0xE0, 0x00, 0x60, 0x03, 0xF0, 0x07, 0x00, 0x07,
  0x00, 0x1B, 0x80, 0x38, 0x00, 0x38, 0x00, 0xDC, 0x01, 0xC0, 0x01, 0xC0,
  0x0E, 0xE0, 0x0E, 0x00, 0x0E, 0x00, 0x77, 0x00, 0x70, 0x00, 0x70, 0x03,
  0xB8, 0x03, 0x80, 0x03, 0x80, 0x1D, 0xC0, 0x1C, 0x00, 0x3C, 0x01, 0xCE,
  0x00, 0x70, 0x01, 0xF0, 0x0E, 0x38, 0x03, 0x80, 0x1B, 0x80, 0xE1, 0xC0,
  0x0F, 0x01, 0xCE, 0x0F, 0x0E, 0x00, 0x7F, 0xFC, 0x7F, 0xF0, 0x70, 0x00,
  0xFF, 0xC1, 0xFF, 0x01, 0xC0, 0x01, 0xF0, 0x03, 0xE0, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x38,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00,
  0x78, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x38, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x70, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00,
  0x03, 0xC3, 0x80, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0x00, 0xF3, 0x80, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x70, 0x01,
  0xFF, 0x0E, 0x00, 0x01, 0xF1, 0xC0, 0x00, 0x1F, 0x38, 0x00, 0x01, 0xE7,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x7B, 0x80, 0x00,
  0x0F, 0x70, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x38,
  0x00, 0x01, 0xE7, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x07,
  0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x81, 0xC0,
  0x01, 0xFC, 0x38, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x03,
  0xDC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x0F, 0x70, 0x00,
  0x03, 0xCE, 0x00, 0x00, 0xF9, 0xC0, 0x00, 0xFE, 0x3F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0x00, 0x1E, 0x03, 0xE0,
  0x00, 0x08, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x60, 0x1F, 0xF8, 0xFF, 0x80, 0x1F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x1F, 0xF8,
  0x0E, 0x00, 0x03, 0xF8, 0x1C, 0x00, 0x00, 0xF8, 0x38, 0x00, 0x00, 0xF8,
  0x70, 0x00, 0x00, 0xF8, 0xE0, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x00, 0xF3,
  0x80, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x03, 0xDC,
  0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x03, 0xDC, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00,
  0x3C, 0xE0, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x0F,
  0x87, 0x00, 0x00, 0x3E, 0x0E, 0x00, 0x01, 0xF8, 0x1C, 0x00, 0x1F, 0xC0,
  0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xB8, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F,
  0x80, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x20, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x00, 0x1D, 0xE0, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x07, 0x3C, 0x00,
  0x00, 0x03, 0x8F, 0x00, 0x00, 0x01, 0xC7, 0xC0, 0x00, 0x00, 0xE1, 0xF0,
  0x00, 0x00, 0x70, 0x7E, 0x00, 0x00, 0x38, 0x1F, 0xC0, 0x00, 0x7C, 0x07,
  0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0x7F, 0xE0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F,
  0x8F, 0xFF, 0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xE0, 0x07, 0x80, 0x3C, 0xFF, 0xF3, 0xFF, 0x8F, 0xF8, 0x00, 0xE0, 0x00,
  0x01, 0xEE, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0xF0,
  0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x78, 0x0E, 0x00,
  0x0F, 0x00, 0xE0, 0x01, 0xE0, 0x0E, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80,
  0x0E, 0x00, 0xF0, 0x00, 0xE0, 0x1E, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0xE0,
  0x7C, 0x00, 0x0E, 0x07, 0x80, 0x00, 0xE0, 0xF0, 0x00, 0x0E, 0x1E, 0x00,
  0x00, 0xE3, 0xE0, 0x00, 0x0E, 0x7F, 0x00, 0x00, 0xEE, 0x78, 0x00, 0x0F,
  0xC7, 0x80, 0x00, 0xF8, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xE0, 0x1F,
  0x00, 0x0E, 0x00, 0xF0, 0x00, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00,
  0xE0, 0x03, 0xC0, 0x0E, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0xF0, 0x0E, 0x00,
  0x07, 0x80, 0xE0, 0x00, 0x78, 0x0E, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x1E,
  0x0E, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x78, 0xE0,
  0x00, 0x03, 0xCE, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x01, 0xF0, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x01, 0xDF, 0xF8, 0x00, 0x00, 0x07, 0x7E, 0xE0, 0x00, 0x00, 0x1D,
  0xFB, 0xC0, 0x00, 0x00, 0xE7, 0xE7, 0x00, 0x00, 0x03, 0x9F, 0x9C, 0x00,
  0x00, 0x1E, 0x7E, 0x78, 0x00, 0x00, 0x71, 0xF8, 0xE0, 0x00, 0x01, 0xC7,
  0xE3, 0xC0, 0x00, 0x0E, 0x1F, 0x87, 0x00, 0x00, 0x38, 0x7E, 0x1C, 0x00,
  0x01, 0xE1, 0xF8, 0x78, 0x00, 0x07, 0x07, 0xE0, 0xE0, 0x00, 0x1C, 0x1F,
  0x83, 0x80, 0x00, 0xE0, 0x7E, 0x07, 0x00, 0x03, 0x81, 0xF8, 0x1C, 0x00,
  0x1E, 0x07, 0xE0, 0x78, 0x00, 0x70, 0x1F, 0x80, 0xE0, 0x01, 0xC0, 0x7E,
  0x03, 0x80, 0x0E, 0x01, 0xF8, 0x07, 0x00, 0x38, 0x07, 0xE0, 0x1C, 0x01,
  0xE0, 0x1F, 0x80, 0x78, 0x07, 0x00, 0x7E, 0x00, 0xE0, 0x1C, 0x01, 0xF8,
  0x03, 0x80, 0xE0, 0x07, 0xE0, 0x0F, 0x03, 0x80, 0x1F, 0x80, 0x1C, 0x1E,
  0x00, 0x7E, 0x00, 0x78, 0x70, 0x01, 0xF8, 0x00, 0xE1, 0xC0, 0x07, 0xE0,
  0x03, 0x8E, 0x00, 0x1F, 0x80, 0x0F, 0x38, 0x00, 0x7E, 0x00, 0x1D, 0xE0,
  0x01, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1E, 0x00,
  0x07, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFB, 0xC0, 0x00, 0x07,
  0xE7, 0x80, 0x00, 0x1F, 0x9E, 0x00, 0x00, 0x7E, 0x3C, 0x00, 0x01, 0xF8,
  0x78, 0x00, 0x07, 0xE1, 0xE0, 0x00, 0x1F, 0x83, 0xC0, 0x00, 0x7E, 0x07,
  0x80, 0x01, 0xF8, 0x1E, 0x00, 0x07, 0xE0, 0x3C, 0x00, 0x1F, 0x80, 0x78,
  0x00, 0x7E, 0x01, 0xE0, 0x01, 0xF8, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0x80,
  0x1F, 0x80, 0x1E, 0x00, 0x7E, 0x00, 0x3C, 0x01, 0xF8, 0x00, 0x78, 0x07,
  0xE0, 0x01, 0xE0, 0x1F, 0x80, 0x03, 0xC0, 0x7E, 0x00, 0x07, 0x81, 0xF8,
  0x00, 0x1E, 0x07, 0xE0, 0x00, 0x3C, 0x1F, 0x80, 0x00, 0x78, 0x7E, 0x00,
  0x01, 0xE1, 0xF8, 0x00, 0x03, 0xC7, 0xE0, 0x00, 0x07, 0x9F, 0x80, 0x00,
  0x1E, 0x7E, 0x00, 0x00, 0x3D, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x00,
  0x3C, 0x78, 0x00, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x00, 0x1E, 0x70, 0x00,
  0x00, 0x00, 0xEF, 0x00, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0E, 0xF0, 0x00,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x01, 0xE3,
  0x80, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x01, 0xF0, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0x0F, 0xF8, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1C, 0x00,
  0xFF, 0x0E, 0x00, 0x07, 0xC7, 0x00, 0x01, 0xF3, 0x80, 0x00, 0x79, 0xC0,
  0x00, 0x1E, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1D,
  0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x07, 0x38, 0x00, 0x07,
  0x9C, 0x00, 0x07, 0x8E, 0x00, 0x0F, 0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x1F, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0x03, 0xC3, 0x80, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x01, 0xE7,
  0x00, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x00,
  0x0E, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x00, 0x1C, 0x3C, 0x00,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x06, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x70, 0x01,
  0xFE, 0x0E, 0x00, 0x07, 0xE1, 0xC0, 0x00, 0x3C, 0x38, 0x00, 0x03, 0xC7,
  0x00, 0x00, 0x78, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x1C, 0x70, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0x38,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x0F, 0x1C, 0x00, 0x03,
  0xC3, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x7C, 0x0E, 0x00, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0x78, 0x03, 0x80, 0x07, 0x00, 0x70, 0x00, 0xF0, 0x0E, 0x00,
  0x0E, 0x01, 0xC0, 0x01, 0xE0, 0x38, 0x00, 0x1E, 0x07, 0x00, 0x03, 0xC0,
  0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x78, 0x70, 0x00,
  0x07, 0x8E, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x0F, 0x38, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x1E, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xC3, 0xF0, 0x03, 0xE3, 0xE0, 0x00, 0x21, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE8,
  0x00, 0x01, 0xE7, 0x00, 0x03, 0xF3, 0xFE, 0x1F, 0xF1, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xDC, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x7C, 0x01, 0xFF, 0x1F, 0xF0,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x02, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x01,
  0xCF, 0x00, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x00,
  0x70, 0xF0, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x1C, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x0E, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x38, 0x00, 0x03, 0x80, 0x1E, 0x00,
  0x03, 0xC0, 0x07, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x00,
  0xE0, 0x0F, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x0E, 0x03, 0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0x3C, 0x78, 0x00,
  0x00, 0x0E, 0x38, 0x00, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x01, 0xDE, 0x00,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xDC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xE7, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x3B,
  0x80, 0x00, 0x78, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x38, 0x78, 0x00, 0x0E,
  0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0x0E, 0x00, 0x07,
  0x1C, 0x00, 0x0F, 0x07, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x03, 0xC0, 0x01,
  0xC7, 0x00, 0x03, 0x80, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0xC0, 0x70, 0x00,
  0xE0, 0xE0, 0x01, 0xC0, 0x3C, 0x00, 0x70, 0x70, 0x00, 0xE0, 0x1E, 0x00,
  0x78, 0x3C, 0x00, 0x70, 0x07, 0x00, 0x38, 0x0E, 0x00, 0x78, 0x03, 0x80,
  0x1C, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x0E, 0x03, 0x80, 0x1C, 0x00, 0xF0,
  0x0F, 0x00, 0xE0, 0x1E, 0x00, 0x38, 0x07, 0x00, 0x70, 0x0F, 0x00, 0x1C,
  0x03, 0x80, 0x38, 0x07, 0x00, 0x0F, 0x01, 0xC0, 0x1E, 0x03, 0x80, 0x03,
  0x81, 0xC0, 0x07, 0x03, 0xC0, 0x01, 0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x00,
  0xE0, 0x70, 0x01, 0xC0, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x70, 0x70, 0x00,
  0x1C, 0x38, 0x00, 0x38, 0x78, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00,
  0x07, 0x0E, 0x00, 0x0F, 0x1C, 0x00, 0x03, 0xCE, 0x00, 0x03, 0x9E, 0x00,
  0x00, 0xE7, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x73, 0x80, 0x00, 0xE7, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1D, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x0F, 0x00, 0xE0, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0x70, 0x01, 0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x03, 0xC0, 0x0E, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x07, 0x80, 0x70,
  0x00, 0x07, 0x81, 0xC0, 0x00, 0x07, 0x07, 0x80, 0x00, 0x0F, 0x0E, 0x00,
  0x00, 0x0E, 0x38, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x1C, 0x78, 0x00, 0x00, 0x78, 0x70, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03,
  0x80, 0xF0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x70,
  0x01, 0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0xC0, 0x0E, 0x00,
  0x03, 0x80, 0x3C, 0x00, 0x07, 0x80, 0x70, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x07, 0x07, 0x80, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x38, 0x07, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xC0, 0x00,
  0x38, 0x07, 0x80, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00,
  0xF0, 0x70, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x01,
  0xCF, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x38, 0x01, 0xC0,
  0x03, 0x80, 0x0E, 0x00, 0x70, 0x00, 0xE0, 0x07, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x70, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0xF0,
  0x00, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xF8, 0x07,
  0xC0, 0x80, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0xFF, 0x83, 0xFF, 0xFF, 0x1F,
  0xC0, 0x0E, 0x7C, 0x00, 0x1D, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x01, 0xBB, 0xC0, 0x0F, 0x77, 0xE0, 0x7C,
  0xE7, 0xFF, 0xE1, 0xC3, 0xFF, 0x83, 0x80, 0xE0, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x3F, 0x80, 0x38, 0x3F, 0xFC, 0x0E, 0x3F, 0xFF, 0x83, 0x9E, 0x01,
  0xF0, 0xEE, 0x00, 0x1E, 0x3F, 0x00, 0x03, 0xCF, 0x80, 0x00, 0xF3, 0xE0,
  0x00, 0x1E, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x3B,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x3B, 0xC0, 0x00, 0x1E, 0xF8, 0x00, 0x07, 0x3E, 0x00, 0x03,
  0xCF, 0xC0, 0x01, 0xE3, 0xB8, 0x00, 0xF0, 0xE7, 0xC1, 0xF8, 0x38, 0xFF,
  0xFC, 0x0C, 0x0F, 0xFE, 0x00, 0x00, 0x50, 0x00, 0x00, 0x1F, 0xE0, 0x03,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xF8, 0x07, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0x01, 0x07, 0xF8, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x00, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x3F, 0x81, 0xC0, 0x7F, 0xF8, 0x70, 0x7F, 0xFF,
  0x1C, 0x3F, 0x01, 0xE7, 0x1F, 0x00, 0x1D, 0xC7, 0x80, 0x03, 0xF3, 0xC0,
  0x00, 0x7C, 0xE0, 0x00, 0x1F, 0x78, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0x3D, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x38, 0x00, 0x07,
  0xCF, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0xFC, 0x7C, 0x00, 0x77, 0x0F, 0xE0,
  0xF9, 0xC1, 0xFF, 0xFC, 0x70, 0x1F, 0xFC, 0x0C, 0x00, 0x38, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0xF8, 0x0F, 0x80,
  0xF0, 0x01, 0xE0, 0xF0, 0x00, 0x70, 0xF0, 0x00, 0x3C, 0x70, 0x00, 0x0E,
  0x38, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x60, 0x7F, 0x07, 0xF0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x00, 0x14, 0x00, 0x00, 0x07, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0x06, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xF8, 0x70,
  0x7F, 0xFF, 0x9C, 0x3F, 0x01, 0xF7, 0x0F, 0x00, 0x1D, 0xC7, 0x80, 0x03,
  0xF3, 0xC0, 0x00, 0x7C, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0x70, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x38,
  0x00, 0x07, 0xCF, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0xDC, 0x7C, 0x00, 0x77,
  0x0F, 0xE0, 0xF9, 0xC0, 0xFF, 0xFC, 0x70, 0x1F, 0xFC, 0x1C, 0x00, 0x20,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78,
  0x80, 0x00, 0x3C, 0x38, 0x00, 0x1F, 0x0F, 0xE0, 0x1F, 0x83, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x3F, 0x80, 0xE0,
  0xFF, 0xF0, 0xE3, 0xFF, 0xF8, 0xE7, 0x80, 0x7C, 0xEE, 0x00, 0x1E, 0xFC,
  0x00, 0x1E, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0x23, 0xFF, 0xF7, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39,
  0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x80, 0x00, 0x40, 0x0F, 0x01,
  0xF0, 0x1F, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x1E, 0x83, 0xCF, 0xF8, 0xFF, 0x03, 0xC0, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x5C, 0x00, 0x0F,
  0x38, 0x00, 0x3C, 0x70, 0x00, 0x70, 0xE0, 0x01, 0xE1, 0xC0, 0x07, 0x83,
  0x80, 0x1E, 0x07, 0x00, 0x78, 0x0E, 0x01, 0xE0, 0x1C, 0x07, 0x80, 0x38,
  0x1E, 0x00, 0x70, 0x78, 0x00, 0xE1, 0xE0, 0x01, 0xC7, 0x80, 0x03, 0x8F,
  0x80, 0x07, 0x3F, 0x00, 0x0E, 0xEF, 0x00, 0x1F, 0x8F, 0x00, 0x3E, 0x0F,
  0x00, 0x78, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1E, 0x03, 0x80, 0x1E,
  0x07, 0x00, 0x1C, 0x0E, 0x00, 0x3C, 0x1C, 0x00, 0x3C, 0x38, 0x00, 0x3C,
  0x70, 0x00, 0x38, 0xE0, 0x00, 0x79, 0xC0, 0x00, 0x7B, 0x80, 0x00, 0x78,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x70, 0xFF,
  0xE0, 0x1F, 0xFC, 0x38, 0xFF, 0xFC, 0x3F, 0xFF, 0x9C, 0xF0, 0x3E, 0x3E,
  0x07, 0xCE, 0xE0, 0x07, 0xBC, 0x00, 0xF7, 0xE0, 0x01, 0xDC, 0x00, 0x3B,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x70, 0x00, 0x0F, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xF0, 0x00, 0x0E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0x00, 0x00, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x70, 0x00, 0x0F, 0xC0, 0x00, 0x38, 0x00, 0x07, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x3F, 0x80, 0xE0,
  0xFF, 0xF0, 0xE3, 0xFF, 0xF8, 0xE7, 0x80, 0x7C, 0xEE, 0x00, 0x1E, 0xEC,
  0x00, 0x1E, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x00, 0xF0, 0x3C, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xCF,
  0x00, 0x00, 0x3D, 0xC0, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x0E, 0x3C, 0x00, 0x03, 0xC3, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x3C,
  0x07, 0xC0, 0x0F, 0x80, 0x7F, 0x0F, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x20, 0x00, 0x00, 0x3F, 0x80, 0x38, 0x3F, 0xFC, 0x0E,
  0x3F, 0xFF, 0x83, 0x9E, 0x01, 0xF0, 0xEE, 0x00, 0x1E, 0x3B, 0x00, 0x03,
  0xCF, 0x80, 0x00, 0xF3, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0xEF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x3B, 0xE0, 0x00, 0x1E, 0xF8,
  0x00, 0x07, 0x3F, 0x00, 0x03, 0xCE, 0xE0, 0x01, 0xE3, 0xBC, 0x00, 0xF8,
  0xE7, 0xE1, 0xFC, 0x38, 0xFF, 0xFC, 0x0E, 0x0F, 0xFE, 0x03, 0x80, 0x30,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xF8, 0x70, 0x7F,
  0xFF, 0x1C, 0x3F, 0x01, 0xE7, 0x1F, 0x00, 0x1D, 0xC7, 0x80, 0x03, 0xF3,
  0xC0, 0x00, 0x7C, 0xE0, 0x00, 0x1F, 0x78, 0x00, 0x03, 0xDC, 0x00, 0x00,
  0xF7, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x38, 0x00,
  0x07, 0xCF, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0xDC, 0x7C, 0x00, 0xF7, 0x0F,
  0xC0, 0xF9, 0xC1, 0xFF, 0xFC, 0x70, 0x1F, 0xFC, 0x1C, 0x00, 0x20, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x3F, 0xF0, 0xFF, 0xB8, 0xFF, 0xDC, 0xF8, 0x2E,
  0xF0, 0x07, 0x60, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x7F, 0xFF, 0x07, 0xFF, 0xFC, 0x78, 0x01, 0xE7, 0x80, 0x01, 0x78, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x03, 0xE0, 0x00, 0x1D, 0x80, 0x01, 0xEF, 0xC0,
  0x7E, 0x7F, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x18, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x7C, 0x30, 0x3F, 0xF8, 0x07, 0xFC, 0x00, 0x30, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x78,
  0x00, 0x77, 0x7C, 0x00, 0xF7, 0x3F, 0x07, 0xE7, 0x1F, 0xFF, 0x87, 0x07,
  0xFF, 0x07, 0x00, 0xA0, 0x00, 0xF0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x39,
  0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x78, 0x78, 0x00,
  0x0F, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x0E, 0x01,
  0xC0, 0x01, 0xC0, 0x3C, 0x00, 0x78, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x03,
  0xC0, 0x0F, 0x00, 0x70, 0x00, 0xE0, 0x0E, 0x00, 0x1C, 0x03, 0xC0, 0x03,
  0xC0, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x70, 0x70,
  0x00, 0x0E, 0x1E, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x03,
  0x9E, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0xEC, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x70, 0x00, 0x3E,
  0x00, 0x0E, 0x70, 0x00, 0x7E, 0x00, 0x0E, 0x78, 0x00, 0x7E, 0x00, 0x0E,
  0x78, 0x00, 0x77, 0x00, 0x1E, 0x38, 0x00, 0xE7, 0x00, 0x1C, 0x38, 0x00,
  0xE7, 0x00, 0x1C, 0x3C, 0x00, 0xE3, 0x80, 0x3C, 0x1C, 0x01, 0xC3, 0x80,
  0x3C, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x1C, 0x01, 0xC1, 0xC0, 0x38, 0x1E,
  0x03, 0xC1, 0xC0, 0x78, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x0E, 0x03, 0x81,
  0xE0, 0x70, 0x0F, 0x07, 0x80, 0xE0, 0x70, 0x07, 0x07, 0x00, 0xE0, 0xF0,
  0x07, 0x07, 0x00, 0xF0, 0xE0, 0x07, 0x0F, 0x00, 0x70, 0xE0, 0x07, 0x8E,
  0x00, 0x70, 0xE0, 0x03, 0x8E, 0x00, 0x71, 0xE0, 0x03, 0x8E, 0x00, 0x39,
  0xC0, 0x03, 0x9C, 0x00, 0x39, 0xC0, 0x01, 0xDC, 0x00, 0x39, 0xC0, 0x01,
  0xDC, 0x00, 0x1F, 0x80, 0x01, 0xD8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x07, 0xCF, 0x00, 0x01, 0xC1,
  0xE0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x1C, 0x01, 0xE0, 0x0F,
  0x00, 0x38, 0x07, 0x80, 0x0F, 0x01, 0xC0, 0x01, 0xE0, 0xE0, 0x00, 0x38,
  0x78, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1E, 0xE0, 0x00, 0x0F, 0x1C, 0x00, 0x03, 0x87, 0x80, 0x01, 0xE0,
  0xF0, 0x00, 0xF0, 0x1C, 0x00, 0x38, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x0F,
  0x00, 0x1C, 0x07, 0x80, 0x07, 0x81, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x1E,
  0x78, 0x00, 0x03, 0xBC, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xEE, 0x00,
  0x00, 0x39, 0xE0, 0x00, 0x0F, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x78,
  0x78, 0x00, 0x0F, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x78, 0x0E, 0x00,
  0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x3C, 0x00, 0x78, 0x03, 0x80, 0x0E, 0x00,
  0x70, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x00, 0xE0, 0x0E, 0x00, 0x1E, 0x03,
  0xC0, 0x01, 0xC0, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x70, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0x70,
  0x00, 0x03, 0xCE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x83, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xF8, 0x01, 0xE0, 0x01, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xFF, 0x00,
  0x3F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xE0, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0xE0, 0x1E,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x3E, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x78, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x2F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x07, 0xF0, 0x0F,
  0xFF, 0xE8, 0x00, 0x7F, 0xF9, 0x00, 0x01, 0xFC, 0x00,
};

const GFXglyph NotoSans_Light57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 6, 42, 14, 4, -41 },
  { 33, 13, 15, 21, 4, -41 },
  { 58, 33, 41, 37, 2, -41 },
  { 228, 24, 46, 33, 4, -43 },
  { 366, 40, 42, 46, 3, -41 },
  { 576, 37, 42, 41, 3, -41 },
  { 771, 3, 15, 11, 4, -41 },
  { 777, 12, 50, 16, 2, -41 },
  { 852, 12, 50, 16, 2, -41 },
  { 927, 25, 24, 31, 3, -43 },
  { 1002, 27, 27, 33, 3, -34 },
  { 1094, 7, 14, 13, 2, -7 },
  { 1107, 14, 3, 18, 2, -17 },
  { 1113, 6, 6, 14, 4, -5 },
  { 1118, 18, 41, 20, 1, -41 },
  { 1211, 26, 42, 33, 3, -41 },
  { 1348, 14, 41, 33, 5, -41 },
  { 1420, 26, 41, 33, 3, -41 },
  { 1554, 26, 42, 33, 3, -41 },
  { 1691, 31, 41, 33, 1, -41 },
  { 1850, 25, 42, 33, 4, -41 },
  { 1982, 26, 42, 33, 4, -41 },
  { 2119, 26, 41, 33, 3, -41 },
  { 2253, 26, 42, 33, 3, -41 },
  { 2390, 26, 42, 33, 3, -41 },
  { 2527, 6, 32, 14, 4, -31 },
  { 2551, 7, 38, 14, 2, -31 },
  { 2585, 27, 27, 33, 3, -34 },
  { 2677, 26, 14, 33, 3, -27 },
  { 2723, 27, 27, 33, 3, -34 },
  { 2815, 21, 42, 24, 1, -41 },
  { 2926, 45, 45, 51, 3, -40 },
  { 3180, 35, 41, 35, 0, -41 },
  { 3360, 27, 41, 36, 6, -41 },
  { 3499, 30, 42, 36, 4, -41 },
  { 3657, 31, 41, 41, 6, -41 },
  { 3816, 22, 41, 32, 6, -41 },
  { 3929, 22, 41, 29, 6, -41 },
  { 4042, 33, 42, 41, 4, -41 },
  { 4216, 30, 41, 41, 6, -41 },
  { 4370, 12, 41, 18, 3, -41 },
  { 4432, 14, 51, 14, -5, -41 },
  { 4522, 28, 41, 34, 6, -41 },
  { 4666, 22, 41, 29, 6, -41 },
  { 4779, 38, 41, 50, 6, -41 },
  { 4974, 30, 41, 42, 6, -41 },
  { 5128, 36, 42, 44, 4, -41 },
  { 5317, 25, 41, 34, 6, -41 },
  { 5446, 36, 51, 44, 4, -41 },
  { 5676, 27, 41, 34, 6, -41 },
  { 5815, 25, 42, 31, 3, -41 },
  { 5947, 30, 41, 30, 0, -41 },
  { 6101, 31, 42, 41, 5, -41 },
  { 6264, 33, 41, 33, 0, -41 },
  { 6434, 49, 41, 51, 1, -41 },
  { 6686, 31, 41, 31, 0, -41 },
  { 6845, 31, 41, 31, 0, -41 },
  { 7004, 29, 41, 33, 2, -41 },
  { 7153, 12, 50, 18, 5, -41 },
  { 7228, 18, 41, 20, 1, -41 },
  { 7321, 13, 50, 18, 1, -41 },
  { 7403, 28, 25, 33, 2, -41 },
  { 7491, 24, 3, 24, 0, 5 },
  { 7500, 11, 9, 15, 2, -44 },
  { 7513, 23, 32, 31, 3, -31 },
  { 7605, 26, 44, 34, 5, -43 },
  { 7748, 22, 32, 27, 3, -31 },
  { 7836, 26, 44, 34, 3, -43 },
  { 7979, 25, 32, 31, 3, -31 },
  { 8079, 20, 44, 18, 1, -44 },
  { 8189, 26, 45, 34, 3, -31 },
  { 8336, 24, 43, 34, 5, -43 },
  { 8465, 5, 42, 13, 4, -42 },
  { 8492, 12, 56, 13, -3, -42 },
  { 8576, 23, 43, 28, 5, -43 },
  { 8700, 3, 43, 13, 5, -43 },
  { 8717, 41, 31, 51, 5, -31 },
  { 8876, 24, 31, 34, 5, -31 },
  { 8969, 27, 32, 34, 3, -31 },
  { 9077, 26, 44, 34, 5, -31 },
  { 9220, 26, 44, 34, 3, -31 },
  { 9363, 17, 31, 22, 5, -31 },
  { 9429, 21, 32, 27, 3, -31 },
  { 9513, 17, 39, 19, 1, -38 },
  { 9596, 24, 31, 34, 5, -30 },
  { 9689, 27, 30, 27, 0, -30 },
  { 9791, 40, 30, 42, 1, -30 },
  { 9941, 26, 30, 29, 1, -30 },
  { 10039, 27, 44, 27, 0, -30 },
  { 10188, 22, 30, 26, 2, -30 },
  { 10271, 16, 50, 20, 2, -41 },
  { 10371, 3, 57, 31, 14, -43 },
  { 10393, 17, 50, 20, 2, -41 },
  { 10500, 27, 6, 33, 3, -23 },
};

const GFXfont NotoSans_Light57pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light57pt7bBitmaps,
  (GFXglyph *)NotoSans_Light57pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _NOTOSANS_LIGHT57PT7B_H_
