#ifndef _NOTOSANS_LIGHT43PT7B_H_
#define _NOTOSANS_LIGHT43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light43pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x60, 0x00, 0x06, 0xFF, 0x70, 0xE1, 0xF8, 0x7E, 0x1F, 0x07, 0xC1, 0xF0,
  0x6C, 0x1B, 0x06, 0xC1, 0xB0, 0x6C, 0x08, 0x00, 0x30, 0x1C, 0x00, 0x0C,
  0x06, 0x00, 0x03, 0x01, 0x80, 0x01, 0xC0, 0x60, 0x00, 0x60, 0x18, 0x00,
  0x18, 0x06, 0x00, 0x06, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0xE0, 0x30,
  0x00, 0x30, 0x0C, 0x03, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x00, 0xC0,
  0x60, 0x00, 0x30, 0x18, 0x00, 0x18, 0x06, 0x00, 0x06, 0x01, 0x80, 0x01,
  0x80, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x03, 0x00,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC0, 0x30, 0x18, 0x00, 0x0C, 0x06,
  0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x60, 0x38, 0x00, 0x18,
  0x0C, 0x00, 0x06, 0x03, 0x00, 0x03, 0x80, 0xC0, 0x00, 0xC0, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x0F, 0xFF, 0x0F,
  0xFF, 0xE7, 0x0C, 0x13, 0x83, 0x00, 0xE0, 0xC0, 0x30, 0x30, 0x0C, 0x0C,
  0x03, 0x03, 0x00, 0xE0, 0xC0, 0x38, 0x30, 0x07, 0x8C, 0x00, 0xFB, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x03, 0x7C, 0x00, 0xC7, 0x80,
  0x30, 0x70, 0x0C, 0x1C, 0x03, 0x03, 0x00, 0xC0, 0xC0, 0x30, 0x30, 0x0C,
  0x1C, 0x03, 0x06, 0x80, 0xC7, 0xBF, 0xFF, 0xCF, 0xFF, 0xC0, 0x1F, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x0F, 0x80, 0x01,
  0x80, 0x7F, 0x80, 0x06, 0x00, 0xC1, 0x80, 0x0C, 0x03, 0x83, 0x80, 0x30,
  0x06, 0x03, 0x00, 0x60, 0x0C, 0x06, 0x01, 0x80, 0x38, 0x0C, 0x07, 0x00,
  0x70, 0x18, 0x0C, 0x00, 0xC0, 0x38, 0x38, 0x01, 0x80, 0x70, 0x60, 0x03,
  0x00, 0xE1, 0x80, 0x07, 0x01, 0x83, 0x00, 0x06, 0x03, 0x0C, 0x3C, 0x0C,
  0x06, 0x18, 0xFE, 0x18, 0x0C, 0x63, 0x8E, 0x38, 0x39, 0xCE, 0x0C, 0x30,
  0xE3, 0x18, 0x0C, 0x3F, 0x8E, 0x30, 0x18, 0x3E, 0x18, 0x60, 0x30, 0x00,
  0x71, 0xC0, 0x60, 0x00, 0xC3, 0x80, 0xE0, 0x03, 0x06, 0x01, 0xC0, 0x06,
  0x0C, 0x03, 0x80, 0x18, 0x1C, 0x07, 0x00, 0x70, 0x38, 0x0C, 0x00, 0xC0,
  0x30, 0x18, 0x03, 0x80, 0x60, 0x30, 0x06, 0x00, 0xC0, 0xE0, 0x1C, 0x00,
  0xC1, 0x80, 0x30, 0x01, 0xEF, 0x00, 0xC0, 0x01, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00,
  0x0C, 0x01, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0xC0,
  0x0C, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0xE0, 0x18, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x38, 0xF0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0xE1, 0xC1, 0xE0,
  0x0C, 0x38, 0x0F, 0x00, 0xC7, 0x00, 0x78, 0x1C, 0x70, 0x03, 0xC1, 0x86,
  0x00, 0x1E, 0x38, 0xE0, 0x00, 0xF3, 0x06, 0x00, 0x07, 0xF0, 0x60, 0x00,
  0x3E, 0x06, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x3F, 0x03, 0x80, 0x07, 0x78,
  0x3E, 0x03, 0xE3, 0xC1, 0xFF, 0xFC, 0x1E, 0x07, 0xFE, 0x00, 0xF0, 0xFF,
  0xED, 0xB6, 0xDB, 0x00, 0x03, 0x83, 0x83, 0x81, 0x81, 0xC0, 0xC0, 0xE0,
  0x60, 0x70, 0x38, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x81, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xC0, 0xE0, 0x70, 0x18, 0x0C, 0x07,
  0x03, 0x80, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0xE0,
  0x38, 0x0E, 0x03, 0x01, 0xC0, 0x60, 0x38, 0x0C, 0x06, 0x03, 0x80, 0xC0,
  0x60, 0x38, 0x1C, 0x0E, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x07, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x70, 0x38, 0x18, 0x1C, 0x0C,
  0x0E, 0x06, 0x07, 0x07, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x10, 0x18, 0x0F, 0xC3,
  0x0F, 0xFF, 0x6F, 0xE1, 0xFF, 0xE0, 0x03, 0x80, 0x00, 0x78, 0x00, 0x1B,
  0x80, 0x06, 0x38, 0x01, 0xC3, 0x00, 0x30, 0x70, 0x0E, 0x07, 0x03, 0x80,
  0xE0, 0x10, 0x08, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x39, 0xCC, 0xE7, 0x31, 0x9C, 0xC6,
  0x30, 0xFF, 0xFF, 0xFF, 0xFC, 0x6F, 0xF7, 0x00, 0x18, 0x00, 0xC0, 0x0E,
  0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00,
  0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30,
  0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01,
  0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x7F, 0xF0, 0x0E, 0x07, 0x81, 0xC0, 0x1C, 0x38, 0x01, 0xC3, 0x80,
  0x0E, 0x30, 0x00, 0xE7, 0x00, 0x06, 0x70, 0x00, 0x66, 0x00, 0x07, 0x60,
  0x00, 0x76, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x36, 0x00, 0x07,
  0x60, 0x00, 0x76, 0x00, 0x07, 0x70, 0x00, 0x77, 0x00, 0x06, 0x30, 0x00,
  0xE3, 0x00, 0x0E, 0x38, 0x00, 0xC1, 0xC0, 0x1C, 0x0E, 0x03, 0x80, 0x7F,
  0xF0, 0x03, 0xFC, 0x00, 0x00, 0xE0, 0x3C, 0x0F, 0x87, 0xF1, 0xCE, 0x71,
  0xFC, 0x3B, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x03,
  0xF8, 0x01, 0xFF, 0xE0, 0x3E, 0x0F, 0x07, 0x00, 0x38, 0x20, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0xF0, 0x7C, 0x07,
  0x8F, 0x00, 0x1C, 0x40, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0xE8, 0x00, 0x1C, 0xE0, 0x07, 0x8F, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x36, 0x00, 0x00,
  0xDC, 0x00, 0x03, 0xB8, 0x00, 0x06, 0x70, 0x00, 0x18, 0xE0, 0x00, 0x71,
  0xC0, 0x01, 0xC3, 0x80, 0x03, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x38, 0x1C,
  0x00, 0x60, 0x38, 0x01, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0xC0,
  0x30, 0x03, 0x80, 0xC0, 0x07, 0x03, 0x80, 0x0E, 0x06, 0x00, 0x1C, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x0C, 0x00,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x40, 0x01, 0xCE,
  0x00, 0xF1, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xF0,
  0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x1F, 0xC1, 0x8F, 0xFE, 0x33, 0x81, 0xE6, 0xC0, 0x0E, 0xF0, 0x00, 0xDC,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0x60, 0x00, 0xEE, 0x00, 0x1C, 0xC0, 0x03, 0x1C,
  0x00, 0xE1, 0xC0, 0x78, 0x1F, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1E, 0x07, 0x83, 0x80,
  0x1C, 0x38, 0x00, 0xE3, 0x00, 0x0E, 0x70, 0x00, 0x67, 0x00, 0x06, 0x30,
  0x00, 0xE3, 0x00, 0x0E, 0x38, 0x01, 0xC1, 0xC0, 0x38, 0x0F, 0x07, 0x00,
  0x7D, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x0F, 0x0F, 0x01, 0xC0, 0x3C,
  0x38, 0x01, 0xC7, 0x00, 0x0E, 0x60, 0x00, 0x76, 0x00, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0x60, 0x00, 0x76, 0x00, 0x07, 0x70, 0x00, 0x63, 0x80,
  0x0E, 0x3C, 0x03, 0xC1, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0xFF, 0xE0, 0x1E, 0x07, 0x03, 0x80, 0x38, 0x70, 0x01, 0xC7, 0x00, 0x0C,
  0x60, 0x00, 0xEE, 0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x76, 0x00, 0x07, 0x70, 0x00, 0xF3, 0x80,
  0x1F, 0x3C, 0x07, 0x71, 0xFF, 0xE7, 0x07, 0xF8, 0x70, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x03, 0xFF, 0xC0,
  0x3F, 0xF0, 0x00, 0x7F, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x06, 0xFF, 0x70, 0x1C, 0xF3, 0xC7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xC6, 0x38, 0xE3, 0x8C, 0x31, 0xC6, 0x18,
  0xC0, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0xF8, 0xF0, 0x3C, 0x40, 0x0E, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x00, 0x3C, 0x01, 0xC0, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x7F, 0x80, 0x63,
  0x00, 0x7F, 0xF0, 0x18, 0xC0, 0x38, 0x0C, 0x06, 0x60, 0x1C, 0x03, 0x01,
  0xD8, 0x0E, 0x00, 0xC0, 0x36, 0x03, 0x00, 0x30, 0x0D, 0x81, 0xC0, 0x0C,
  0x03, 0xE0, 0x70, 0x03, 0x00, 0xF8, 0x18, 0x00, 0xC0, 0x3E, 0x06, 0x00,
  0x30, 0x0F, 0x81, 0x80, 0x1C, 0x06, 0xE0, 0x70, 0x07, 0x01, 0xB8, 0x1C,
  0x01, 0xC0, 0x66, 0x03, 0x00, 0xF0, 0x31, 0x80, 0xE0, 0x66, 0x1C, 0x60,
  0x1F, 0xF9, 0xFE, 0x1C, 0x03, 0xF8, 0x3F, 0x03, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x02, 0x00, 0x01, 0xF0, 0x07,
  0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3B, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x38, 0x00, 0x01, 0xC6, 0x00,
  0x00, 0x61, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x03,
  0x80, 0x01, 0xC0, 0x60, 0x00, 0x60, 0x18, 0x00, 0x38, 0x07, 0x00, 0x0E,
  0x00, 0xC0, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x0E, 0x00, 0x1C, 0x03, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0xE0, 0x70, 0x00, 0x18, 0x18, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x00,
  0x00, 0x31, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x01, 0x98, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1C, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x38, 0x1F, 0xF1, 0xC0,
  0x03, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00, 0x0E,
  0xE0, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x19, 0xC0, 0x01, 0xCE, 0x00,
  0x1C, 0x70, 0x03, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xE0, 0x03, 0xC7,
  0x00, 0x07, 0x38, 0x00, 0x1D, 0xC0, 0x00, 0x6E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xB8,
  0x00, 0x1D, 0xC0, 0x01, 0xCE, 0x00, 0x7C, 0x7F, 0xFF, 0xC3, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xF0, 0x3E, 0x03, 0xC3, 0xC0, 0x01,
  0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0xC0, 0x0C, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0xE0, 0xFF, 0xC0,
  0xE0, 0x03, 0xE0, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x1C,
  0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x06,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x70,
  0xE0, 0x01, 0xE0, 0xE0, 0x1F, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xFF, 0xFD, 0xFF, 0xFE, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xFF, 0xFE, 0xFF, 0xFF, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0xFC, 0x07, 0xC0, 0xF0, 0x00,
  0x20, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x0E,
  0xE0, 0x00, 0x07, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0xE1, 0xE0, 0x00, 0x70, 0x7C, 0x00, 0x78, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xF0, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xC7, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC7, 0xFF, 0xFE, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xEE, 0xF9, 0xFE, 0x1F, 0x00,
  0xE0, 0x00, 0x3F, 0x00, 0x03, 0xB8, 0x00, 0x39, 0xC0, 0x03, 0x8E, 0x00,
  0x38, 0x70, 0x03, 0x83, 0x80, 0x38, 0x1C, 0x03, 0x80, 0xE0, 0x38, 0x07,
  0x03, 0x80, 0x38, 0x38, 0x01, 0xC3, 0x80, 0x0E, 0x38, 0x00, 0x73, 0xC0,
  0x03, 0xBE, 0x00, 0x1F, 0xB8, 0x00, 0xF8, 0xE0, 0x07, 0x87, 0x00, 0x38,
  0x1C, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0x38,
  0x1C, 0x00, 0xE0, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x00, 0x71, 0xC0,
  0x01, 0xCE, 0x00, 0x0F, 0x70, 0x00, 0x3B, 0x80, 0x00, 0xE0, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0D, 0xF6, 0x00,
  0x00, 0xEF, 0xB8, 0x00, 0x06, 0x7D, 0xC0, 0x00, 0x33, 0xE6, 0x00, 0x03,
  0x9F, 0x38, 0x00, 0x18, 0xF8, 0xC0, 0x01, 0xC7, 0xC6, 0x00, 0x0C, 0x3E,
  0x38, 0x00, 0x61, 0xF0, 0xC0, 0x07, 0x0F, 0x87, 0x00, 0x30, 0x7C, 0x18,
  0x03, 0x83, 0xE0, 0xC0, 0x18, 0x1F, 0x07, 0x00, 0xC0, 0xF8, 0x18, 0x0E,
  0x07, 0xC0, 0xE0, 0x60, 0x3E, 0x03, 0x07, 0x01, 0xF0, 0x18, 0x30, 0x0F,
  0x80, 0xE1, 0x80, 0x7C, 0x03, 0x1C, 0x03, 0xE0, 0x1C, 0xC0, 0x1F, 0x00,
  0xEE, 0x00, 0xF8, 0x03, 0x60, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x78,
  0x01, 0xF0, 0x03, 0x80, 0x0F, 0x80, 0x1C, 0x00, 0x60, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3D, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFB, 0x80, 0x01, 0xF3, 0x80, 0x03, 0xE7, 0x00, 0x07, 0xC7,
  0x00, 0x0F, 0x87, 0x00, 0x1F, 0x0E, 0x00, 0x3E, 0x0E, 0x00, 0x7C, 0x0E,
  0x00, 0xF8, 0x1C, 0x01, 0xF0, 0x1C, 0x03, 0xE0, 0x1C, 0x07, 0xC0, 0x38,
  0x0F, 0x80, 0x38, 0x1F, 0x00, 0x38, 0x3E, 0x00, 0x70, 0x7C, 0x00, 0x70,
  0xF8, 0x00, 0x71, 0xF0, 0x00, 0xE3, 0xE0, 0x00, 0xE7, 0xC0, 0x00, 0xEF,
  0x80, 0x01, 0xDF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0x01,
  0xF0, 0x07, 0x80, 0x0F, 0x01, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x33, 0x80, 0x00, 0x0E,
  0x70, 0x00, 0x01, 0x87, 0x00, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x07, 0x00,
  0x07, 0x00, 0x78, 0x03, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC3, 0x83, 0xFC, 0x70, 0x03, 0xCE, 0x00, 0x1D,
  0xC0, 0x01, 0xB8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0D, 0xC0, 0x03, 0xB8, 0x00, 0xE7,
  0x00, 0x7C, 0xFF, 0xFE, 0x1F, 0xFF, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0x01, 0xF0,
  0x07, 0x80, 0x0F, 0x01, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x33, 0x80, 0x00, 0x0E, 0x70,
  0x00, 0x01, 0x87, 0x00, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x07,
  0x00, 0x78, 0x03, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x38, 0x3F, 0xE1, 0xC0, 0x07, 0x8E, 0x00, 0x1C,
  0x70, 0x00, 0x73, 0x80, 0x03, 0x9C, 0x00, 0x1C, 0xE0, 0x00, 0xE7, 0x00,
  0x07, 0x38, 0x00, 0x39, 0xC0, 0x01, 0xCE, 0x00, 0x1C, 0x70, 0x00, 0xE3,
  0x80, 0x1E, 0x1C, 0x0F, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x38, 0x06,
  0x01, 0xC0, 0x38, 0x0E, 0x00, 0xE0, 0x70, 0x07, 0x03, 0x80, 0x1C, 0x1C,
  0x00, 0xE0, 0xE0, 0x03, 0x87, 0x00, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x01,
  0xCE, 0x00, 0x0E, 0x70, 0x00, 0x3B, 0x80, 0x00, 0xE0, 0x03, 0xFF, 0x01,
  0xFF, 0xFC, 0x7C, 0x0F, 0x1C, 0x00, 0x27, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0xEE, 0x00, 0x79, 0xFF, 0xFE, 0x0F, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0x60, 0x00, 0x0C, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x71, 0xE0,
  0x03, 0xC1, 0xE0, 0x0F, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0xCE, 0x00, 0x00, 0xE3,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x30, 0x00, 0x18,
  0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x03, 0x00, 0x06, 0x01, 0xC0, 0x07,
  0x00, 0xE0, 0x03, 0x80, 0x30, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x06, 0x00,
  0xC0, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0x70, 0x00, 0x60, 0x30, 0x00, 0x38,
  0x38, 0x00, 0x1C, 0x1C, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0xC7, 0x00, 0x00, 0x63, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0D, 0x80, 0x00,
  0x06, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x3F, 0x00, 0x03, 0x80, 0x01, 0x98, 0x00, 0x3C,
  0x00, 0x0C, 0xC0, 0x01, 0xE0, 0x00, 0xE7, 0x00, 0x0F, 0x80, 0x07, 0x38,
  0x00, 0xEC, 0x00, 0x30, 0xC0, 0x07, 0x60, 0x03, 0x86, 0x00, 0x33, 0x80,
  0x1C, 0x38, 0x01, 0x8C, 0x00, 0xE1, 0xC0, 0x1C, 0x60, 0x06, 0x06, 0x00,
  0xC3, 0x00, 0x70, 0x38, 0x06, 0x1C, 0x03, 0x81, 0xC0, 0x70, 0x60, 0x18,
  0x06, 0x03, 0x83, 0x00, 0xC0, 0x30, 0x18, 0x1C, 0x0E, 0x01, 0xC0, 0xC0,
  0x60, 0x70, 0x0E, 0x0E, 0x03, 0x03, 0x00, 0x30, 0x60, 0x18, 0x18, 0x01,
  0x83, 0x00, 0xE1, 0xC0, 0x0E, 0x18, 0x03, 0x0E, 0x00, 0x71, 0xC0, 0x18,
  0x60, 0x01, 0x8C, 0x00, 0xE7, 0x00, 0x0C, 0x60, 0x03, 0x38, 0x00, 0x77,
  0x00, 0x19, 0x80, 0x03, 0xB8, 0x00, 0xCC, 0x00, 0x0D, 0x80, 0x07, 0xE0,
  0x00, 0x6C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x0E, 0x30, 0x00, 0x1C, 0x38, 0x00, 0x18, 0x1C, 0x00, 0x38,
  0x0C, 0x00, 0x70, 0x0E, 0x00, 0x60, 0x07, 0x00, 0xE0, 0x07, 0x00, 0xC0,
  0x03, 0x81, 0xC0, 0x01, 0xC3, 0x80, 0x01, 0xC3, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x6E, 0x00, 0x00, 0xE7, 0x00, 0x01, 0xC7, 0x00,
  0x01, 0x83, 0x80, 0x03, 0x81, 0x80, 0x03, 0x01, 0xC0, 0x07, 0x00, 0xE0,
  0x0E, 0x00, 0x60, 0x0C, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x38,
  0x30, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0E,
  0xC0, 0x00, 0x19, 0xC0, 0x00, 0x71, 0x80, 0x00, 0xC3, 0x80, 0x03, 0x83,
  0x80, 0x0E, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E,
  0x03, 0x80, 0x0C, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x18, 0x30, 0x00, 0x38,
  0xE0, 0x00, 0x31, 0x80, 0x00, 0x77, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0F, 0xFF, 0xFC, 0xC0, 0x06, 0x00, 0x38,
  0x00, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0,
  0x07, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00,
  0x18, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00,
  0x60, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0x60, 0xFF,
  0xFF, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x3F, 0xFF, 0xFC, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xB0, 0x00, 0x19, 0x80, 0x00, 0xC6, 0x00, 0x0C, 0x30,
  0x00, 0x60, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x18, 0x03, 0x00, 0xC0, 0x18,
  0x03, 0x01, 0x80, 0x18, 0x0C, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x0C,
  0x70, 0x00, 0x63, 0x00, 0x01, 0xB8, 0x00, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xE0, 0x70, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0xFC, 0x0F, 0xFF,
  0xC1, 0xC0, 0x70, 0x40, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x3F, 0xFC, 0x7F, 0xF7, 0x3C,
  0x01, 0xDC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x1F, 0x70, 0x0D, 0xCF, 0xFE, 0x31, 0xFF, 0x0C,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x0F, 0xF0, 0x67, 0xFF, 0x8D, 0xC0, 0x79, 0xB0, 0x07, 0x3C, 0x00, 0x77,
  0x00, 0x06, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x6F, 0x00, 0x1D, 0xE0, 0x07, 0x37,
  0x01, 0xE6, 0x7F, 0xF8, 0xC7, 0xFC, 0x00, 0x01, 0xFF, 0x03, 0xFF, 0xC3,
  0xC0, 0x63, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x08, 0x7F, 0xFC, 0x0F, 0xFC, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x03, 0xFC, 0x30,
  0xFF, 0xF3, 0x1E, 0x03, 0xB3, 0xC0, 0x1B, 0x38, 0x00, 0xF7, 0x00, 0x07,
  0x70, 0x00, 0x76, 0x00, 0x07, 0x60, 0x00, 0x76, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0x60, 0x00, 0x76, 0x00,
  0x07, 0x70, 0x00, 0x77, 0x00, 0x07, 0x30, 0x00, 0xF3, 0x80, 0x1B, 0x1E,
  0x03, 0xB0, 0xFF, 0xF3, 0x07, 0xFC, 0x30, 0x03, 0xFC, 0x00, 0xFF, 0xE0,
  0x38, 0x0E, 0x0E, 0x00, 0xE3, 0x80, 0x0C, 0x60, 0x01, 0xDC, 0x00, 0x3B,
  0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x0C, 0x1F, 0xFF, 0x80,
  0xFF, 0xE0, 0x00, 0xFE, 0x07, 0xF8, 0x1E, 0x10, 0x70, 0x00, 0xE0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x01, 0xFF, 0xC7, 0xFF,
  0x80, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x03, 0xFC, 0x30, 0xFF, 0xF3, 0x1E, 0x03, 0xB1,
  0xC0, 0x1B, 0x38, 0x00, 0xF7, 0x00, 0x07, 0x70, 0x00, 0x76, 0x00, 0x07,
  0x60, 0x00, 0x76, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x36, 0x00, 0x03, 0x60, 0x00, 0x76, 0x00, 0x07, 0x70, 0x00, 0x77, 0x00,
  0x07, 0x38, 0x00, 0xF3, 0x80, 0x1B, 0x1E, 0x03, 0xB0, 0xFF, 0xF3, 0x07,
  0xFC, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0xE2, 0x00, 0x1E, 0x38, 0x03, 0xC3, 0xFF, 0xF8,
  0x0F, 0xFE, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x3F, 0xC3, 0x3F, 0xFC, 0xDC, 0x07, 0xB6, 0x00, 0xEF, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0x6F, 0x70, 0x00, 0x00, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x03, 0x03,
  0xC0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x38, 0x1D, 0xFC, 0xFC, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x01, 0xD8, 0x01, 0xCC, 0x01,
  0xC6, 0x01, 0xC3, 0x01, 0xC1, 0x80, 0xC0, 0xC0, 0xE0, 0x60, 0xE0, 0x30,
  0xE0, 0x18, 0xE0, 0x0C, 0xF0, 0x06, 0xFC, 0x03, 0xEE, 0x01, 0xE3, 0x80,
  0xE0, 0xE0, 0x60, 0x38, 0x30, 0x1C, 0x18, 0x07, 0x0C, 0x01, 0xC6, 0x00,
  0x73, 0x00, 0x39, 0x80, 0x0E, 0xC0, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC3, 0xF8, 0x0F, 0xE1, 0x9F, 0xFC, 0x7F,
  0xF3, 0x70, 0x39, 0xC0, 0xF7, 0x80, 0x3F, 0x00, 0xEF, 0x00, 0x3C, 0x00,
  0xFC, 0x00, 0x70, 0x01, 0xF8, 0x00, 0xE0, 0x03, 0xE0, 0x01, 0xC0, 0x03,
  0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80,
  0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0x80, 0xC3,
  0xFC, 0x33, 0xFF, 0xCD, 0xC0, 0x7B, 0x60, 0x0E, 0xF0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0C, 0x03, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0x80, 0xF0, 0x38,
  0x01, 0xC3, 0x80, 0x06, 0x18, 0x00, 0x39, 0xC0, 0x00, 0xCC, 0x00, 0x06,
  0x60, 0x00, 0x3B, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xB0, 0x00, 0x1D, 0x80, 0x00, 0xEC, 0x00, 0x06, 0x70, 0x00, 0x31,
  0x80, 0x03, 0x8E, 0x00, 0x18, 0x38, 0x01, 0xC1, 0xE0, 0x3C, 0x03, 0xFF,
  0xC0, 0x0F, 0xF8, 0x00, 0xC3, 0xFC, 0x19, 0xFF, 0xE3, 0x70, 0x1E, 0x6C,
  0x01, 0xEF, 0x00, 0x1D, 0xC0, 0x01, 0xB8, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1B, 0xC0,
  0x07, 0x7C, 0x01, 0xCD, 0xC0, 0x79, 0x9F, 0xFE, 0x30, 0xFF, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x30, 0xFF, 0xF3, 0x1E, 0x03, 0xB3, 0xC0, 0x1B, 0x38, 0x00, 0xF7,
  0x00, 0x07, 0x70, 0x00, 0x76, 0x00, 0x07, 0x60, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x60, 0x00,
  0x76, 0x00, 0x07, 0x70, 0x00, 0x77, 0x00, 0x07, 0x38, 0x00, 0xF3, 0x80,
  0x1B, 0x1E, 0x03, 0xB0, 0xFF, 0xF3, 0x07, 0xFC, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0xC3, 0xFC,
  0xFF, 0xDC, 0x0D, 0x80, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x0F, 0xFC, 0x3F,
  0xFF, 0x78, 0x06, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x07, 0xC0, 0x0E, 0xFF, 0xFC, 0x7F, 0xF0, 0x08, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x7F, 0xFB, 0xFF, 0xC3, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00,
  0x70, 0x03, 0xFE, 0x0F, 0xF0, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0x60, 0x00, 0xEC, 0x00, 0x3D,
  0xC0, 0x07, 0xB8, 0x01, 0xF3, 0x80, 0x66, 0x3F, 0xF8, 0xC3, 0xFE, 0x18,
  0xE0, 0x00, 0x76, 0x00, 0x07, 0x70, 0x00, 0x67, 0x00, 0x0E, 0x30, 0x00,
  0xE3, 0x80, 0x0C, 0x38, 0x01, 0xC1, 0x80, 0x18, 0x1C, 0x03, 0x80, 0xC0,
  0x38, 0x0E, 0x03, 0x00, 0xE0, 0x70, 0x06, 0x06, 0x00, 0x70, 0x60, 0x03,
  0x0E, 0x00, 0x30, 0xC0, 0x03, 0x9C, 0x00, 0x19, 0xC0, 0x01, 0x98, 0x00,
  0x1F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x03,
  0x00, 0x1F, 0x80, 0x1E, 0x00, 0x7E, 0x00, 0x78, 0x01, 0x98, 0x01, 0xE0,
  0x06, 0x60, 0x0F, 0xC0, 0x39, 0xC0, 0x33, 0x00, 0xE7, 0x00, 0xCC, 0x03,
  0x0C, 0x07, 0x38, 0x0C, 0x30, 0x18, 0x60, 0x70, 0xE0, 0x61, 0x81, 0xC1,
  0x83, 0x87, 0x06, 0x06, 0x0C, 0x0C, 0x18, 0x1C, 0x30, 0x30, 0xE0, 0x71,
  0xC0, 0xE3, 0x00, 0xC6, 0x03, 0x8C, 0x03, 0x18, 0x06, 0x70, 0x0E, 0xE0,
  0x19, 0xC0, 0x3B, 0x00, 0x76, 0x00, 0x6C, 0x00, 0xD8, 0x01, 0xB0, 0x03,
  0x60, 0x07, 0x80, 0x0F, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0xE7, 0x00, 0x1C, 0x38, 0x01, 0x81, 0xC0, 0x38, 0x1C,
  0x07, 0x00, 0xE0, 0x60, 0x07, 0x0E, 0x00, 0x31, 0xC0, 0x03, 0x98, 0x00,
  0x1F, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xF0, 0x00, 0x1B, 0x80,
  0x03, 0x9C, 0x00, 0x70, 0xC0, 0x06, 0x0E, 0x00, 0xE0, 0x70, 0x1C, 0x03,
  0x03, 0x80, 0x38, 0x38, 0x01, 0xC7, 0x00, 0x0E, 0xE0, 0x00, 0xF0, 0xE0,
  0x00, 0x76, 0x00, 0x07, 0x70, 0x00, 0x67, 0x00, 0x0E, 0x30, 0x00, 0xE3,
  0x80, 0x0C, 0x18, 0x01, 0xC1, 0x80, 0x18, 0x1C, 0x03, 0x80, 0xC0, 0x38,
  0x0E, 0x03, 0x00, 0x60, 0x70, 0x06, 0x06, 0x00, 0x70, 0x60, 0x03, 0x0E,
  0x00, 0x38, 0xC0, 0x03, 0x9C, 0x00, 0x19, 0xC0, 0x01, 0xD8, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0x7F, 0xFF, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x07, 0xC0,
  0x78, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00,
  0xE0, 0x3E, 0x01, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0xE0, 0x0F, 0x80, 0x1C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xE0,
  0x1F, 0x80, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x03,
  0x80, 0x0E, 0x00, 0x3E, 0x00, 0xF0, 0x1E, 0x01, 0xC0, 0x0E, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x7C, 0x0F, 0xC0, 0x70, 0x00, 0x04,
  0x00, 0x03, 0xFC, 0x01, 0xFF, 0xF0, 0x3C, 0x07, 0xFF, 0x80, 0x0F, 0xC0,
};

const GFXglyph NotoSans_Light43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 4, 31, 11, 3, -31 },
  { 17, 10, 11, 16, 3, -31 },
  { 31, 26, 31, 28, 1, -31 },
  { 132, 18, 36, 25, 3, -33 },
  { 213, 31, 31, 35, 2, -31 },
  { 334, 28, 31, 31, 2, -31 },
  { 443, 3, 11, 9, 3, -31 },
  { 448, 9, 38, 12, 2, -31 },
  { 491, 9, 38, 12, 1, -31 },
  { 534, 19, 19, 24, 2, -33 },
  { 580, 20, 20, 25, 2, -25 },
  { 630, 5, 11, 10, 2, -5 },
  { 637, 10, 3, 14, 2, -13 },
  { 641, 4, 4, 10, 3, -4 },
  { 643, 13, 31, 15, 1, -31 },
  { 694, 20, 31, 25, 2, -31 },
  { 772, 11, 31, 25, 4, -31 },
  { 815, 20, 31, 25, 2, -31 },
  { 893, 20, 31, 25, 2, -31 },
  { 971, 23, 31, 25, 1, -31 },
  { 1061, 19, 31, 25, 3, -31 },
  { 1135, 19, 31, 25, 3, -31 },
  { 1209, 20, 31, 25, 2, -31 },
  { 1287, 20, 31, 25, 2, -31 },
  { 1365, 20, 31, 25, 2, -31 },
  { 1443, 4, 23, 10, 3, -23 },
  { 1455, 6, 29, 10, 1, -23 },
  { 1477, 20, 21, 25, 2, -26 },
  { 1530, 20, 11, 25, 2, -21 },
  { 1558, 20, 21, 25, 2, -26 },
  { 1611, 16, 31, 18, 1, -31 },
  { 1673, 34, 35, 38, 2, -31 },
  { 1822, 26, 31, 26, 0, -31 },
  { 1923, 21, 31, 27, 4, -31 },
  { 2005, 22, 31, 27, 3, -31 },
  { 2091, 24, 31, 31, 4, -31 },
  { 2184, 17, 31, 24, 4, -31 },
  { 2250, 17, 31, 22, 4, -31 },
  { 2316, 25, 31, 31, 3, -31 },
  { 2413, 23, 31, 31, 4, -31 },
  { 2503, 9, 31, 13, 2, -31 },
  { 2538, 11, 39, 11, -4, -31 },
  { 2592, 21, 31, 25, 4, -31 },
  { 2674, 17, 31, 22, 4, -31 },
  { 2740, 29, 31, 38, 4, -31 },
  { 2853, 23, 31, 31, 4, -31 },
  { 2943, 27, 31, 33, 3, -31 },
  { 3048, 19, 31, 25, 4, -31 },
  { 3122, 27, 38, 33, 3, -31 },
  { 3251, 21, 31, 26, 4, -31 },
  { 3333, 19, 31, 23, 2, -31 },
  { 3407, 23, 31, 23, 0, -31 },
  { 3497, 23, 31, 31, 4, -31 },
  { 3587, 25, 31, 25, 0, -31 },
  { 3684, 37, 31, 39, 1, -31 },
  { 3828, 24, 31, 24, 0, -31 },
  { 3921, 23, 31, 23, 0, -31 },
  { 4011, 21, 31, 25, 2, -31 },
  { 4093, 9, 38, 14, 4, -31 },
  { 4136, 13, 31, 15, 1, -31 },
  { 4187, 9, 38, 14, 1, -31 },
  { 4230, 21, 19, 25, 2, -31 },
  { 4280, 18, 2, 18, 0, 4 },
  { 4285, 8, 7, 11, 2, -33 },
  { 4292, 18, 23, 23, 2, -23 },
  { 4344, 19, 33, 26, 4, -33 },
  { 4423, 17, 23, 20, 2, -23 },
  { 4472, 20, 33, 26, 2, -33 },
  { 4555, 19, 23, 24, 2, -23 },
  { 4610, 15, 33, 13, 1, -33 },
  { 4672, 20, 33, 26, 2, -23 },
  { 4755, 18, 33, 26, 4, -33 },
  { 4830, 4, 31, 10, 3, -31 },
  { 4846, 9, 41, 10, -2, -31 },
  { 4893, 17, 33, 21, 4, -33 },
  { 4964, 2, 33, 10, 4, -33 },
  { 4973, 31, 23, 38, 4, -23 },
  { 5063, 18, 23, 26, 4, -23 },
  { 5115, 21, 23, 25, 2, -23 },
  { 5176, 19, 33, 26, 4, -23 },
  { 5255, 20, 33, 26, 2, -23 },
  { 5338, 12, 23, 17, 4, -23 },
  { 5373, 16, 23, 20, 2, -23 },
  { 5419, 13, 28, 15, 1, -28 },
  { 5465, 19, 23, 26, 3, -23 },
  { 5520, 20, 23, 20, 0, -23 },
  { 5578, 30, 23, 32, 1, -23 },
  { 5665, 20, 23, 22, 1, -23 },
  { 5723, 20, 33, 20, 0, -23 },
  { 5806, 16, 23, 20, 2, -23 },
  { 5852, 13, 38, 15, 1, -31 },
  { 5914, 2, 44, 23, 11, -33 },
  { 5925, 13, 38, 15, 1, -31 },
  { 5987, 20, 5, 25, 2, -18 },
};

const GFXfont NotoSans_Light43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light43pt7bBitmaps,
  (GFXglyph *)NotoSans_Light43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_LIGHT43PT7B_H_
