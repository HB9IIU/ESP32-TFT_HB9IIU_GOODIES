#ifndef _NOTOSANS_LIGHT8PT7B_H_
#define _NOTOSANS_LIGHT8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light8pt7bBitmaps[] PROGMEM = {
  0x00, 0xFC, 0xC0, 0x31, 0x96, 0xAF, 0xB0, 0x7A, 0x43, 0x36, 0x4A, 0xAB,
  0x95, 0x35, 0x30, 0x61, 0x42, 0x19, 0x99, 0xF0, 0xC0, 0x6A, 0xA4, 0x95,
  0x5C, 0x2F, 0x60, 0x22, 0xF2, 0xC0, 0xC0, 0x80, 0x29, 0x29, 0x00, 0x69,
  0x99, 0x97, 0x75, 0x50, 0x61, 0x12, 0x4F, 0xE1, 0x17, 0x1F, 0x13, 0x59,
  0xF1, 0xF3, 0x13, 0xC0, 0x34, 0xE9, 0x97, 0xF1, 0x12, 0x24, 0x69, 0x75,
  0x97, 0x69, 0x97, 0x16, 0x10, 0x18, 0x16, 0xC3, 0xFF, 0xC2, 0x3C, 0xE4,
  0xA4, 0x80, 0x38, 0x8A, 0xED, 0x5B, 0xE8, 0x0E, 0x00, 0x23, 0x14, 0xE8,
  0xC4, 0xE9, 0xAD, 0x9E, 0x3A, 0x21, 0x08, 0x3C, 0xE9, 0x99, 0x9E, 0xF2,
  0x79, 0xC0, 0xF2, 0x79, 0x00, 0x3A, 0x21, 0x38, 0xBC, 0x99, 0x9F, 0x99,
  0xD5, 0x70, 0x55, 0x5C, 0x9A, 0xCC, 0xA9, 0x92, 0x49, 0xC0, 0x8C, 0x67,
  0xBD, 0xD4, 0x99, 0xDB, 0xB9, 0x39, 0x18, 0x61, 0x85, 0xE0, 0xD6, 0xE9,
  0x00, 0x39, 0x18, 0x61, 0x85, 0xA1, 0x80, 0xEA, 0xAC, 0xA9, 0x78, 0x43,
  0x1F, 0xF2, 0x22, 0x22, 0x99, 0x99, 0x9F, 0x8C, 0x94, 0xA6, 0x10, 0x93,
  0x25, 0xAB, 0x66, 0x48, 0x80, 0x95, 0x22, 0x59, 0x99, 0x62, 0x22, 0xF1,
  0x24, 0x4F, 0xFE, 0x91, 0x24, 0x40, 0xD5, 0x5C, 0x26, 0x59, 0xE0, 0xC0,
  0x77, 0x9F, 0x9A, 0xDB, 0xC0, 0x78, 0x87, 0x13, 0x59, 0x97, 0x7F, 0x87,
  0x79, 0x24, 0x80, 0x79, 0x97, 0x17, 0x9A, 0xDB, 0x40, 0xBC, 0xBF, 0x97,
  0x4D, 0x40, 0xFC, 0xFE, 0x9A, 0x69, 0xF6, 0xD0, 0x79, 0x97, 0xF6, 0xF9,
  0x00, 0x79, 0x97, 0x11, 0xEA, 0xE8, 0xF0, 0xF2, 0x46, 0xB6, 0xF0, 0x9A,
  0x64, 0xA6, 0xD5, 0x92, 0xF2, 0x69, 0x9A, 0x64, 0x48, 0xE5, 0x70, 0x29,
  0x64, 0x98, 0xFF, 0x89, 0x34, 0xB0, 0xF0,
};

const GFXglyph NotoSans_Light8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 6, 2, 0, -6 },
  { 2, 1, 2, 3, 1, -6 },
  { 3, 5, 6, 5, 0, -6 },
  { 7, 4, 6, 5, 0, -6 },
  { 10, 6, 6, 7, 0, -6 },
  { 15, 6, 6, 6, 0, -6 },
  { 20, 1, 2, 2, 0, -6 },
  { 21, 2, 7, 2, 0, -6 },
  { 23, 2, 7, 2, 0, -6 },
  { 25, 4, 3, 4, 0, -6 },
  { 27, 4, 4, 5, 0, -5 },
  { 29, 1, 2, 2, 0, -1 },
  { 30, 2, 1, 3, 0, -3 },
  { 31, 1, 1, 2, 0, -1 },
  { 32, 3, 6, 3, 0, -6 },
  { 35, 4, 6, 5, 0, -6 },
  { 38, 2, 6, 5, 1, -6 },
  { 40, 4, 6, 5, 0, -6 },
  { 43, 4, 6, 5, 0, -6 },
  { 46, 4, 6, 5, 0, -6 },
  { 49, 3, 6, 5, 1, -6 },
  { 52, 4, 6, 5, 0, -6 },
  { 55, 4, 6, 5, 0, -6 },
  { 58, 4, 6, 5, 0, -6 },
  { 61, 4, 6, 5, 0, -6 },
  { 64, 1, 4, 2, 0, -4 },
  { 65, 1, 5, 2, 0, -4 },
  { 66, 4, 4, 5, 0, -5 },
  { 68, 4, 2, 5, 0, -4 },
  { 69, 4, 4, 5, 0, -5 },
  { 71, 3, 6, 3, 0, -6 },
  { 74, 7, 7, 7, 0, -6 },
  { 81, 5, 6, 5, 0, -6 },
  { 85, 4, 6, 5, 1, -6 },
  { 88, 5, 6, 5, 0, -6 },
  { 92, 4, 6, 6, 1, -6 },
  { 95, 3, 6, 4, 1, -6 },
  { 98, 3, 6, 4, 1, -6 },
  { 101, 5, 6, 6, 0, -6 },
  { 105, 4, 6, 6, 1, -6 },
  { 108, 2, 6, 2, 0, -6 },
  { 110, 2, 7, 2, -1, -6 },
  { 112, 4, 6, 5, 1, -6 },
  { 115, 3, 6, 4, 1, -6 },
  { 118, 5, 6, 7, 1, -6 },
  { 122, 4, 6, 6, 1, -6 },
  { 125, 6, 6, 6, 0, -6 },
  { 130, 3, 6, 5, 1, -6 },
  { 133, 6, 7, 6, 0, -6 },
  { 139, 4, 6, 5, 1, -6 },
  { 142, 4, 6, 4, 0, -6 },
  { 145, 4, 6, 4, 0, -6 },
  { 148, 4, 6, 6, 1, -6 },
  { 151, 5, 6, 5, 0, -6 },
  { 155, 7, 6, 7, 0, -6 },
  { 161, 4, 6, 4, 0, -6 },
  { 164, 4, 6, 4, 0, -6 },
  { 167, 4, 6, 5, 0, -6 },
  { 170, 1, 7, 3, 1, -6 },
  { 171, 3, 6, 3, 0, -6 },
  { 174, 2, 7, 3, 0, -6 },
  { 176, 4, 4, 5, 0, -6 },
  { 178, 3, 1, 3, 0, 0 },
  { 179, 2, 1, 2, 0, -6 },
  { 180, 4, 4, 4, 0, -4 },
  { 182, 3, 6, 5, 1, -6 },
  { 185, 4, 4, 4, 0, -4 },
  { 187, 4, 6, 5, 0, -6 },
  { 190, 4, 4, 4, 0, -4 },
  { 192, 3, 6, 2, 0, -6 },
  { 195, 4, 6, 5, 0, -4 },
  { 198, 3, 6, 5, 1, -6 },
  { 201, 1, 6, 2, 0, -6 },
  { 202, 1, 8, 2, 0, -6 },
  { 203, 3, 6, 4, 1, -6 },
  { 206, 1, 6, 2, 0, -6 },
  { 207, 6, 4, 7, 1, -4 },
  { 210, 3, 4, 5, 1, -4 },
  { 212, 4, 4, 5, 0, -4 },
  { 214, 3, 6, 5, 1, -4 },
  { 217, 4, 6, 5, 0, -4 },
  { 220, 2, 4, 3, 1, -4 },
  { 221, 3, 4, 4, 0, -4 },
  { 223, 3, 5, 3, 0, -5 },
  { 225, 3, 4, 5, 1, -4 },
  { 227, 4, 4, 4, 0, -4 },
  { 229, 6, 4, 6, 0, -4 },
  { 232, 4, 4, 4, 0, -4 },
  { 234, 4, 6, 4, 0, -4 },
  { 237, 3, 4, 4, 0, -4 },
  { 239, 3, 7, 3, 0, -6 },
  { 242, 1, 8, 4, 2, -6 },
  { 243, 3, 7, 3, 0, -6 },
  { 246, 4, 1, 5, 0, -3 },
};

const GFXfont NotoSans_Light8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light8pt7bBitmaps,
  (GFXglyph *)NotoSans_Light8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_LIGHT8PT7B_H_
