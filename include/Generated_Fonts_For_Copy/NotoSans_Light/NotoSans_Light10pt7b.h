#ifndef _NOTOSANS_LIGHT10PT7B_H_
#define _NOTOSANS_LIGHT10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light10pt7bBitmaps[] PROGMEM = {
  0x00, 0xFA, 0xF0, 0x28, 0xA7, 0xCA, 0xFD, 0x45, 0x00, 0x4F, 0xCC, 0x65,
  0x5E, 0x40, 0xC9, 0x52, 0xD6, 0xD3, 0x29, 0x53, 0x00, 0xF2, 0x46, 0x28,
  0x96, 0x2F, 0x40, 0xC0, 0x5A, 0xA5, 0x40, 0xD5, 0x55, 0x80, 0x44, 0xF6,
  0xA0, 0x44, 0xF4, 0x40, 0x60, 0xE0, 0x80, 0x24, 0xA5, 0x20, 0xF9, 0x99,
  0x99, 0xE0, 0x75, 0x54, 0xE1, 0x12, 0x48, 0xF0, 0x78, 0x42, 0x60, 0x87,
  0xC0, 0x10, 0xA2, 0x92, 0xFC, 0x20, 0x80, 0xF8, 0xC3, 0x11, 0xE0, 0x78,
  0xE9, 0x99, 0xF0, 0xF1, 0x22, 0x24, 0x40, 0xF9, 0x96, 0x99, 0xF0, 0xF9,
  0x9B, 0x51, 0xE0, 0x88, 0x40, 0x60, 0x16, 0x86, 0x10, 0xF0, 0xF0, 0x86,
  0x16, 0x80, 0xF1, 0x12, 0x40, 0x40, 0x7D, 0x06, 0xEE, 0x5C, 0xB6, 0xE0,
  0x3C, 0x10, 0xC2, 0x92, 0x7A, 0x18, 0x40, 0xF4, 0x65, 0xE8, 0xC7, 0xC0,
  0x7C, 0x21, 0x08, 0x41, 0xE0, 0xF4, 0x63, 0x18, 0xC7, 0xC0, 0xF8, 0x8F,
  0x88, 0xF0, 0xF8, 0x8F, 0x88, 0x80, 0x7C, 0x21, 0x38, 0xC5, 0xE0, 0x8C,
  0x63, 0xF8, 0xC6, 0x20, 0xEA, 0xAC, 0x24, 0x92, 0x49, 0xC0, 0x9D, 0x31,
  0x8A, 0x4A, 0x20, 0x88, 0x88, 0x88, 0xF0, 0x83, 0x8F, 0x1D, 0x5A, 0xB6,
  0x64, 0x80, 0x8E, 0x6B, 0x59, 0xC6, 0x20, 0x7A, 0x18, 0x61, 0x86, 0x17,
  0x80, 0xF9, 0x9F, 0x88, 0x80, 0x7A, 0x18, 0x61, 0x86, 0x16, 0x84, 0x08,
  0xF4, 0x65, 0xCA, 0x4A, 0x20, 0xF8, 0x86, 0x11, 0xE0, 0xF9, 0x08, 0x42,
  0x10, 0x80, 0x8C, 0x63, 0x18, 0xC5, 0xC0, 0x86, 0x24, 0x92, 0x30, 0xC2,
  0x00, 0x88, 0xCC, 0x55, 0x4A, 0xA5, 0x51, 0x10, 0x88, 0x8A, 0x8C, 0x45,
  0x26, 0x20, 0x8A, 0x54, 0x42, 0x10, 0x80, 0x78, 0x44, 0x42, 0x23, 0xE0,
  0xEA, 0xAA, 0xC0, 0x89, 0x22, 0x48, 0xD5, 0x55, 0xC0, 0x21, 0x93, 0x90,
  0xF0, 0x90, 0x78, 0x5F, 0x17, 0x80, 0x88, 0xE9, 0x99, 0x9F, 0xF2, 0x4E,
  0x11, 0x79, 0x99, 0x9F, 0xF9, 0xE8, 0xF0, 0x34, 0xE4, 0x44, 0x44, 0xF9,
  0x99, 0xF1, 0xF0, 0x88, 0xE9, 0x99, 0x99, 0xBE, 0x20, 0x92, 0x49, 0xE0,
  0x88, 0x9A, 0xCC, 0xA9, 0xFF, 0xFF, 0x26, 0x4C, 0x99, 0x20, 0xF9, 0x99,
  0x90, 0xF9, 0x99, 0xF0, 0xF9, 0x99, 0xF8, 0x80, 0xF9, 0x99, 0xF1, 0x10,
  0xF2, 0x48, 0xFC, 0x31, 0xF0, 0x5D, 0x24, 0x98, 0x99, 0x99, 0xF0, 0x8C,
  0x94, 0xC2, 0x00, 0x93, 0x35, 0xAB, 0x64, 0x40, 0xDA, 0x88, 0xA8, 0x80,
  0x8A, 0x94, 0xC2, 0x13, 0x00, 0x72, 0x24, 0xF0, 0x29, 0x2C, 0x92, 0x20,
  0xFF, 0xC0, 0xC9, 0x22, 0x92, 0x80, 0xF0,
};

const GFXglyph NotoSans_Light10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 7, 2, 1, -7 },
  { 2, 2, 2, 4, 1, -7 },
  { 3, 6, 7, 6, 0, -7 },
  { 9, 4, 9, 6, 1, -8 },
  { 14, 7, 7, 8, 1, -7 },
  { 21, 6, 7, 7, 1, -7 },
  { 27, 1, 2, 2, 1, -7 },
  { 28, 2, 9, 3, 0, -7 },
  { 31, 2, 9, 3, 0, -7 },
  { 34, 4, 5, 6, 1, -8 },
  { 37, 4, 5, 6, 1, -6 },
  { 40, 2, 2, 2, 0, -1 },
  { 41, 3, 1, 3, 0, -3 },
  { 42, 1, 1, 2, 1, -1 },
  { 43, 3, 7, 3, 0, -7 },
  { 46, 4, 7, 6, 1, -7 },
  { 50, 2, 7, 6, 1, -7 },
  { 52, 4, 7, 6, 1, -7 },
  { 56, 5, 7, 6, 0, -7 },
  { 61, 6, 7, 6, 0, -7 },
  { 67, 4, 7, 6, 1, -7 },
  { 71, 4, 7, 6, 1, -7 },
  { 75, 4, 7, 6, 1, -7 },
  { 79, 4, 7, 6, 1, -7 },
  { 83, 4, 7, 6, 1, -7 },
  { 87, 1, 5, 2, 1, -5 },
  { 88, 2, 6, 2, 0, -5 },
  { 90, 4, 5, 6, 1, -6 },
  { 93, 4, 3, 6, 1, -5 },
  { 95, 4, 5, 6, 1, -6 },
  { 98, 4, 7, 4, 0, -7 },
  { 102, 7, 8, 9, 1, -7 },
  { 109, 6, 7, 6, 0, -7 },
  { 115, 5, 7, 6, 1, -7 },
  { 120, 5, 7, 6, 1, -7 },
  { 125, 5, 7, 7, 1, -7 },
  { 130, 4, 7, 6, 1, -7 },
  { 134, 4, 7, 5, 1, -7 },
  { 138, 5, 7, 7, 1, -7 },
  { 143, 5, 7, 7, 1, -7 },
  { 148, 2, 7, 3, 1, -7 },
  { 150, 3, 9, 3, -1, -7 },
  { 154, 5, 7, 6, 1, -7 },
  { 159, 4, 7, 5, 1, -7 },
  { 163, 7, 7, 9, 1, -7 },
  { 170, 5, 7, 7, 1, -7 },
  { 175, 6, 7, 8, 1, -7 },
  { 181, 4, 7, 6, 1, -7 },
  { 185, 6, 9, 8, 1, -7 },
  { 192, 5, 7, 6, 1, -7 },
  { 197, 4, 7, 5, 1, -7 },
  { 201, 5, 7, 5, 0, -7 },
  { 206, 5, 7, 7, 1, -7 },
  { 211, 6, 7, 6, 0, -7 },
  { 217, 9, 7, 9, 0, -7 },
  { 225, 5, 7, 5, 0, -7 },
  { 230, 5, 7, 5, 0, -7 },
  { 235, 5, 7, 6, 0, -7 },
  { 240, 2, 9, 3, 1, -7 },
  { 243, 3, 7, 3, 0, -7 },
  { 246, 2, 9, 3, 0, -7 },
  { 249, 5, 4, 6, 0, -7 },
  { 252, 4, 1, 4, 0, 1 },
  { 253, 2, 2, 3, 0, -8 },
  { 254, 5, 5, 5, 0, -5 },
  { 258, 4, 8, 6, 1, -8 },
  { 262, 3, 5, 5, 1, -5 },
  { 264, 4, 8, 6, 1, -8 },
  { 268, 4, 5, 6, 1, -5 },
  { 271, 4, 8, 3, 0, -8 },
  { 275, 4, 7, 6, 1, -5 },
  { 279, 4, 8, 6, 1, -8 },
  { 283, 1, 7, 2, 1, -7 },
  { 284, 3, 9, 2, -1, -7 },
  { 288, 4, 8, 5, 1, -8 },
  { 292, 1, 8, 2, 1, -8 },
  { 293, 7, 5, 9, 1, -5 },
  { 298, 4, 5, 6, 1, -5 },
  { 301, 4, 5, 6, 1, -5 },
  { 304, 4, 7, 6, 1, -5 },
  { 308, 4, 7, 6, 1, -5 },
  { 312, 3, 5, 4, 1, -5 },
  { 314, 4, 5, 5, 0, -5 },
  { 317, 3, 7, 3, 0, -7 },
  { 320, 4, 5, 6, 1, -5 },
  { 323, 5, 5, 5, 0, -5 },
  { 327, 7, 5, 7, 0, -5 },
  { 332, 5, 5, 5, 0, -5 },
  { 336, 5, 7, 5, 0, -5 },
  { 341, 4, 5, 5, 0, -5 },
  { 344, 3, 9, 4, 0, -7 },
  { 348, 1, 10, 5, 2, -8 },
  { 350, 3, 9, 4, 0, -7 },
  { 354, 4, 1, 6, 1, -4 },
};

const GFXfont NotoSans_Light10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light10pt7bBitmaps,
  (GFXglyph *)NotoSans_Light10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_LIGHT10PT7B_H_
