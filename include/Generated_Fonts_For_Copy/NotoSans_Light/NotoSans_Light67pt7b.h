#ifndef _NOTOSANS_LIGHT67PT7B_H_
#define _NOTOSANS_LIGHT67PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light67pt7bBitmaps[] PROGMEM = {
  0x00, 0x7D, 0xF7, 0xDF, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0x9F, 0xFF, 0xFF,
  0xDF, 0x30, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xF8, 0x07, 0x70, 0x0E, 0xE0, 0x1D, 0xC0, 0x3B, 0x80, 0x77, 0x00,
  0xEE, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x1C, 0x00, 0x01,
  0xE0, 0x03, 0x80, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x07, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00,
  0x01, 0xE0, 0x03, 0x80, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0x00, 0x78, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x1E, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x00, 0x70, 0x01, 0xE0,
  0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x1F, 0xF7, 0x3F,
  0xE1, 0xF8, 0x38, 0x0E, 0x0F, 0x01, 0xC0, 0x10, 0xF0, 0x0E, 0x00, 0x07,
  0x80, 0x70, 0x00, 0x78, 0x03, 0x80, 0x03, 0xC0, 0x1C, 0x00, 0x1E, 0x00,
  0xE0, 0x00, 0xF0, 0x07, 0x00, 0x07, 0x80, 0x38, 0x00, 0x3C, 0x01, 0xC0,
  0x00, 0xF0, 0x0E, 0x00, 0x07, 0xC0, 0x70, 0x00, 0x1F, 0x03, 0x80, 0x00,
  0xFC, 0x1C, 0x00, 0x03, 0xFC, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xBF, 0xC0, 0x00, 0x1C, 0x7F, 0x00, 0x00, 0xE0, 0xFC,
  0x00, 0x07, 0x01, 0xF0, 0x00, 0x38, 0x07, 0x80, 0x01, 0xC0, 0x1E, 0x00,
  0x0E, 0x00, 0xF0, 0x00, 0x70, 0x07, 0x80, 0x03, 0x80, 0x3C, 0x00, 0x1C,
  0x01, 0xE0, 0x00, 0xE0, 0x0F, 0x00, 0x07, 0x00, 0x78, 0x00, 0x38, 0x07,
  0x80, 0x01, 0xC0, 0x7D, 0x00, 0x0E, 0x07, 0xCF, 0x80, 0x70, 0xFE, 0x7F,
  0xFB, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x38, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0xF9, 0xF8, 0x00, 0x03, 0xC0, 0x03,
  0xC0, 0xF0, 0x00, 0x07, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x38, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x78, 0x07, 0x80, 0x00, 0x70, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0xE0, 0x01,
  0xE0, 0x3C, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0x70, 0x00, 0x03, 0x80, 0x07,
  0x81, 0xE0, 0x00, 0x07, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x1C,
  0x0F, 0x07, 0xF8, 0x1C, 0x00, 0x38, 0x3C, 0x1F, 0xFC, 0x3C, 0x00, 0x70,
  0x70, 0x7F, 0xFC, 0x38, 0x01, 0xE1, 0xE1, 0xE0, 0x78, 0x78, 0x03, 0x83,
  0x83, 0x80, 0x78, 0xF0, 0x0F, 0x0F, 0x0F, 0x00, 0x70, 0xF0, 0x3C, 0x1C,
  0x1C, 0x00, 0xF0, 0xFD, 0xF8, 0x78, 0x78, 0x00, 0xE0, 0xFF, 0xE0, 0xE0,
  0xF0, 0x01, 0xC0, 0xFF, 0x03, 0xC1, 0xC0, 0x03, 0x80, 0x10, 0x0F, 0x03,
  0x80, 0x07, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x0E,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x38,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xE0,
  0x01, 0xE0, 0x00, 0x38, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0xF0, 0x03, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x0F, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x78, 0x07,
  0x80, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x0E, 0x00, 0x00, 0x7C, 0x7C,
  0x00, 0x3C, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x07,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x07, 0xC0,
  0x00, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0xFC, 0x00, 0x00,
  0x00, 0x7C, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x7C, 0x00,
  0x00, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x1E, 0x07, 0xC0, 0x7C, 0x00, 0x07,
  0x81, 0xF0, 0x07, 0xC0, 0x00, 0xF0, 0x7C, 0x00, 0x7C, 0x00, 0x1E, 0x1F,
  0x00, 0x07, 0xC0, 0x07, 0x83, 0xC0, 0x00, 0x7C, 0x00, 0xF0, 0xF8, 0x00,
  0x07, 0xC0, 0x1E, 0x1E, 0x00, 0x00, 0x7C, 0x07, 0x83, 0xC0, 0x00, 0x07,
  0xC0, 0xF0, 0x78, 0x00, 0x00, 0x7C, 0x3C, 0x0F, 0x00, 0x00, 0x07, 0xCF,
  0x81, 0xE0, 0x00, 0x00, 0x7D, 0xE0, 0x3C, 0x00, 0x00, 0x07, 0xF8, 0x07,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0x00,
  0x00, 0x01, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0x00, 0x00,
  0x3F, 0x7C, 0x03, 0xF0, 0x00, 0x1F, 0x87, 0xC0, 0x3F, 0x80, 0x0F, 0xE0,
  0x7C, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x7C,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xE0, 0x00, 0x78, 0x07, 0x80,
  0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x03,
  0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x01, 0x00, 0x0E, 0x00, 0x17, 0x80, 0x38, 0x03, 0xDF, 0xC0, 0xE0,
  0x7F, 0x7F, 0xE3, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x38, 0x78, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0x80, 0x01, 0xE0,
  0x0F, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x60, 0x01,
  0xC0, 0x00, 0x80, 0x02, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x1F, 0x1E, 0x1E, 0x1E, 0x3C,
  0x3C, 0x3C, 0x3C, 0x78, 0x78, 0x78, 0x70, 0xF0, 0xE0, 0xE0, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x39, 0xFF, 0xFF, 0xFD, 0xF3,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0xF8,
  0x03, 0xC0, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x03, 0xBC, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x0E, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0x77, 0x80, 0x00,
  0x00, 0xEF, 0x00, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x03,
  0x8F, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0,
  0x0F, 0xF8, 0x1F, 0xBC, 0x1F, 0x1E, 0x1F, 0x0F, 0x3F, 0x07, 0xFF, 0x03,
  0xDE, 0x01, 0xE6, 0x00, 0xF2, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x02, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x3F, 0xC0, 0x3F, 0x81, 0xF8, 0x00, 0x3F, 0x07, 0x80, 0x00, 0x7C, 0x0C,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x01, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFC, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x7C,
  0x1E, 0x00, 0x00, 0x7C, 0x10, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE4,
  0x00, 0x00, 0x0F, 0x8E, 0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x01, 0xFC, 0x3F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x01,
  0xE7, 0x00, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00,
  0x03, 0xC3, 0x80, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0x3C, 0x0E, 0x00,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x78, 0x07,
  0x00, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0xF0,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x0F, 0x00, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x1E, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x07, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF1, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0x07, 0xFE, 0x02, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x20, 0x00, 0x01, 0xF1, 0x80, 0x00, 0x1F,
  0x0F, 0x80, 0x07, 0xF8, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x0F,
  0xE0, 0x01, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x1F, 0x80,
  0x07, 0x03, 0xFF, 0xE0, 0x0E, 0x1F, 0xFF, 0xF0, 0x3C, 0x7F, 0xDF, 0xF0,
  0x79, 0xF0, 0x01, 0xF0, 0xF7, 0x80, 0x01, 0xF1, 0xFE, 0x00, 0x01, 0xF3,
  0xF8, 0x00, 0x01, 0xE7, 0xE0, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x03, 0xDF,
  0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x0F, 0x1E, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0x80, 0x7C, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x7C, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x1F, 0x0F,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x3C, 0x01, 0xF0, 0x03, 0xE0,
  0x03, 0xF0, 0x3F, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x3F,
  0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x00, 0x07, 0xE0, 0xF8, 0x00,
  0x07, 0xC3, 0xC0, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xF7, 0x80,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x01, 0xF0, 0x7E, 0x00,
  0x1F, 0x80, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x3F, 0x80,
  0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x3F, 0x7C,
  0x00, 0x01, 0xFC, 0xF8, 0x00, 0x0E, 0xF1, 0xF0, 0x00, 0xF3, 0xC3, 0xFC,
  0x3F, 0x8F, 0x07, 0xFF, 0xFC, 0x3C, 0x07, 0xFF, 0xC0, 0xF0, 0x03, 0xF8,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x9F, 0xFF, 0xFF, 0xDF, 0x30, 0x0F, 0x0F, 0xC7, 0xE3, 0xF1, 0xF8, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x78, 0x7C, 0x3E, 0x1E, 0x0F, 0x07, 0x83, 0xC3, 0xC1, 0xE0,
  0xF0, 0x70, 0x78, 0x3C, 0x1C, 0x0E, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0xFC, 0x01, 0xFC, 0x60, 0x00, 0x7E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x7F, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x03, 0x81, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xC3,
  0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x1E, 0x3C, 0x00, 0x1F, 0xFF, 0xF8, 0x01,
  0xE3, 0x80, 0x03, 0xE0, 0x07, 0x80, 0x0E, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xE7, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x0F, 0x70, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0xFF, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x0F, 0xF0, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x07, 0xE0, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x7E, 0x00, 0x78, 0x00, 0x07, 0x00, 0x07, 0xE0,
  0x07, 0x80, 0x00, 0x70, 0x00, 0xFE, 0x00, 0x78, 0x00, 0x07, 0x00, 0x0F,
  0xE0, 0x07, 0x80, 0x00, 0x70, 0x00, 0xFE, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x0E, 0xE0, 0x07, 0x80, 0x00, 0xF0, 0x00, 0xEE, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x0E, 0xE0, 0x03, 0x80, 0x00, 0xF0, 0x01, 0xEE, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x1C, 0xE0, 0x03, 0xC0, 0x01, 0xF8, 0x03, 0xCF, 0x00, 0x1E,
  0x00, 0x3B, 0x80, 0x38, 0xF0, 0x01, 0xF0, 0x07, 0x3C, 0x07, 0x87, 0x00,
  0x0F, 0xC1, 0xF1, 0xE1, 0xF0, 0x70, 0x00, 0x7F, 0xFE, 0x0F, 0xFE, 0x07,
  0x80, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x38, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x03, 0x80,
  0x0E, 0x00, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0,
  0x00, 0x07, 0xF0, 0xF0, 0x00, 0x01, 0xF8, 0xF0, 0x00, 0x00, 0xF8, 0xF0,
  0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0,
  0x00, 0x07, 0xF0, 0xF0, 0x00, 0x01, 0xF8, 0xF0, 0x00, 0x00, 0x7C, 0xF0,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3E, 0xF0,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0xF8, 0xF0,
  0x00, 0x03, 0xF0, 0xF0, 0x00, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x0E, 0x01, 0xF8,
  0x00, 0x00, 0x20, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x40, 0x0F, 0xF8, 0x00, 0x3C, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x00,
  0x0F, 0xF8, 0x0F, 0x00, 0x00, 0x1F, 0xC0, 0xF0, 0x00, 0x00, 0x7E, 0x0F,
  0x00, 0x00, 0x03, 0xF0, 0xF0, 0x00, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x00,
  0xF8, 0xF0, 0x00, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x00, 0x03, 0xEF, 0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x00, 0x07, 0xCF, 0x00, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x0F, 0x8F,
  0x00, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x0F,
  0xC0, 0xF0, 0x00, 0x03, 0xF8, 0x0F, 0x00, 0x00, 0xFF, 0x00, 0xF0, 0x0F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xBC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x00, 0x07, 0x80, 0x3F, 0x00,
  0x00, 0x01, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x00, 0x3D, 0xF0, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x00, 0x03, 0xC7, 0xC0, 0x00,
  0x00, 0x07, 0x8F, 0x80, 0x00, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x00, 0x1E,
  0x0F, 0x80, 0x00, 0x00, 0x3C, 0x1F, 0x80, 0x00, 0x00, 0x78, 0x1F, 0xC0,
  0x00, 0x00, 0xF0, 0x1F, 0xE0, 0x00, 0x01, 0xE0, 0x0F, 0xF8, 0x00, 0x1F,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x81, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x7C, 0xF1, 0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x0F, 0xF8, 0x00, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x7C, 0xF0, 0x00,
  0x00, 0xF8, 0xF0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x03, 0xE0, 0xF0, 0x00,
  0x07, 0xC0, 0xF0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x1F, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF0, 0x01,
  0xF0, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0xF0, 0x0F,
  0x80, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF1, 0xF8,
  0x00, 0x00, 0xF3, 0xFC, 0x00, 0x00, 0xF7, 0xBE, 0x00, 0x00, 0xFF, 0x3E,
  0x00, 0x00, 0xFE, 0x1F, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0xF8, 0x07,
  0xC0, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0xF0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x07, 0xC0, 0xF0, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x01, 0xF0, 0xF0, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0x7C, 0xF0, 0x00,
  0x00, 0x3E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xF7, 0x80, 0x00, 0x00, 0x03, 0xBF, 0xBC, 0x00, 0x00, 0x00,
  0x3D, 0xFC, 0xE0, 0x00, 0x00, 0x01, 0xEF, 0xE7, 0x80, 0x00, 0x00, 0x0E,
  0x7F, 0x3C, 0x00, 0x00, 0x00, 0xF3, 0xF8, 0xF0, 0x00, 0x00, 0x07, 0x1F,
  0xC7, 0x80, 0x00, 0x00, 0x78, 0xFE, 0x1C, 0x00, 0x00, 0x03, 0xC7, 0xF0,
  0xF0, 0x00, 0x00, 0x1C, 0x3F, 0x87, 0x80, 0x00, 0x01, 0xE1, 0xFC, 0x1E,
  0x00, 0x00, 0x0E, 0x0F, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x7F, 0x03, 0x80,
  0x00, 0x07, 0x83, 0xF8, 0x1E, 0x00, 0x00, 0x38, 0x1F, 0xC0, 0xF0, 0x00,
  0x03, 0xC0, 0xFE, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0xF0, 0x1E, 0x00, 0x01,
  0xE0, 0x3F, 0x80, 0xF0, 0x00, 0x0F, 0x01, 0xFC, 0x03, 0xC0, 0x00, 0x70,
  0x0F, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0x7F, 0x00, 0x78, 0x00, 0x3C, 0x03,
  0xF8, 0x03, 0xC0, 0x03, 0xC0, 0x1F, 0xC0, 0x1E, 0x00, 0x1E, 0x00, 0xFE,
  0x00, 0x78, 0x00, 0xE0, 0x07, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0x80,
  0x0F, 0x00, 0x78, 0x01, 0xFC, 0x00, 0x78, 0x07, 0x80, 0x0F, 0xE0, 0x03,
  0xC0, 0x3C, 0x00, 0x7F, 0x00, 0x0F, 0x01, 0xC0, 0x03, 0xF8, 0x00, 0x78,
  0x1E, 0x00, 0x1F, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x0F,
  0x00, 0x07, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3F, 0x80, 0x01, 0xE3, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0xE0, 0x00, 0x39, 0xE0, 0x00,
  0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x7C,
  0x00, 0x00, 0x0F, 0xE7, 0x80, 0x00, 0x01, 0xFC, 0xF8, 0x00, 0x00, 0x3F,
  0x8F, 0x80, 0x00, 0x07, 0xF0, 0xF0, 0x00, 0x00, 0xFE, 0x1F, 0x00, 0x00,
  0x1F, 0xC1, 0xF0, 0x00, 0x03, 0xF8, 0x1E, 0x00, 0x00, 0x7F, 0x03, 0xE0,
  0x00, 0x0F, 0xE0, 0x3E, 0x00, 0x01, 0xFC, 0x03, 0xC0, 0x00, 0x3F, 0x80,
  0x7C, 0x00, 0x07, 0xF0, 0x07, 0xC0, 0x00, 0xFE, 0x00, 0x78, 0x00, 0x1F,
  0xC0, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0x00,
  0x0F, 0xE0, 0x01, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0x00, 0x3F, 0x80, 0x01,
  0xE0, 0x07, 0xF0, 0x00, 0x3E, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x1F, 0xC0,
  0x00, 0x3C, 0x03, 0xF8, 0x00, 0x07, 0xC0, 0x7F, 0x00, 0x00, 0x7C, 0x0F,
  0xE0, 0x00, 0x07, 0x81, 0xFC, 0x00, 0x00, 0xF8, 0x3F, 0x80, 0x00, 0x0F,
  0x87, 0xF0, 0x00, 0x00, 0xF0, 0xFE, 0x00, 0x00, 0x1F, 0x0F, 0xC0, 0x00,
  0x01, 0xF1, 0xF8, 0x00, 0x00, 0x1E, 0x3F, 0x00, 0x00, 0x03, 0xE7, 0xE0,
  0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x03, 0xDF, 0x80, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x01, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0x00, 0x7D, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x00, 0x00,
  0x79, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x00, 0x01,
  0xF0, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x0F, 0x00, 0x03, 0xFC, 0x78, 0x00, 0x03,
  0xF3, 0xC0, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xF3, 0xC0,
  0x00, 0x1F, 0x1E, 0x00, 0x03, 0xF0, 0xF0, 0x00, 0xFF, 0x07, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x01, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0x00, 0x7D, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0x00, 0x79,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x00, 0x01, 0xF0,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0xF0, 0x00, 0x1F, 0xC0, 0xF0, 0x00, 0x07, 0xE0, 0xF0, 0x00, 0x03, 0xE0,
  0xF0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x07, 0xC0,
  0xF0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xF0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0xE0,
  0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x01, 0x80, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE1, 0xFE,
  0x00, 0x7E, 0x0F, 0x80, 0x00, 0x70, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xCC,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x00, 0x05, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x00,
  0x78, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x07, 0xF8,
  0x00, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x03,
  0xC0, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x78, 0x78, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x38, 0x70, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x0F, 0x00,
  0x01, 0xE0, 0x1E, 0x00, 0x07, 0x03, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x03,
  0xC0, 0x01, 0xC0, 0x38, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0xE0, 0x1E, 0x00,
  0x1E, 0x00, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03,
  0xC0, 0x01, 0xE0, 0x0F, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x78, 0x07, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x80, 0xF0, 0x00, 0x1E,
  0x03, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0xE0, 0x3C,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x0F, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x8E, 0x00, 0x00,
  0x71, 0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x07, 0x78, 0x00,
  0x00, 0x3D, 0xC0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF1, 0xF0, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x07, 0xDF, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x00, 0x1E,
  0x7C, 0x00, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00,
  0x07, 0xC1, 0xE0, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x3E, 0x00,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00,
  0xE0, 0x07, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x07, 0x80, 0x01, 0xE0, 0x07,
  0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x70, 0x1E,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0E, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x70,
  0x00, 0x7C, 0x08, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xF8,
  0x03, 0x8F, 0xE0, 0x00, 0x73, 0xF0, 0x00, 0x0E, 0x78, 0x00, 0x01, 0xDE,
  0x00, 0x00, 0x3B, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xDE, 0x00, 0x03, 0xBB, 0xE0, 0x00, 0xF7, 0x3E, 0x00, 0x7C,
  0xE3, 0xFF, 0xFF, 0x1C, 0x3F, 0xFF, 0xC3, 0x83, 0xFF, 0xE0, 0x70, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x07,
  0xFE, 0x00, 0xF0, 0xFF, 0xFE, 0x03, 0xC7, 0xFF, 0xFE, 0x0F, 0x3E, 0x01,
  0xFC, 0x3D, 0xE0, 0x01, 0xF8, 0xFF, 0x00, 0x03, 0xE3, 0xB8, 0x00, 0x07,
  0xCF, 0xC0, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x7B,
  0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7B,
  0xE0, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x07, 0xBF, 0x00, 0x00, 0x3C, 0xFC,
  0x00, 0x01, 0xF3, 0xB8, 0x00, 0x0F, 0x8E, 0xF0, 0x00, 0x7E, 0x39, 0xF0,
  0x03, 0xF0, 0xE3, 0xFF, 0xFF, 0x83, 0x87, 0xFF, 0xF8, 0x0E, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x0F, 0xF0, 0x3E, 0x07, 0xE0, 0x00, 0x83, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x01, 0x07, 0xE0, 0x03, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x0F, 0xFC, 0x0F, 0x01, 0xFF, 0xFC, 0x1C, 0x0F, 0xFF,
  0xF8, 0x70, 0x7F, 0x01, 0xF1, 0xC3, 0xF0, 0x00, 0xE7, 0x1F, 0x00, 0x01,
  0xDC, 0xF8, 0x00, 0x03, 0xF3, 0xC0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x1F,
  0x78, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x07, 0xCF,
  0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0xFC, 0x78, 0x00, 0x07, 0x71, 0xF0,
  0x00, 0x39, 0xC3, 0xF0, 0x03, 0xE7, 0x07, 0xFF, 0xFF, 0x1C, 0x0F, 0xFF,
  0xF0, 0x70, 0x0F, 0xFF, 0x81, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0, 0x3F, 0x00,
  0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x78, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x06, 0x07, 0xF0, 0x01, 0xF0, 0x1F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xE0, 0x30,
  0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x1C, 0x07, 0xFF, 0xF0, 0x70, 0x3F,
  0xFF, 0xF1, 0xC1, 0xFC, 0x07, 0xE7, 0x0F, 0x80, 0x03, 0x9C, 0x7C, 0x00,
  0x07, 0x71, 0xE0, 0x00, 0x0F, 0xCF, 0x00, 0x00, 0x3F, 0x3C, 0x00, 0x00,
  0x7D, 0xE0, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x1F,
  0x3C, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xF1, 0xE0, 0x00, 0x1D, 0xC7,
  0xE0, 0x00, 0xE7, 0x0F, 0xC0, 0x0F, 0xBC, 0x1F, 0xFF, 0xFC, 0xF0, 0x3F,
  0xFF, 0xC3, 0xC0, 0x3F, 0xFE, 0x0F, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC2, 0x00, 0x00, 0x1F, 0x0F,
  0x00, 0x01, 0xF8, 0x3F, 0xE0, 0x3F, 0xC0, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x01,
  0xFF, 0x80, 0xF0, 0xFF, 0xFE, 0x0F, 0x1F, 0xFF, 0xF8, 0xF3, 0xE0, 0x1F,
  0xCF, 0x78, 0x00, 0x7C, 0xFF, 0x00, 0x03, 0xEE, 0xE0, 0x00, 0x1E, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x70, 0x73, 0xFF, 0xFF, 0xB8, 0x00, 0x00, 0x00,
  0x00, 0x3D, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD,
  0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x78,
  0x00, 0x70, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C,
  0x01, 0xE0, 0x1F, 0x41, 0xF3, 0xFF, 0x9F, 0xF8, 0xFF, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0xF0, 0x00, 0x0F, 0x9E, 0x00, 0x03, 0xE3, 0xC0,
  0x00, 0xF8, 0x78, 0x00, 0x3E, 0x0F, 0x00, 0x0F, 0x81, 0xE0, 0x01, 0xE0,
  0x3C, 0x00, 0x78, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x01,
  0xE0, 0x03, 0xC0, 0x7C, 0x00, 0x78, 0x1F, 0x00, 0x0F, 0x07, 0xC0, 0x01,
  0xE1, 0xF0, 0x00, 0x3C, 0x7C, 0x00, 0x07, 0x9F, 0x80, 0x00, 0xF3, 0xF8,
  0x00, 0x1E, 0xFF, 0x80, 0x03, 0xFC, 0xF8, 0x00, 0x7F, 0x0F, 0x00, 0x0F,
  0xC0, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x3E, 0x03, 0xC0, 0x03, 0xE0, 0x78,
  0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x07,
  0xC7, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xFB, 0xC0,
  0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0xE0,
  0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0xE3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0xE3,
  0xE0, 0x7F, 0x1F, 0x80, 0xFC, 0xE7, 0x00, 0x1F, 0x3C, 0x00, 0x3E, 0xEE,
  0x00, 0x0F, 0xB8, 0x00, 0x1E, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x0E, 0x0F, 0xFF, 0xE0,
  0xE1, 0xFF, 0xFF, 0x8E, 0x3E, 0x01, 0xFC, 0xE7, 0x80, 0x07, 0xEE, 0xE0,
  0x00, 0x3E, 0xFE, 0x00, 0x01, 0xEF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07,
  0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x1E,
  0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C, 0x78,
  0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x0E, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x78, 0x1F,
  0x00, 0x00, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0xE0, 0x1F, 0xF8, 0x03, 0x81, 0xFF, 0xF8, 0x0E, 0x1F,
  0xFF, 0xF8, 0x38, 0xF8, 0x07, 0xF0, 0xE7, 0x80, 0x07, 0xE3, 0x9C, 0x00,
  0x0F, 0x8E, 0xE0, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00,
  0x7B, 0xE0, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x1E,
  0xFC, 0x00, 0x00, 0xF3, 0xF0, 0x00, 0x07, 0xCE, 0xE0, 0x00, 0x3E, 0x3D,
  0xC0, 0x01, 0xF8, 0xF7, 0xC0, 0x0F, 0xC3, 0xCF, 0xFF, 0xFE, 0x0F, 0x0F,
  0xFF, 0xE0, 0x3C, 0x1F, 0xFF, 0x00, 0xF0, 0x07, 0xC0, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x1C, 0x07, 0xFF,
  0xF0, 0x70, 0x3F, 0xFF, 0xE1, 0xC1, 0xF8, 0x07, 0xC7, 0x0F, 0x80, 0x07,
  0x9C, 0x7C, 0x00, 0x07, 0x73, 0xE0, 0x00, 0x0F, 0xCF, 0x00, 0x00, 0x3F,
  0x7C, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0xDE,
  0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0xFC, 0xF0, 0x00, 0x03, 0xF3, 0xE0,
  0x00, 0x1D, 0xC7, 0xC0, 0x00, 0xEF, 0x0F, 0xC0, 0x0F, 0x3C, 0x1F, 0xFF,
  0xF8, 0xF0, 0x3F, 0xFF, 0xC3, 0xC0, 0x3F, 0xFC, 0x0F, 0x00, 0x1F, 0x80,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0xFC,
  0x1F, 0xFF, 0x87, 0xFF, 0xF1, 0xF8, 0x3E, 0x78, 0x01, 0xCE, 0x00, 0x3B,
  0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC7, 0xF0, 0x07, 0xE3,
  0xC0, 0x00, 0x23, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x07, 0x00,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xDE, 0x00,
  0x00, 0x3E, 0xF0, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x1F, 0xBE, 0x00, 0x00,
  0xFC, 0xF0, 0x00, 0x0F, 0xE7, 0xC0, 0x01, 0xEF, 0x1F, 0x80, 0x1E, 0x38,
  0x7F, 0xFF, 0xE1, 0xC1, 0xFF, 0xFE, 0x0E, 0x03, 0xFF, 0xC0, 0x70, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x78, 0x01, 0xE0, 0x00,
  0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x03, 0xC0, 0x0F,
  0x00, 0x07, 0x80, 0x1C, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0xF0, 0xE0, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x03, 0xCE, 0x00, 0x00,
  0x03, 0xBC, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3D, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0x8F, 0x00,
  0x03, 0xBC, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x38, 0x00, 0x1C, 0x3C, 0x00,
  0x1E, 0x78, 0x00, 0x78, 0x38, 0x00, 0x3C, 0xF0, 0x00, 0xF0, 0x78, 0x00,
  0x71, 0xE0, 0x01, 0xE0, 0xF0, 0x01, 0xE1, 0xC0, 0x03, 0x81, 0xE0, 0x03,
  0xC3, 0xC0, 0x0F, 0x01, 0xE0, 0x07, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0x1E,
  0x07, 0x00, 0x3C, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70,
  0x1E, 0x01, 0xE0, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x1E, 0x03, 0xC0,
  0x3C, 0x07, 0x00, 0x3C, 0x07, 0x00, 0x78, 0x1E, 0x00, 0x38, 0x1E, 0x00,
  0x70, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x70, 0x01,
  0xE0, 0xE0, 0x01, 0xE1, 0xE0, 0x01, 0xC3, 0xC0, 0x01, 0xE3, 0xC0, 0x03,
  0xC7, 0x80, 0x03, 0xC7, 0x00, 0x07, 0x8F, 0x00, 0x07, 0x8E, 0x00, 0x07,
  0x1C, 0x00, 0x07, 0x3C, 0x00, 0x0E, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x1E,
  0xF0, 0x00, 0x1E, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x3D, 0xC0, 0x00, 0x3B,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x77, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x78,
  0x00, 0x00, 0xF8, 0x78, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x1F, 0x00, 0xF0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0xF0, 0x01, 0xF0,
  0x03, 0xC0, 0x01, 0xE0, 0x0F, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x03, 0xE0,
  0x78, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07, 0xCF,
  0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0F, 0x1F, 0x00,
  0x00, 0x3E, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x3E, 0x00,
  0x07, 0x80, 0x3C, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF7, 0xC0,
  0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0x0F, 0x8F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x03, 0xC0, 0x0F,
  0x00, 0x07, 0x80, 0x1E, 0x00, 0x07, 0x00, 0x78, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0x38, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF0, 0xE0, 0x00,
  0x00, 0xE3, 0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x03, 0xBC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x81, 0xF0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0x00,
  0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x10, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x00,
  0x0F, 0xF0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x07,
  0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xA0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x02, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F,
  0x80, 0xFF, 0x83, 0xFC, 0x00, 0x3F, 0xFF, 0xD0, 0x00, 0x1F, 0xFE, 0x20,
  0x00, 0x07, 0xF0, 0x00,
};

const GFXglyph NotoSans_Light67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 6, 49, 16, 5, -48 },
  { 38, 15, 17, 24, 5, -48 },
  { 70, 39, 48, 43, 2, -48 },
  { 304, 29, 55, 38, 4, -51 },
  { 504, 47, 50, 54, 4, -49 },
  { 798, 43, 50, 48, 4, -49 },
  { 1067, 4, 17, 13, 5, -48 },
  { 1076, 13, 59, 19, 3, -48 },
  { 1172, 14, 59, 19, 2, -48 },
  { 1276, 30, 29, 37, 3, -51 },
  { 1385, 31, 31, 38, 4, -39 },
  { 1506, 8, 17, 15, 3, -8 },
  { 1523, 16, 4, 22, 3, -20 },
  { 1531, 6, 7, 16, 5, -6 },
  { 1537, 22, 48, 23, 1, -48 },
  { 1669, 31, 50, 38, 4, -49 },
  { 1863, 17, 48, 38, 6, -48 },
  { 1965, 30, 49, 38, 4, -49 },
  { 2149, 31, 50, 38, 3, -49 },
  { 2343, 35, 48, 38, 2, -48 },
  { 2553, 29, 49, 38, 5, -48 },
  { 2731, 31, 50, 38, 4, -49 },
  { 2925, 32, 48, 38, 3, -48 },
  { 3117, 30, 50, 38, 4, -49 },
  { 3305, 30, 50, 38, 4, -49 },
  { 3493, 6, 37, 16, 5, -36 },
  { 3521, 9, 45, 16, 2, -36 },
  { 3572, 31, 31, 38, 4, -40 },
  { 3693, 31, 17, 38, 4, -32 },
  { 3759, 31, 31, 38, 4, -40 },
  { 3880, 24, 50, 28, 2, -49 },
  { 4030, 52, 54, 60, 4, -48 },
  { 4381, 41, 48, 41, 0, -48 },
  { 4627, 32, 48, 42, 7, -48 },
  { 4819, 36, 50, 42, 4, -49 },
  { 5044, 36, 48, 48, 7, -48 },
  { 5260, 26, 48, 37, 7, -48 },
  { 5416, 26, 48, 34, 7, -48 },
  { 5572, 39, 50, 49, 4, -49 },
  { 5816, 35, 48, 49, 7, -48 },
  { 6026, 14, 48, 21, 3, -48 },
  { 6110, 17, 60, 17, -6, -48 },
  { 6238, 32, 48, 39, 7, -48 },
  { 6430, 26, 48, 35, 7, -48 },
  { 6586, 45, 48, 58, 7, -48 },
  { 6856, 35, 48, 49, 7, -48 },
  { 7066, 43, 50, 51, 4, -49 },
  { 7335, 29, 48, 39, 7, -48 },
  { 7509, 43, 60, 51, 4, -49 },
  { 7832, 32, 48, 40, 7, -48 },
  { 8024, 29, 50, 37, 4, -49 },
  { 8206, 35, 48, 36, 0, -48 },
  { 8416, 36, 49, 48, 6, -48 },
  { 8637, 39, 48, 39, 0, -48 },
  { 8871, 57, 48, 60, 2, -48 },
  { 9213, 37, 48, 37, 0, -48 },
  { 9435, 36, 48, 36, 0, -48 },
  { 9651, 34, 48, 39, 2, -48 },
  { 9855, 14, 59, 22, 6, -48 },
  { 9959, 22, 48, 23, 1, -48 },
  { 10091, 14, 59, 22, 2, -48 },
  { 10195, 32, 30, 38, 3, -48 },
  { 10315, 28, 3, 28, 0, 6 },
  { 10326, 12, 10, 18, 3, -51 },
  { 10341, 27, 37, 36, 3, -36 },
  { 10466, 30, 52, 40, 6, -51 },
  { 10661, 26, 37, 32, 4, -36 },
  { 10782, 30, 52, 40, 4, -51 },
  { 10977, 29, 37, 37, 4, -36 },
  { 11112, 23, 51, 21, 1, -51 },
  { 11259, 30, 52, 40, 4, -36 },
  { 11454, 28, 51, 40, 6, -51 },
  { 11633, 5, 49, 16, 5, -49 },
  { 11664, 13, 65, 16, -3, -49 },
  { 11770, 27, 51, 33, 6, -51 },
  { 11943, 4, 51, 16, 6, -51 },
  { 11969, 48, 36, 60, 6, -36 },
  { 12185, 28, 36, 40, 6, -36 },
  { 12311, 32, 37, 40, 4, -36 },
  { 12459, 30, 52, 40, 6, -36 },
  { 12654, 30, 52, 40, 4, -36 },
  { 12849, 19, 36, 26, 6, -36 },
  { 12935, 25, 37, 31, 3, -36 },
  { 13051, 20, 45, 23, 1, -44 },
  { 13164, 29, 37, 40, 5, -36 },
  { 13299, 31, 36, 31, 0, -36 },
  { 13439, 47, 36, 49, 1, -36 },
  { 13651, 31, 36, 34, 1, -36 },
  { 13791, 31, 52, 31, 0, -36 },
  { 13993, 25, 36, 31, 3, -36 },
  { 14106, 20, 59, 24, 2, -48 },
  { 14254, 4, 67, 36, 16, -51 },
  { 14288, 20, 59, 24, 2, -48 },
  { 14436, 31, 7, 38, 4, -27 },
};

const GFXfont NotoSans_Light67pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light67pt7bBitmaps,
  (GFXglyph *)NotoSans_Light67pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _NOTOSANS_LIGHT67PT7B_H_
