#ifndef _NOTOSANS_LIGHT20PT7B_H_
#define _NOTOSANS_LIGHT20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light20pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xCC, 0xCE, 0x63, 0x18, 0x80, 0x08, 0x81, 0x10, 0x22, 0x08,
  0x4F, 0xFE, 0x22, 0x04, 0x40, 0x88, 0x21, 0x1F, 0xFC, 0x88, 0x11, 0x02,
  0x20, 0x84, 0x00, 0x08, 0x0F, 0x1A, 0x59, 0x08, 0x86, 0x41, 0xA0, 0x70,
  0x0F, 0x04, 0xC2, 0x21, 0x10, 0x9F, 0xF8, 0x20, 0x10, 0x78, 0x32, 0x20,
  0x88, 0x44, 0x21, 0x30, 0x84, 0x82, 0x14, 0xC8, 0x94, 0xD6, 0x91, 0x22,
  0x44, 0x12, 0x10, 0x48, 0x42, 0x11, 0x18, 0x44, 0x40, 0xE0, 0x04, 0x01,
  0xD8, 0x08, 0x40, 0x42, 0x02, 0x10, 0x19, 0x80, 0x58, 0x03, 0x00, 0x64,
  0x12, 0x10, 0xA0, 0x4D, 0x01, 0x4C, 0x04, 0x20, 0xD0, 0xFC, 0x60, 0xFA,
  0x80, 0x32, 0x44, 0xC8, 0x88, 0x88, 0x88, 0xC4, 0x42, 0x30, 0x84, 0x62,
  0x22, 0x31, 0x11, 0x32, 0x22, 0x64, 0x80, 0x08, 0x04, 0x02, 0x1D, 0x71,
  0xC0, 0xA0, 0xD8, 0xC6, 0x08, 0x04, 0x02, 0x01, 0x0F, 0xF8, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x00, 0x5A, 0x80, 0xF8, 0xC0, 0x06, 0x08, 0x10, 0x40,
  0x83, 0x04, 0x08, 0x20, 0x40, 0x82, 0x04, 0x18, 0x00, 0x08, 0x1F, 0x10,
  0x48, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x28, 0x14, 0x1B,
  0x08, 0xF8, 0x1B, 0x72, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x7E,
  0x60, 0x80, 0x40, 0x30, 0x10, 0x08, 0x08, 0x0C, 0x0C, 0x0C, 0x04, 0x04,
  0x04, 0x07, 0xFC, 0x7F, 0x40, 0x80, 0x60, 0x30, 0x10, 0x18, 0xF0, 0x06,
  0x01, 0x80, 0x40, 0x20, 0x18, 0x17, 0xF0, 0x01, 0x80, 0x50, 0x0A, 0x02,
  0x40, 0x88, 0x21, 0x04, 0x21, 0x04, 0x40, 0x9F, 0xFC, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x7F, 0x20, 0x10, 0x08, 0x04, 0x02, 0xE1, 0x8C, 0x03,
  0x00, 0x80, 0x40, 0x20, 0x18, 0x13, 0xF0, 0x02, 0x0E, 0x88, 0x0C, 0x04,
  0x02, 0x03, 0x79, 0x42, 0xC0, 0xC0, 0x60, 0x28, 0x14, 0x09, 0x0C, 0x7C,
  0xFF, 0x80, 0x40, 0x40, 0x20, 0x30, 0x10, 0x08, 0x08, 0x04, 0x04, 0x02,
  0x03, 0x01, 0x01, 0x80, 0x3F, 0x20, 0xD0, 0x28, 0x14, 0x11, 0x90, 0x70,
  0x46, 0x41, 0xC0, 0x60, 0x30, 0x14, 0x19, 0xF0, 0x3E, 0x20, 0xA0, 0x30,
  0x18, 0x0C, 0x05, 0x06, 0xCD, 0x18, 0x80, 0x40, 0x40, 0x20, 0x23, 0xE0,
  0xC0, 0x60, 0x50, 0x00, 0x1E, 0xA0, 0x00, 0x81, 0x83, 0x06, 0x0C, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x0C, 0x38, 0x60, 0xC0, 0x00, 0xFE, 0x03,
  0x01, 0x01, 0x03, 0x06, 0x0C, 0x18, 0x10, 0x10, 0x00, 0x00, 0x10, 0x30,
  0x07, 0xF0, 0x18, 0x08, 0x20, 0x04, 0x40, 0x02, 0x43, 0xE2, 0x84, 0x21,
  0x8C, 0x21, 0x88, 0x21, 0x88, 0x21, 0x88, 0x22, 0x84, 0x62, 0x43, 0x9C,
  0x40, 0x00, 0x20, 0x00, 0x18, 0x10, 0x07, 0xE0, 0x06, 0x00, 0x60, 0x05,
  0x00, 0x90, 0x09, 0x81, 0x08, 0x10, 0x81, 0x0C, 0x3F, 0xC2, 0x04, 0x60,
  0x24, 0x02, 0x40, 0x38, 0x01, 0xFF, 0x20, 0x68, 0x0A, 0x02, 0x80, 0xA0,
  0x4F, 0xE2, 0x06, 0x80, 0xA0, 0x38, 0x0E, 0x02, 0x81, 0xBF, 0x80, 0x1F,
  0xE6, 0x01, 0x80, 0x20, 0x04, 0x01, 0x80, 0x20, 0x04, 0x00, 0xC0, 0x08,
  0x01, 0x00, 0x30, 0x03, 0x00, 0x1F, 0x80, 0xFF, 0x10, 0x32, 0x01, 0x40,
  0x28, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x40, 0x68,
  0x39, 0xFC, 0x00, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFE, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0xFF, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0xFE, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x01, 0x00, 0xFF, 0x30, 0x06,
  0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x81, 0xFC, 0x01, 0x40, 0x14,
  0x01, 0x60, 0x13, 0x01, 0x0F, 0xF0, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x1F, 0xFE, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10,
  0xF2, 0x22, 0x22, 0x22, 0x22, 0x22, 0x2F, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0xB3, 0x00, 0x81, 0xE0, 0xC8, 0x22, 0x10,
  0x88, 0x24, 0x0B, 0x03, 0x20, 0x8C, 0x21, 0x08, 0x22, 0x04, 0x81, 0xA0,
  0x30, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0xFF, 0xC0, 0x1E, 0x00, 0xE8, 0x07, 0x40, 0x5B, 0x02, 0xC8,
  0x36, 0x41, 0x31, 0x09, 0x88, 0x8C, 0x64, 0x61, 0x63, 0x0A, 0x18, 0x30,
  0xC1, 0x04, 0xC0, 0x78, 0x0E, 0x81, 0xD8, 0x39, 0x07, 0x10, 0xE3, 0x1C,
  0x23, 0x82, 0x70, 0x6E, 0x04, 0xC0, 0x58, 0x0F, 0x00, 0xC0, 0x02, 0x00,
  0xFE, 0x0C, 0x08, 0xC0, 0x24, 0x01, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80,
  0x0E, 0x00, 0x50, 0x02, 0x80, 0x26, 0x01, 0x18, 0x30, 0x3F, 0x00, 0xFE,
  0x40, 0xA0, 0x70, 0x38, 0x1C, 0x0A, 0x0D, 0xFC, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x00, 0x02, 0x00, 0xFE, 0x0C, 0x08, 0xC0, 0x24, 0x01, 0xE0,
  0x07, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x50, 0x02, 0x80, 0x26, 0x01,
  0x18, 0x30, 0x3F, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x80, 0xFE, 0x20, 0x48,
  0x1A, 0x06, 0x81, 0xA0, 0x48, 0x33, 0xF0, 0x84, 0x20, 0x88, 0x22, 0x04,
  0x81, 0xA0, 0x30, 0x7F, 0xA0, 0x20, 0x10, 0x0C, 0x03, 0x00, 0xE0, 0x0E,
  0x01, 0x00, 0x40, 0x20, 0x18, 0x17, 0xF0, 0xFF, 0xC1, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0x60, 0x26, 0x08, 0x7E, 0x00, 0xC0, 0x34, 0x02,
  0x40, 0x66, 0x04, 0x20, 0x42, 0x0C, 0x30, 0x81, 0x08, 0x11, 0x00, 0x90,
  0x0B, 0x00, 0xE0, 0x06, 0x00, 0x60, 0xC0, 0xC0, 0xD0, 0x30, 0x24, 0x0C,
  0x09, 0x84, 0x86, 0x21, 0x21, 0x08, 0x48, 0x42, 0x33, 0x10, 0x48, 0x48,
  0x12, 0x12, 0x04, 0x84, 0x81, 0xC0, 0xE0, 0x30, 0x30, 0x0C, 0x0C, 0x03,
  0x03, 0x00, 0xC0, 0x64, 0x10, 0x82, 0x08, 0x81, 0xB0, 0x14, 0x01, 0x00,
  0x50, 0x0A, 0x02, 0x20, 0xC6, 0x10, 0x44, 0x05, 0x80, 0xC0, 0xC0, 0x68,
  0x18, 0x82, 0x10, 0xC1, 0x10, 0x26, 0x02, 0x80, 0x60, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0xFF, 0xC0, 0x20, 0x10, 0x0C, 0x02,
  0x01, 0x00, 0xC0, 0x20, 0x10, 0x0C, 0x02, 0x01, 0x00, 0x80, 0x3F, 0xF0,
  0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0xF0, 0xC0, 0x81, 0x01,
  0x02, 0x06, 0x04, 0x08, 0x08, 0x10, 0x20, 0x20, 0x40, 0xC0, 0xF8, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0xF8, 0x0C, 0x05, 0x01,
  0x60, 0x88, 0x23, 0x10, 0x44, 0x1A, 0x02, 0x80, 0xC0, 0xFF, 0xC4, 0x30,
  0x3C, 0x43, 0x01, 0x01, 0x01, 0x3F, 0xC1, 0x81, 0x81, 0xC3, 0x7D, 0x80,
  0x40, 0x20, 0x10, 0x09, 0xC7, 0x1B, 0x05, 0x03, 0x80, 0xC0, 0x60, 0x30,
  0x38, 0x16, 0x1A, 0xF8, 0x1E, 0x31, 0x40, 0xC0, 0x80, 0x80, 0x80, 0xC0,
  0x40, 0x60, 0x3F, 0x00, 0x80, 0x40, 0x20, 0x11, 0xCB, 0x1D, 0x07, 0x81,
  0x80, 0xC0, 0x60, 0x30, 0x14, 0x0B, 0x0C, 0xFA, 0x1E, 0x11, 0x90, 0x58,
  0x18, 0x0F, 0xFE, 0x01, 0x80, 0x40, 0x30, 0x4F, 0xC0, 0x1E, 0x60, 0x81,
  0x0F, 0xC4, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x00, 0x1C,
  0xB1, 0xD0, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x40, 0xB0, 0xCF, 0xA0,
  0x10, 0x08, 0x05, 0x0C, 0x7C, 0x80, 0x80, 0x80, 0x80, 0x9C, 0xE3, 0xC1,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xCF, 0xFE, 0x11, 0x00,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x3E, 0x80, 0x80, 0x80, 0x80,
  0x83, 0x84, 0x8C, 0x98, 0xB0, 0xF0, 0xD0, 0x88, 0x84, 0x86, 0x83, 0xFF,
  0xFE, 0xBC, 0x7B, 0x1A, 0x38, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x40, 0x9C, 0xE3, 0xC1,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x1E, 0x08, 0x44, 0x0B,
  0x02, 0x80, 0xE0, 0x38, 0x0F, 0x02, 0x40, 0x98, 0x63, 0xE0, 0x9C, 0x71,
  0xB0, 0x50, 0x38, 0x0C, 0x06, 0x03, 0x03, 0x81, 0x61, 0xAF, 0x90, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x1C, 0xB1, 0xD0, 0x78, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x40, 0xB0, 0xCF, 0xA0, 0x10, 0x08, 0x04, 0x02, 0x01, 0x9F, 0x8C,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x00, 0x3D, 0x86, 0x04, 0x06, 0x07,
  0x01, 0x81, 0x03, 0x07, 0xF0, 0x20, 0x8F, 0xC8, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x1C, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x83, 0x7D, 0x80, 0xE0, 0x50, 0x68, 0x22, 0x11, 0x10, 0xC8, 0x24, 0x14,
  0x06, 0x02, 0x00, 0xC1, 0x05, 0x04, 0x14, 0x28, 0x50, 0xA3, 0x62, 0x88,
  0x91, 0x22, 0x44, 0x89, 0x14, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x00, 0x40,
  0x98, 0x62, 0x10, 0x48, 0x0C, 0x03, 0x00, 0xC0, 0x48, 0x21, 0x08, 0x6C,
  0x0C, 0x80, 0xE0, 0x50, 0x68, 0x22, 0x11, 0x10, 0xC8, 0x24, 0x14, 0x06,
  0x03, 0x01, 0x00, 0x80, 0x80, 0xC1, 0xC0, 0xFE, 0x04, 0x10, 0x60, 0x82,
  0x0C, 0x10, 0x41, 0x83, 0xF8, 0x19, 0x08, 0x42, 0x10, 0x8C, 0x83, 0x08,
  0x42, 0x10, 0x84, 0x18, 0xFF, 0xFF, 0xF0, 0xC0, 0x82, 0x08, 0x20, 0x82,
  0x04, 0x0C, 0xC2, 0x08, 0x20, 0x82, 0x08, 0xC0, 0xF8, 0xC3, 0xC0,
};

const GFXglyph NotoSans_Light20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 14, 5, 2, -14 },
  { 3, 5, 5, 7, 1, -14 },
  { 7, 11, 14, 13, 1, -14 },
  { 27, 9, 16, 11, 1, -15 },
  { 45, 14, 14, 16, 1, -14 },
  { 70, 13, 15, 14, 1, -15 },
  { 95, 2, 5, 4, 1, -14 },
  { 97, 4, 17, 6, 1, -14 },
  { 106, 4, 17, 6, 1, -14 },
  { 115, 9, 8, 11, 1, -15 },
  { 124, 9, 10, 11, 1, -12 },
  { 136, 2, 5, 5, 1, -2 },
  { 138, 5, 1, 6, 1, -6 },
  { 139, 1, 2, 5, 2, -2 },
  { 140, 7, 14, 7, 0, -14 },
  { 153, 9, 15, 11, 1, -15 },
  { 170, 5, 14, 11, 2, -14 },
  { 179, 9, 14, 11, 1, -14 },
  { 195, 9, 14, 11, 1, -14 },
  { 211, 11, 14, 11, 0, -14 },
  { 231, 9, 14, 11, 1, -14 },
  { 247, 9, 15, 11, 1, -15 },
  { 264, 9, 14, 11, 1, -14 },
  { 280, 9, 14, 11, 1, -14 },
  { 296, 9, 14, 11, 1, -14 },
  { 312, 1, 11, 5, 2, -11 },
  { 314, 2, 14, 5, 1, -11 },
  { 318, 9, 9, 11, 1, -12 },
  { 329, 9, 5, 11, 1, -10 },
  { 335, 9, 9, 11, 1, -12 },
  { 346, 8, 14, 8, 0, -14 },
  { 360, 16, 16, 18, 1, -14 },
  { 392, 12, 14, 12, 0, -14 },
  { 413, 10, 14, 13, 2, -14 },
  { 431, 11, 14, 12, 1, -14 },
  { 451, 11, 14, 14, 2, -14 },
  { 471, 8, 14, 11, 2, -14 },
  { 485, 8, 14, 10, 2, -14 },
  { 499, 12, 15, 14, 1, -15 },
  { 522, 10, 14, 14, 2, -14 },
  { 540, 4, 14, 6, 1, -14 },
  { 547, 5, 18, 5, -2, -14 },
  { 559, 10, 14, 12, 2, -14 },
  { 577, 8, 14, 10, 2, -14 },
  { 591, 13, 14, 17, 2, -14 },
  { 614, 11, 14, 15, 2, -14 },
  { 634, 13, 15, 15, 1, -15 },
  { 659, 9, 14, 12, 2, -14 },
  { 675, 13, 18, 15, 1, -15 },
  { 705, 10, 14, 12, 2, -14 },
  { 723, 9, 14, 11, 1, -14 },
  { 739, 10, 14, 11, 0, -14 },
  { 757, 11, 14, 14, 2, -14 },
  { 777, 12, 14, 12, 0, -14 },
  { 798, 18, 14, 18, 0, -14 },
  { 830, 11, 14, 11, 0, -14 },
  { 850, 11, 14, 11, 0, -14 },
  { 870, 10, 14, 12, 1, -14 },
  { 888, 4, 17, 6, 2, -14 },
  { 897, 7, 14, 7, 0, -14 },
  { 910, 5, 17, 6, 0, -14 },
  { 921, 10, 9, 11, 1, -14 },
  { 933, 8, 1, 8, 0, 2 },
  { 934, 4, 3, 5, 1, -15 },
  { 936, 8, 11, 11, 1, -11 },
  { 947, 9, 15, 12, 2, -15 },
  { 964, 8, 11, 10, 1, -11 },
  { 975, 9, 15, 12, 1, -15 },
  { 992, 9, 11, 11, 1, -11 },
  { 1005, 7, 15, 6, 0, -15 },
  { 1019, 9, 16, 12, 1, -11 },
  { 1037, 8, 15, 12, 2, -15 },
  { 1052, 1, 15, 5, 2, -15 },
  { 1054, 4, 20, 5, -1, -15 },
  { 1064, 8, 15, 10, 2, -15 },
  { 1079, 1, 15, 5, 2, -15 },
  { 1081, 14, 11, 18, 2, -11 },
  { 1101, 8, 11, 12, 2, -11 },
  { 1112, 10, 11, 12, 1, -11 },
  { 1126, 9, 16, 12, 2, -11 },
  { 1144, 9, 16, 12, 1, -11 },
  { 1162, 6, 11, 8, 2, -11 },
  { 1171, 7, 11, 9, 1, -11 },
  { 1181, 6, 13, 7, 0, -13 },
  { 1191, 8, 11, 12, 2, -11 },
  { 1202, 9, 11, 9, 0, -11 },
  { 1215, 14, 11, 15, 0, -11 },
  { 1235, 10, 11, 10, 0, -11 },
  { 1249, 9, 16, 9, 0, -11 },
  { 1267, 7, 11, 9, 1, -11 },
  { 1277, 5, 17, 7, 1, -14 },
  { 1288, 1, 20, 11, 5, -15 },
  { 1291, 6, 17, 7, 1, -14 },
  { 1304, 9, 2, 11, 1, -8 },
};

const GFXfont NotoSans_Light20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light20pt7bBitmaps,
  (GFXglyph *)NotoSans_Light20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_LIGHT20PT7B_H_
