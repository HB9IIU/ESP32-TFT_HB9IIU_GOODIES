#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/NotoSans_Light
// Headers: 67

#include "NotoSans_Light6pt7b.h"
#include "NotoSans_Light7pt7b.h"
#include "NotoSans_Light8pt7b.h"
#include "NotoSans_Light9pt7b.h"
#include "NotoSans_Light10pt7b.h"
#include "NotoSans_Light11pt7b.h"
#include "NotoSans_Light12pt7b.h"
#include "NotoSans_Light13pt7b.h"
#include "NotoSans_Light14pt7b.h"
#include "NotoSans_Light15pt7b.h"
#include "NotoSans_Light16pt7b.h"
#include "NotoSans_Light17pt7b.h"
#include "NotoSans_Light18pt7b.h"
#include "NotoSans_Light19pt7b.h"
#include "NotoSans_Light20pt7b.h"
#include "NotoSans_Light21pt7b.h"
#include "NotoSans_Light22pt7b.h"
#include "NotoSans_Light23pt7b.h"
#include "NotoSans_Light24pt7b.h"
#include "NotoSans_Light25pt7b.h"
#include "NotoSans_Light26pt7b.h"
#include "NotoSans_Light27pt7b.h"
#include "NotoSans_Light28pt7b.h"
#include "NotoSans_Light29pt7b.h"
#include "NotoSans_Light30pt7b.h"
#include "NotoSans_Light31pt7b.h"
#include "NotoSans_Light32pt7b.h"
#include "NotoSans_Light33pt7b.h"
#include "NotoSans_Light34pt7b.h"
#include "NotoSans_Light35pt7b.h"
#include "NotoSans_Light36pt7b.h"
#include "NotoSans_Light37pt7b.h"
#include "NotoSans_Light38pt7b.h"
#include "NotoSans_Light39pt7b.h"
#include "NotoSans_Light40pt7b.h"
#include "NotoSans_Light41pt7b.h"
#include "NotoSans_Light42pt7b.h"
#include "NotoSans_Light43pt7b.h"
#include "NotoSans_Light44pt7b.h"
#include "NotoSans_Light45pt7b.h"
#include "NotoSans_Light46pt7b.h"
#include "NotoSans_Light47pt7b.h"
#include "NotoSans_Light48pt7b.h"
#include "NotoSans_Light49pt7b.h"
#include "NotoSans_Light50pt7b.h"
#include "NotoSans_Light51pt7b.h"
#include "NotoSans_Light52pt7b.h"
#include "NotoSans_Light53pt7b.h"
#include "NotoSans_Light54pt7b.h"
#include "NotoSans_Light55pt7b.h"
#include "NotoSans_Light56pt7b.h"
#include "NotoSans_Light57pt7b.h"
#include "NotoSans_Light58pt7b.h"
#include "NotoSans_Light59pt7b.h"
#include "NotoSans_Light60pt7b.h"
#include "NotoSans_Light61pt7b.h"
#include "NotoSans_Light62pt7b.h"
#include "NotoSans_Light63pt7b.h"
#include "NotoSans_Light64pt7b.h"
#include "NotoSans_Light65pt7b.h"
#include "NotoSans_Light66pt7b.h"
#include "NotoSans_Light67pt7b.h"
#include "NotoSans_Light68pt7b.h"
#include "NotoSans_Light69pt7b.h"
#include "NotoSans_Light70pt7b.h"
#include "NotoSans_Light71pt7b.h"
#include "NotoSans_Light72pt7b.h"
