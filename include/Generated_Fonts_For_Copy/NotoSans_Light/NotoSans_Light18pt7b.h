#ifndef _NOTOSANS_LIGHT18PT7B_H_
#define _NOTOSANS_LIGHT18PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light18pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x51, 0xC0, 0x99, 0x99, 0x90, 0x0C, 0x81, 0x10, 0x22,
  0x04, 0x47, 0xFE, 0x12, 0x04, 0x40, 0x88, 0xFF, 0xE2, 0x20, 0x44, 0x11,
  0x02, 0x20, 0x10, 0x10, 0x7E, 0x90, 0x90, 0x90, 0x70, 0x18, 0x16, 0x11,
  0x11, 0x11, 0xEE, 0x10, 0x10, 0x70, 0x44, 0x42, 0x22, 0x21, 0x11, 0x08,
  0x90, 0x45, 0x32, 0x2A, 0x4E, 0x91, 0x05, 0x08, 0x48, 0x42, 0x22, 0x21,
  0x23, 0x0F, 0x00, 0x3C, 0x02, 0x20, 0x42, 0x04, 0x20, 0x26, 0x01, 0xC0,
  0x38, 0x04, 0x42, 0x82, 0x48, 0x14, 0x80, 0x8C, 0x14, 0x7E, 0x30, 0xF8,
  0x29, 0x69, 0x24, 0x92, 0x4C, 0x91, 0x89, 0x32, 0x49, 0x24, 0x96, 0x94,
  0x10, 0x10, 0x10, 0xF7, 0x18, 0x18, 0x24, 0x46, 0x08, 0x08, 0x08, 0x08,
  0xFF, 0x08, 0x08, 0x08, 0x08, 0x7A, 0xF0, 0x70, 0x04, 0x10, 0x82, 0x10,
  0x41, 0x08, 0x20, 0x84, 0x10, 0x80, 0x3C, 0x42, 0x41, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x41, 0x42, 0x3C, 0x17, 0xD9, 0x11, 0x11, 0x11,
  0x11, 0x10, 0x3C, 0xC2, 0x02, 0x03, 0x02, 0x02, 0x04, 0x0C, 0x18, 0x10,
  0x20, 0x40, 0xFF, 0x7C, 0x82, 0x01, 0x01, 0x02, 0x06, 0x3C, 0x02, 0x01,
  0x01, 0x01, 0x82, 0xFC, 0x03, 0x00, 0xC0, 0x50, 0x24, 0x09, 0x04, 0x42,
  0x11, 0x04, 0x41, 0x3F, 0xF0, 0x10, 0x04, 0x01, 0x00, 0x7E, 0x40, 0x40,
  0x40, 0x40, 0x7C, 0x02, 0x01, 0x01, 0x01, 0x01, 0x82, 0xFC, 0x1E, 0x20,
  0x40, 0x40, 0x80, 0xBE, 0xC3, 0x81, 0x81, 0x81, 0x41, 0x43, 0x3E, 0xFF,
  0x01, 0x01, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x18, 0x10, 0x10, 0x20,
  0x3C, 0x42, 0xC1, 0x81, 0x42, 0x34, 0x3C, 0x42, 0x81, 0x81, 0x81, 0xC1,
  0x7E, 0x3C, 0x42, 0x81, 0x81, 0x81, 0x81, 0x43, 0x7D, 0x01, 0x01, 0x02,
  0x06, 0x78, 0x70, 0x00, 0x70, 0x70, 0x00, 0xEA, 0x01, 0x03, 0x0C, 0x70,
  0x80, 0x60, 0x1C, 0x03, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x06, 0x18, 0x60, 0x80, 0x7D, 0x0C, 0x08, 0x10, 0x20,
  0x82, 0x08, 0x10, 0x40, 0x00, 0x83, 0x00, 0x07, 0xC0, 0x60, 0xC2, 0x00,
  0x90, 0x02, 0x47, 0xC6, 0x21, 0x18, 0x84, 0x62, 0x11, 0x88, 0x46, 0x23,
  0x28, 0x73, 0x90, 0x00, 0x60, 0x00, 0xC1, 0x00, 0xF8, 0x00, 0x04, 0x01,
  0x40, 0x28, 0x05, 0x01, 0x10, 0x22, 0x04, 0x41, 0x04, 0x3F, 0x88, 0x19,
  0x01, 0x20, 0x28, 0x02, 0xFC, 0x83, 0x81, 0x81, 0x81, 0x82, 0xFE, 0x81,
  0x81, 0x81, 0x81, 0x83, 0xFC, 0x0F, 0x8C, 0x16, 0x01, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x1F, 0x80, 0xFC, 0x20,
  0xC8, 0x1A, 0x02, 0x80, 0xA0, 0x18, 0x06, 0x01, 0x80, 0xA0, 0x28, 0x1A,
  0x0C, 0xFC, 0x00, 0xFF, 0x02, 0x04, 0x08, 0x10, 0x3F, 0xC0, 0x81, 0x02,
  0x04, 0x0F, 0xE0, 0xFF, 0x02, 0x04, 0x08, 0x10, 0x3F, 0xC0, 0x81, 0x02,
  0x04, 0x08, 0x00, 0x0F, 0xC6, 0x09, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x20,
  0xFC, 0x01, 0x80, 0x28, 0x05, 0x00, 0x90, 0x11, 0xFC, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x07, 0xFF, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x08,
  0xF4, 0x44, 0x44, 0x44, 0x44, 0x44, 0xF0, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x7E, 0x81, 0x41, 0x21, 0x11, 0x09, 0x05, 0x03,
  0x41, 0x30, 0x88, 0x42, 0x20, 0x90, 0x68, 0x18, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x0F, 0xE0, 0xC0, 0x3C, 0x03, 0xC0,
  0x5A, 0x05, 0xA0, 0x5A, 0x09, 0x90, 0x99, 0x11, 0x89, 0x18, 0x91, 0x8A,
  0x18, 0x61, 0x84, 0x10, 0x80, 0xE0, 0x70, 0x34, 0x19, 0x0C, 0x86, 0x23,
  0x09, 0x84, 0xC1, 0x60, 0x70, 0x38, 0x08, 0x1F, 0x82, 0x0C, 0x40, 0x24,
  0x02, 0x80, 0x28, 0x01, 0x80, 0x18, 0x01, 0x80, 0x34, 0x02, 0x40, 0x22,
  0x04, 0x1F, 0x80, 0xF8, 0x86, 0x82, 0x81, 0x81, 0x82, 0x86, 0xF8, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x1F, 0x82, 0x0C, 0x40, 0x24, 0x02, 0x80, 0x28,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x34, 0x02, 0x40, 0x22, 0x04, 0x1F, 0x80,
  0x10, 0x00, 0x80, 0x0C, 0xFC, 0x86, 0x82, 0x81, 0x83, 0x82, 0x8C, 0xF8,
  0x84, 0x84, 0x82, 0x83, 0x81, 0x3E, 0x41, 0x80, 0x80, 0xC0, 0x60, 0x18,
  0x06, 0x01, 0x01, 0x01, 0x02, 0xFC, 0xFF, 0x84, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x28, 0x23, 0xE0,
  0x80, 0x70, 0x14, 0x05, 0x02, 0x20, 0x88, 0x62, 0x10, 0x44, 0x12, 0x06,
  0x80, 0xA0, 0x30, 0x04, 0x00, 0xC1, 0x81, 0x41, 0x82, 0x41, 0x82, 0x41,
  0x42, 0x22, 0x42, 0x22, 0x44, 0x22, 0x44, 0x24, 0x24, 0x14, 0x2C, 0x14,
  0x28, 0x14, 0x18, 0x18, 0x18, 0x08, 0x10, 0xC0, 0xD0, 0x22, 0x10, 0x48,
  0x12, 0x03, 0x00, 0xC0, 0x30, 0x12, 0x08, 0xC2, 0x11, 0x02, 0x80, 0xC0,
  0x80, 0xD0, 0x24, 0x10, 0x84, 0x22, 0x04, 0x81, 0xC0, 0x30, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x00, 0xFF, 0x00, 0x80, 0x80, 0x40, 0x40, 0x40,
  0x20, 0x20, 0x20, 0x30, 0x10, 0x10, 0x0F, 0xF8, 0xF2, 0x49, 0x24, 0x92,
  0x49, 0x27, 0x81, 0x04, 0x10, 0x20, 0x81, 0x04, 0x10, 0x20, 0x82, 0x04,
  0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1F, 0x08, 0x0C, 0x05, 0x04,
  0x82, 0x22, 0x11, 0x05, 0x03, 0xFF, 0x88, 0x80, 0x38, 0x8C, 0x08, 0x11,
  0xEC, 0x60, 0xC1, 0x86, 0xF4, 0x80, 0x80, 0x80, 0x80, 0xB8, 0xC6, 0x82,
  0x81, 0x81, 0x81, 0x81, 0x82, 0x82, 0xFC, 0x1C, 0xC5, 0x04, 0x08, 0x10,
  0x20, 0x60, 0x40, 0x7C, 0x01, 0x01, 0x01, 0x01, 0x1D, 0x63, 0x41, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x43, 0x3D, 0x1C, 0x62, 0x43, 0x81, 0xFF, 0x80,
  0x80, 0xC0, 0x40, 0x3F, 0x1E, 0x60, 0x81, 0x0F, 0x84, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x00, 0x1D, 0x63, 0x41, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x43, 0x3D, 0x01, 0x01, 0x01, 0x7E, 0x81, 0x02, 0x04, 0x0B, 0x98,
  0xE0, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x40, 0xC1, 0x55, 0x55, 0x40,
  0x30, 0x01, 0x11, 0x11, 0x11, 0x11, 0x11, 0x13, 0xE0, 0x81, 0x02, 0x04,
  0x08, 0x71, 0xA6, 0x58, 0xA1, 0xC2, 0x44, 0x48, 0x50, 0xC0, 0xFF, 0xFC,
  0xB8, 0xE6, 0x28, 0xA1, 0x87, 0x04, 0x18, 0x20, 0xC1, 0x06, 0x08, 0x30,
  0x41, 0x82, 0x0C, 0x10, 0x40, 0xB9, 0x8E, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x04, 0x1C, 0x31, 0x10, 0x50, 0x28, 0x0C, 0x06, 0x05, 0x82, 0x43,
  0x1F, 0x00, 0xB8, 0xC6, 0x82, 0x81, 0x81, 0x81, 0x81, 0x82, 0xC2, 0xBC,
  0x80, 0x80, 0x80, 0x80, 0x1D, 0x63, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x43, 0x3D, 0x01, 0x01, 0x01, 0x01, 0xBE, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x00, 0x39, 0x8A, 0x04, 0x06, 0x03, 0x81, 0x01, 0x05, 0xF8, 0x20, 0x8F,
  0xC8, 0x20, 0x82, 0x08, 0x20, 0x82, 0x0F, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x41, 0x43, 0x3D, 0x81, 0x81, 0x41, 0x42, 0x22, 0x24, 0x24,
  0x14, 0x18, 0x18, 0x82, 0x0A, 0x18, 0x51, 0x44, 0x8A, 0x24, 0x49, 0x12,
  0x48, 0xA2, 0x85, 0x14, 0x28, 0x60, 0x83, 0x00, 0x41, 0x30, 0x88, 0x82,
  0x81, 0xC0, 0x40, 0x50, 0x44, 0x63, 0x60, 0xC0, 0x81, 0xC1, 0x41, 0x42,
  0x22, 0x26, 0x24, 0x14, 0x18, 0x08, 0x08, 0x10, 0x10, 0xE0, 0xFE, 0x08,
  0x30, 0x41, 0x06, 0x08, 0x20, 0x81, 0xFC, 0x0C, 0x41, 0x04, 0x10, 0x43,
  0x38, 0x60, 0xC1, 0x04, 0x10, 0x41, 0x03, 0xFF, 0xFF, 0xC0, 0xC3, 0x08,
  0x42, 0x10, 0x83, 0x31, 0x08, 0x42, 0x11, 0x90, 0xF9, 0x86,
};

const GFXglyph NotoSans_Light18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 13, 4, 1, -13 },
  { 5, 4, 5, 7, 1, -13 },
  { 8, 11, 13, 12, 0, -13 },
  { 26, 8, 15, 10, 1, -14 },
  { 41, 13, 13, 15, 1, -13 },
  { 63, 12, 13, 13, 1, -13 },
  { 83, 1, 5, 4, 1, -13 },
  { 84, 3, 16, 5, 1, -13 },
  { 90, 3, 16, 5, 1, -13 },
  { 96, 8, 8, 10, 1, -14 },
  { 104, 8, 9, 10, 1, -11 },
  { 113, 2, 4, 4, 1, -2 },
  { 114, 4, 1, 6, 1, -5 },
  { 115, 2, 2, 4, 1, -2 },
  { 116, 6, 13, 6, 0, -13 },
  { 126, 8, 13, 10, 1, -13 },
  { 139, 4, 13, 10, 2, -13 },
  { 146, 8, 13, 10, 1, -13 },
  { 159, 8, 13, 10, 1, -13 },
  { 172, 10, 13, 10, 0, -13 },
  { 189, 8, 13, 10, 1, -13 },
  { 202, 8, 13, 10, 1, -13 },
  { 215, 8, 13, 10, 1, -13 },
  { 228, 8, 13, 10, 1, -13 },
  { 241, 8, 13, 10, 1, -13 },
  { 254, 2, 10, 4, 1, -10 },
  { 257, 2, 12, 4, 1, -10 },
  { 260, 8, 9, 10, 1, -11 },
  { 269, 8, 5, 10, 1, -9 },
  { 274, 8, 9, 10, 1, -11 },
  { 283, 7, 13, 8, 0, -13 },
  { 295, 14, 15, 16, 1, -13 },
  { 322, 11, 13, 11, 0, -13 },
  { 340, 8, 13, 11, 2, -13 },
  { 353, 10, 13, 11, 1, -13 },
  { 370, 10, 13, 13, 2, -13 },
  { 387, 7, 13, 10, 2, -13 },
  { 399, 7, 13, 9, 2, -13 },
  { 411, 11, 13, 13, 1, -13 },
  { 429, 9, 13, 13, 2, -13 },
  { 444, 4, 13, 6, 1, -13 },
  { 451, 5, 16, 5, -2, -13 },
  { 461, 9, 13, 11, 2, -13 },
  { 476, 7, 13, 9, 2, -13 },
  { 488, 12, 13, 16, 2, -13 },
  { 508, 9, 13, 13, 2, -13 },
  { 523, 12, 13, 14, 1, -13 },
  { 543, 8, 13, 11, 2, -13 },
  { 556, 12, 16, 14, 1, -13 },
  { 580, 8, 13, 11, 2, -13 },
  { 593, 8, 13, 10, 1, -13 },
  { 606, 9, 13, 10, 0, -13 },
  { 621, 9, 13, 13, 2, -13 },
  { 636, 10, 13, 10, 0, -13 },
  { 653, 16, 13, 16, 0, -13 },
  { 679, 10, 13, 10, 0, -13 },
  { 696, 10, 13, 10, 0, -13 },
  { 713, 9, 13, 10, 1, -13 },
  { 728, 3, 16, 6, 2, -13 },
  { 734, 6, 13, 6, 0, -13 },
  { 744, 4, 16, 6, 0, -13 },
  { 752, 9, 8, 10, 1, -13 },
  { 761, 8, 1, 8, 0, 2 },
  { 762, 3, 3, 5, 1, -14 },
  { 764, 7, 10, 10, 1, -10 },
  { 773, 8, 14, 11, 2, -14 },
  { 787, 7, 10, 9, 1, -10 },
  { 796, 8, 14, 11, 1, -14 },
  { 810, 8, 10, 10, 1, -10 },
  { 820, 7, 14, 6, 0, -14 },
  { 833, 8, 14, 11, 1, -10 },
  { 847, 7, 14, 11, 2, -14 },
  { 860, 2, 13, 4, 1, -13 },
  { 864, 4, 17, 4, -1, -13 },
  { 873, 7, 14, 9, 2, -14 },
  { 886, 1, 14, 4, 2, -14 },
  { 888, 13, 10, 16, 2, -10 },
  { 905, 7, 10, 11, 2, -10 },
  { 914, 9, 10, 11, 1, -10 },
  { 926, 8, 14, 11, 2, -10 },
  { 940, 8, 14, 11, 1, -10 },
  { 954, 5, 10, 7, 2, -10 },
  { 961, 7, 10, 8, 1, -10 },
  { 970, 6, 12, 6, 0, -12 },
  { 979, 8, 10, 11, 1, -10 },
  { 989, 8, 10, 8, 0, -10 },
  { 999, 13, 10, 13, 0, -10 },
  { 1016, 9, 10, 9, 0, -10 },
  { 1028, 8, 14, 8, 0, -10 },
  { 1042, 7, 10, 8, 1, -10 },
  { 1051, 6, 16, 6, 0, -13 },
  { 1063, 1, 18, 10, 4, -14 },
  { 1066, 5, 16, 6, 1, -13 },
  { 1076, 8, 2, 10, 1, -7 },
};

const GFXfont NotoSans_Light18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light18pt7bBitmaps,
  (GFXglyph *)NotoSans_Light18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_LIGHT18PT7B_H_
