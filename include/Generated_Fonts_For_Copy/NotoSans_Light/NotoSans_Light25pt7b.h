#ifndef _NOTOSANS_LIGHT25PT7B_H_
#define _NOTOSANS_LIGHT25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light25pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xF5, 0x40, 0xF0, 0x8C, 0x63, 0x18, 0xC6, 0x20, 0x06,
  0x10, 0x10, 0x40, 0x43, 0x01, 0x08, 0x04, 0x20, 0x30, 0x87, 0xFF, 0xC2,
  0x18, 0x08, 0x60, 0x21, 0x01, 0x84, 0x3F, 0xFF, 0xFF, 0xFC, 0x43, 0x01,
  0x08, 0x0C, 0x20, 0x30, 0x80, 0x86, 0x00, 0x08, 0x02, 0x03, 0xFF, 0xA2,
  0x88, 0x22, 0x08, 0x83, 0x20, 0x68, 0x0F, 0x00, 0xF0, 0x26, 0x08, 0xC2,
  0x10, 0x84, 0x23, 0x89, 0xBF, 0xC0, 0x80, 0x20, 0x3C, 0x06, 0x19, 0x81,
  0x04, 0x20, 0x83, 0x08, 0x20, 0xC2, 0x10, 0x30, 0x8C, 0x0C, 0x22, 0x03,
  0x09, 0x9C, 0x42, 0x49, 0x99, 0xB6, 0x33, 0xC9, 0x0C, 0x06, 0x41, 0x01,
  0x10, 0x40, 0x84, 0x10, 0x61, 0x04, 0x10, 0x43, 0x0C, 0x08, 0x82, 0x03,
  0xC0, 0x0F, 0x80, 0x18, 0xC0, 0x30, 0x60, 0x30, 0x60, 0x30, 0x60, 0x10,
  0x40, 0x19, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x3B, 0x03, 0x61, 0x82, 0x40,
  0xC2, 0x40, 0x66, 0xC0, 0x3C, 0x40, 0x18, 0x60, 0x3C, 0x70, 0x66, 0x1F,
  0xC3, 0xFE, 0x18, 0x8C, 0x46, 0x21, 0x18, 0xC6, 0x21, 0x0C, 0x63, 0x08,
  0x43, 0x08, 0x61, 0x0C, 0xC2, 0x18, 0x43, 0x08, 0x43, 0x18, 0xC6, 0x31,
  0x8C, 0x62, 0x11, 0x88, 0xC4, 0x60, 0x06, 0x00, 0xC0, 0x10, 0x42, 0x1F,
  0x4E, 0x3F, 0x01, 0x80, 0x58, 0x19, 0x86, 0x18, 0x42, 0x00, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0xFF, 0xF0, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x6D, 0x2D, 0x00, 0xFC, 0xF0, 0x01, 0x03, 0x03,
  0x02, 0x06, 0x04, 0x04, 0x0C, 0x08, 0x18, 0x18, 0x10, 0x30, 0x20, 0x20,
  0x60, 0x40, 0xC0, 0x0F, 0x83, 0x0C, 0x20, 0x66, 0x02, 0x40, 0x24, 0x03,
  0x40, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x34, 0x03, 0x40, 0x34, 0x02,
  0x60, 0x22, 0x06, 0x30, 0xC1, 0xF8, 0x04, 0x73, 0x79, 0x44, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x1F, 0x87, 0x0C, 0x40,
  0x40, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x10, 0x02, 0x00, 0x40, 0x0F, 0xFF, 0x1F,
  0x8E, 0x0C, 0x40, 0x60, 0x06, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x1F,
  0x00, 0x3C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0xC0,
  0xC7, 0xF8, 0x00, 0xC0, 0x0E, 0x00, 0x50, 0x04, 0x80, 0x64, 0x02, 0x20,
  0x21, 0x03, 0x08, 0x30, 0x41, 0x02, 0x10, 0x11, 0x80, 0x8F, 0xFF, 0xFF,
  0xFC, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x7F, 0xC8, 0x01, 0x00,
  0x20, 0x04, 0x01, 0x80, 0x30, 0x07, 0xF0, 0xE7, 0x80, 0x18, 0x01, 0x00,
  0x30, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x81, 0x9F, 0xE0, 0x0F, 0xC3, 0x00,
  0x80, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x04, 0xF8, 0xB0, 0xD8, 0x0A, 0x01,
  0xC0, 0x38, 0x03, 0x00, 0xF0, 0x1A, 0x02, 0x60, 0xC3, 0xE0, 0xFF, 0xF0,
  0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80,
  0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01,
  0x80, 0x1F, 0x83, 0x0C, 0x60, 0x64, 0x02, 0x40, 0x26, 0x06, 0x30, 0x41,
  0x98, 0x0F, 0x01, 0x98, 0x20, 0x64, 0x02, 0xC0, 0x3C, 0x03, 0xC0, 0x34,
  0x02, 0x70, 0x61, 0xF8, 0x1F, 0x03, 0x0C, 0x60, 0x64, 0x02, 0xC0, 0x2C,
  0x03, 0xC0, 0x34, 0x03, 0x40, 0x76, 0x0F, 0x1F, 0x30, 0x02, 0x00, 0x20,
  0x06, 0x00, 0x40, 0x0C, 0x01, 0x87, 0xF0, 0x7C, 0x00, 0x00, 0xF0, 0x2D,
  0x80, 0x00, 0x00, 0x36, 0x96, 0x80, 0x00, 0x10, 0x07, 0x01, 0xC0, 0x60,
  0x18, 0x06, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x1C, 0x07, 0x01, 0x80,
  0xE0, 0x08, 0x00, 0x7E, 0x61, 0x80, 0x40, 0x30, 0x18, 0x0C, 0x04, 0x06,
  0x04, 0x0C, 0x04, 0x02, 0x01, 0x00, 0x00, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x00, 0xF8, 0x00, 0x78, 0xF0, 0x0C, 0x01, 0x81, 0x80, 0x04, 0x30, 0x00,
  0x62, 0x07, 0x82, 0x41, 0x84, 0x34, 0x30, 0x43, 0x42, 0x04, 0x1C, 0x20,
  0x41, 0xC6, 0x04, 0x1C, 0x60, 0x43, 0xC2, 0x0C, 0x24, 0x30, 0xC6, 0x41,
  0xF3, 0xC6, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x02, 0x00,
  0x7F, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0A, 0x00, 0x16, 0x00, 0x64, 0x00,
  0x88, 0x01, 0x18, 0x06, 0x10, 0x08, 0x30, 0x30, 0x60, 0x40, 0x40, 0xFF,
  0xC3, 0x00, 0x84, 0x01, 0x18, 0x03, 0x20, 0x02, 0x40, 0x07, 0x80, 0x0C,
  0xFF, 0x8C, 0x3E, 0xC0, 0x2C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x2C, 0x06,
  0xFF, 0x8C, 0x1E, 0xC0, 0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03,
  0xC0, 0xEF, 0xF8, 0x07, 0xF0, 0xE1, 0xCC, 0x00, 0xC0, 0x0C, 0x00, 0x60,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00,
  0x60, 0x01, 0x80, 0x0C, 0x00, 0x38, 0x10, 0x7F, 0x80, 0xFF, 0x83, 0x0F,
  0x8C, 0x03, 0x30, 0x06, 0xC0, 0x0B, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x2C, 0x01, 0xB0,
  0x0C, 0xC3, 0xE3, 0xFE, 0x00, 0xFF, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xFF, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x3F, 0xF0, 0xFF, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x3F, 0xFC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x00, 0x07, 0xF8, 0x70, 0x73, 0x00, 0x18, 0x00, 0x40, 0x03,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x03, 0xF8, 0x00, 0x60, 0x01,
  0xC0, 0x07, 0x00, 0x16, 0x00, 0x5C, 0x01, 0x3C, 0x0C, 0x3F, 0xE0, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x30, 0xFC, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x33, 0xF0, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0B, 0xE6, 0x00, 0xC0, 0x3E, 0x03, 0x30, 0x31, 0x81, 0x0C, 0x10, 0x61,
  0x03, 0x10, 0x19, 0x80, 0xDC, 0x07, 0x30, 0x31, 0x81, 0x86, 0x0C, 0x18,
  0x60, 0x43, 0x03, 0x18, 0x0C, 0xC0, 0x36, 0x00, 0xC0, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x3F, 0xF0, 0xE0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0xFA, 0x00, 0x5D, 0x00, 0x6E, 0xC0, 0x27, 0x20, 0x13, 0x98,
  0x19, 0xC4, 0x08, 0xE2, 0x0C, 0x71, 0x84, 0x38, 0x42, 0x1C, 0x33, 0x0E,
  0x19, 0x07, 0x05, 0x83, 0x83, 0x81, 0xC0, 0xC0, 0xE0, 0x60, 0x40, 0xC0,
  0x0F, 0x80, 0x3F, 0x00, 0xF4, 0x03, 0xD8, 0x0F, 0x30, 0x3C, 0x40, 0xF1,
  0x83, 0xC3, 0x0F, 0x04, 0x3C, 0x18, 0xF0, 0x33, 0xC0, 0x4F, 0x01, 0xBC,
  0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x30, 0x0F, 0xE0, 0x18, 0x38, 0x30,
  0x0C, 0x60, 0x04, 0xC0, 0x06, 0xC0, 0x02, 0x80, 0x02, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x02, 0xC0, 0x02, 0xC0, 0x06, 0x40,
  0x04, 0x60, 0x0C, 0x38, 0x38, 0x0F, 0xE0, 0xFF, 0x18, 0x7B, 0x01, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0xDF, 0xF3, 0xF0, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x00, 0x0F, 0xE0, 0x18, 0x38,
  0x30, 0x0C, 0x60, 0x04, 0xC0, 0x06, 0xC0, 0x02, 0x80, 0x02, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x02, 0xC0, 0x02, 0xC0, 0x06,
  0x40, 0x04, 0x60, 0x0C, 0x38, 0x38, 0x0F, 0xE0, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x1C, 0xFE, 0x0C, 0x7C, 0xC0, 0x6C, 0x02, 0xC0, 0x2C,
  0x02, 0xC0, 0x2C, 0x06, 0xC0, 0xCF, 0xF8, 0xC3, 0x0C, 0x18, 0xC1, 0x8C,
  0x0C, 0xC0, 0x4C, 0x06, 0xC0, 0x3C, 0x03, 0x1F, 0xC6, 0x0D, 0x80, 0x20,
  0x04, 0x00, 0x80, 0x18, 0x01, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0x00, 0x30,
  0x02, 0x00, 0x40, 0x08, 0x03, 0xC0, 0xDF, 0xF0, 0xFF, 0xF8, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x34, 0x00, 0x98, 0x06, 0x38, 0x70, 0x7F, 0x80, 0xC0, 0x07,
  0x80, 0x19, 0x00, 0x33, 0x00, 0x42, 0x01, 0x84, 0x03, 0x0C, 0x04, 0x08,
  0x18, 0x18, 0x30, 0x30, 0x40, 0x21, 0x80, 0x62, 0x00, 0x4C, 0x00, 0x98,
  0x01, 0xA0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x80, 0x60, 0x1C, 0x03,
  0x00, 0xF0, 0x1C, 0x05, 0x81, 0xA0, 0x24, 0x0D, 0x03, 0x20, 0x48, 0x19,
  0x82, 0x60, 0x84, 0x31, 0x0C, 0x21, 0x08, 0x61, 0x88, 0x62, 0x0C, 0x41,
  0x10, 0x26, 0x09, 0x81, 0x20, 0x4C, 0x0D, 0x03, 0x40, 0x78, 0x0A, 0x01,
  0xC0, 0x70, 0x0C, 0x03, 0x80, 0x60, 0x08, 0x00, 0x40, 0x19, 0x80, 0x43,
  0x03, 0x04, 0x08, 0x18, 0x40, 0x33, 0x00, 0x48, 0x01, 0xE0, 0x03, 0x00,
  0x1C, 0x00, 0x58, 0x03, 0x30, 0x08, 0x40, 0x41, 0x83, 0x02, 0x08, 0x0C,
  0x60, 0x1B, 0x00, 0x30, 0xC0, 0x0A, 0x00, 0xD8, 0x04, 0x40, 0x63, 0x06,
  0x08, 0x30, 0x63, 0x01, 0x90, 0x05, 0x80, 0x38, 0x00, 0xC0, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0xFF, 0xF0,
  0x03, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x30, 0x02, 0x00,
  0x60, 0x0C, 0x00, 0x80, 0x18, 0x03, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x0F,
  0xFF, 0xFE, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x8C, 0x7C, 0xC0, 0x40, 0x60, 0x20, 0x20, 0x30, 0x10, 0x10, 0x18,
  0x08, 0x0C, 0x04, 0x04, 0x06, 0x02, 0x02, 0x03, 0x01, 0xF8, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0xFC, 0x06,
  0x00, 0x60, 0x0D, 0x00, 0x90, 0x18, 0x81, 0x08, 0x30, 0x42, 0x04, 0x60,
  0x24, 0x02, 0xC0, 0x10, 0xFF, 0xE0, 0xC3, 0x0C, 0x30, 0x06, 0x0F, 0xE2,
  0x0C, 0x01, 0x00, 0x40, 0x10, 0x7C, 0xF1, 0x60, 0x70, 0x1C, 0x07, 0x03,
  0x61, 0x4F, 0x90, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x20,
  0xDF, 0x8E, 0x0C, 0xC0, 0x6C, 0x02, 0xC0, 0x2C, 0x03, 0xC0, 0x3C, 0x02,
  0xC0, 0x2C, 0x02, 0xC0, 0x6B, 0x0C, 0x9F, 0x80, 0x02, 0x07, 0xF3, 0x01,
  0x80, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x80, 0x30,
  0x47, 0xF0, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x23, 0x1F,
  0xB3, 0x07, 0x60, 0x34, 0x03, 0x40, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x40,
  0x34, 0x03, 0x60, 0x73, 0x0D, 0x1F, 0x90, 0x06, 0x03, 0xF0, 0xC1, 0x30,
  0x34, 0x02, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x08, 0x01, 0x00, 0x30, 0x03,
  0x02, 0x3F, 0xC0, 0x0F, 0x8C, 0x04, 0x02, 0x01, 0x00, 0x83, 0xF8, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x00, 0x02, 0x01, 0xF9, 0x30, 0x76, 0x03, 0x40, 0x34, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x34, 0x03, 0x40, 0x36, 0x07, 0x30, 0xF1, 0xFB, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x06, 0x70, 0xC3, 0xF8, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x8C, 0x37, 0xE7, 0x06, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0x80, 0xF0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x18, 0xC0, 0x00, 0x0C, 0x63, 0x18, 0xC6, 0x31, 0x8C,
  0x63, 0x18, 0xC6, 0x31, 0x8E, 0xDC, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x1C, 0x1B, 0x0C, 0xC2, 0x31, 0x0C, 0x83, 0x60, 0xE8, 0x33, 0x0C,
  0x63, 0x0C, 0xC1, 0x30, 0x6C, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x06,
  0x06, 0x27, 0xE7, 0xEE, 0x0A, 0x0F, 0x03, 0x01, 0xC0, 0x40, 0x70, 0x10,
  0x1C, 0x04, 0x07, 0x01, 0x01, 0xC0, 0x40, 0x70, 0x10, 0x1C, 0x04, 0x07,
  0x01, 0x01, 0xC0, 0x40, 0x70, 0x10, 0x10, 0x06, 0x13, 0xF3, 0x83, 0x60,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xC0, 0x02, 0x01, 0xFC, 0x30, 0x66, 0x03, 0x40, 0x34, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x14, 0x01, 0x40, 0x36, 0x02, 0x30, 0x61, 0xF8,
  0x06, 0x09, 0xF8, 0xE0, 0xCC, 0x06, 0xC0, 0x2C, 0x02, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x02, 0xC0, 0x2E, 0x06, 0xF0, 0xCD, 0xF8, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x02, 0x01, 0xF9, 0x30, 0x76, 0x03,
  0x40, 0x34, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x34, 0x03, 0x40, 0x36, 0x07,
  0x30, 0xF1, 0xFB, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x05, 0x3F, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x00, 0x04, 0x1F, 0xE4, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x3C, 0x01,
  0x80, 0x20, 0x0C, 0x02, 0x81, 0xBF, 0xC0, 0x10, 0x30, 0x30, 0xFF, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x10, 0x1F, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x78,
  0x0F, 0x03, 0xB0, 0xF3, 0xF6, 0xC0, 0x34, 0x02, 0x60, 0x66, 0x04, 0x20,
  0xC3, 0x0C, 0x10, 0x81, 0x18, 0x19, 0x00, 0x90, 0x0F, 0x00, 0x60, 0x06,
  0x00, 0xC0, 0xC0, 0xD0, 0x38, 0x36, 0x0A, 0x09, 0x86, 0x82, 0x21, 0x31,
  0x88, 0x44, 0x43, 0x31, 0x10, 0x48, 0x64, 0x12, 0x1B, 0x05, 0x82, 0x81,
  0xC0, 0xA0, 0x30, 0x38, 0x0C, 0x06, 0x00, 0xC0, 0x6C, 0x10, 0x86, 0x19,
  0x81, 0xA0, 0x1C, 0x03, 0x00, 0xD0, 0x13, 0x06, 0x31, 0x82, 0x20, 0x6C,
  0x06, 0xC0, 0x34, 0x02, 0x60, 0x62, 0x04, 0x20, 0xC3, 0x0C, 0x10, 0x81,
  0x98, 0x19, 0x00, 0x90, 0x0F, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00,
  0xC0, 0x08, 0x01, 0x80, 0xF0, 0x00, 0x7F, 0xC0, 0x60, 0x10, 0x0C, 0x06,
  0x01, 0x00, 0x80, 0x60, 0x30, 0x08, 0x06, 0x03, 0x00, 0xFF, 0xC0, 0x06,
  0x38, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x63, 0x87, 0x03, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0xC0, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xC0,
  0xE0, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x30, 0x38, 0x71, 0x82, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x87, 0x18, 0x00, 0x7C, 0x1C, 0x7F, 0x00, 0x80,
};

const GFXglyph NotoSans_Light25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 18, 6, 2, -18 },
  { 6, 5, 7, 9, 2, -18 },
  { 11, 14, 18, 16, 1, -18 },
  { 43, 10, 20, 14, 2, -19 },
  { 68, 18, 18, 20, 1, -18 },
  { 109, 16, 18, 18, 1, -18 },
  { 145, 1, 7, 5, 2, -18 },
  { 146, 5, 22, 7, 1, -18 },
  { 160, 5, 22, 7, 1, -18 },
  { 174, 11, 11, 14, 1, -19 },
  { 190, 12, 12, 14, 1, -15 },
  { 208, 3, 6, 6, 1, -3 },
  { 211, 6, 1, 8, 1, -7 },
  { 212, 2, 2, 6, 2, -2 },
  { 213, 8, 18, 9, 0, -18 },
  { 231, 12, 18, 14, 1, -18 },
  { 258, 6, 18, 14, 2, -18 },
  { 272, 12, 18, 14, 1, -18 },
  { 299, 12, 18, 14, 1, -18 },
  { 326, 13, 18, 14, 1, -18 },
  { 356, 11, 18, 14, 2, -18 },
  { 381, 11, 18, 14, 2, -18 },
  { 406, 12, 18, 14, 1, -18 },
  { 433, 12, 18, 14, 1, -18 },
  { 460, 12, 18, 14, 1, -18 },
  { 487, 2, 14, 6, 2, -14 },
  { 491, 3, 17, 6, 1, -14 },
  { 498, 12, 12, 14, 1, -15 },
  { 516, 12, 6, 14, 1, -12 },
  { 525, 12, 12, 14, 1, -15 },
  { 543, 9, 18, 11, 1, -18 },
  { 564, 20, 20, 22, 1, -18 },
  { 614, 15, 18, 15, 0, -18 },
  { 648, 12, 18, 16, 2, -18 },
  { 675, 13, 18, 16, 2, -18 },
  { 705, 14, 18, 18, 2, -18 },
  { 737, 10, 18, 14, 2, -18 },
  { 760, 10, 18, 13, 2, -18 },
  { 783, 14, 18, 18, 2, -18 },
  { 815, 14, 18, 18, 2, -18 },
  { 847, 6, 18, 8, 1, -18 },
  { 861, 6, 23, 6, -2, -18 },
  { 879, 13, 18, 15, 2, -18 },
  { 909, 10, 18, 13, 2, -18 },
  { 932, 17, 18, 22, 2, -18 },
  { 971, 14, 18, 18, 2, -18 },
  { 1003, 16, 18, 19, 2, -18 },
  { 1039, 11, 18, 15, 2, -18 },
  { 1064, 16, 22, 19, 2, -18 },
  { 1108, 12, 18, 15, 2, -18 },
  { 1135, 11, 18, 14, 1, -18 },
  { 1160, 13, 18, 13, 0, -18 },
  { 1190, 14, 18, 18, 2, -18 },
  { 1222, 15, 18, 15, 0, -18 },
  { 1256, 21, 18, 23, 1, -18 },
  { 1304, 14, 18, 14, 0, -18 },
  { 1336, 13, 18, 13, 0, -18 },
  { 1366, 12, 18, 14, 1, -18 },
  { 1393, 5, 22, 8, 2, -18 },
  { 1407, 8, 18, 9, 0, -18 },
  { 1425, 5, 22, 8, 1, -18 },
  { 1439, 12, 11, 14, 1, -18 },
  { 1456, 11, 1, 10, 0, 2 },
  { 1458, 5, 4, 7, 1, -19 },
  { 1461, 10, 14, 13, 1, -14 },
  { 1479, 12, 19, 15, 2, -19 },
  { 1508, 10, 14, 12, 1, -14 },
  { 1526, 12, 19, 15, 1, -19 },
  { 1555, 11, 14, 14, 1, -14 },
  { 1575, 9, 19, 8, 0, -19 },
  { 1597, 12, 20, 15, 1, -14 },
  { 1627, 11, 19, 15, 2, -19 },
  { 1654, 2, 18, 6, 2, -18 },
  { 1659, 5, 24, 6, -1, -18 },
  { 1674, 10, 19, 12, 2, -19 },
  { 1698, 2, 19, 6, 2, -19 },
  { 1703, 18, 14, 22, 2, -14 },
  { 1735, 11, 14, 15, 2, -14 },
  { 1755, 12, 14, 15, 1, -14 },
  { 1776, 12, 20, 15, 2, -14 },
  { 1806, 12, 20, 15, 1, -14 },
  { 1836, 7, 14, 10, 2, -14 },
  { 1849, 10, 14, 12, 1, -14 },
  { 1867, 8, 16, 9, 0, -16 },
  { 1883, 11, 13, 15, 2, -13 },
  { 1901, 12, 13, 12, 0, -13 },
  { 1921, 18, 13, 18, 0, -13 },
  { 1951, 11, 13, 13, 1, -13 },
  { 1969, 12, 19, 12, 0, -13 },
  { 1998, 10, 13, 12, 1, -13 },
  { 2015, 7, 22, 9, 1, -18 },
  { 2035, 1, 25, 14, 6, -19 },
  { 2039, 7, 22, 9, 1, -18 },
  { 2059, 12, 3, 14, 1, -10 },
};

const GFXfont NotoSans_Light25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light25pt7bBitmaps,
  (GFXglyph *)NotoSans_Light25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_LIGHT25PT7B_H_
