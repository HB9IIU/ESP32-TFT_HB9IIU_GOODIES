#ifndef _NOTOSANS_LIGHT35PT7B_H_
#define _NOTOSANS_LIGHT35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light35pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x6D, 0xB6, 0xDB, 0x6D, 0x92, 0x48, 0x00, 0x3F, 0xE0, 0xE3,
  0xE3, 0x43, 0x43, 0x43, 0x43, 0x43, 0x41, 0x41, 0x00, 0xC0, 0x80, 0x04,
  0x0C, 0x00, 0x20, 0x60, 0x03, 0x03, 0x00, 0x18, 0x18, 0x00, 0xC0, 0x80,
  0x04, 0x0C, 0x00, 0x20, 0x60, 0x7F, 0xFF, 0xF8, 0x18, 0x18, 0x00, 0xC0,
  0x80, 0x06, 0x0C, 0x00, 0x20, 0x60, 0x03, 0x03, 0x00, 0x18, 0x18, 0x00,
  0xC0, 0x80, 0xFF, 0xFF, 0xE0, 0x20, 0x60, 0x03, 0x03, 0x00, 0x18, 0x18,
  0x00, 0xC0, 0x80, 0x06, 0x04, 0x00, 0x20, 0x60, 0x01, 0x03, 0x00, 0x18,
  0x18, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x7F, 0x83, 0xFF, 0xCE,
  0x20, 0x98, 0x40, 0x60, 0x80, 0xC1, 0x01, 0x82, 0x03, 0x84, 0x03, 0x88,
  0x03, 0x90, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x01, 0x1C, 0x02, 0x1C,
  0x04, 0x18, 0x08, 0x30, 0x10, 0x60, 0x20, 0xC0, 0x43, 0xE0, 0x8E, 0xFF,
  0xF8, 0x3F, 0xC0, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x3F, 0x00, 0x30,
  0x39, 0x80, 0x30, 0x18, 0x60, 0x18, 0x18, 0x10, 0x18, 0x0C, 0x0C, 0x0C,
  0x06, 0x06, 0x0C, 0x03, 0x03, 0x04, 0x01, 0x81, 0x86, 0x00, 0xC0, 0xC2,
  0x00, 0x60, 0x63, 0x00, 0x30, 0x33, 0x1F, 0x18, 0x11, 0x98, 0xC6, 0x19,
  0x98, 0x33, 0x98, 0xCC, 0x18, 0xF8, 0xC6, 0x04, 0x00, 0x62, 0x02, 0x00,
  0x61, 0x01, 0x00, 0x20, 0x80, 0xC0, 0x30, 0x40, 0x60, 0x30, 0x20, 0x20,
  0x18, 0x18, 0x10, 0x18, 0x0C, 0x18, 0x0C, 0x06, 0x0C, 0x0C, 0x01, 0x8C,
  0x0E, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x00, 0x38, 0xE0, 0x01, 0x80, 0xC0,
  0x06, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x30, 0x01, 0x80, 0xC0, 0x06,
  0x07, 0x00, 0x0C, 0x38, 0x00, 0x39, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0xE3, 0x80, 0x67, 0x07, 0x01, 0x98, 0x0E, 0x06,
  0xC0, 0x1C, 0x33, 0x00, 0x38, 0xCC, 0x00, 0x76, 0x30, 0x00, 0xF8, 0xC0,
  0x01, 0xC1, 0x80, 0x0F, 0x87, 0x00, 0xF7, 0x0F, 0xFF, 0x0E, 0x0F, 0xF0,
  0x1C, 0xFD, 0x24, 0x92, 0x40, 0x07, 0x0E, 0x0C, 0x18, 0x18, 0x30, 0x30,
  0x30, 0x60, 0x60, 0x60, 0x60, 0x60, 0xE0, 0xC0, 0xC0, 0xC0, 0xE0, 0x60,
  0x60, 0x60, 0x60, 0x60, 0x30, 0x30, 0x38, 0x18, 0x1C, 0x0C, 0x06, 0x03,
  0xE0, 0xC0, 0xC1, 0xC1, 0x83, 0x03, 0x06, 0x0C, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC3, 0x06, 0x0C, 0x30, 0x61,
  0x83, 0x0C, 0x30, 0x00, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x10, 0x10, 0x20, 0x7C, 0x47, 0xBF, 0xFE, 0x03, 0x80, 0x05, 0x00, 0x1B,
  0x00, 0x63, 0x01, 0xC7, 0x03, 0x06, 0x0E, 0x06, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x39, 0x8C, 0x66, 0x31, 0x88,
  0xC0, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00,
  0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x00, 0x0F, 0xF0, 0x1E, 0x78, 0x38,
  0x1C, 0x30, 0x0C, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x60, 0x06, 0x60, 0x06, 0x60,
  0x06, 0x30, 0x0C, 0x38, 0x1C, 0x1E, 0x78, 0x0F, 0xF0, 0x03, 0x83, 0xC3,
  0xE3, 0x37, 0x1F, 0x0D, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0x1F, 0xE0, 0x3C, 0xF8, 0xE0, 0x1C, 0x40, 0x0C, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xF0, 0x7C, 0xF8, 0xE0, 0x1C, 0x80, 0x0C,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x38, 0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E,
  0x80, 0x1C, 0xFD, 0xF8, 0x7F, 0xE0, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x6C, 0x00, 0x33, 0x00, 0x18, 0xC0, 0x06, 0x30,
  0x03, 0x0C, 0x01, 0x83, 0x00, 0x60, 0xC0, 0x30, 0x30, 0x18, 0x0C, 0x0C,
  0x03, 0x03, 0x00, 0xC1, 0x80, 0x30, 0xC0, 0x0C, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x7F,
  0xE0, 0x7F, 0xF8, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0xC0,
  0x1C, 0xFC, 0xF8, 0x3F, 0xE0, 0x01, 0xFC, 0x07, 0x84, 0x0E, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40,
  0x80, 0xC7, 0xF8, 0xDC, 0x1C, 0xD0, 0x06, 0xE0, 0x07, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x07, 0x30,
  0x06, 0x38, 0x0E, 0x1F, 0x7C, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0F, 0xF0, 0x3E,
  0x7C, 0x30, 0x0C, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60,
  0x06, 0x30, 0x0C, 0x38, 0x18, 0x0E, 0x70, 0x07, 0xC0, 0x0F, 0xF0, 0x1C,
  0x38, 0x30, 0x0C, 0x60, 0x06, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0x60, 0x06, 0x70, 0x0E, 0x3E, 0x7C, 0x0F, 0xF0, 0x0F,
  0xE0, 0x3E, 0x78, 0x70, 0x1C, 0x60, 0x0C, 0xE0, 0x06, 0xC0, 0x06, 0xC0,
  0x06, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0x60,
  0x0B, 0x38, 0x3B, 0x1F, 0xE3, 0x01, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x61, 0xE0, 0x7F,
  0xC0, 0xDF, 0xA0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x31, 0xCE, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x31, 0x9C, 0xC6, 0x33, 0x18,
  0x00, 0x01, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x0E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x00, 0xC0, 0x00,
  0x80, 0x00, 0x7F, 0xC7, 0xDF, 0x20, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x03, 0x80, 0x0C, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0x00, 0x78, 0x03, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x38,
  0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x31, 0x00, 0x7E, 0x06, 0x60, 0x3F,
  0xE0, 0x6C, 0x0C, 0x04, 0x0F, 0x03, 0x01, 0x81, 0xE0, 0x60, 0x30, 0x3C,
  0x18, 0x06, 0x07, 0x83, 0x00, 0xC0, 0xF0, 0x60, 0x18, 0x1E, 0x0C, 0x03,
  0x03, 0xC1, 0x80, 0x60, 0x78, 0x30, 0x1C, 0x0B, 0x03, 0x02, 0x83, 0x60,
  0x79, 0xDC, 0xC6, 0x03, 0xE1, 0xF0, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x02, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x66, 0x00, 0x06, 0x30,
  0x00, 0x30, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC0, 0xC0, 0x0C,
  0x06, 0x00, 0x60, 0x38, 0x07, 0x00, 0xC0, 0x30, 0x06, 0x01, 0xFF, 0xF8,
  0x18, 0x00, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00,
  0x07, 0x30, 0x00, 0x19, 0x80, 0x00, 0xCC, 0x00, 0x03, 0xC0, 0x00, 0x18,
  0xFF, 0xF0, 0x7F, 0xFE, 0x38, 0x03, 0x9C, 0x00, 0xEE, 0x00, 0x37, 0x00,
  0x1B, 0x80, 0x0D, 0xC0, 0x06, 0xE0, 0x03, 0x70, 0x03, 0x38, 0x03, 0x9F,
  0xFF, 0x0F, 0xFF, 0xC7, 0x00, 0x73, 0x80, 0x0D, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1B, 0x80,
  0x3D, 0xFF, 0xF8, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xFC, 0x3C,
  0x01, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x3F, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xE0,
  0x0F, 0x0E, 0x00, 0x38, 0xE0, 0x01, 0xCE, 0x00, 0x0C, 0xE0, 0x00, 0xEE,
  0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x06, 0xE0, 0x00,
  0x6E, 0x00, 0x06, 0xE0, 0x00, 0xEE, 0x00, 0x0C, 0xE0, 0x01, 0xCE, 0x00,
  0x38, 0xE0, 0x1F, 0x0F, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xBF, 0x83, 0xC0, 0x0C, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x00,
  0xD8, 0x00, 0x06, 0x60, 0x00, 0x33, 0x80, 0x01, 0x8E, 0x00, 0x0C, 0x38,
  0x00, 0x60, 0xFE, 0xFF, 0x01, 0xFF, 0xE0, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x60, 0xFE, 0xF8, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x3C, 0xFE, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0x80, 0xC0,
  0x60, 0x76, 0xF3, 0xF0, 0xE0, 0x03, 0xB8, 0x01, 0xCE, 0x00, 0xE3, 0x80,
  0x70, 0xE0, 0x18, 0x38, 0x0C, 0x0E, 0x06, 0x03, 0x83, 0x00, 0xE1, 0x80,
  0x38, 0xC0, 0x0E, 0x60, 0x03, 0xBC, 0x00, 0xFB, 0x00, 0x3C, 0x60, 0x0E,
  0x1C, 0x03, 0x83, 0x80, 0xE0, 0x60, 0x38, 0x0C, 0x0E, 0x03, 0x83, 0x80,
  0x70, 0xE0, 0x0C, 0x38, 0x01, 0x8E, 0x00, 0x73, 0x80, 0x0E, 0xE0, 0x01,
  0xC0, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xD8, 0x00, 0x0F, 0xD8, 0x00, 0x0F, 0xD8, 0x00, 0x1B,
  0xCC, 0x00, 0x1B, 0xCC, 0x00, 0x33, 0xCE, 0x00, 0x33, 0xC6, 0x00, 0x33,
  0xC6, 0x00, 0x63, 0xC3, 0x00, 0x63, 0xC3, 0x00, 0xC3, 0xC3, 0x00, 0xC3,
  0xC1, 0x80, 0xC3, 0xC1, 0x81, 0x83, 0xC0, 0xC1, 0x83, 0xC0, 0xC3, 0x03,
  0xC0, 0xC3, 0x03, 0xC0, 0x63, 0x03, 0xC0, 0x66, 0x03, 0xC0, 0x36, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x1C, 0x03, 0xC0, 0x18, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xEC, 0x00, 0x3D, 0xC0, 0x07,
  0x98, 0x00, 0xF1, 0x80, 0x1E, 0x38, 0x03, 0xC3, 0x00, 0x78, 0x30, 0x0F,
  0x07, 0x01, 0xE0, 0x60, 0x3C, 0x06, 0x07, 0x80, 0xE0, 0xF0, 0x0C, 0x1E,
  0x00, 0xC3, 0xC0, 0x1C, 0x78, 0x01, 0x8F, 0x00, 0x19, 0xE0, 0x03, 0xBC,
  0x00, 0x37, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x60,
  0x01, 0xFF, 0x00, 0x0F, 0xDF, 0x80, 0x38, 0x03, 0x80, 0xE0, 0x03, 0x83,
  0x80, 0x03, 0x86, 0x00, 0x03, 0x18, 0x00, 0x07, 0x30, 0x00, 0x06, 0x60,
  0x00, 0x0D, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x06, 0x60, 0x00,
  0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x71, 0x80, 0x00, 0xC3, 0x80, 0x03,
  0x83, 0x00, 0x0E, 0x03, 0x80, 0x38, 0x03, 0xF7, 0xE0, 0x01, 0xFF, 0x00,
  0xFF, 0xE0, 0xFF, 0xF8, 0xE0, 0x1C, 0xE0, 0x0E, 0xE0, 0x06, 0xE0, 0x07,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x06, 0xE0, 0x06, 0xE0, 0x0E,
  0xE0, 0x3C, 0xFF, 0xF0, 0xFF, 0xC0, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xDF, 0x80, 0x38, 0x03, 0x80, 0xE0,
  0x03, 0x83, 0x80, 0x03, 0x86, 0x00, 0x03, 0x18, 0x00, 0x07, 0x30, 0x00,
  0x06, 0x60, 0x00, 0x0D, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x06,
  0x60, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x71, 0x80, 0x00, 0xC3,
  0x80, 0x03, 0x83, 0x00, 0x0E, 0x03, 0x80, 0x38, 0x03, 0xF7, 0xE0, 0x01,
  0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0xFF, 0xE0, 0x7F, 0xFC,
  0x38, 0x07, 0x1C, 0x01, 0xCE, 0x00, 0x67, 0x00, 0x3B, 0x80, 0x0D, 0xC0,
  0x06, 0xE0, 0x07, 0x70, 0x03, 0x38, 0x03, 0x9C, 0x03, 0x8F, 0xFF, 0x87,
  0xFF, 0x03, 0x81, 0x81, 0xC0, 0xE0, 0xE0, 0x30, 0x70, 0x1C, 0x38, 0x06,
  0x1C, 0x01, 0x8E, 0x00, 0xE7, 0x00, 0x33, 0x80, 0x1D, 0xC0, 0x06, 0xE0,
  0x01, 0x80, 0x0F, 0xF8, 0x7F, 0xFD, 0xC0, 0x13, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xE0, 0x07, 0x7E, 0xFC, 0x7F,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xB0, 0x00, 0x76, 0x00, 0x0C,
  0x60, 0x03, 0x8E, 0x00, 0xE0, 0xFD, 0xF8, 0x07, 0xFC, 0x00, 0xC0, 0x00,
  0x36, 0x00, 0x03, 0x60, 0x00, 0x66, 0x00, 0x06, 0x30, 0x00, 0x63, 0x00,
  0x0C, 0x38, 0x00, 0xC1, 0x80, 0x1C, 0x18, 0x01, 0x81, 0xC0, 0x18, 0x0C,
  0x03, 0x80, 0xC0, 0x30, 0x06, 0x03, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00,
  0x30, 0x60, 0x03, 0x0C, 0x00, 0x38, 0xC0, 0x01, 0x9C, 0x00, 0x19, 0x80,
  0x00, 0xD8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0xC0, 0x07, 0x00, 0x1F, 0x00, 0x1C, 0x00, 0x6E, 0x00, 0x70, 0x01,
  0x98, 0x01, 0x60, 0x06, 0x60, 0x0D, 0x80, 0x39, 0x80, 0x36, 0x00, 0xC3,
  0x00, 0xCC, 0x03, 0x0C, 0x06, 0x30, 0x0C, 0x30, 0x18, 0xC0, 0x60, 0xC0,
  0x61, 0x01, 0x81, 0x81, 0x86, 0x06, 0x06, 0x0C, 0x18, 0x18, 0x18, 0x30,
  0x60, 0xC0, 0x60, 0xC0, 0xC3, 0x00, 0xC2, 0x03, 0x0C, 0x03, 0x18, 0x0C,
  0x70, 0x0C, 0x60, 0x11, 0x80, 0x19, 0x80, 0x66, 0x00, 0x6C, 0x01, 0x98,
  0x01, 0xB0, 0x06, 0xC0, 0x06, 0xC0, 0x0F, 0x00, 0x0B, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x80, 0x06, 0x00, 0x60,
  0x00, 0xE6, 0x00, 0x38, 0xE0, 0x06, 0x0C, 0x01, 0x80, 0xC0, 0x70, 0x18,
  0x0C, 0x01, 0x83, 0x00, 0x18, 0x60, 0x03, 0x18, 0x00, 0x36, 0x00, 0x07,
  0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xE0, 0x00, 0x6C, 0x00, 0x18,
  0xC0, 0x03, 0x1C, 0x00, 0xC1, 0x80, 0x30, 0x18, 0x06, 0x03, 0x81, 0x80,
  0x30, 0x60, 0x03, 0x0C, 0x00, 0x73, 0x00, 0x06, 0xE0, 0x00, 0x60, 0xE0,
  0x00, 0xEC, 0x00, 0x19, 0xC0, 0x06, 0x18, 0x00, 0xC3, 0x80, 0x30, 0x30,
  0x06, 0x03, 0x01, 0x80, 0x60, 0x30, 0x06, 0x0C, 0x00, 0xC3, 0x80, 0x0C,
  0x60, 0x01, 0x9C, 0x00, 0x1B, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x7F,
  0xFF, 0x9F, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x1F, 0xFF, 0x80,
  0xE0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06,
  0x00, 0x30, 0xFF, 0xFC, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x7F, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0x0C, 0x80, 0x03, 0x30, 0x01, 0x84, 0x00, 0x61, 0x80, 0x30, 0x20,
  0x0C, 0x0C, 0x06, 0x01, 0x81, 0x80, 0x60, 0xC0, 0x0C, 0x30, 0x03, 0x18,
  0x00, 0x6E, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0xE0, 0xC0, 0xC0,
  0xC0, 0xC0, 0x0F, 0xE0, 0xFF, 0xC3, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x03, 0xFC, 0x7F, 0xF7, 0x80, 0xF8, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xE0, 0x2D, 0xE7, 0xB3, 0xF8, 0xC0,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC3, 0xE0, 0xCF, 0xF8, 0xD8, 0x1C, 0xF0, 0x0E,
  0xE0, 0x06, 0xE0, 0x06, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x06, 0xE0, 0x06, 0xE0, 0x0E,
  0xF0, 0x1C, 0xDC, 0x78, 0xC7, 0xF0, 0x03, 0xF0, 0x3F, 0xF1, 0xC0, 0x8C,
  0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x7D, 0xE0, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x07, 0xE3, 0x1F, 0xF3,
  0x38, 0x1B, 0x70, 0x0F, 0x60, 0x07, 0x60, 0x07, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0x60, 0x07, 0x60, 0x07, 0x30, 0x0B, 0x3E, 0x7B, 0x0F, 0xE3, 0x07, 0xE0,
  0x3F, 0xF0, 0xE0, 0x71, 0x80, 0x66, 0x00, 0x6C, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x38, 0x02, 0x3E, 0x7C, 0x3F, 0xF0, 0x01, 0xF0,
  0x1F, 0xC1, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1F,
  0xC7, 0xFE, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x07, 0xE3, 0x1F, 0xF3, 0x38, 0x1B,
  0x70, 0x0F, 0x60, 0x07, 0x60, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0x60, 0x07,
  0x60, 0x07, 0x30, 0x0B, 0x1E, 0x3B, 0x0F, 0xE3, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x40, 0x0E, 0x7C, 0x7C, 0x3F, 0xF0,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC3, 0xE1, 0x9F, 0xF3, 0x60, 0x77, 0x80, 0x6E, 0x00,
  0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x18, 0x7D, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x02, 0x0C,
  0x18, 0x10, 0x00, 0x00, 0x03, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x9D, 0xF8, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x1F, 0x00, 0xEC, 0x07, 0x30,
  0x38, 0xC1, 0xC3, 0x0E, 0x0C, 0x30, 0x31, 0x80, 0xCC, 0x03, 0x78, 0x0F,
  0x30, 0x38, 0xE0, 0xC1, 0x83, 0x03, 0x0C, 0x0E, 0x30, 0x1C, 0xC0, 0x33,
  0x00, 0x6C, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC7,
  0xC0, 0x7C, 0x67, 0xF8, 0xFF, 0xB6, 0x0E, 0xC0, 0xFC, 0x03, 0xC0, 0x3E,
  0x01, 0xC0, 0x1E, 0x00, 0x60, 0x0F, 0x00, 0x30, 0x07, 0x80, 0x18, 0x03,
  0xC0, 0x0C, 0x01, 0xE0, 0x06, 0x00, 0xF0, 0x03, 0x00, 0x78, 0x01, 0x80,
  0x3C, 0x00, 0xC0, 0x1E, 0x00, 0x60, 0x0F, 0x00, 0x30, 0x07, 0x80, 0x18,
  0x03, 0xC0, 0x0C, 0x01, 0xE0, 0x06, 0x00, 0xF0, 0x03, 0x00, 0x60, 0xC3,
  0xE1, 0x9F, 0xF3, 0x60, 0x77, 0x80, 0x6E, 0x00, 0x7C, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x18, 0x07,
  0xE0, 0x0F, 0xFC, 0x0E, 0x07, 0x06, 0x00, 0xC6, 0x00, 0x73, 0x00, 0x1B,
  0x00, 0x0D, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x33, 0x00, 0x19, 0x80, 0x0C, 0xE0, 0x0C, 0x38, 0x0E, 0x0F,
  0x3E, 0x03, 0xFC, 0x00, 0xC3, 0xE0, 0xCF, 0xF8, 0xD8, 0x1C, 0xF0, 0x0E,
  0xE0, 0x06, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x06, 0xE0, 0x0E,
  0xF0, 0x1C, 0xDE, 0x78, 0xC7, 0xF0, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x07, 0xE3,
  0x1F, 0xF3, 0x38, 0x1B, 0x70, 0x0F, 0x60, 0x07, 0xE0, 0x07, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0x60, 0x07, 0x60, 0x07, 0x30, 0x0B, 0x3C, 0x7B, 0x0F, 0xE3,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0xC7, 0xF3, 0xFD, 0x83, 0xC0, 0xE0, 0x38, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x00, 0x1F, 0xC3, 0xFF, 0xB8, 0x05, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x0E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xE0,
  0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x37, 0x8F, 0x3F, 0xF0, 0x08,
  0x01, 0x00, 0x60, 0x0C, 0x03, 0xFF, 0xFF, 0xC6, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x00, 0xC0, 0x1E, 0x41, 0xF8, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0,
  0x0F, 0x60, 0x36, 0xF9, 0xCC, 0x7F, 0x18, 0xC0, 0x03, 0xE0, 0x03, 0x60,
  0x03, 0x60, 0x06, 0x30, 0x06, 0x30, 0x0C, 0x30, 0x0C, 0x18, 0x0C, 0x18,
  0x18, 0x0C, 0x18, 0x0C, 0x18, 0x0C, 0x30, 0x06, 0x30, 0x06, 0x60, 0x06,
  0x60, 0x03, 0x60, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0xE0, 0x0C, 0x01,
  0xB0, 0x06, 0x00, 0xD8, 0x07, 0x80, 0x6C, 0x03, 0xC0, 0x63, 0x01, 0xE0,
  0x31, 0x81, 0x98, 0x18, 0xC0, 0xCC, 0x0C, 0x70, 0x66, 0x0C, 0x18, 0x61,
  0x86, 0x0C, 0x30, 0xC3, 0x06, 0x18, 0x61, 0x81, 0x98, 0x19, 0x80, 0xCC,
  0x0C, 0xC0, 0x66, 0x06, 0x60, 0x36, 0x01, 0x20, 0x0F, 0x00, 0xF0, 0x07,
  0x80, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x60,
  0x0E, 0x30, 0x0C, 0x38, 0x18, 0x18, 0x30, 0x0C, 0x30, 0x0E, 0x60, 0x06,
  0xC0, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x06, 0xC0, 0x0E, 0x60, 0x0C,
  0x30, 0x18, 0x38, 0x38, 0x18, 0x30, 0x0C, 0x60, 0x0E, 0xC0, 0x07, 0xC0,
  0x03, 0xE0, 0x03, 0x60, 0x03, 0x60, 0x06, 0x30, 0x06, 0x30, 0x0E, 0x30,
  0x0C, 0x18, 0x0C, 0x18, 0x18, 0x0C, 0x18, 0x0C, 0x18, 0x0C, 0x30, 0x06,
  0x30, 0x06, 0x60, 0x02, 0x60, 0x03, 0x60, 0x03, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x9C, 0x00, 0xF8, 0x00, 0x7F, 0xFD, 0xFF, 0xF0, 0x01, 0x80, 0x0E,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x70,
  0x01, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xC1, 0xF0, 0x60, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x0F, 0x03, 0x80, 0x38,
  0x07, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x38, 0x07, 0x00, 0xF0, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0,
  0x1F, 0x00, 0x70, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xF8, 0x0F, 0x03, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x30,
  0x06, 0x03, 0xC1, 0xF0, 0x20, 0x00, 0x7F, 0x01, 0xE7, 0xC3, 0x80, 0xFE,
  0x00, 0x08,
};

const GFXglyph NotoSans_Light35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 25, 9, 3, -25 },
  { 11, 8, 9, 13, 2, -25 },
  { 20, 21, 25, 23, 1, -25 },
  { 86, 15, 29, 20, 2, -27 },
  { 141, 25, 25, 28, 2, -25 },
  { 220, 22, 25, 25, 2, -25 },
  { 289, 3, 9, 7, 2, -25 },
  { 293, 8, 31, 10, 1, -25 },
  { 324, 7, 31, 10, 1, -25 },
  { 352, 15, 15, 19, 2, -27 },
  { 381, 16, 17, 20, 2, -21 },
  { 415, 5, 9, 8, 1, -4 },
  { 421, 9, 1, 11, 1, -10 },
  { 423, 3, 3, 9, 3, -3 },
  { 425, 12, 25, 12, 0, -25 },
  { 463, 16, 25, 20, 2, -25 },
  { 513, 9, 25, 20, 3, -25 },
  { 542, 16, 25, 20, 2, -25 },
  { 592, 16, 25, 20, 2, -25 },
  { 642, 18, 25, 20, 1, -25 },
  { 699, 16, 25, 20, 2, -25 },
  { 749, 16, 25, 20, 2, -25 },
  { 799, 16, 25, 20, 2, -25 },
  { 849, 16, 25, 20, 2, -25 },
  { 899, 16, 25, 20, 2, -25 },
  { 949, 3, 19, 9, 3, -19 },
  { 957, 5, 24, 9, 1, -19 },
  { 972, 16, 17, 20, 2, -21 },
  { 1006, 16, 9, 20, 2, -17 },
  { 1024, 16, 17, 20, 2, -21 },
  { 1058, 13, 25, 15, 1, -25 },
  { 1099, 27, 28, 31, 2, -25 },
  { 1194, 21, 25, 21, 0, -25 },
  { 1260, 17, 25, 22, 3, -25 },
  { 1314, 19, 25, 22, 2, -25 },
  { 1374, 20, 25, 25, 3, -25 },
  { 1437, 14, 25, 19, 3, -25 },
  { 1481, 14, 25, 18, 3, -25 },
  { 1525, 21, 25, 25, 2, -25 },
  { 1591, 19, 25, 25, 3, -25 },
  { 1651, 7, 25, 11, 2, -25 },
  { 1673, 9, 31, 9, -3, -25 },
  { 1708, 18, 25, 21, 3, -25 },
  { 1765, 14, 25, 18, 3, -25 },
  { 1809, 24, 25, 31, 3, -25 },
  { 1884, 19, 25, 26, 3, -25 },
  { 1944, 23, 25, 27, 2, -25 },
  { 2016, 16, 25, 21, 3, -25 },
  { 2066, 23, 31, 27, 2, -25 },
  { 2156, 17, 25, 21, 3, -25 },
  { 2210, 15, 25, 19, 2, -25 },
  { 2257, 18, 25, 19, 0, -25 },
  { 2314, 19, 25, 25, 3, -25 },
  { 2374, 20, 25, 20, 0, -25 },
  { 2437, 30, 25, 32, 1, -25 },
  { 2531, 19, 25, 19, 0, -25 },
  { 2591, 19, 25, 19, 0, -25 },
  { 2651, 18, 25, 20, 1, -25 },
  { 2708, 7, 31, 11, 3, -25 },
  { 2736, 12, 25, 12, 0, -25 },
  { 2774, 7, 31, 11, 1, -25 },
  { 2802, 18, 15, 20, 1, -25 },
  { 2836, 15, 2, 15, 0, 3 },
  { 2840, 7, 6, 9, 1, -27 },
  { 2846, 14, 19, 19, 2, -19 },
  { 2880, 16, 27, 21, 3, -27 },
  { 2934, 14, 19, 17, 2, -19 },
  { 2968, 16, 27, 21, 2, -27 },
  { 3022, 15, 19, 19, 2, -19 },
  { 3058, 13, 27, 11, 0, -27 },
  { 3102, 16, 27, 21, 2, -19 },
  { 3156, 15, 27, 21, 3, -27 },
  { 3207, 2, 26, 8, 3, -26 },
  { 3214, 7, 34, 8, -2, -26 },
  { 3244, 14, 27, 17, 3, -27 },
  { 3292, 2, 27, 8, 3, -27 },
  { 3299, 25, 19, 31, 3, -19 },
  { 3359, 15, 19, 21, 3, -19 },
  { 3395, 17, 19, 21, 2, -19 },
  { 3436, 16, 27, 21, 3, -19 },
  { 3490, 16, 27, 21, 2, -19 },
  { 3544, 10, 19, 14, 3, -19 },
  { 3568, 13, 19, 16, 2, -19 },
  { 3599, 11, 23, 12, 0, -23 },
  { 3631, 15, 19, 21, 3, -19 },
  { 3667, 16, 19, 16, 0, -19 },
  { 3705, 25, 19, 26, 0, -19 },
  { 3765, 16, 19, 18, 1, -19 },
  { 3803, 16, 27, 16, 0, -19 },
  { 3857, 14, 19, 16, 1, -19 },
  { 3891, 10, 31, 13, 1, -25 },
  { 3930, 1, 36, 19, 9, -27 },
  { 3935, 11, 31, 13, 1, -25 },
  { 3978, 16, 4, 20, 2, -14 },
};

const GFXfont NotoSans_Light35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light35pt7bBitmaps,
  (GFXglyph *)NotoSans_Light35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_LIGHT35PT7B_H_
