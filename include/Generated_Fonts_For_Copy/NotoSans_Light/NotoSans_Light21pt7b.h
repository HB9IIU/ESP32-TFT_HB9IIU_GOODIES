#ifndef _NOTOSANS_LIGHT21PT7B_H_
#define _NOTOSANS_LIGHT21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light21pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xA8, 0x2C, 0xCA, 0x52, 0x94, 0x80, 0x08, 0x40, 0x84,
  0x08, 0x40, 0x88, 0x08, 0x8F, 0xFF, 0x10, 0x81, 0x08, 0x11, 0x0F, 0xFE,
  0x21, 0x02, 0x10, 0x21, 0x02, 0x20, 0x22, 0x00, 0x08, 0x04, 0x0F, 0xE9,
  0x0C, 0x86, 0x41, 0x20, 0xF0, 0x1E, 0x05, 0x82, 0x21, 0x10, 0x88, 0x4F,
  0xFC, 0x10, 0x08, 0x00, 0x78, 0x10, 0x88, 0x42, 0x10, 0x84, 0x22, 0x08,
  0x44, 0x10, 0x90, 0x21, 0x2F, 0x26, 0xB2, 0x7B, 0x42, 0x04, 0x84, 0x11,
  0x08, 0x22, 0x10, 0x84, 0x21, 0x0C, 0x84, 0x0F, 0x00, 0x1F, 0x00, 0x86,
  0x02, 0x08, 0x08, 0x20, 0x21, 0x00, 0x4C, 0x00, 0xC0, 0x0D, 0x00, 0x62,
  0x09, 0x04, 0x6C, 0x09, 0x30, 0x18, 0xC0, 0x61, 0x83, 0x43, 0xF0, 0xC0,
  0xD5, 0x40, 0x12, 0x64, 0x4C, 0x88, 0x88, 0x88, 0x8C, 0x44, 0x23, 0x84,
  0x62, 0x23, 0x11, 0x11, 0x11, 0x32, 0x26, 0x4C, 0x08, 0x04, 0x02, 0x19,
  0x33, 0xF0, 0x60, 0x58, 0x64, 0x21, 0x00, 0x08, 0x02, 0x00, 0x80, 0x20,
  0xFF, 0xC2, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x5E, 0x80, 0xF8, 0xB0,
  0x02, 0x0C, 0x10, 0x20, 0x81, 0x06, 0x08, 0x10, 0x60, 0x81, 0x04, 0x08,
  0x30, 0x00, 0x3F, 0x08, 0x44, 0x09, 0x02, 0xC0, 0xE0, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x1C, 0x0D, 0x02, 0x40, 0x88, 0x41, 0xE0, 0x19, 0xD3, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x20, 0x3E, 0x30, 0x40, 0x08, 0x02,
  0x00, 0x80, 0x60, 0x10, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x40, 0x20, 0x10,
  0x0F, 0xFC, 0x7F, 0x30, 0x60, 0x08, 0x02, 0x00, 0x80, 0x60, 0x70, 0xF8,
  0x01, 0x80, 0x20, 0x0C, 0x03, 0x00, 0xA0, 0x6F, 0xE0, 0x00, 0x80, 0x18,
  0x02, 0x80, 0x68, 0x04, 0x80, 0x88, 0x10, 0x83, 0x08, 0x20, 0x84, 0x08,
  0xFF, 0xF0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x7F, 0x90, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x07, 0xF0, 0x06, 0x00, 0x80, 0x30, 0x0C, 0x03, 0x00,
  0xA0, 0x67, 0xE0, 0x0F, 0x8C, 0x02, 0x01, 0x00, 0x40, 0x10, 0x0D, 0xF2,
  0x82, 0xC0, 0xF0, 0x1C, 0x05, 0x01, 0x40, 0x88, 0x61, 0xF0, 0xFF, 0xC0,
  0x30, 0x08, 0x06, 0x01, 0x00, 0x40, 0x20, 0x08, 0x06, 0x01, 0x00, 0xC0,
  0x20, 0x18, 0x04, 0x03, 0x00, 0x3F, 0x18, 0x64, 0x09, 0x02, 0x40, 0x98,
  0x41, 0xE0, 0x78, 0x61, 0x90, 0x28, 0x06, 0x01, 0xC0, 0xD0, 0x63, 0xF0,
  0x3E, 0x18, 0x44, 0x0A, 0x02, 0x80, 0xE0, 0x3C, 0x0D, 0x05, 0x3E, 0xC0,
  0x20, 0x08, 0x02, 0x01, 0x00, 0xC7, 0xC0, 0xE0, 0x00, 0x2C, 0x50, 0x00,
  0x16, 0xA0, 0x00, 0x40, 0x30, 0x30, 0x30, 0x30, 0x30, 0x07, 0x00, 0x30,
  0x03, 0x00, 0x30, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x80, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x38, 0x30, 0x30, 0x30, 0x00, 0xFD,
  0x0C, 0x08, 0x10, 0x20, 0xC3, 0x0C, 0x30, 0x40, 0x80, 0x00, 0x04, 0x08,
  0x00, 0x03, 0xF0, 0x06, 0x06, 0x04, 0x01, 0x84, 0x00, 0x64, 0x1E, 0x12,
  0x10, 0x8B, 0x10, 0x45, 0x08, 0x23, 0x8C, 0x11, 0x46, 0x18, 0xA1, 0x0C,
  0x58, 0xCA, 0x44, 0x38, 0xC2, 0x00, 0x00, 0x80, 0x00, 0x30, 0x20, 0x07,
  0xE0, 0x00, 0x02, 0x00, 0x38, 0x01, 0x40, 0x0A, 0x00, 0x88, 0x04, 0x40,
  0x63, 0x02, 0x08, 0x10, 0x41, 0xFF, 0x08, 0x08, 0xC0, 0x44, 0x01, 0x20,
  0x0A, 0x00, 0x60, 0xFF, 0x20, 0x68, 0x0E, 0x03, 0x80, 0xE0, 0x28, 0x33,
  0xFC, 0x80, 0xA0, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x6F, 0xF0, 0x0F, 0xE3,
  0x04, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x01,
  0x00, 0x20, 0x02, 0x00, 0x60, 0x03, 0xF8, 0xFE, 0x08, 0x18, 0x80, 0x48,
  0x06, 0x80, 0x28, 0x02, 0x80, 0x38, 0x03, 0x80, 0x38, 0x02, 0x80, 0x28,
  0x06, 0x80, 0xC8, 0x18, 0xFE, 0x00, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0xFF, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x0F, 0xF0, 0xC0, 0x88, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18,
  0x3F, 0xC0, 0x1E, 0x00, 0xD0, 0x06, 0x80, 0x32, 0x01, 0x9C, 0x0C, 0x3F,
  0xC0, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0F, 0xFF,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0xF2, 0x22,
  0x22, 0x22, 0x22, 0x22, 0x22, 0xF0, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x0C, 0xF8, 0x80, 0xE0, 0x68, 0x32, 0x18, 0x8C,
  0x26, 0x09, 0x02, 0xE0, 0xCC, 0x21, 0x08, 0x22, 0x0C, 0x81, 0xA0, 0x28,
  0x04, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0xFF, 0xC0, 0x0F, 0x80, 0x3A, 0x01, 0xE8, 0x05, 0xB0,
  0x16, 0x40, 0x99, 0x82, 0x62, 0x19, 0x88, 0x46, 0x31, 0x18, 0x48, 0x61,
  0x21, 0x83, 0x86, 0x0C, 0x18, 0x30, 0x40, 0xC0, 0x38, 0x06, 0x80, 0xD8,
  0x19, 0x03, 0x10, 0x63, 0x0C, 0x21, 0x82, 0x30, 0x66, 0x04, 0xC0, 0x58,
  0x0F, 0x00, 0xE0, 0x08, 0x0F, 0xC0, 0xC0, 0xC2, 0x01, 0x90, 0x02, 0x40,
  0x0B, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x0F, 0x00, 0x34, 0x00, 0x90,
  0x02, 0x20, 0x18, 0xC0, 0xC0, 0xFC, 0x00, 0xFE, 0x41, 0xA0, 0x30, 0x18,
  0x0C, 0x06, 0x07, 0x06, 0xFC, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00,
  0x0F, 0xC0, 0xC0, 0xC2, 0x01, 0x90, 0x02, 0x40, 0x0B, 0x00, 0x3C, 0x00,
  0xF0, 0x01, 0xC0, 0x0F, 0x00, 0x34, 0x00, 0x90, 0x02, 0x20, 0x18, 0xC0,
  0xC0, 0xFC, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0xFE, 0x20,
  0xC8, 0x0A, 0x02, 0x80, 0xA0, 0x28, 0x1B, 0xFC, 0xFC, 0x21, 0x88, 0x22,
  0x04, 0x81, 0xA0, 0x28, 0x0C, 0x3F, 0xB0, 0x70, 0x18, 0x0C, 0x02, 0x00,
  0xC0, 0x3C, 0x03, 0x00, 0x40, 0x20, 0x10, 0x0C, 0x0F, 0xF8, 0xFF, 0xE0,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x14,
  0x06, 0xC1, 0x8F, 0xE0, 0x80, 0x14, 0x03, 0x40, 0x26, 0x02, 0x20, 0x62,
  0x04, 0x30, 0x41, 0x08, 0x10, 0x81, 0x98, 0x09, 0x00, 0xD0, 0x07, 0x00,
  0x60, 0x06, 0x00, 0xC0, 0x40, 0x50, 0x30, 0x14, 0x0A, 0x05, 0x82, 0x82,
  0x20, 0xA0, 0x88, 0x4C, 0x22, 0x11, 0x18, 0x44, 0x44, 0x13, 0x11, 0x04,
  0x82, 0x41, 0xA0, 0xB0, 0x28, 0x28, 0x0C, 0x0E, 0x03, 0x01, 0x80, 0xC0,
  0x40, 0xC0, 0x6C, 0x08, 0x83, 0x08, 0x41, 0x90, 0x16, 0x01, 0x80, 0x30,
  0x0A, 0x01, 0x20, 0x46, 0x18, 0x42, 0x04, 0x80, 0xF0, 0x08, 0xC0, 0x28,
  0x09, 0x81, 0x10, 0x43, 0x08, 0x22, 0x02, 0xC0, 0x50, 0x06, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0xFF, 0xC0, 0x30, 0x08, 0x04,
  0x03, 0x00, 0x80, 0x40, 0x30, 0x08, 0x04, 0x03, 0x00, 0x80, 0x40, 0x30,
  0x0F, 0xFC, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x8F, 0xC0,
  0x81, 0x01, 0x02, 0x06, 0x04, 0x08, 0x18, 0x10, 0x20, 0x20, 0x40, 0xC0,
  0x80, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1F, 0x0C, 0x03,
  0x01, 0x20, 0x48, 0x21, 0x08, 0x44, 0x09, 0x02, 0x80, 0x40, 0xFF, 0x80,
  0xC4, 0x30, 0x7F, 0x00, 0x80, 0x40, 0x30, 0x7B, 0xCF, 0x07, 0x03, 0x81,
  0xE1, 0xDF, 0x20, 0x80, 0x40, 0x20, 0x10, 0x08, 0x05, 0xFB, 0x05, 0x81,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0E, 0x07, 0x05, 0x7C, 0x3F, 0x60, 0x40,
  0xC0, 0x80, 0x80, 0xC0, 0xC0, 0x40, 0x60, 0x1F, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x4F, 0xD6, 0x15, 0x03, 0xC0, 0xE0, 0x18, 0x06, 0x01, 0xC0,
  0xD0, 0x36, 0x14, 0xF9, 0x3F, 0x30, 0xD0, 0x38, 0x18, 0x0F, 0xFE, 0x01,
  0x80, 0x40, 0x30, 0x47, 0xE0, 0x0F, 0x10, 0x30, 0x30, 0x30, 0xFC, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x3F, 0x58, 0x54,
  0x0F, 0x03, 0x80, 0x60, 0x18, 0x07, 0x03, 0x40, 0xD8, 0x53, 0xE4, 0x01,
  0x00, 0xC0, 0x24, 0x19, 0xFC, 0x80, 0x40, 0x20, 0x10, 0x08, 0x05, 0xFB,
  0x05, 0x03, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xCF,
  0xFE, 0x11, 0x00, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x3E, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x83, 0x84, 0x88, 0x98, 0xB0, 0xF0, 0xC8, 0x8C,
  0x84, 0x82, 0x81, 0xFF, 0xFF, 0xBE, 0x7D, 0x87, 0x0E, 0x04, 0x0C, 0x08,
  0x18, 0x10, 0x30, 0x20, 0x60, 0x40, 0xC0, 0x81, 0x81, 0x03, 0x02, 0x06,
  0x04, 0x08, 0xBF, 0x60, 0xA0, 0x70, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x20, 0x3F, 0x18, 0x24, 0x0F, 0x01, 0x80, 0x60, 0x1C, 0x07,
  0x01, 0x40, 0xD8, 0x61, 0xF0, 0xBF, 0x60, 0xF0, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0xC1, 0xE0, 0xAF, 0x90, 0x08, 0x04, 0x02, 0x01, 0x00, 0x3F,
  0x58, 0x54, 0x0F, 0x03, 0x80, 0x60, 0x18, 0x0F, 0x03, 0x40, 0xD8, 0x53,
  0xE4, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0xBF, 0x0C, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x00, 0x7F, 0xC0, 0x80, 0xC0, 0x70, 0x1C, 0x02, 0x01,
  0x01, 0x83, 0xFE, 0x20, 0x40, 0x87, 0xF2, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x03, 0x03, 0xC0, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xE1, 0x5F, 0x20, 0xC0, 0xD0, 0x24, 0x09, 0x84, 0x21, 0x08,
  0xC1, 0x20, 0x48, 0x16, 0x03, 0x00, 0xC0, 0xC1, 0x82, 0x83, 0x0D, 0x0A,
  0x13, 0x16, 0x22, 0x24, 0x44, 0xC9, 0x89, 0x1A, 0x1A, 0x14, 0x1C, 0x28,
  0x30, 0x70, 0x60, 0x40, 0x60, 0xC8, 0x61, 0x10, 0x68, 0x0E, 0x03, 0x00,
  0xA0, 0x4C, 0x31, 0x08, 0x2C, 0x0C, 0xC0, 0xD0, 0x24, 0x09, 0x84, 0x21,
  0x08, 0xC1, 0x20, 0x48, 0x1E, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01,
  0x03, 0x80, 0xFF, 0x02, 0x06, 0x04, 0x08, 0x10, 0x30, 0x20, 0x40, 0xC0,
  0xFF, 0x1C, 0xC2, 0x08, 0x20, 0x82, 0x08, 0x63, 0x02, 0x08, 0x20, 0x82,
  0x08, 0x30, 0x70, 0xFF, 0xFF, 0xF8, 0xC0, 0x82, 0x0C, 0x30, 0xC3, 0x0C,
  0x18, 0x71, 0x0C, 0x30, 0xC3, 0x0C, 0x23, 0x80, 0x20, 0x37, 0x18, 0x38,
};

const GFXglyph NotoSans_Light21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 15, 5, 2, -15 },
  { 5, 5, 5, 8, 1, -15 },
  { 9, 12, 15, 14, 1, -15 },
  { 32, 9, 17, 12, 1, -16 },
  { 52, 15, 15, 17, 1, -15 },
  { 81, 14, 15, 15, 1, -15 },
  { 108, 2, 5, 4, 1, -15 },
  { 110, 4, 18, 6, 1, -15 },
  { 119, 4, 18, 6, 1, -15 },
  { 128, 9, 9, 12, 1, -16 },
  { 139, 10, 10, 12, 1, -12 },
  { 152, 2, 5, 5, 1, -2 },
  { 154, 5, 1, 7, 1, -6 },
  { 155, 2, 2, 5, 2, -2 },
  { 156, 7, 15, 7, 0, -15 },
  { 170, 10, 15, 12, 1, -15 },
  { 189, 5, 15, 12, 2, -15 },
  { 199, 10, 15, 12, 1, -15 },
  { 218, 10, 15, 12, 1, -15 },
  { 237, 12, 15, 12, 0, -15 },
  { 260, 10, 15, 12, 1, -15 },
  { 279, 10, 15, 12, 1, -15 },
  { 298, 10, 15, 12, 1, -15 },
  { 317, 10, 15, 12, 1, -15 },
  { 336, 10, 15, 12, 1, -15 },
  { 355, 2, 11, 5, 2, -11 },
  { 358, 2, 14, 5, 1, -11 },
  { 362, 10, 10, 12, 1, -13 },
  { 375, 10, 5, 12, 1, -10 },
  { 382, 10, 10, 12, 1, -13 },
  { 395, 7, 15, 9, 1, -15 },
  { 409, 17, 17, 19, 1, -15 },
  { 446, 13, 15, 13, 0, -15 },
  { 471, 10, 15, 13, 2, -15 },
  { 490, 11, 15, 13, 1, -15 },
  { 511, 12, 15, 15, 2, -15 },
  { 534, 8, 15, 12, 2, -15 },
  { 549, 8, 15, 11, 2, -15 },
  { 564, 13, 15, 15, 1, -15 },
  { 589, 11, 15, 15, 2, -15 },
  { 610, 4, 15, 7, 1, -15 },
  { 618, 5, 19, 5, -2, -15 },
  { 630, 10, 15, 12, 2, -15 },
  { 649, 8, 15, 11, 2, -15 },
  { 664, 14, 15, 18, 2, -15 },
  { 691, 11, 15, 15, 2, -15 },
  { 712, 14, 15, 16, 1, -15 },
  { 739, 9, 15, 12, 2, -15 },
  { 756, 14, 19, 16, 1, -15 },
  { 790, 10, 15, 13, 2, -15 },
  { 809, 9, 15, 11, 1, -15 },
  { 826, 11, 15, 11, 0, -15 },
  { 847, 11, 15, 15, 2, -15 },
  { 868, 12, 15, 12, 0, -15 },
  { 891, 18, 15, 19, 0, -15 },
  { 925, 11, 15, 12, 0, -15 },
  { 946, 11, 15, 11, 0, -15 },
  { 967, 10, 15, 12, 1, -15 },
  { 986, 4, 18, 7, 2, -15 },
  { 995, 7, 15, 7, 0, -15 },
  { 1009, 4, 18, 7, 1, -15 },
  { 1018, 10, 9, 12, 1, -15 },
  { 1030, 9, 1, 9, 0, 2 },
  { 1032, 4, 3, 6, 1, -16 },
  { 1034, 9, 11, 11, 1, -11 },
  { 1047, 9, 16, 13, 2, -16 },
  { 1065, 8, 11, 10, 1, -11 },
  { 1076, 10, 16, 13, 1, -16 },
  { 1096, 9, 11, 12, 1, -11 },
  { 1109, 8, 16, 6, 0, -16 },
  { 1125, 10, 16, 13, 1, -11 },
  { 1145, 9, 16, 13, 2, -16 },
  { 1163, 1, 15, 5, 2, -15 },
  { 1165, 4, 20, 5, -1, -15 },
  { 1175, 8, 16, 10, 2, -16 },
  { 1191, 1, 16, 5, 2, -16 },
  { 1193, 15, 11, 19, 2, -11 },
  { 1214, 9, 11, 13, 2, -11 },
  { 1227, 10, 11, 12, 1, -11 },
  { 1241, 9, 16, 13, 2, -11 },
  { 1259, 10, 16, 13, 1, -11 },
  { 1279, 6, 11, 8, 2, -11 },
  { 1288, 8, 11, 10, 1, -11 },
  { 1299, 7, 14, 7, 0, -14 },
  { 1312, 9, 11, 13, 2, -11 },
  { 1325, 10, 11, 10, 0, -11 },
  { 1339, 15, 11, 15, 0, -11 },
  { 1360, 10, 11, 11, 0, -11 },
  { 1374, 10, 16, 10, 0, -11 },
  { 1394, 8, 11, 10, 1, -11 },
  { 1405, 6, 18, 8, 1, -15 },
  { 1419, 1, 21, 11, 5, -16 },
  { 1422, 6, 18, 8, 1, -15 },
  { 1436, 10, 3, 12, 1, -9 },
};

const GFXfont NotoSans_Light21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light21pt7bBitmaps,
  (GFXglyph *)NotoSans_Light21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_LIGHT21PT7B_H_
