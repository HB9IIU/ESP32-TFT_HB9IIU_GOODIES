#ifndef _NOTOSANS_LIGHT59PT7B_H_
#define _NOTOSANS_LIGHT59PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light59pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xC0, 0x00, 0x00, 0x00,
  0x7B, 0xFF, 0xFF, 0x98, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3B, 0x01, 0xD8, 0x0E, 0xC0, 0x76,
  0x03, 0xB0, 0x1D, 0x80, 0xE0, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x07, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x1C, 0x00,
  0x00, 0x70, 0x03, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x1C,
  0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x0E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x06, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x18, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0x80, 0x1C, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x3F, 0xBB, 0xFC, 0x3C, 0x1C,
  0x0E, 0x3C, 0x0E, 0x00, 0x3C, 0x07, 0x00, 0x1E, 0x03, 0x80, 0x0E, 0x01,
  0xC0, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x38, 0x00, 0xF0,
  0x1C, 0x00, 0x78, 0x0E, 0x00, 0x1E, 0x07, 0x00, 0x0F, 0x83, 0x80, 0x03,
  0xF1, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0x7F, 0x00, 0x03, 0x87,
  0xC0, 0x01, 0xC1, 0xF0, 0x00, 0xE0, 0x38, 0x00, 0x70, 0x1E, 0x00, 0x38,
  0x07, 0x00, 0x1C, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x03,
  0x80, 0xF0, 0x01, 0xC0, 0x78, 0x00, 0xE0, 0x7A, 0x00, 0x70, 0x79, 0xF0,
  0x38, 0xFC, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x70, 0x01, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0xF0, 0x78, 0x00, 0x0E, 0x00,
  0x38, 0x0E, 0x00, 0x07, 0x00, 0x1E, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x78, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0x38, 0x00, 0xE0, 0x0E, 0x00, 0x0E, 0x00, 0x38, 0x03, 0x80,
  0x03, 0x80, 0x0E, 0x01, 0xC0, 0x00, 0xE0, 0x03, 0x80, 0x70, 0x00, 0x38,
  0x00, 0xE0, 0x38, 0x00, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x80, 0x0E,
  0x07, 0x00, 0x00, 0xE0, 0x03, 0x83, 0xC0, 0x00, 0x38, 0x00, 0xE0, 0xE0,
  0x7C, 0x07, 0x00, 0x38, 0x70, 0x7F, 0xC1, 0xC0, 0x1C, 0x1C, 0x3F, 0xF8,
  0x70, 0x07, 0x0E, 0x1E, 0x0F, 0x1E, 0x01, 0xC3, 0x8F, 0x01, 0xC3, 0x80,
  0xE1, 0xC3, 0x80, 0x78, 0xF0, 0x78, 0x70, 0xE0, 0x0E, 0x1F, 0xFC, 0x38,
  0x70, 0x03, 0x83, 0xFE, 0x1E, 0x1C, 0x00, 0xE0, 0x1E, 0x07, 0x07, 0x00,
  0x18, 0x00, 0x03, 0x81, 0xC0, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x01, 0xC0,
  0x00, 0x70, 0x1C, 0x00, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x1C, 0x00, 0x0E,
  0x01, 0xC0, 0x07, 0x00, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x01, 0xC0, 0x1C,
  0x00, 0x70, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x03,
  0x80, 0x03, 0x80, 0x70, 0x00, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x00,
  0x1E, 0x1E, 0x00, 0x1C, 0x00, 0x03, 0xFF, 0x80, 0x0E, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7C, 0x0F, 0x80,
  0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x78, 0x00, 0x01, 0xC0,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0xF8, 0x00, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1C,
  0x1F, 0x01, 0xF0, 0x00, 0x70, 0xF8, 0x03, 0xE0, 0x03, 0xC3, 0xC0, 0x07,
  0xC0, 0x0E, 0x1E, 0x00, 0x0F, 0x80, 0x78, 0x78, 0x00, 0x1F, 0x01, 0xE1,
  0xC0, 0x00, 0x3E, 0x07, 0x0F, 0x00, 0x00, 0x7C, 0x3C, 0x3C, 0x00, 0x00,
  0xF9, 0xE0, 0xF0, 0x00, 0x01, 0xF7, 0x03, 0xC0, 0x00, 0x03, 0xFC, 0x07,
  0x00, 0x00, 0x07, 0xE0, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x00,
  0x7F, 0x00, 0xF0, 0x00, 0x07, 0xFE, 0x03, 0xE0, 0x00, 0x3E, 0x7C, 0x07,
  0xE0, 0x03, 0xF0, 0xF8, 0x0F, 0xFB, 0xFF, 0x01, 0xF0, 0x1F, 0xFF, 0xF8,
  0x03, 0xE0, 0x1F, 0xFF, 0x80, 0x07, 0xC0, 0x03, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0xFE, 0xEE, 0xE6, 0x66, 0x66, 0x60, 0x00, 0x70, 0x0E, 0x01, 0xE0,
  0x3C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x01,
  0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x38, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00,
  0xF0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xF0,
  0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70,
  0x07, 0x80, 0x38, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x1E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x3C,
  0x03, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0,
  0x3C, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x40, 0x0C, 0x00, 0x7E, 0x03,
  0x00, 0xFF, 0xF0, 0xC1, 0xFF, 0xFF, 0xB3, 0xFF, 0x0F, 0xFF, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x1C, 0xF0, 0x00, 0x0E, 0x1E, 0x00, 0x07, 0x83, 0x80, 0x03, 0xC0,
  0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x00, 0xF0, 0x03,
  0x00, 0x10, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x3C, 0x78, 0xF1, 0xC3, 0x8F, 0x1E,
  0x38, 0x71, 0xE3, 0x87, 0x0C, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xF7, 0xFF, 0xFF, 0x30, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0xF8,
  0x01, 0xE0, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x3C,
  0x3C, 0x00, 0x03, 0x87, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x07, 0x3C, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x03, 0xDC, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x78, 0x3C, 0x00, 0x0E, 0x03, 0xC0, 0x03, 0xC0, 0x3C, 0x01, 0xF0,
  0x03, 0xF0, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x0F, 0xC0, 0xFF, 0x07, 0xDC, 0x3C,
  0x73, 0xE1, 0xDF, 0x07, 0xF8, 0x1F, 0x80, 0x74, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFF, 0xE0, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x03, 0xE0, 0x70, 0x00, 0x3E,
  0x0C, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xE0, 0x7F, 0x0F, 0xC0, 0x01, 0xF0, 0xE0,
  0x00, 0x1E, 0x18, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x20, 0x00, 0x03, 0xE7, 0x80, 0x01, 0xF8, 0xFF, 0x83, 0xFC,
  0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1B, 0x80, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x00, 0xF3, 0x80, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x03, 0xC3, 0x80, 0x00, 0x07, 0x83, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x38, 0x03, 0x80, 0x00, 0x78, 0x03, 0x80, 0x00, 0xF0, 0x03, 0x80, 0x00,
  0xE0, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x03, 0xC0, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x07, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x03, 0x80, 0x1E,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03, 0x80, 0x78,
  0x00, 0x03, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x1F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x80, 0xFF, 0x1F, 0xF0, 0x10, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x20,
  0x00, 0x07, 0x8F, 0x00, 0x07, 0xC3, 0xFE, 0x3F, 0xE0, 0x7F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xFE, 0x01, 0x80, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1C, 0x07, 0xFC, 0x03, 0x87, 0xFF, 0xE0, 0x71,
  0xFF, 0xFE, 0x0E, 0x78, 0x03, 0xF1, 0xDC, 0x00, 0x1E, 0x3F, 0x00, 0x01,
  0xE7, 0xC0, 0x00, 0x1C, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x07, 0x70, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0x70, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x39, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x38,
  0x38, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC0, 0x7C, 0x00, 0xF0, 0x07, 0xF1,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x02, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF,
  0xF0, 0x07, 0xF0, 0x3F, 0x00, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0xE1, 0xE0, 0x00, 0x1E, 0x38, 0x00, 0x03, 0xC7, 0x00, 0x00,
  0x78, 0xE0, 0x00, 0x0F, 0x1C, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x3C, 0x78,
  0x00, 0x07, 0x07, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x0F, 0x80, 0x1E,
  0x00, 0xF8, 0x07, 0x80, 0x0F, 0xC3, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7C, 0xFE, 0x00, 0x3E, 0x03, 0xF0,
  0x0F, 0x00, 0x1F, 0x03, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x1F, 0x3C, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x1E, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1C, 0xF0, 0x00, 0x07, 0x8F,
  0x00, 0x01, 0xE0, 0xF8, 0x00, 0x7C, 0x0F, 0xE0, 0x7E, 0x00, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xE0, 0x7E, 0x01, 0xF0, 0x03,
  0xE0, 0x7C, 0x00, 0x3E, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x70,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x07, 0x78, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x07,
  0xB8, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x3E, 0x78, 0x00, 0x0D, 0xCF, 0x80,
  0x07, 0xB8, 0xFC, 0x03, 0xE7, 0x0F, 0xFF, 0xF9, 0xE0, 0x7F, 0xFC, 0x3C,
  0x03, 0xFE, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x18,
  0x0F, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x77, 0xFF, 0xFF, 0xB8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xEF, 0xFF, 0xFE, 0x60, 0x0E, 0x1F,
  0x1F, 0x1F, 0x1F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x78, 0x70, 0x70, 0x70,
  0xE0, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x7F, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xC3, 0xFC, 0x70, 0x00, 0xF1, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x0F, 0xFE, 0x00,
  0x38, 0x70, 0x00, 0xFF, 0xFE, 0x00, 0xE3, 0x80, 0x07, 0xE1, 0xF8, 0x03,
  0x8E, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x1D,
  0xC0, 0x0F, 0x00, 0x0E, 0x00, 0x77, 0x00, 0x38, 0x00, 0x38, 0x01, 0xDC,
  0x01, 0xC0, 0x00, 0xE0, 0x07, 0x70, 0x07, 0x00, 0x03, 0x80, 0x1F, 0x80,
  0x1C, 0x00, 0x0E, 0x00, 0x7E, 0x00, 0xF0, 0x00, 0x38, 0x01, 0xF8, 0x03,
  0x80, 0x00, 0xE0, 0x07, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0x1F, 0x80, 0x38,
  0x00, 0x1C, 0x00, 0x7E, 0x00, 0xE0, 0x00, 0x70, 0x01, 0xF8, 0x03, 0xC0,
  0x01, 0xC0, 0x0E, 0xE0, 0x07, 0x00, 0x0F, 0x00, 0x3B, 0x80, 0x1C, 0x00,
  0x3E, 0x00, 0xE7, 0x00, 0x78, 0x01, 0xF8, 0x07, 0x1C, 0x00, 0xE0, 0x0E,
  0x60, 0x3C, 0x70, 0x03, 0xE0, 0x79, 0xC1, 0xE1, 0xC0, 0x07, 0xFF, 0xC3,
  0xFF, 0x03, 0x80, 0x07, 0xFC, 0x07, 0xF8, 0x0E, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x02, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x3F, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x38,
  0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x38,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x0E, 0x00,
  0x00, 0x07, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x07, 0x81,
  0xC0, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x00,
  0x1C, 0x78, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x1E, 0x70, 0x00,
  0x00, 0x00, 0xEF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0E, 0x00, 0x03, 0xF8, 0xE0, 0x00, 0x0F,
  0x8E, 0x00, 0x00, 0x7C, 0xE0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x1E, 0xE0,
  0x00, 0x01, 0xEE, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x01, 0xEE, 0x00, 0x00,
  0x1E, 0xE0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0xCE,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x8E, 0x00, 0x01, 0xF0, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0E, 0x00, 0x3F, 0xF0,
  0xE0, 0x00, 0x0F, 0x8E, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x01, 0xEE, 0x00,
  0x00, 0x1E, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xEE, 0x00, 0x00,
  0x1E, 0xE0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0xFC, 0xE0, 0x00, 0x7F, 0x8F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFE,
  0x1F, 0xF0, 0x1F, 0x80, 0x01, 0xC0, 0x7C, 0x00, 0x00, 0x81, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0E, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xE0, 0x00, 0x7F, 0x80, 0xE0, 0x00, 0x0F, 0xC0, 0xE0, 0x00, 0x03,
  0xE0, 0xE0, 0x00, 0x01, 0xF0, 0xE0, 0x00, 0x00, 0xF8, 0xE0, 0x00, 0x00,
  0x7C, 0xE0, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00,
  0x1E, 0xE0, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x1E, 0xE0, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00,
  0x3C, 0xE0, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x01,
  0xF0, 0xE0, 0x00, 0x07, 0xE0, 0xE0, 0x00, 0x1F, 0xC0, 0xE0, 0x00, 0xFF,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xDC, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x01, 0xFC, 0x00, 0x07,
  0x80, 0xFC, 0x00, 0x00, 0x20, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x77, 0x80,
  0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x01, 0xCF,
  0x00, 0x00, 0x00, 0x73, 0xE0, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x07,
  0x0F, 0x00, 0x00, 0x01, 0xC1, 0xF0, 0x00, 0x00, 0x70, 0x7E, 0x00, 0x00,
  0x1C, 0x07, 0xF0, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0x1F, 0x80, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x01, 0xFC, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xFB, 0x9F, 0xCF,
  0xFE, 0x3F, 0xF0, 0x3C, 0x00, 0xE0, 0x00, 0x01, 0xF7, 0x00, 0x00, 0x1F,
  0x38, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0xF0, 0x70,
  0x00, 0x0F, 0x03, 0x80, 0x00, 0xF0, 0x1C, 0x00, 0x0F, 0x00, 0xE0, 0x00,
  0xF0, 0x07, 0x00, 0x0F, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x0F, 0x00,
  0x0E, 0x00, 0xF0, 0x00, 0x70, 0x0F, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x1C,
  0x0F, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x38, 0xFC,
  0x00, 0x01, 0xCF, 0xE0, 0x00, 0x0E, 0xF7, 0x80, 0x00, 0x77, 0x1E, 0x00,
  0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x07,
  0x00, 0x7C, 0x00, 0x38, 0x01, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x1E, 0x00, 0x70, 0x00, 0xF8, 0x03, 0x80, 0x03, 0xC0, 0x1C, 0x00, 0x0F,
  0x00, 0xE0, 0x00, 0x3C, 0x07, 0x00, 0x01, 0xF0, 0x38, 0x00, 0x07, 0x81,
  0xC0, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x78, 0x70, 0x00, 0x03, 0xC3, 0x80,
  0x00, 0x0F, 0x1C, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x07, 0xC0, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xEE, 0x00, 0x00, 0x00, 0xEF, 0xEF, 0x00, 0x00,
  0x00, 0xEF, 0xE7, 0x00, 0x00, 0x01, 0xEF, 0xE7, 0x00, 0x00, 0x01, 0xCF,
  0xE7, 0x80, 0x00, 0x01, 0xCF, 0xE3, 0x80, 0x00, 0x03, 0x8F, 0xE3, 0xC0,
  0x00, 0x03, 0x8F, 0xE1, 0xC0, 0x00, 0x07, 0x8F, 0xE1, 0xC0, 0x00, 0x07,
  0x0F, 0xE1, 0xE0, 0x00, 0x07, 0x0F, 0xE0, 0xE0, 0x00, 0x0E, 0x0F, 0xE0,
  0xF0, 0x00, 0x0E, 0x0F, 0xE0, 0x70, 0x00, 0x1E, 0x0F, 0xE0, 0x70, 0x00,
  0x1C, 0x0F, 0xE0, 0x78, 0x00, 0x1C, 0x0F, 0xE0, 0x38, 0x00, 0x38, 0x0F,
  0xE0, 0x3C, 0x00, 0x38, 0x0F, 0xE0, 0x1C, 0x00, 0x78, 0x0F, 0xE0, 0x1C,
  0x00, 0x70, 0x0F, 0xE0, 0x1E, 0x00, 0x70, 0x0F, 0xE0, 0x0E, 0x00, 0xF0,
  0x0F, 0xE0, 0x0F, 0x00, 0xE0, 0x0F, 0xE0, 0x0F, 0x01, 0xE0, 0x0F, 0xE0,
  0x07, 0x01, 0xC0, 0x0F, 0xE0, 0x07, 0x81, 0xC0, 0x0F, 0xE0, 0x03, 0x83,
  0xC0, 0x0F, 0xE0, 0x03, 0xC3, 0x80, 0x0F, 0xE0, 0x03, 0xC7, 0x80, 0x0F,
  0xE0, 0x01, 0xC7, 0x00, 0x0F, 0xE0, 0x01, 0xE7, 0x00, 0x0F, 0xE0, 0x00,
  0xEF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFB, 0xC0, 0x00, 0x03,
  0xF3, 0xC0, 0x00, 0x07, 0xE7, 0x80, 0x00, 0x0F, 0xC7, 0x80, 0x00, 0x1F,
  0x87, 0x80, 0x00, 0x3F, 0x0F, 0x00, 0x00, 0x7E, 0x0F, 0x00, 0x00, 0xFC,
  0x0F, 0x00, 0x01, 0xF8, 0x1E, 0x00, 0x03, 0xF0, 0x1E, 0x00, 0x07, 0xE0,
  0x1E, 0x00, 0x0F, 0xC0, 0x3C, 0x00, 0x1F, 0x80, 0x3C, 0x00, 0x3F, 0x00,
  0x3C, 0x00, 0x7E, 0x00, 0x78, 0x00, 0xFC, 0x00, 0x78, 0x01, 0xF8, 0x00,
  0x78, 0x03, 0xF0, 0x00, 0xF0, 0x07, 0xE0, 0x00, 0xF0, 0x0F, 0xC0, 0x01,
  0xF0, 0x1F, 0x80, 0x01, 0xE0, 0x3F, 0x00, 0x01, 0xE0, 0x7E, 0x00, 0x01,
  0xE0, 0xFC, 0x00, 0x03, 0xC1, 0xF8, 0x00, 0x03, 0xC3, 0xF0, 0x00, 0x07,
  0xC7, 0xE0, 0x00, 0x07, 0x8F, 0xC0, 0x00, 0x07, 0x9F, 0x80, 0x00, 0x0F,
  0xBF, 0x00, 0x00, 0x0F, 0x7E, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00,
  0x78, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0xF0,
  0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x78, 0x00, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x00,
  0x3B, 0xC0, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x03, 0xB8, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x00, 0x03,
  0xBC, 0x00, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x00, 0x79, 0xC0, 0x00,
  0x00, 0x01, 0xE7, 0x00, 0x00, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x03, 0x83, 0xC0, 0x00,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x07, 0xC0,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0x80, 0x00, 0xFF, 0xDF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0x80, 0x03, 0xF8, 0xE0, 0x00,
  0x3E, 0x38, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x1E, 0xE0,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x0E, 0xE0, 0x00, 0x07, 0xB8, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xF3, 0x80,
  0x00, 0x78, 0xE0, 0x00, 0x7E, 0x38, 0x01, 0xFE, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x07,
  0xC0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x78,
  0x00, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x00, 0x3B, 0xC0,
  0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x00, 0x03, 0xBC, 0x00,
  0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x00, 0x01,
  0xE7, 0x00, 0x00, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80,
  0x00, 0xFF, 0xDF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x0D, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC,
  0x0E, 0x00, 0x0F, 0xE0, 0xE0, 0x00, 0x1F, 0x0E, 0x00, 0x00, 0xF0, 0xE0,
  0x00, 0x07, 0x8E, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x03, 0xCE,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x78, 0xE0, 0x00,
  0x07, 0x8E, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0xE0,
  0xE0, 0x01, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x00, 0xE0, 0x03, 0xC0, 0x0E, 0x00, 0x3C, 0x00, 0xE0, 0x01, 0xE0,
  0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xF0, 0x0E, 0x00, 0x07, 0x80, 0xE0,
  0x00, 0x78, 0x0E, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x01,
  0xE0, 0xE0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07, 0x8E,
  0x00, 0x00, 0x78, 0xE0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x1E, 0xE0, 0x00,
  0x01, 0xEE, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0x80,
  0x7F, 0xFF, 0xF8, 0x3F, 0xC3, 0xFE, 0x1F, 0x00, 0x07, 0x0F, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE8, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x00, 0x02, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0E, 0x78,
  0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xF0, 0x03,
  0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x01, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x01, 0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x78, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x01, 0xE0, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x78, 0x03,
  0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x78, 0x00, 0x00, 0xF0,
  0x1C, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x00, 0x07, 0xB8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x39, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x3C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3C, 0x70, 0x00,
  0x07, 0x70, 0x00, 0x07, 0x0F, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x3D, 0xC0, 0x00, 0x3C, 0x1C, 0x00, 0x07, 0x3C, 0x00, 0x07, 0x03,
  0x80, 0x00, 0xE3, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x1C, 0x70, 0x00, 0x3C,
  0x0F, 0x00, 0x07, 0x8F, 0x00, 0x07, 0x80, 0xE0, 0x00, 0xE0, 0xE0, 0x00,
  0xE0, 0x1E, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x03, 0xC0, 0x07, 0x83, 0x80,
  0x07, 0x80, 0x38, 0x00, 0xE0, 0x78, 0x00, 0xF0, 0x07, 0x00, 0x1C, 0x07,
  0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0,
  0x1E, 0x00, 0xF0, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x07, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x00, 0xF0,
  0x1C, 0x00, 0xF0, 0x1E, 0x00, 0x0E, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x01,
  0xC0, 0x70, 0x01, 0xC0, 0x70, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x00,
  0x03, 0x83, 0x80, 0x03, 0x83, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70,
  0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xE3, 0xC0, 0x01, 0xE3,
  0xC0, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x70, 0x00,
  0x07, 0x78, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x1D, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0x1C, 0x1E, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0x70, 0x07, 0x80, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x03, 0xC0,
  0x01, 0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x00, 0xF0,
  0x07, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x3C,
  0x1C, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1C,
  0x3C, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x70,
  0x0F, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x01, 0xE0, 0x07, 0x80,
  0x00, 0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0x38, 0x3C, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0x78, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0xF0, 0x0F, 0x00,
  0x00, 0xE0, 0x07, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xC0, 0x03, 0x80,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xE0,
  0x07, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1C,
  0x78, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x07, 0x00, 0x07, 0x00, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0xE0, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F,
  0x80, 0x7C, 0x0C, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x7F, 0xFF, 0x03,
  0xFF, 0xFF, 0x0F, 0xFC, 0x0F, 0x3F, 0x00, 0x0F, 0x7C, 0x00, 0x0F, 0x78,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x77, 0x78, 0x00, 0xE7, 0x3F, 0x07, 0xC7, 0x1F, 0xFF, 0x87, 0x0F,
  0xFE, 0x07, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xC0, 0x7F, 0x80, 0x38, 0x3F, 0xFC, 0x07, 0x1F, 0xFF, 0xE0, 0xE7,
  0xC0, 0x7E, 0x1D, 0xE0, 0x03, 0xE3, 0xB8, 0x00, 0x3E, 0x7E, 0x00, 0x03,
  0xCF, 0x80, 0x00, 0x3D, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x77, 0x80,
  0x00, 0x0E, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0x78, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x3D, 0xF0, 0x00,
  0x07, 0xBE, 0x00, 0x01, 0xE7, 0xE0, 0x00, 0x3C, 0xEE, 0x00, 0x0F, 0x1C,
  0xE0, 0x07, 0xC3, 0x9F, 0x83, 0xF0, 0x70, 0xFF, 0xFC, 0x0E, 0x0F, 0xFE,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x3F, 0x80, 0xF0, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x60, 0xFF, 0xBF, 0xC0, 0x7F, 0xFF, 0x80, 0x3F,
  0xFC, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x7F, 0x01, 0xC0, 0x7F, 0xFC, 0x38, 0x1F, 0xFF, 0xC7, 0x07, 0xC0,
  0x3C, 0xE1, 0xE0, 0x01, 0xDC, 0x78, 0x00, 0x1F, 0x9E, 0x00, 0x01, 0xF3,
  0xC0, 0x00, 0x3E, 0x70, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x0F, 0x70, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x1F, 0x1E, 0x00, 0x06, 0xE1, 0xF0,
  0x03, 0xDC, 0x1F, 0xC3, 0xF3, 0x81, 0xFF, 0xFC, 0x70, 0x0F, 0xFE, 0x0E,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFF, 0xC0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x1F, 0x07, 0x80, 0x03, 0xC1,
  0xC0, 0x00, 0x78, 0xF0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x9E, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x3D, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0xC0, 0x03, 0x81, 0xFE, 0x0F, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0,
  0x1F, 0x01, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xFE, 0x1C, 0x0F, 0xFF, 0xE3, 0x83, 0xE0, 0x1E, 0x70, 0xF0,
  0x00, 0xEE, 0x3C, 0x00, 0x0F, 0xCF, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x1F,
  0x38, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0xB8, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x38, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x7C, 0xF8, 0x00, 0x1F, 0x8F, 0x00, 0x03, 0x70, 0xF8, 0x01, 0xEE, 0x0F,
  0xE1, 0xF9, 0xC0, 0xFF, 0xFE, 0x38, 0x07, 0xFF, 0x07, 0x00, 0x0C, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0xC6, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0xFC, 0x1F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x81, 0xFE, 0x03, 0xC3, 0xFF, 0xE1, 0xE7, 0xFF, 0xF8, 0xF7,
  0xC0, 0x7E, 0x77, 0x80, 0x0F, 0xBB, 0x00, 0x03, 0xDF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x38, 0xEF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xE0,
  0x3E, 0xFF, 0xCF, 0xF8, 0xFE, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x02,
  0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF0, 0xF0, 0x01, 0xE0,
  0xF0, 0x03, 0xE0, 0xF0, 0x03, 0xC0, 0xF0, 0x07, 0x80, 0xF0, 0x0F, 0x00,
  0xF0, 0x1E, 0x00, 0xE0, 0x3C, 0x00, 0xE0, 0x78, 0x00, 0xE0, 0xF0, 0x00,
  0xE1, 0xE0, 0x00, 0xE3, 0xE0, 0x00, 0xE7, 0xF0, 0x00, 0xE7, 0xF0, 0x00,
  0xEE, 0x78, 0x00, 0xFC, 0x3C, 0x00, 0xF8, 0x1E, 0x00, 0xF0, 0x1E, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xC0,
  0xF0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78,
  0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x07,
  0xF8, 0x1C, 0x3F, 0xFC, 0x03, 0xFF, 0xC3, 0x8F, 0xFF, 0xC1, 0xFF, 0xFC,
  0x73, 0xC0, 0x7C, 0x7C, 0x07, 0xCE, 0xE0, 0x03, 0xDE, 0x00, 0x7D, 0xD8,
  0x00, 0x7B, 0x80, 0x07, 0xBE, 0x00, 0x07, 0xE0, 0x00, 0x77, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x38, 0x00, 0x03, 0xF8, 0x00, 0x07, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x70, 0x00, 0x07, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x70, 0x00, 0x07, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x38, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1C, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x3F, 0xC0, 0x70, 0x7F, 0xFC, 0x38, 0xFF, 0xFF, 0x1C, 0xF8, 0x0F,
  0xCE, 0x70, 0x01, 0xF7, 0x70, 0x00, 0x7B, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xFE, 0x00, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x0F, 0x81, 0xE0, 0x00,
  0x3C, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x38, 0x00, 0x00, 0xE7,
  0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0x70, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x07, 0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x0E, 0x3C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E, 0x1E,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x0F, 0x80, 0x0F, 0x00, 0x7F, 0x8F,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x1C, 0x1F, 0xFF, 0x03, 0x87, 0xFF, 0xF0, 0x71, 0xE0,
  0x3F, 0x0E, 0x70, 0x01, 0xF1, 0xDC, 0x00, 0x1F, 0x3F, 0x00, 0x01, 0xE7,
  0xC0, 0x00, 0x1E, 0xF8, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x3B, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x77, 0xC0, 0x00, 0x1E, 0xF8, 0x00, 0x03,
  0xDF, 0x00, 0x00, 0xF3, 0xF0, 0x00, 0x1E, 0x77, 0x00, 0x07, 0x8E, 0x70,
  0x03, 0xE1, 0xC7, 0xE3, 0xF8, 0x3C, 0x7F, 0xFE, 0x07, 0x87, 0xFF, 0x80,
  0xF0, 0x06, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFE, 0x1C, 0x0F, 0xFF, 0xE3, 0x83, 0xE0,
  0x1E, 0x70, 0xF0, 0x00, 0xEE, 0x3C, 0x00, 0x0F, 0xCF, 0x00, 0x00, 0xF9,
  0xE0, 0x00, 0x1F, 0x78, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3D, 0xC0, 0x00,
  0x07, 0xB8, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x03, 0xDC, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x03,
  0xE7, 0x80, 0x00, 0x7C, 0xF0, 0x00, 0x1F, 0x8F, 0x00, 0x07, 0x70, 0xF8,
  0x01, 0xCE, 0x0F, 0xC3, 0xF1, 0xC0, 0xFF, 0xFC, 0x38, 0x0F, 0xFF, 0x07,
  0x00, 0x0C, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x3F, 0xF0, 0x7F, 0xF8, 0xFF, 0xFC, 0xF8, 0x1E, 0x70, 0x07, 0x70,
  0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFF, 0x8F, 0x80, 0x3E, 0x78, 0x00, 0x11, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0xE0, 0x00, 0xFB, 0xF8, 0x1F, 0xCF, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xBF,
  0xFF, 0xE0, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x03, 0xF0, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0x30, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xB8, 0x00, 0x0F, 0xDE, 0x00, 0x0E, 0xE7, 0x80, 0x0E,
  0x73, 0xF8, 0x7E, 0x38, 0xFF, 0xFE, 0x1C, 0x1F, 0xFC, 0x0E, 0x00, 0x60,
  0x00, 0xF0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x1C, 0x38, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x38, 0x1C, 0x00,
  0x03, 0x81, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0xF0,
  0x0F, 0x00, 0x0F, 0x00, 0x70, 0x00, 0xE0, 0x07, 0x00, 0x1E, 0x00, 0x78,
  0x01, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x38,
  0x00, 0x1C, 0x07, 0x80, 0x01, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0xE0, 0xF0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x1E,
  0x00, 0x00, 0x39, 0xC0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xFC, 0x00, 0x07, 0x80, 0x00,
  0xE7, 0x00, 0x03, 0xF0, 0x00, 0x79, 0xC0, 0x00, 0xFC, 0x00, 0x1E, 0x78,
  0x00, 0x3F, 0x00, 0x07, 0x1E, 0x00, 0x1D, 0xE0, 0x01, 0xC3, 0x80, 0x07,
  0x38, 0x00, 0xF0, 0xF0, 0x01, 0xCE, 0x00, 0x38, 0x3C, 0x00, 0xF3, 0xC0,
  0x0E, 0x07, 0x00, 0x38, 0x70, 0x03, 0x81, 0xC0, 0x0E, 0x1C, 0x01, 0xE0,
  0x78, 0x07, 0x87, 0x00, 0x70, 0x1E, 0x01, 0xC0, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x38, 0x0F, 0x00, 0xE0, 0x3C, 0x0E, 0x03, 0xC0, 0x3C, 0x0E, 0x03,
  0xC0, 0xE0, 0x07, 0x03, 0x80, 0x70, 0x38, 0x01, 0xC1, 0xE0, 0x1C, 0x1E,
  0x00, 0x70, 0x70, 0x07, 0x87, 0x00, 0x1E, 0x1C, 0x00, 0xE1, 0xC0, 0x03,
  0x8F, 0x00, 0x38, 0x70, 0x00, 0xE3, 0x80, 0x0F, 0x3C, 0x00, 0x3C, 0xE0,
  0x01, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x73, 0x80, 0x01, 0xDC, 0x00, 0x1C,
  0xE0, 0x00, 0x77, 0x00, 0x03, 0xF8, 0x00, 0x1D, 0xC0, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x03,
  0xE7, 0x80, 0x00, 0x70, 0x78, 0x00, 0x1E, 0x07, 0x00, 0x07, 0x80, 0xF0,
  0x01, 0xE0, 0x0F, 0x00, 0x38, 0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x03, 0xC0,
  0x01, 0xE0, 0x70, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x3C,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xE7,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0xF0, 0x1E, 0x00, 0x1C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x01, 0xE0, 0x01,
  0xC0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0xF0,
  0x00, 0x07, 0xBE, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x78, 0x0E, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0x70, 0x00, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0x3C,
  0x03, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x07, 0x80, 0x01, 0xE0, 0x78,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0xFE, 0x00, 0x78, 0x00, 0x3F, 0x80, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7F, 0x80, 0x1F,
  0xC0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x3F, 0xC0, 0x01, 0xF0, 0x01, 0xFC, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0xFF, 0x80, 0x3F, 0x80, 0x0F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x13, 0xFF, 0xC0, 0x03, 0x7F, 0xFF, 0x00, 0x7F,
  0x01, 0xFF, 0x3E, 0xC0, 0x07, 0xFF, 0xC8, 0x00, 0x0F, 0xF8,
};

const GFXglyph NotoSans_Light59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 5, 43, 15, 5, -42 },
  { 28, 13, 15, 21, 4, -42 },
  { 53, 35, 42, 38, 2, -42 },
  { 237, 25, 48, 34, 4, -45 },
  { 387, 42, 44, 48, 3, -43 },
  { 618, 38, 44, 42, 3, -43 },
  { 827, 4, 15, 12, 4, -42 },
  { 835, 12, 51, 16, 2, -42 },
  { 912, 12, 51, 16, 2, -42 },
  { 989, 26, 25, 33, 3, -45 },
  { 1071, 28, 28, 34, 3, -35 },
  { 1169, 7, 15, 13, 2, -7 },
  { 1183, 15, 3, 19, 2, -17 },
  { 1189, 5, 6, 14, 5, -5 },
  { 1193, 19, 42, 20, 1, -42 },
  { 1293, 27, 44, 34, 3, -43 },
  { 1442, 14, 42, 34, 6, -42 },
  { 1516, 27, 43, 34, 3, -43 },
  { 1662, 27, 44, 34, 3, -43 },
  { 1811, 32, 42, 34, 1, -42 },
  { 1979, 26, 43, 34, 4, -42 },
  { 2119, 27, 44, 34, 4, -43 },
  { 2268, 28, 42, 34, 3, -42 },
  { 2415, 27, 44, 34, 3, -43 },
  { 2564, 27, 44, 34, 3, -43 },
  { 2713, 5, 33, 14, 5, -32 },
  { 2734, 8, 40, 14, 2, -32 },
  { 2774, 28, 28, 34, 3, -35 },
  { 2872, 27, 15, 34, 3, -28 },
  { 2923, 28, 28, 34, 3, -35 },
  { 3021, 22, 44, 25, 1, -43 },
  { 3142, 46, 48, 52, 3, -42 },
  { 3418, 36, 42, 36, 0, -42 },
  { 3607, 28, 42, 37, 6, -42 },
  { 3754, 31, 44, 37, 4, -43 },
  { 3925, 32, 42, 42, 6, -42 },
  { 4093, 23, 42, 33, 6, -42 },
  { 4214, 23, 42, 30, 6, -42 },
  { 4335, 34, 44, 43, 4, -43 },
  { 4522, 31, 42, 43, 6, -42 },
  { 4685, 12, 42, 18, 3, -42 },
  { 4748, 14, 53, 15, -5, -42 },
  { 4841, 29, 42, 35, 6, -42 },
  { 4994, 23, 42, 30, 6, -42 },
  { 5115, 40, 42, 51, 6, -42 },
  { 5325, 31, 42, 43, 6, -42 },
  { 5488, 38, 44, 45, 4, -43 },
  { 5697, 26, 42, 35, 6, -42 },
  { 5834, 38, 53, 45, 4, -43 },
  { 6086, 28, 42, 35, 6, -42 },
  { 6233, 26, 44, 32, 3, -43 },
  { 6376, 31, 42, 31, 0, -42 },
  { 6539, 32, 43, 43, 5, -42 },
  { 6711, 34, 42, 34, 0, -42 },
  { 6890, 51, 42, 53, 1, -42 },
  { 7158, 32, 42, 32, 0, -42 },
  { 7326, 32, 42, 32, 0, -42 },
  { 7494, 30, 42, 34, 2, -42 },
  { 7652, 12, 51, 19, 5, -42 },
  { 7729, 19, 42, 20, 1, -42 },
  { 7829, 13, 51, 19, 1, -42 },
  { 7912, 29, 26, 34, 2, -42 },
  { 8007, 25, 3, 25, 0, 5 },
  { 8017, 11, 9, 16, 2, -45 },
  { 8030, 24, 33, 32, 3, -32 },
  { 8129, 27, 46, 35, 5, -45 },
  { 8285, 23, 33, 28, 3, -32 },
  { 8380, 27, 46, 35, 3, -45 },
  { 8536, 26, 33, 33, 3, -32 },
  { 8644, 20, 45, 18, 1, -45 },
  { 8757, 27, 46, 35, 3, -32 },
  { 8913, 25, 45, 35, 5, -45 },
  { 9054, 4, 43, 14, 5, -43 },
  { 9076, 12, 57, 14, -3, -43 },
  { 9162, 24, 45, 29, 5, -45 },
  { 9297, 4, 45, 14, 5, -45 },
  { 9320, 43, 32, 53, 5, -32 },
  { 9492, 25, 32, 35, 5, -32 },
  { 9592, 28, 33, 35, 3, -32 },
  { 9708, 27, 46, 35, 5, -32 },
  { 9864, 27, 46, 35, 3, -32 },
  { 10020, 17, 32, 23, 5, -32 },
  { 10088, 22, 33, 28, 3, -32 },
  { 10179, 18, 40, 20, 1, -39 },
  { 10269, 25, 32, 35, 5, -31 },
  { 10369, 28, 31, 28, 0, -31 },
  { 10478, 42, 31, 43, 1, -31 },
  { 10641, 27, 31, 30, 1, -31 },
  { 10746, 28, 45, 28, 0, -31 },
  { 10904, 23, 31, 27, 2, -31 },
  { 10994, 17, 51, 21, 2, -42 },
  { 11103, 2, 60, 32, 15, -45 },
  { 11118, 18, 51, 21, 2, -42 },
  { 11233, 28, 6, 34, 3, -24 },
};

const GFXfont NotoSans_Light59pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light59pt7bBitmaps,
  (GFXglyph *)NotoSans_Light59pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _NOTOSANS_LIGHT59PT7B_H_
