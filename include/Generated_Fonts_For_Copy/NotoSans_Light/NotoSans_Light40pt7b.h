#ifndef _NOTOSANS_LIGHT40PT7B_H_
#define _NOTOSANS_LIGHT40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light40pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60,
  0x00, 0x04, 0xFF, 0xF0, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x1E, 0x0F, 0x07,
  0x82, 0xC1, 0x60, 0xB0, 0x40, 0x00, 0x60, 0x30, 0x00, 0x60, 0x30, 0x00,
  0x60, 0x30, 0x00, 0x60, 0x60, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x60, 0x00,
  0xC0, 0x60, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x40, 0x3F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0x80, 0x80, 0x01,
  0x81, 0x80, 0x03, 0x01, 0x80, 0x03, 0x01, 0x80, 0x03, 0x01, 0x80, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x06, 0x03, 0x00, 0x06, 0x03, 0x00, 0x06,
  0x03, 0x00, 0x06, 0x03, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x0C,
  0x06, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x03, 0xFF, 0xC3, 0xFF, 0xF3, 0x8C, 0x13, 0x86, 0x01, 0x83,
  0x00, 0xC1, 0x80, 0x60, 0xC0, 0x30, 0x60, 0x1C, 0x30, 0x0F, 0x18, 0x03,
  0xEC, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0xDF, 0x00, 0x63,
  0xC0, 0x30, 0x60, 0x18, 0x38, 0x0C, 0x1C, 0x06, 0x0E, 0x03, 0x07, 0x01,
  0x83, 0x40, 0xC3, 0xBE, 0x6F, 0x9F, 0xFF, 0x00, 0xFE, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x06, 0x03, 0xF8, 0x00, 0x60, 0x70,
  0xC0, 0x0C, 0x06, 0x06, 0x01, 0xC0, 0x60, 0x60, 0x18, 0x0C, 0x06, 0x03,
  0x00, 0xC0, 0x60, 0x30, 0x0C, 0x03, 0x06, 0x00, 0xC0, 0x30, 0x60, 0x0C,
  0x03, 0x0C, 0x00, 0xC0, 0x70, 0xC0, 0x0C, 0x06, 0x18, 0x20, 0xC0, 0x63,
  0x9F, 0xC6, 0x06, 0x31, 0xCE, 0x60, 0x66, 0x30, 0x63, 0x0C, 0x63, 0x03,
  0x3F, 0x8C, 0x60, 0x30, 0xF0, 0xC6, 0x03, 0x00, 0x18, 0x60, 0x30, 0x01,
  0x86, 0x03, 0x00, 0x30, 0x60, 0x30, 0x07, 0x06, 0x03, 0x00, 0x60, 0x60,
  0x30, 0x0C, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x03, 0x03, 0x01,
  0x80, 0x30, 0x60, 0x30, 0x01, 0xDE, 0x07, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x30, 0x0C, 0x00, 0x1C,
  0x03, 0x80, 0x06, 0x00, 0xE0, 0x01, 0x80, 0x38, 0x00, 0x70, 0x0E, 0x00,
  0x0C, 0x03, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x60, 0xE0, 0x00, 0x0C, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x79,
  0xC0, 0x0E, 0x38, 0x38, 0x03, 0x1C, 0x07, 0x00, 0xC7, 0x00, 0xE0, 0x71,
  0x80, 0x1C, 0x18, 0xE0, 0x03, 0xCE, 0x38, 0x00, 0x7B, 0x0E, 0x00, 0x0F,
  0xC3, 0x80, 0x01, 0xE0, 0x60, 0x00, 0x78, 0x1C, 0x00, 0x3F, 0x03, 0xC0,
  0x3C, 0xE0, 0x7F, 0xFC, 0x1C, 0x07, 0xFC, 0x03, 0xC0, 0xFF, 0xFF, 0xFC,
  0x07, 0x06, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0x70, 0x60, 0x60, 0xE0, 0xE0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xE0, 0x60, 0x60, 0x70, 0x70, 0x30, 0x38, 0x18, 0x1C, 0x0C, 0x07, 0xE0,
  0x60, 0x30, 0x38, 0x18, 0x1C, 0x0C, 0x0E, 0x06, 0x06, 0x07, 0x07, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x07,
  0x07, 0x06, 0x06, 0x0E, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0xE0, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x30, 0x2F,
  0x8C, 0x7F, 0xFF, 0xFF, 0x07, 0xF8, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0C,
  0xC0, 0x06, 0x18, 0x03, 0x87, 0x01, 0xC0, 0xC0, 0x70, 0x38, 0x08, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x33,
  0x77, 0x66, 0x6C, 0xCC, 0xFF, 0xFF, 0xC0, 0x4F, 0xFF, 0x00, 0x18, 0x00,
  0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xC0,
  0x06, 0x00, 0x70, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x06,
  0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00,
  0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x03, 0xF8, 0x01,
  0xFF, 0x80, 0x78, 0x38, 0x0C, 0x01, 0x83, 0x80, 0x38, 0x60, 0x03, 0x1C,
  0x00, 0x73, 0x00, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x1B, 0x80, 0x03, 0x70,
  0x00, 0x6E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1B, 0x80, 0x03, 0x30, 0x00, 0x66, 0x00, 0x0C, 0xC0,
  0x01, 0x98, 0x00, 0x71, 0x80, 0x0C, 0x30, 0x01, 0x87, 0x00, 0x60, 0x70,
  0x1C, 0x07, 0xFF, 0x00, 0x7F, 0x80, 0x01, 0xC0, 0xF0, 0x7C, 0x3F, 0x39,
  0xDC, 0x7E, 0x1D, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x03, 0xF0, 0x07, 0xFF, 0x07,
  0xC1, 0xE1, 0xC0, 0x1C, 0x40, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xF0, 0x07, 0xFF, 0x87, 0x80, 0xF3, 0x80, 0x0C, 0x40, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x1E, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xEC,
  0x00, 0x73, 0xFF, 0xF8, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xB0, 0x00, 0x1D, 0x80, 0x00,
  0xCC, 0x00, 0x0C, 0x60, 0x00, 0xE3, 0x00, 0x0E, 0x18, 0x00, 0x60, 0xC0,
  0x06, 0x06, 0x00, 0x70, 0x30, 0x03, 0x01, 0x80, 0x30, 0x0C, 0x03, 0x00,
  0x60, 0x38, 0x03, 0x01, 0x80, 0x18, 0x18, 0x00, 0xC1, 0xC0, 0x06, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xCE, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0xB0, 0x07, 0x9F, 0xFF, 0x87,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x1E, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x7C, 0x06, 0x3F, 0xE0, 0xDE, 0x1E, 0x1E,
  0x00, 0xE7, 0x80, 0x0E, 0xF0, 0x00, 0xDC, 0x00, 0x1D, 0x80, 0x03, 0xB0,
  0x00, 0x76, 0x00, 0x0E, 0xC0, 0x01, 0xD8, 0x00, 0x39, 0x80, 0x06, 0x30,
  0x01, 0xC3, 0x00, 0x30, 0x78, 0x1E, 0x07, 0xFF, 0x80, 0x3F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x03, 0xF8, 0x01, 0xFF,
  0xC0, 0x70, 0x3C, 0x1C, 0x01, 0xC3, 0x00, 0x18, 0xE0, 0x03, 0x18, 0x00,
  0x73, 0x00, 0x0E, 0x70, 0x01, 0x86, 0x00, 0x70, 0xE0, 0x0C, 0x0F, 0x07,
  0x00, 0xFB, 0xC0, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x78, 0xF0, 0x1C, 0x07,
  0x06, 0x00, 0x71, 0xC0, 0x07, 0x30, 0x00, 0x6E, 0x00, 0x0D, 0xC0, 0x01,
  0xF8, 0x00, 0x37, 0x00, 0x06, 0x60, 0x00, 0xCE, 0x00, 0x38, 0xE0, 0x0E,
  0x0F, 0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xC0, 0xE0,
  0xE0, 0x1C, 0x70, 0x03, 0x98, 0x00, 0x6E, 0x00, 0x1B, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xD8, 0x00,
  0x77, 0x00, 0x3C, 0xE0, 0x3B, 0x1F, 0xFC, 0xC1, 0xFC, 0x30, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0x4F,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x4F, 0xFF, 0x10, 0xF3,
  0xCE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE3,
  0x8E, 0x30, 0xC3, 0x1C, 0x61, 0x8C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x1F, 0xC1, 0xFF, 0xE3, 0xC1, 0xE4, 0x00, 0xE0, 0x00,
  0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70,
  0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x38, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0x80, 0x07, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x07, 0x1C, 0x00, 0x60, 0x06, 0x30, 0x07, 0xFC, 0x0E, 0xE0, 0x3C, 0x38,
  0x0D, 0x80, 0xE0, 0x30, 0x1B, 0x01, 0x80, 0x60, 0x36, 0x06, 0x00, 0xC0,
  0x78, 0x0C, 0x01, 0x80, 0xF0, 0x38, 0x03, 0x01, 0xE0, 0x60, 0x06, 0x03,
  0xC0, 0xC0, 0x0C, 0x07, 0x81, 0x80, 0x18, 0x0F, 0x03, 0x80, 0x70, 0x1E,
  0x03, 0x00, 0xE0, 0x66, 0x07, 0x03, 0x40, 0xCC, 0x07, 0x0C, 0xC3, 0x18,
  0x07, 0xF0, 0xFC, 0x38, 0x01, 0x80, 0x60, 0x30, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x20, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x36, 0x00, 0x00, 0x66, 0x00, 0x00, 0x67, 0x00, 0x00,
  0xE3, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xC1, 0x80, 0x01, 0xC1, 0x80, 0x01,
  0x81, 0xC0, 0x03, 0x80, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xE0, 0x07,
  0x00, 0x60, 0x06, 0x00, 0x70, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0C,
  0x00, 0x38, 0x1C, 0x00, 0x18, 0x18, 0x00, 0x18, 0x18, 0x00, 0x1C, 0x38,
  0x00, 0x0C, 0x30, 0x00, 0x0E, 0x70, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xC3, 0x03, 0xFC,
  0x60, 0x01, 0xCC, 0x00, 0x1D, 0x80, 0x03, 0xB0, 0x00, 0x36, 0x00, 0x06,
  0xC0, 0x00, 0xD8, 0x00, 0x3B, 0x00, 0x07, 0x60, 0x01, 0xCC, 0x00, 0xF1,
  0xFF, 0xF8, 0x3F, 0xFF, 0x86, 0x00, 0x7C, 0xC0, 0x01, 0xD8, 0x00, 0x1B,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xD8, 0x00, 0x3B, 0x00, 0x3E, 0x7F, 0xFF, 0x8F,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xF0, 0x3E, 0x03, 0x81, 0xC0,
  0x02, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0xFF, 0xC0,
  0x03, 0xFF, 0xF0, 0x0C, 0x1F, 0xF0, 0x30, 0x01, 0xF0, 0xC0, 0x01, 0xE3,
  0x00, 0x01, 0xCC, 0x00, 0x07, 0x30, 0x00, 0x0E, 0xC0, 0x00, 0x3B, 0x00,
  0x00, 0x6C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x06, 0xC0, 0x00, 0x3B, 0x00, 0x00, 0xEC, 0x00,
  0x07, 0x30, 0x00, 0x1C, 0xC0, 0x00, 0xE3, 0x00, 0x0F, 0x0C, 0x01, 0xF8,
  0x3F, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0x03, 0xE0, 0x1E, 0x07,
  0x80, 0x02, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x07, 0xFF, 0xE0,
  0x07, 0xFF, 0x60, 0x07, 0xFF, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x70,
  0x00, 0x03, 0x70, 0x00, 0x03, 0x30, 0x00, 0x03, 0x38, 0x00, 0x03, 0x18,
  0x00, 0x03, 0x1C, 0x00, 0x03, 0x0F, 0x00, 0x03, 0x07, 0xC0, 0x07, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0x80, 0xFF, 0xFF,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0xFF, 0xFF, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0xEF, 0xF3, 0xF8,
  0xC0, 0x00, 0xEC, 0x00, 0x1C, 0xC0, 0x03, 0x8C, 0x00, 0x70, 0xC0, 0x0E,
  0x0C, 0x00, 0xC0, 0xC0, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x0C, 0x0E,
  0x00, 0xC1, 0xC0, 0x0C, 0x38, 0x00, 0xC7, 0x00, 0x0C, 0xF0, 0x00, 0xDF,
  0x80, 0x0F, 0x9C, 0x00, 0xE0, 0xC0, 0x0C, 0x0E, 0x00, 0xC0, 0x70, 0x0C,
  0x03, 0x80, 0xC0, 0x38, 0x0C, 0x01, 0xC0, 0xC0, 0x0E, 0x0C, 0x00, 0x70,
  0xC0, 0x07, 0x0C, 0x00, 0x38, 0xC0, 0x01, 0xCC, 0x00, 0x0C, 0xC0, 0x00,
  0xF0, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xBD, 0x80, 0x00, 0x37, 0xB8, 0x00, 0x0E, 0xF3, 0x00, 0x01, 0x9E, 0x60,
  0x00, 0x33, 0xCE, 0x00, 0x0C, 0x78, 0xC0, 0x01, 0x8F, 0x18, 0x00, 0x71,
  0xE1, 0x80, 0x0C, 0x3C, 0x30, 0x01, 0x87, 0x87, 0x00, 0x60, 0xF0, 0x60,
  0x0C, 0x1E, 0x0C, 0x03, 0x83, 0xC1, 0xC0, 0x60, 0x78, 0x18, 0x0C, 0x0F,
  0x03, 0x83, 0x01, 0xE0, 0x30, 0x60, 0x3C, 0x06, 0x1C, 0x07, 0x80, 0xE3,
  0x00, 0xF0, 0x0C, 0x60, 0x1E, 0x01, 0xD8, 0x03, 0xC0, 0x1B, 0x00, 0x78,
  0x03, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xC0,
  0x06, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xEE, 0x00, 0x0F, 0x38, 0x00, 0x79, 0xC0, 0x03, 0xC7, 0x00,
  0x1E, 0x1C, 0x00, 0xF0, 0xE0, 0x07, 0x83, 0x80, 0x3C, 0x0C, 0x01, 0xE0,
  0x70, 0x0F, 0x01, 0xC0, 0x78, 0x06, 0x03, 0xC0, 0x38, 0x1E, 0x00, 0xE0,
  0xF0, 0x03, 0x07, 0x80, 0x1C, 0x3C, 0x00, 0x71, 0xE0, 0x01, 0x8F, 0x00,
  0x0E, 0x78, 0x00, 0x3B, 0xC0, 0x00, 0xDE, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFC,
  0x00, 0x7C, 0x07, 0x80, 0x3C, 0x00, 0x78, 0x1C, 0x00, 0x0E, 0x07, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x38, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x01, 0x9C,
  0x00, 0x00, 0x76, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x03, 0x60, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0x60, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x07, 0x70,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x63, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x0C,
  0x1C, 0x00, 0x07, 0x03, 0x80, 0x03, 0x80, 0x78, 0x03, 0xC0, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0xFC, 0x30, 0x7F, 0x98,
  0x01, 0xEC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3B, 0x00,
  0x79, 0xFF, 0xF8, 0xFF, 0xF0, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0xFC, 0x00, 0x7C, 0x07, 0x80, 0x3C, 0x00, 0x78, 0x1C, 0x00, 0x0E, 0x07,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x01,
  0x9C, 0x00, 0x00, 0x76, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x03, 0x60, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0x60,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x07,
  0x70, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x63, 0x80, 0x00, 0x38, 0xE0, 0x00,
  0x0C, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x03, 0x80, 0x78, 0x03, 0xC0, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0xFF, 0x00, 0x1F, 0xFF, 0x83, 0x07, 0xF8, 0x60,
  0x07, 0x8C, 0x00, 0x39, 0x80, 0x07, 0x30, 0x00, 0x66, 0x00, 0x0C, 0xC0,
  0x01, 0x98, 0x00, 0x33, 0x00, 0x06, 0x60, 0x01, 0xCC, 0x00, 0x31, 0x80,
  0x1E, 0x30, 0x1F, 0x87, 0xFF, 0xC0, 0xFF, 0xF0, 0x18, 0x06, 0x03, 0x00,
  0xE0, 0x60, 0x0C, 0x0C, 0x01, 0xC1, 0x80, 0x1C, 0x30, 0x01, 0x86, 0x00,
  0x38, 0xC0, 0x03, 0x18, 0x00, 0x73, 0x00, 0x07, 0x60, 0x00, 0x6C, 0x00,
  0x0E, 0x03, 0xFC, 0x03, 0xFF, 0xE3, 0xE0, 0x78, 0xE0, 0x02, 0x70, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xEC,
  0x00, 0xF3, 0xFF, 0xF8, 0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x06, 0x70, 0x00, 0x73, 0xC0, 0x07, 0x0F, 0x00, 0x70, 0x3F,
  0xFF, 0x00, 0x7F, 0xF0, 0x00, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x1D, 0x80,
  0x00, 0x3B, 0x80, 0x00, 0x67, 0x00, 0x01, 0xC6, 0x00, 0x03, 0x0E, 0x00,
  0x06, 0x0C, 0x00, 0x1C, 0x18, 0x00, 0x30, 0x38, 0x00, 0xE0, 0x30, 0x01,
  0xC0, 0x60, 0x03, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x30,
  0x01, 0x80, 0xE0, 0x03, 0x01, 0x80, 0x07, 0x03, 0x00, 0x06, 0x0E, 0x00,
  0x0C, 0x18, 0x00, 0x1C, 0x70, 0x00, 0x18, 0xE0, 0x00, 0x39, 0x80, 0x00,
  0x77, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xF8, 0x00, 0x70,
  0x00, 0x7E, 0x00, 0x1E, 0x00, 0x1D, 0x80, 0x07, 0x80, 0x06, 0x60, 0x01,
  0xE0, 0x01, 0x9C, 0x00, 0xDC, 0x00, 0xE3, 0x00, 0x33, 0x00, 0x30, 0xC0,
  0x0C, 0xC0, 0x0C, 0x30, 0x07, 0x30, 0x03, 0x0E, 0x01, 0x86, 0x01, 0xC1,
  0x80, 0x61, 0x80, 0x60, 0x60, 0x18, 0x60, 0x18, 0x1C, 0x0C, 0x1C, 0x0E,
  0x07, 0x03, 0x03, 0x03, 0x80, 0xC0, 0xC0, 0xC0, 0xC0, 0x30, 0x70, 0x30,
  0x30, 0x0E, 0x18, 0x06, 0x1C, 0x03, 0x86, 0x01, 0x87, 0x00, 0x61, 0x80,
  0x61, 0x80, 0x18, 0xE0, 0x1C, 0x60, 0x07, 0x30, 0x03, 0x38, 0x00, 0xCC,
  0x00, 0xCC, 0x00, 0x37, 0x00, 0x33, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x18,
  0xC0, 0x00, 0xE3, 0x80, 0x07, 0x06, 0x00, 0x18, 0x1C, 0x00, 0xE0, 0x38,
  0x07, 0x00, 0x60, 0x18, 0x01, 0xC0, 0xE0, 0x03, 0x83, 0x00, 0x06, 0x18,
  0x00, 0x1C, 0xE0, 0x00, 0x33, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xFC, 0x00, 0x07, 0x38, 0x00, 0x18,
  0x60, 0x00, 0xE1, 0xC0, 0x03, 0x03, 0x00, 0x18, 0x06, 0x00, 0xE0, 0x1C,
  0x03, 0x00, 0x30, 0x18, 0x00, 0xE0, 0xE0, 0x01, 0xC3, 0x00, 0x03, 0x1C,
  0x00, 0x0E, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1B, 0x00, 0x01, 0xDC, 0x00,
  0x0C, 0x60, 0x00, 0xE3, 0x80, 0x06, 0x0C, 0x00, 0x70, 0x70, 0x03, 0x01,
  0x80, 0x38, 0x0E, 0x01, 0x80, 0x30, 0x1C, 0x01, 0xC1, 0xC0, 0x06, 0x0C,
  0x00, 0x18, 0xE0, 0x00, 0xE6, 0x00, 0x03, 0x70, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF8, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x7F, 0xFF, 0xE0, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x1C,
  0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80,
  0x0C, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00,
  0x30, 0x01, 0x80, 0xFF, 0xFF, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xD8, 0x00,
  0x3B, 0x00, 0x06, 0x30, 0x01, 0xC6, 0x00, 0x30, 0x60, 0x0E, 0x0C, 0x01,
  0x80, 0xC0, 0x70, 0x18, 0x0C, 0x01, 0x83, 0x80, 0x30, 0x60, 0x03, 0x1C,
  0x00, 0x63, 0x00, 0x06, 0xE0, 0x00, 0xD8, 0x00, 0x0C, 0xFF, 0xFF, 0x80,
  0xC1, 0xC1, 0xC1, 0xC1, 0x81, 0x81, 0x80, 0x00, 0xC0, 0x1F, 0xFC, 0x3E,
  0x3E, 0x10, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x07, 0xFF, 0x1F, 0xC3, 0x78, 0x03, 0x60, 0x03, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x0F, 0x70, 0x1B, 0x7F,
  0xF3, 0x1F, 0xE3, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0xF0,
  0x1C, 0xFF, 0xC3, 0xBC, 0x7C, 0x7C, 0x01, 0xCF, 0x00, 0x19, 0xE0, 0x03,
  0xB8, 0x00, 0x37, 0x00, 0x06, 0xE0, 0x00, 0xDC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x37, 0x00, 0x06,
  0xE0, 0x01, 0xDE, 0x00, 0x3B, 0xE0, 0x0E, 0x7E, 0x03, 0x8C, 0xFF, 0xE1,
  0x87, 0xF8, 0x00, 0x00, 0xF0, 0x07, 0xFF, 0x0F, 0x8E, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x01, 0x0F, 0xFF, 0x07, 0xFE, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x01, 0xE0, 0xC1, 0xFF, 0x31, 0xF1, 0xEC,
  0xF0, 0x0F, 0x38, 0x01, 0xDC, 0x00, 0x76, 0x00, 0x0D, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0D, 0x80, 0x03, 0x60, 0x00, 0xDC, 0x00, 0x73, 0x80, 0x3C,
  0xF0, 0x1B, 0x1F, 0xFE, 0x41, 0xFE, 0x10, 0x00, 0xE0, 0x01, 0xFF, 0x00,
  0xF1, 0xE0, 0x70, 0x1C, 0x38, 0x03, 0x9C, 0x00, 0x66, 0x00, 0x19, 0x80,
  0x07, 0x60, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x02, 0x0F, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x60, 0x0F,
  0xF0, 0x79, 0x83, 0x80, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x0F, 0xFE, 0x3F, 0xF8, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x01, 0xFF, 0x11, 0xF1, 0xEC, 0xF0,
  0x0F, 0x38, 0x01, 0xDC, 0x00, 0x76, 0x00, 0x0D, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0D, 0x80, 0x03, 0x60, 0x00, 0xDC, 0x00, 0x73, 0x80, 0x3C, 0x70,
  0x1B, 0x1F, 0xFE, 0xC1, 0xFE, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x20, 0x03, 0x8F, 0xCF, 0xC3,
  0xFF, 0xE0, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC1, 0xE0, 0x67,
  0xFE, 0x37, 0x8F, 0x9E, 0x00, 0xEE, 0x00, 0x77, 0x00, 0x1B, 0x00, 0x0D,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1C, 0xFF, 0x80, 0x00, 0x6D,
  0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0x07, 0x07, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x07, 0x07, 0x06, 0x9E, 0xFC, 0x30, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x02, 0xC0, 0x0C, 0xC0, 0x18, 0xC0, 0x30, 0xC0, 0x70,
  0xC0, 0xE0, 0xC1, 0xC0, 0xC3, 0x80, 0xC7, 0x00, 0xCE, 0x00, 0xDE, 0x00,
  0xFF, 0x00, 0xF3, 0x80, 0xE1, 0x80, 0xC1, 0xC0, 0xC0, 0xE0, 0xC0, 0x70,
  0xC0, 0x30, 0xC0, 0x38, 0xC0, 0x1C, 0xC0, 0x0E, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x0E, 0x08, 0xFF, 0x87,
  0xFC, 0xDC, 0x3C, 0xF1, 0xEF, 0x01, 0xD8, 0x07, 0xE0, 0x0F, 0x00, 0x3E,
  0x00, 0x70, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06,
  0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03,
  0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00,
  0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00,
  0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0x01,
  0xC0, 0x47, 0xFE, 0x37, 0x8F, 0x9E, 0x00, 0xEE, 0x00, 0x77, 0x00, 0x1B,
  0x00, 0x0D, 0x80, 0x06, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0xFF, 0xC0, 0x3C, 0x3C, 0x0E, 0x01, 0xC3, 0x80, 0x1C, 0xE0, 0x01,
  0x98, 0x00, 0x3B, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x07,
  0x70, 0x00, 0xC6, 0x00, 0x18, 0xE0, 0x06, 0x0E, 0x01, 0xC0, 0xFF, 0xF0,
  0x0F, 0xF8, 0x00, 0x01, 0xE0, 0x21, 0xFF, 0x0D, 0xE1, 0xE3, 0xE0, 0x1C,
  0xF0, 0x03, 0x38, 0x00, 0xEC, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1B, 0x00, 0x06, 0xE0, 0x03, 0xB8, 0x00, 0xEF, 0x00, 0x73, 0x60, 0x38,
  0xDF, 0xFC, 0x31, 0xFE, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xE0, 0x01, 0xFF, 0x11, 0xF1, 0xEC, 0xE0, 0x0F, 0x30, 0x01,
  0xDC, 0x00, 0x76, 0x00, 0x1D, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0D, 0x80,
  0x03, 0x60, 0x01, 0xDC, 0x00, 0x73, 0x80, 0x3C, 0xF0, 0x1B, 0x1F, 0xFC,
  0xC1, 0xFE, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x01,
  0xD1, 0xFF, 0x7D, 0xFC, 0x0F, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x3F, 0xF9, 0xE0, 0xF3,
  0x00, 0x2E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0xEF, 0xFF, 0x8F, 0xFE, 0x00,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x0F, 0xFE, 0xFF, 0xE1, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xC0,
  0x0F, 0xF0, 0x7F, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0x60, 0x03, 0xB8, 0x03, 0xDE, 0x03, 0x67, 0xFF, 0x31, 0xFF, 0x18,
  0xE0, 0x00, 0xEC, 0x00, 0x19, 0x80, 0x07, 0x38, 0x00, 0xC3, 0x00, 0x18,
  0x70, 0x07, 0x06, 0x00, 0xC0, 0xC0, 0x38, 0x1C, 0x06, 0x01, 0x80, 0xC0,
  0x30, 0x38, 0x03, 0x06, 0x00, 0x60, 0xC0, 0x0E, 0x30, 0x00, 0xC6, 0x00,
  0x19, 0xC0, 0x03, 0xB0, 0x00, 0x36, 0x00, 0x07, 0xC0, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0xC0, 0x0E, 0x00, 0x7C, 0x00, 0xF0, 0x06, 0xE0, 0x0F, 0x00,
  0x66, 0x00, 0xF0, 0x06, 0x60, 0x1B, 0x80, 0xE7, 0x01, 0x98, 0x0C, 0x70,
  0x19, 0x80, 0xC3, 0x03, 0x1C, 0x1C, 0x30, 0x30, 0xC1, 0x83, 0x83, 0x0C,
  0x18, 0x18, 0x60, 0xC1, 0x81, 0x86, 0x06, 0x38, 0x18, 0x60, 0x63, 0x01,
  0xCC, 0x06, 0x30, 0x0C, 0xC0, 0x33, 0x00, 0xCC, 0x03, 0x70, 0x0D, 0x80,
  0x36, 0x00, 0x78, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0xCC, 0x00, 0xE3, 0x80, 0x70, 0x70,
  0x18, 0x0C, 0x0C, 0x03, 0x87, 0x00, 0x73, 0x80, 0x0C, 0xC0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0x30, 0x01, 0xCE, 0x00,
  0xE1, 0xC0, 0x30, 0x30, 0x1C, 0x0E, 0x0E, 0x01, 0xC3, 0x00, 0x31, 0xC0,
  0x06, 0xE0, 0x01, 0xC0, 0xE0, 0x00, 0xEC, 0x00, 0x19, 0xC0, 0x07, 0x18,
  0x00, 0xC3, 0x00, 0x18, 0x70, 0x07, 0x06, 0x00, 0xC0, 0xC0, 0x38, 0x1C,
  0x06, 0x01, 0x80, 0xC0, 0x38, 0x38, 0x03, 0x06, 0x00, 0x60, 0xC0, 0x0E,
  0x38, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x06,
  0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x09, 0xE0,
  0x01, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x70,
  0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0xE0, 0x03, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x10,
  0x1F, 0x03, 0xE0, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x3C, 0x0F,
  0x00, 0xF8, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x70, 0x07, 0x00,
  0x3F, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0x80, 0x7C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x30, 0x03, 0xC0, 0x0F, 0x01, 0xF0, 0x38, 0x03, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x60, 0x0E, 0x0F, 0xC0, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0xFC, 0x0F, 0x03,
  0xFF, 0x40, 0x0F, 0xC0,
};

const GFXglyph NotoSans_Light40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 4, 29, 10, 3, -29 },
  { 16, 9, 11, 15, 3, -29 },
  { 29, 24, 29, 26, 1, -29 },
  { 116, 17, 32, 23, 3, -30 },
  { 184, 28, 29, 32, 2, -29 },
  { 286, 26, 29, 29, 2, -29 },
  { 381, 2, 11, 8, 3, -29 },
  { 384, 8, 35, 11, 2, -29 },
  { 419, 8, 35, 11, 1, -29 },
  { 454, 18, 17, 22, 2, -30 },
  { 493, 19, 19, 23, 2, -24 },
  { 539, 4, 10, 9, 2, -5 },
  { 544, 9, 2, 13, 2, -12 },
  { 547, 4, 4, 10, 3, -4 },
  { 549, 13, 29, 14, 0, -29 },
  { 597, 19, 29, 23, 2, -29 },
  { 666, 10, 29, 23, 4, -29 },
  { 703, 18, 29, 23, 2, -29 },
  { 769, 18, 29, 23, 2, -29 },
  { 835, 21, 29, 23, 1, -29 },
  { 912, 17, 29, 23, 3, -29 },
  { 974, 19, 29, 23, 2, -29 },
  { 1043, 19, 29, 23, 2, -29 },
  { 1112, 19, 29, 23, 2, -29 },
  { 1181, 18, 29, 23, 2, -29 },
  { 1247, 4, 22, 10, 3, -22 },
  { 1258, 6, 27, 10, 1, -22 },
  { 1279, 19, 19, 23, 2, -24 },
  { 1325, 19, 10, 23, 2, -19 },
  { 1349, 19, 19, 23, 2, -24 },
  { 1395, 15, 29, 17, 1, -29 },
  { 1450, 31, 32, 36, 2, -28 },
  { 1574, 24, 29, 24, 0, -29 },
  { 1661, 19, 29, 25, 4, -29 },
  { 1730, 22, 29, 25, 2, -29 },
  { 1810, 22, 29, 28, 4, -29 },
  { 1890, 16, 29, 22, 4, -29 },
  { 1948, 16, 29, 20, 4, -29 },
  { 2006, 24, 29, 29, 2, -29 },
  { 2093, 21, 29, 29, 4, -29 },
  { 2170, 8, 29, 12, 2, -29 },
  { 2199, 10, 36, 10, -4, -29 },
  { 2244, 20, 29, 24, 4, -29 },
  { 2317, 16, 29, 21, 4, -29 },
  { 2375, 27, 29, 35, 4, -29 },
  { 2473, 21, 29, 29, 4, -29 },
  { 2550, 26, 29, 31, 2, -29 },
  { 2645, 17, 29, 24, 4, -29 },
  { 2707, 26, 36, 31, 2, -29 },
  { 2824, 19, 29, 24, 4, -29 },
  { 2893, 18, 29, 22, 2, -29 },
  { 2959, 21, 29, 21, 0, -29 },
  { 3036, 21, 29, 29, 4, -29 },
  { 3113, 23, 29, 23, 0, -29 },
  { 3197, 34, 29, 36, 1, -29 },
  { 3321, 22, 29, 22, 0, -29 },
  { 3401, 21, 29, 21, 0, -29 },
  { 3478, 20, 29, 23, 1, -29 },
  { 3551, 9, 35, 13, 3, -29 },
  { 3591, 13, 29, 14, 0, -29 },
  { 3639, 8, 35, 13, 1, -29 },
  { 3674, 19, 18, 23, 2, -29 },
  { 3717, 17, 1, 17, 0, 4 },
  { 3720, 7, 7, 11, 2, -31 },
  { 3727, 16, 22, 21, 2, -22 },
  { 3771, 19, 30, 24, 3, -30 },
  { 3843, 16, 22, 19, 2, -22 },
  { 3887, 18, 30, 24, 2, -30 },
  { 3955, 18, 22, 22, 2, -22 },
  { 4005, 14, 31, 12, 1, -31 },
  { 4060, 18, 32, 24, 2, -22 },
  { 4132, 17, 30, 24, 4, -30 },
  { 4196, 3, 29, 9, 3, -29 },
  { 4207, 8, 39, 9, -2, -29 },
  { 4246, 16, 30, 20, 4, -30 },
  { 4306, 2, 30, 9, 4, -30 },
  { 4314, 28, 22, 36, 4, -22 },
  { 4391, 17, 22, 24, 4, -22 },
  { 4438, 19, 22, 24, 2, -22 },
  { 4491, 18, 31, 24, 4, -22 },
  { 4561, 18, 31, 24, 2, -22 },
  { 4631, 11, 22, 16, 4, -22 },
  { 4662, 15, 22, 19, 2, -22 },
  { 4704, 12, 26, 14, 1, -26 },
  { 4743, 17, 21, 24, 3, -21 },
  { 4788, 19, 21, 19, 0, -21 },
  { 4838, 28, 21, 29, 1, -21 },
  { 4912, 18, 21, 20, 1, -21 },
  { 4960, 19, 31, 19, 0, -21 },
  { 5034, 15, 21, 19, 2, -21 },
  { 5074, 12, 35, 14, 1, -29 },
  { 5127, 2, 40, 22, 10, -30 },
  { 5137, 12, 35, 14, 1, -29 },
  { 5190, 19, 4, 23, 2, -16 },
};

const GFXfont NotoSans_Light40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light40pt7bBitmaps,
  (GFXglyph *)NotoSans_Light40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_LIGHT40PT7B_H_
