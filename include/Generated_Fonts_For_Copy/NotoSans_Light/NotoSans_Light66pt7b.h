#ifndef _NOTOSANS_LIGHT66PT7B_H_
#define _NOTOSANS_LIGHT66PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light66pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0x80, 0x00, 0x00, 0x00, 0x00, 0xE7, 0xFF, 0xFF, 0xF7,
  0xCC, 0xF0, 0x3F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x07, 0x80,
  0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x00, 0x70, 0x01, 0xE0,
  0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x00, 0x07,
  0x80, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x01,
  0xE0, 0x03, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00,
  0x78, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x07,
  0x80, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00,
  0x07, 0x80, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xE0, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFC, 0x1F, 0x87, 0x0F, 0xC1, 0xF0, 0x38, 0x06, 0x1F, 0x01, 0xC0,
  0x00, 0xF0, 0x0E, 0x00, 0x07, 0x00, 0x70, 0x00, 0x78, 0x03, 0x80, 0x03,
  0xC0, 0x1C, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0xF0, 0x07, 0x00, 0x07, 0x80,
  0x38, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0xF0, 0x0E, 0x00, 0x07, 0xC0, 0x70,
  0x00, 0x1F, 0x03, 0x80, 0x00, 0x7E, 0x1C, 0x00, 0x01, 0xFE, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0x9F, 0xE0, 0x00, 0x1C,
  0x1F, 0x80, 0x00, 0xE0, 0x7C, 0x00, 0x07, 0x01, 0xF0, 0x00, 0x38, 0x07,
  0x80, 0x01, 0xC0, 0x3C, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x70, 0x07, 0x80,
  0x03, 0x80, 0x3C, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x1E, 0x00, 0x07,
  0x00, 0xF0, 0x00, 0x38, 0x0F, 0x20, 0x01, 0xC0, 0xF9, 0xE0, 0x0E, 0x1F,
  0x8F, 0xFC, 0x7F, 0xF8, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xF0,
  0x01, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x0F, 0x87, 0xC0, 0x00, 0x1C, 0x00,
  0x38, 0x0F, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x03, 0x80, 0x07,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xE0,
  0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0x38, 0x00, 0x70, 0x03, 0xC0, 0x00, 0xE0, 0x01,
  0xC0, 0x0E, 0x00, 0x03, 0x80, 0x07, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x70, 0x0F, 0x00, 0x00, 0xE0, 0x01, 0xC0,
  0x78, 0x00, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x1C, 0x0F,
  0x00, 0x00, 0x38, 0x00, 0x70, 0x38, 0x0F, 0x80, 0xE0, 0x01, 0xC1, 0xE0,
  0xFF, 0x83, 0xC0, 0x0F, 0x07, 0x07, 0xFF, 0x8F, 0x00, 0x38, 0x3C, 0x3C,
  0x1E, 0x1C, 0x00, 0xE0, 0xE1, 0xE0, 0x3C, 0x78, 0x07, 0x87, 0x87, 0x00,
  0x70, 0xF0, 0x3C, 0x3C, 0x3C, 0x01, 0xE3, 0xE1, 0xF0, 0xE0, 0xE0, 0x03,
  0x87, 0xFF, 0x87, 0x83, 0x80, 0x0E, 0x0F, 0xF8, 0x1C, 0x0E, 0x00, 0x3C,
  0x07, 0x80, 0xF0, 0x78, 0x00, 0xF0, 0x00, 0x03, 0x81, 0xE0, 0x01, 0xC0,
  0x00, 0x1E, 0x07, 0x80, 0x07, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x70, 0x00, 0x1E, 0x01, 0xE0, 0x01, 0xC0, 0x00,
  0x70, 0x07, 0x80, 0x07, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x01, 0xC0,
  0x03, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0x0F, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x38, 0x00, 0x07, 0x80, 0xF0, 0x01, 0xE0, 0x00, 0x0F,
  0x8F, 0x80, 0x07, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x3C, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xF9, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x00, 0x01,
  0xE7, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x03, 0xC0,
  0xF8, 0x0F, 0x80, 0x00, 0xF0, 0x7C, 0x03, 0xF0, 0x00, 0x3C, 0x3E, 0x00,
  0x7E, 0x00, 0x1E, 0x1F, 0x00, 0x07, 0xC0, 0x07, 0x87, 0x80, 0x00, 0xF8,
  0x01, 0xE3, 0xE0, 0x00, 0x1F, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xE0, 0x3C,
  0x3C, 0x00, 0x00, 0x7C, 0x1E, 0x0F, 0x00, 0x00, 0x0F, 0x87, 0x83, 0xC0,
  0x00, 0x01, 0xF3, 0xC0, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x3C, 0x00, 0x00,
  0x07, 0xF8, 0x0F, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x78, 0x00, 0x00, 0x1F, 0xE0, 0x1F, 0x00, 0x00, 0x0F, 0xFC, 0x07,
  0xC0, 0x00, 0x07, 0xCF, 0x80, 0xFC, 0x00, 0x07, 0xE1, 0xF0, 0x1F, 0xC0,
  0x0F, 0xF0, 0x3E, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x7F, 0xFF, 0xF0,
  0x00, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x17, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xE0, 0x00, 0x78,
  0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01,
  0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x0E,
  0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0xF8, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0F,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38,
  0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78,
  0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x01, 0x80, 0x0E, 0x00,
  0x67, 0xC0, 0x30, 0x0F, 0x9F, 0xE0, 0xC1, 0xFE, 0xFF, 0xF3, 0x3F, 0xFC,
  0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x0E,
  0x1C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03,
  0xE0, 0x00, 0x78, 0x07, 0x80, 0x03, 0xE0, 0x0F, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0x20, 0x01, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x1F, 0x1E,
  0x1E, 0x3E, 0x3C, 0x3C, 0x3C, 0x38, 0x78, 0x78, 0x70, 0x70, 0xF0, 0xE0,
  0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x39, 0xFF,
  0xFF, 0xFD, 0xF3, 0x00, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0x7F, 0xC0, 0x07,
  0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x78, 0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x0F, 0x1E, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x01,
  0xE7, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x3B,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3B,
  0xC0, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x79, 0xE0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x3C, 0x03, 0xE0, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0xFF, 0x01, 0xF7, 0x03, 0xE7,
  0x0F, 0xC7, 0x1F, 0x07, 0x3E, 0x07, 0xFC, 0x07, 0x78, 0x07, 0x20, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE,
  0x07, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xC1, 0xC0, 0x00, 0x1F, 0x04,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0x3F, 0xE0, 0x7F, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x0F, 0x87, 0x00, 0x00, 0x1F, 0x08, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xE8, 0x00, 0x00, 0x1F, 0x38, 0x00, 0x00,
  0xF8, 0xFC, 0x00, 0x1F, 0xC3, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x80, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0x71, 0xE0, 0x00,
  0x00, 0x1E, 0x3C, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x38, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0xF0, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x78, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xE4, 0x00, 0x00, 0x3E, 0x30, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80,
  0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xF8, 0x78, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x07, 0xFF, 0x00, 0x70, 0x7F, 0xFF, 0x03, 0xC7,
  0xFF, 0xFE, 0x0F, 0x3F, 0x00, 0xFC, 0x3D, 0xE0, 0x00, 0xF8, 0xF7, 0x00,
  0x00, 0xF3, 0xF8, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x07, 0xBE, 0x00, 0x00,
  0x0E, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1F, 0x01, 0xE0, 0x00,
  0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFE,
  0x3F, 0xE0, 0x0F, 0x80, 0x0F, 0xC0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x01, 0xE0, 0x7C, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x78, 0x01, 0xF8,
  0x07, 0xC0, 0x03, 0xF8, 0x7E, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xC3, 0xFC,
  0x00, 0x7C, 0x01, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0,
  0xF0, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x80, 0x0F, 0xC0,
  0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x07, 0x40, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xE0,
  0x00, 0xF8, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x01, 0xC7, 0x80, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x07, 0x9C, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00,
  0x3D, 0xC0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x03,
  0xEF, 0x00, 0x00, 0x0F, 0xCF, 0x00, 0x00, 0x1F, 0x9E, 0x00, 0x00, 0x7F,
  0x1E, 0x00, 0x01, 0xDE, 0x3F, 0x00, 0x0F, 0x38, 0x3F, 0x80, 0x7C, 0x70,
  0x3F, 0xFF, 0xF0, 0xE0, 0x1F, 0xFF, 0x83, 0xC0, 0x0F, 0xFC, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x31, 0xFF, 0xFF, 0xFD, 0xF3, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x9F, 0xFF, 0xFF, 0xDF, 0x30, 0x06, 0x07, 0x87, 0xE3, 0xF1, 0xF8, 0x7C,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x78, 0x7C, 0x3E, 0x1E, 0x0F, 0x07, 0x87, 0x83, 0xC1, 0xE0,
  0xE0, 0x70, 0x78, 0x38, 0x1C, 0x0E, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xF8, 0x00,
  0xFC, 0x40, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x01, 0xFE, 0x00, 0x07, 0x0F, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0xF1, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0E, 0x38, 0x00, 0x3F, 0x00, 0xF0,
  0x01, 0xCF, 0x00, 0x0F, 0x80, 0x0E, 0x00, 0x39, 0xC0, 0x03, 0xC0, 0x01,
  0xC0, 0x07, 0xB8, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x7F, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x0F, 0xE0, 0x07, 0x80, 0x00, 0xE0, 0x01, 0xF8, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x3F, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x07, 0xE0, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x1F, 0x80,
  0x1E, 0x00, 0x03, 0xC0, 0x03, 0xF0, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x7E,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x1F, 0xC0, 0x0F, 0x00, 0x01, 0xE0, 0x03,
  0xB8, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x77, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x0E, 0xE0, 0x03, 0x80, 0x01, 0xF0, 0x03, 0xDC, 0x00, 0x78, 0x00, 0x7E,
  0x00, 0x73, 0xC0, 0x0F, 0x00, 0x0F, 0xC0, 0x1E, 0x78, 0x00, 0xF0, 0x03,
  0x9C, 0x07, 0x87, 0x00, 0x0F, 0x81, 0xE3, 0xC1, 0xE0, 0xE0, 0x00, 0xFF,
  0xF8, 0x3F, 0xF8, 0x1E, 0x00, 0x0F, 0xFE, 0x03, 0xFE, 0x01, 0xC0, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x00, 0x00, 0xE7,
  0x80, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x01, 0xE3, 0x80, 0x00,
  0x00, 0x01, 0xC3, 0xC0, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x00, 0x07, 0x80, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x03, 0xE0,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x00,
  0xF8, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0x00, 0x03,
  0xFF, 0x0E, 0x00, 0x00, 0x7F, 0x1C, 0x00, 0x00, 0x3E, 0x38, 0x00, 0x00,
  0x3E, 0x70, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x00,
  0xFB, 0x80, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x03,
  0xDC, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x3C,
  0xE0, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x07, 0x87,
  0x00, 0x00, 0x3E, 0x0E, 0x00, 0x07, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0xE0, 0x00, 0x1F, 0xE1, 0xC0,
  0x00, 0x07, 0xE3, 0x80, 0x00, 0x03, 0xE7, 0x00, 0x00, 0x03, 0xEE, 0x00,
  0x00, 0x03, 0xDC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x3E, 0xE0, 0x00, 0x00,
  0xF9, 0xC0, 0x00, 0x03, 0xF3, 0x80, 0x00, 0x1F, 0xC7, 0x00, 0x03, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x7C, 0x01,
  0xF8, 0x00, 0x01, 0x80, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x20, 0x0F, 0xF0, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x0E, 0x00, 0x0F, 0xFE, 0x00, 0xE0, 0x00, 0x07, 0xF0, 0x0E, 0x00,
  0x00, 0x1F, 0xC0, 0xE0, 0x00, 0x00, 0x7E, 0x0E, 0x00, 0x00, 0x03, 0xE0,
  0xE0, 0x00, 0x00, 0x1F, 0x0E, 0x00, 0x00, 0x00, 0xF8, 0xE0, 0x00, 0x00,
  0x07, 0x8E, 0x00, 0x00, 0x00, 0x7C, 0xE0, 0x00, 0x00, 0x03, 0xCE, 0x00,
  0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x00, 0x1E,
  0xE0, 0x00, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xEE, 0x00,
  0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x00, 0x1E,
  0xE0, 0x00, 0x00, 0x03, 0xEE, 0x00, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00,
  0x07, 0xCE, 0x00, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0x0F, 0x8E, 0x00,
  0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0x1F, 0x0E, 0x00, 0x00, 0x07, 0xE0,
  0xE0, 0x00, 0x00, 0xFC, 0x0E, 0x00, 0x00, 0x3F, 0x80, 0xE0, 0x00, 0x0F,
  0xF0, 0x0E, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCE,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x00,
  0x07, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00,
  0x03, 0xC7, 0xC0, 0x00, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x00, 0x0F, 0x0F,
  0xC0, 0x00, 0x00, 0x1E, 0x0F, 0xC0, 0x00, 0x00, 0x3C, 0x0F, 0xC0, 0x00,
  0x00, 0x78, 0x0F, 0xE0, 0x00, 0x00, 0xF0, 0x0F, 0xF8, 0x00, 0x1F, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0x81, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x7F, 0xFB, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x7C, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0x7F, 0x80,
  0xE0, 0x00, 0x00, 0x3E, 0xE0, 0x00, 0x00, 0x7C, 0xE0, 0x00, 0x00, 0xF8,
  0xE0, 0x00, 0x01, 0xF0, 0xE0, 0x00, 0x03, 0xE0, 0xE0, 0x00, 0x07, 0xC0,
  0xE0, 0x00, 0x0F, 0x80, 0xE0, 0x00, 0x1F, 0x00, 0xE0, 0x00, 0x3E, 0x00,
  0xE0, 0x00, 0x7C, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0xE0, 0x01, 0xF0, 0x00,
  0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0xE0, 0x07, 0x80, 0x00,
  0xE0, 0x0F, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00,
  0xE0, 0x7C, 0x00, 0x00, 0xE0, 0xF8, 0x00, 0x00, 0xE1, 0xF8, 0x00, 0x00,
  0xE3, 0xF8, 0x00, 0x00, 0xE7, 0xFC, 0x00, 0x00, 0xEF, 0x3E, 0x00, 0x00,
  0xFE, 0x1E, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00,
  0xF0, 0x07, 0xC0, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0xE0, 0x03, 0xE0, 0x00,
  0xE0, 0x01, 0xF0, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0xE0, 0x00, 0x7C, 0x00, 0xE0, 0x00, 0x3E, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0xE0, 0x00, 0x07, 0xC0,
  0xE0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x03, 0xE0, 0xE0, 0x00, 0x01, 0xF0,
  0xE0, 0x00, 0x00, 0xF8, 0xE0, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0x7C,
  0xE0, 0x00, 0x00, 0x3E, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xEF, 0x00, 0x00, 0x00, 0x0E, 0xFE, 0x70, 0x00, 0x00, 0x01,
  0xEF, 0xE7, 0x80, 0x00, 0x00, 0x1C, 0xFE, 0x78, 0x00, 0x00, 0x03, 0xCF,
  0xE3, 0xC0, 0x00, 0x00, 0x3C, 0xFE, 0x3C, 0x00, 0x00, 0x03, 0x8F, 0xE1,
  0xC0, 0x00, 0x00, 0x78, 0xFE, 0x1E, 0x00, 0x00, 0x07, 0x0F, 0xE1, 0xE0,
  0x00, 0x00, 0xF0, 0xFE, 0x0F, 0x00, 0x00, 0x0F, 0x0F, 0xE0, 0xF0, 0x00,
  0x00, 0xE0, 0xFE, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0xE0, 0x78, 0x00, 0x01,
  0xC0, 0xFE, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0xE0, 0x3C, 0x00, 0x03, 0xC0,
  0xFE, 0x03, 0xC0, 0x00, 0x38, 0x0F, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0xFE,
  0x01, 0xE0, 0x00, 0x70, 0x0F, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0xFE, 0x00,
  0xE0, 0x00, 0xF0, 0x0F, 0xE0, 0x0F, 0x00, 0x0E, 0x00, 0xFE, 0x00, 0xF0,
  0x01, 0xE0, 0x0F, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xFE, 0x00, 0x78, 0x03,
  0xC0, 0x0F, 0xE0, 0x03, 0x80, 0x3C, 0x00, 0xFE, 0x00, 0x3C, 0x03, 0x80,
  0x0F, 0xE0, 0x03, 0xC0, 0x78, 0x00, 0xFE, 0x00, 0x1E, 0x07, 0x80, 0x0F,
  0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xFE, 0x00, 0x0E, 0x0F, 0x00, 0x0F, 0xE0,
  0x00, 0xF0, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0xE0, 0x00,
  0x79, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0xE0, 0x00, 0x3B,
  0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x03, 0xFB, 0xC0, 0x00, 0x00, 0x7F, 0x7C, 0x00, 0x00, 0x0F, 0xE7,
  0x80, 0x00, 0x01, 0xFC, 0x78, 0x00, 0x00, 0x3F, 0x8F, 0x80, 0x00, 0x07,
  0xF0, 0xF0, 0x00, 0x00, 0xFE, 0x0F, 0x00, 0x00, 0x1F, 0xC1, 0xF0, 0x00,
  0x03, 0xF8, 0x1E, 0x00, 0x00, 0x7F, 0x01, 0xE0, 0x00, 0x0F, 0xE0, 0x3E,
  0x00, 0x01, 0xFC, 0x03, 0xC0, 0x00, 0x3F, 0x80, 0x3C, 0x00, 0x07, 0xF0,
  0x07, 0xC0, 0x00, 0xFE, 0x00, 0x78, 0x00, 0x1F, 0xC0, 0x0F, 0x80, 0x03,
  0xF8, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0x00, 0x0F, 0xE0, 0x01, 0xF0,
  0x01, 0xFC, 0x00, 0x1F, 0x00, 0x3F, 0x80, 0x01, 0xE0, 0x07, 0xF0, 0x00,
  0x3E, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x1F, 0xC0, 0x00, 0x3C, 0x03, 0xF8,
  0x00, 0x07, 0xC0, 0x7F, 0x00, 0x00, 0x7C, 0x0F, 0xE0, 0x00, 0x07, 0x81,
  0xFC, 0x00, 0x00, 0xF8, 0x3F, 0x80, 0x00, 0x0F, 0x87, 0xF0, 0x00, 0x00,
  0xF0, 0xFE, 0x00, 0x00, 0x1F, 0x1F, 0xC0, 0x00, 0x01, 0xF3, 0xF8, 0x00,
  0x00, 0x1E, 0x7F, 0x00, 0x00, 0x03, 0xEF, 0xE0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x00,
  0x7C, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x78, 0x00, 0x00, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x01,
  0xF0, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE,
  0x0E, 0x00, 0x1F, 0xF8, 0xE0, 0x00, 0x1F, 0xCE, 0x00, 0x00, 0x7C, 0xE0,
  0x00, 0x03, 0xEE, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1E,
  0xE0, 0x00, 0x03, 0xEE, 0x00, 0x00, 0x7C, 0xE0, 0x00, 0x0F, 0x8E, 0x00,
  0x07, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x00,
  0x00, 0x0F, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0x00,
  0x3E, 0x78, 0x00, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0x00, 0x7B,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00,
  0x00, 0xF1, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFC, 0x07, 0x00, 0x0F, 0xFC, 0x0E, 0x00, 0x01, 0xFC,
  0x1C, 0x00, 0x00, 0xFC, 0x38, 0x00, 0x00, 0xF8, 0x70, 0x00, 0x00, 0xF8,
  0xE0, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x03, 0xC7,
  0x00, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x1E, 0x38,
  0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0xF1, 0xC0,
  0x00, 0x03, 0xE3, 0x80, 0x00, 0x07, 0x87, 0x00, 0x00, 0x1F, 0x0E, 0x00,
  0x00, 0x7C, 0x1C, 0x00, 0x01, 0xF0, 0x38, 0x00, 0x0F, 0xC0, 0x7F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x1F,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x3E, 0x00, 0xE0, 0x00, 0x3C,
  0x01, 0xC0, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x7C, 0x07, 0x00, 0x00, 0x78,
  0x0E, 0x00, 0x00, 0xF8, 0x1C, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0xF0,
  0x70, 0x00, 0x01, 0xF0, 0xE0, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x03, 0xE3,
  0x80, 0x00, 0x03, 0xE7, 0x00, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x07, 0xDC,
  0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC1, 0xFC,
  0x00, 0x3E, 0x1F, 0x80, 0x00, 0x31, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF9, 0x80, 0x00, 0x0F, 0x8F,
  0x80, 0x03, 0xF8, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x3D, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x3E,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3C, 0x78, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x78, 0x1E,
  0x00, 0x03, 0x83, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0xF0, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x01,
  0xC0, 0x01, 0xE0, 0x0F, 0x00, 0x07, 0x01, 0xE0, 0x01, 0xE0, 0x07, 0x00,
  0x0F, 0x01, 0xE0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0xE0, 0x01, 0xE0,
  0x07, 0x80, 0x0E, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0xF0,
  0x03, 0xC0, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x1E,
  0x00, 0x70, 0x03, 0xC0, 0x03, 0xC0, 0x1C, 0x00, 0x78, 0x07, 0x80, 0x03,
  0xC0, 0x3C, 0x00, 0x78, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x38, 0x07,
  0x80, 0x01, 0xE0, 0x38, 0x00, 0x38, 0x07, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x0E,
  0x1E, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x78, 0xE0,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x39, 0xE0, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x07, 0x38,
  0x00, 0x00, 0x3D, 0xC0, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x1E, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x3C, 0x00,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00,
  0x79, 0xF0, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x00, 0x1E, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x78, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x00, 0x1E,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x00, 0x7D, 0xF0, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x0F, 0x00, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x0F, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x1C, 0x78,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xE0, 0x0F,
  0x00, 0x00, 0xE0, 0x07, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x01, 0xC0, 0x03,
  0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x07, 0x80, 0x01,
  0xE0, 0x07, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00,
  0x70, 0x1E, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00,
  0x3C, 0x38, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00,
  0x0E, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x01,
  0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0xF8,
  0x00, 0xF8, 0x08, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0x07, 0x8F, 0xF0, 0x00, 0xF3, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xDE, 0x00, 0x03, 0xBB, 0xE0, 0x00, 0xE7, 0x3E, 0x00, 0x78,
  0xE7, 0xFF, 0xFE, 0x1C, 0x7F, 0xFF, 0x83, 0x83, 0xFF, 0xC0, 0x70, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x7E, 0x00, 0x38, 0x1F,
  0xFF, 0x00, 0xE1, 0xFF, 0xFE, 0x03, 0x8F, 0xFF, 0xFE, 0x0E, 0x7C, 0x00,
  0xFC, 0x3B, 0xC0, 0x00, 0xF8, 0xEE, 0x00, 0x01, 0xE3, 0xF0, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x0E, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x7B,
  0xE0, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x0F, 0x3F, 0x00, 0x00, 0x78, 0xEE,
  0x00, 0x03, 0xE3, 0xBC, 0x00, 0x1F, 0x0E, 0x7C, 0x01, 0xF8, 0x38, 0xFF,
  0xFF, 0xC0, 0xE1, 0xFF, 0xFE, 0x03, 0x81, 0xFF, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x7E, 0x00, 0x38, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x01, 0x0F, 0xE0, 0x03, 0x81, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0xFC, 0x03, 0xC0, 0x3F, 0xFE, 0x0F, 0x03, 0xFF,
  0xFC, 0x3C, 0x1F, 0xFF, 0xFC, 0xF0, 0xFC, 0x00, 0xFB, 0xC7, 0xE0, 0x00,
  0xEF, 0x1E, 0x00, 0x01, 0xFC, 0xF8, 0x00, 0x03, 0xF3, 0xC0, 0x00, 0x0F,
  0xDE, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x0F, 0xCF, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x01, 0xFC, 0x7C,
  0x00, 0x0E, 0xF0, 0xFC, 0x00, 0xF3, 0xC1, 0xFF, 0xFF, 0x87, 0x03, 0xFF,
  0xFC, 0x1C, 0x03, 0xFF, 0xC0, 0x70, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xF9, 0xFE,
  0x00, 0x7C, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x78, 0x00, 0x0F, 0x07,
  0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x04, 0x07, 0xE0, 0x01, 0xE0, 0x1F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xC0,
  0x20, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x70, 0x3F, 0xFF, 0xE1,
  0xC1, 0xFF, 0xFF, 0xCF, 0x0F, 0xC0, 0x0F, 0xBC, 0x7C, 0x00, 0x0E, 0xF1,
  0xE0, 0x00, 0x1F, 0xCF, 0x80, 0x00, 0x3F, 0x3C, 0x00, 0x00, 0xFD, 0xE0,
  0x00, 0x01, 0xF7, 0x80, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xF7, 0x80, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x1F, 0x7C, 0x00,
  0x00, 0xFC, 0xF0, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x1F, 0xC7, 0xC0, 0x00,
  0xEF, 0x0F, 0xC0, 0x0F, 0x3C, 0x1F, 0xFF, 0xF8, 0xF0, 0x3F, 0xFF, 0xC3,
  0xC0, 0x3F, 0xFC, 0x0F, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0xC3, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x01,
  0xF8, 0x3F, 0xF8, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0xC0, 0x0F, 0x07, 0xFF, 0xC0,
  0xF1, 0xFF, 0xFF, 0x0F, 0x3F, 0xEF, 0xF8, 0xF7, 0xC0, 0x0F, 0xCE, 0xF0,
  0x00, 0x7C, 0xEE, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x1E, 0xF8, 0x00, 0x01,
  0xEF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x77,
  0xFF, 0xF7, 0x90, 0x00, 0x00, 0x00, 0x00, 0x3D, 0xEF, 0x7B, 0xDE, 0xF7,
  0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF,
  0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x00, 0x70, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x07, 0x80, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x70, 0x07, 0x80, 0x3C, 0x03, 0xEC, 0xFE, 0x7F, 0xE3, 0xFE, 0x0F,
  0xC0, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0xF0, 0x00, 0x1F, 0x3C, 0x00, 0x0F, 0x8F,
  0x00, 0x07, 0xC3, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x78,
  0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x07,
  0xC0, 0x0E, 0x03, 0xE0, 0x03, 0x81, 0xF0, 0x00, 0xE0, 0xF8, 0x00, 0x38,
  0x7C, 0x00, 0x0E, 0x3F, 0x00, 0x03, 0x8F, 0xE0, 0x00, 0xE7, 0xF8, 0x00,
  0x3B, 0xCF, 0x00, 0x0F, 0xE3, 0xE0, 0x03, 0xF0, 0x7C, 0x00, 0xF8, 0x0F,
  0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xC0, 0x0F, 0x80, 0xF0,
  0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x83, 0xC0, 0x01, 0xF0,
  0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xF3, 0xC0, 0x00,
  0x3E, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0xE0, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0xE1, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xE7, 0x80, 0x3F,
  0x3E, 0x00, 0xFC, 0xEE, 0x00, 0x1F, 0x38, 0x00, 0x3C, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x0F, 0xE0,
  0x0E, 0x07, 0xFF, 0xC0, 0xE1, 0xFF, 0xFF, 0x0E, 0x3F, 0xEF, 0xF8, 0xE7,
  0xC0, 0x0F, 0xCE, 0xF0, 0x00, 0x7C, 0xEE, 0x00, 0x03, 0xEF, 0xC0, 0x00,
  0x1E, 0xF8, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x01, 0xF0,
  0x00, 0x7C, 0x07, 0x80, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x7C, 0x3C, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x07,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0x81, 0xFF, 0xF0, 0x0E, 0x0F,
  0xFF, 0xF0, 0x38, 0xFF, 0xFF, 0xE0, 0xE7, 0xC0, 0x0F, 0xC3, 0x9C, 0x00,
  0x0F, 0x8E, 0xE0, 0x00, 0x1E, 0x3F, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00,
  0xF3, 0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x3C,
  0xFC, 0x00, 0x00, 0xF3, 0xF0, 0x00, 0x07, 0x8E, 0xE0, 0x00, 0x3E, 0x3B,
  0xC0, 0x01, 0xF0, 0xE7, 0xC0, 0x1F, 0x83, 0x8F, 0xFF, 0xFC, 0x0F, 0x1F,
  0xFF, 0xE0, 0x3C, 0x1F, 0xFE, 0x00, 0xF0, 0x07, 0x80, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF,
  0xE0, 0x70, 0x3F, 0xFF, 0xC1, 0xC1, 0xFF, 0xFF, 0xCF, 0x0F, 0xC0, 0x0F,
  0x3C, 0x7C, 0x00, 0x0E, 0xF1, 0xE0, 0x00, 0x1F, 0xCF, 0x00, 0x00, 0x3F,
  0x3C, 0x00, 0x00, 0xFD, 0xE0, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x07, 0xDE,
  0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0xFC, 0xF0, 0x00, 0x07, 0xF3, 0xE0,
  0x00, 0x1B, 0xC7, 0xC0, 0x01, 0xEF, 0x0F, 0xC0, 0x0F, 0x3C, 0x1F, 0xFF,
  0xF8, 0xF0, 0x3F, 0xFF, 0xC3, 0xC0, 0x3F, 0xFC, 0x0F, 0x00, 0x1F, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x9C,
  0x0F, 0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0xFE, 0x7C, 0x01, 0xCE, 0x00, 0x3B,
  0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC3, 0xFE, 0x3F, 0xE3,
  0xE0, 0x00, 0xE3, 0xE0, 0x00, 0x11, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3D,
  0x80, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x07, 0x00,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xF7, 0x80,
  0x00, 0x1F, 0x78, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x77, 0x3E, 0x00, 0x0F,
  0x71, 0xF0, 0x03, 0xE7, 0x1F, 0xFF, 0xFC, 0x70, 0x7F, 0xFF, 0x87, 0x03,
  0xFF, 0xE0, 0x70, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x1C, 0x0F, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80,
  0x03, 0xC0, 0x1E, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x79, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0xEE, 0x00, 0x03, 0x8F, 0x00, 0x01, 0xDC, 0x00, 0x0F, 0x0F, 0x00, 0x03,
  0xBC, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1C,
  0x70, 0x00, 0x70, 0x3C, 0x00, 0x38, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0xF1,
  0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xC1, 0xC0, 0x07, 0x01, 0xE0, 0x03, 0x83,
  0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x07,
  0x00, 0x78, 0x07, 0x80, 0x38, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0xF0, 0x1E,
  0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x1E, 0x03, 0x80, 0x38,
  0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x78, 0x1C, 0x00, 0x38, 0x1E, 0x00, 0xF0,
  0x78, 0x00, 0x78, 0x38, 0x00, 0xE0, 0xF0, 0x00, 0xF0, 0xF0, 0x01, 0xE1,
  0xC0, 0x00, 0xE1, 0xE0, 0x03, 0xC3, 0x80, 0x01, 0xE3, 0x80, 0x03, 0x8F,
  0x00, 0x03, 0xCF, 0x00, 0x07, 0x9E, 0x00, 0x07, 0x9E, 0x00, 0x0F, 0x38,
  0x00, 0x07, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x1D, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x01, 0xE0, 0x0F, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x03, 0xC0, 0x1E, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xFB,
  0xE0, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0x80, 0x3C,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x01, 0xC0, 0x07, 0x80, 0x03, 0xC0,
  0x1E, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x71, 0xE0,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x01, 0xDE, 0x00,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x61, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x03, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0x80, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x7F, 0x80, 0x0F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0xFF, 0x00, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0xFF, 0xC0, 0x0F, 0xF0,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x02, 0x3F, 0xFC, 0x00, 0x04,
  0xFF, 0xFE, 0x00, 0x1F, 0xE1, 0xFF, 0x80, 0xFF, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x20, 0x00, 0x0F, 0xFC, 0x00,
};

const GFXglyph NotoSans_Light66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 6, 48, 16, 5, -47 },
  { 37, 14, 17, 24, 5, -47 },
  { 67, 39, 47, 43, 2, -47 },
  { 297, 29, 54, 38, 4, -50 },
  { 493, 46, 49, 54, 4, -48 },
  { 775, 42, 49, 47, 4, -48 },
  { 1033, 4, 17, 13, 5, -47 },
  { 1042, 13, 57, 18, 3, -47 },
  { 1135, 14, 57, 18, 2, -47 },
  { 1235, 30, 28, 36, 3, -50 },
  { 1340, 31, 31, 38, 3, -39 },
  { 1461, 8, 17, 15, 3, -8 },
  { 1478, 16, 4, 21, 3, -20 },
  { 1486, 6, 7, 16, 5, -6 },
  { 1492, 21, 47, 23, 1, -47 },
  { 1616, 30, 49, 38, 4, -48 },
  { 1800, 16, 47, 38, 6, -47 },
  { 1894, 29, 48, 38, 4, -48 },
  { 2068, 30, 49, 38, 3, -48 },
  { 2252, 35, 47, 38, 2, -47 },
  { 2458, 29, 48, 38, 5, -47 },
  { 2632, 30, 49, 38, 4, -48 },
  { 2816, 31, 47, 38, 3, -47 },
  { 2999, 30, 49, 38, 4, -48 },
  { 3183, 31, 49, 38, 3, -48 },
  { 3373, 6, 37, 16, 5, -36 },
  { 3401, 9, 45, 16, 2, -36 },
  { 3452, 31, 31, 38, 3, -39 },
  { 3573, 30, 16, 38, 4, -31 },
  { 3633, 31, 31, 38, 3, -39 },
  { 3754, 24, 49, 28, 2, -48 },
  { 3901, 51, 53, 59, 4, -47 },
  { 4239, 40, 47, 40, 0, -47 },
  { 4474, 31, 47, 42, 7, -47 },
  { 4657, 35, 49, 41, 4, -48 },
  { 4872, 36, 47, 47, 7, -47 },
  { 5084, 25, 47, 37, 7, -47 },
  { 5231, 26, 47, 33, 7, -47 },
  { 5384, 39, 49, 48, 4, -48 },
  { 5623, 34, 47, 48, 7, -47 },
  { 5823, 14, 47, 21, 3, -47 },
  { 5906, 16, 59, 17, -6, -47 },
  { 6024, 32, 47, 39, 7, -47 },
  { 6212, 26, 47, 34, 7, -47 },
  { 6365, 44, 47, 58, 7, -47 },
  { 6624, 35, 47, 48, 7, -47 },
  { 6830, 43, 49, 51, 4, -48 },
  { 7094, 28, 47, 39, 7, -47 },
  { 7259, 43, 59, 51, 4, -48 },
  { 7577, 31, 47, 40, 7, -47 },
  { 7760, 29, 49, 36, 4, -48 },
  { 7938, 35, 47, 35, 0, -47 },
  { 8144, 36, 48, 48, 6, -47 },
  { 8360, 38, 47, 38, 0, -47 },
  { 8584, 56, 47, 59, 2, -47 },
  { 8913, 36, 47, 36, 0, -47 },
  { 9125, 35, 47, 35, 0, -47 },
  { 9331, 33, 47, 38, 2, -47 },
  { 9525, 14, 57, 21, 6, -47 },
  { 9625, 21, 47, 23, 1, -47 },
  { 9749, 14, 57, 21, 2, -47 },
  { 9849, 32, 29, 38, 3, -47 },
  { 9965, 28, 3, 28, 0, 6 },
  { 9976, 12, 11, 17, 3, -51 },
  { 9993, 27, 37, 35, 3, -36 },
  { 10118, 30, 51, 40, 6, -50 },
  { 10310, 25, 37, 31, 4, -36 },
  { 10426, 30, 51, 40, 4, -50 },
  { 10618, 29, 37, 36, 4, -36 },
  { 10753, 23, 50, 20, 1, -50 },
  { 10897, 30, 52, 40, 4, -36 },
  { 11092, 28, 50, 39, 6, -50 },
  { 11267, 5, 48, 15, 5, -48 },
  { 11297, 13, 64, 15, -3, -48 },
  { 11401, 26, 50, 33, 6, -50 },
  { 11564, 4, 50, 15, 6, -50 },
  { 11589, 48, 36, 59, 6, -36 },
  { 11805, 28, 36, 39, 6, -36 },
  { 11931, 31, 37, 39, 4, -36 },
  { 12075, 30, 52, 40, 6, -36 },
  { 12270, 30, 52, 40, 4, -36 },
  { 12465, 19, 36, 26, 6, -36 },
  { 12551, 25, 37, 31, 3, -36 },
  { 12667, 20, 45, 22, 1, -44 },
  { 12780, 28, 36, 39, 5, -35 },
  { 12906, 31, 35, 31, 0, -35 },
  { 13042, 47, 35, 49, 1, -35 },
  { 13248, 31, 35, 33, 1, -35 },
  { 13384, 31, 51, 31, 0, -35 },
  { 13582, 25, 35, 31, 3, -35 },
  { 13692, 19, 57, 24, 2, -47 },
  { 13828, 3, 66, 36, 16, -50 },
  { 13853, 20, 57, 24, 2, -47 },
  { 13996, 31, 7, 38, 3, -27 },
};

const GFXfont NotoSans_Light66pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light66pt7bBitmaps,
  (GFXglyph *)NotoSans_Light66pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _NOTOSANS_LIGHT66PT7B_H_
