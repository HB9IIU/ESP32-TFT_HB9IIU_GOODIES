#ifndef _NOTOSANS_LIGHT29PT7B_H_
#define _NOTOSANS_LIGHT29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light29pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB4, 0x92, 0x49, 0x24, 0x92, 0x01, 0x7E, 0xC7, 0x8F, 0x16,
  0x2C, 0x58, 0xB1, 0x42, 0x03, 0x04, 0x01, 0x82, 0x00, 0x83, 0x00, 0x41,
  0x80, 0x20, 0x80, 0x30, 0x40, 0x18, 0x20, 0xFF, 0xFF, 0x04, 0x18, 0x02,
  0x08, 0x01, 0x04, 0x01, 0x82, 0x00, 0xC3, 0x07, 0xFF, 0xFB, 0xFF, 0xFC,
  0x10, 0x40, 0x18, 0x20, 0x0C, 0x30, 0x04, 0x18, 0x02, 0x0C, 0x01, 0x04,
  0x00, 0x06, 0x00, 0x60, 0x1F, 0xC7, 0xFF, 0xC6, 0x2C, 0x60, 0xC6, 0x0C,
  0x60, 0xC6, 0x06, 0x60, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x66, 0x06, 0x30,
  0x61, 0x06, 0x10, 0x63, 0x06, 0x3F, 0x7E, 0x7F, 0x80, 0x60, 0x06, 0x00,
  0x60, 0x3C, 0x01, 0x06, 0x60, 0x30, 0xC2, 0x02, 0x08, 0x30, 0x60, 0x83,
  0x0C, 0x08, 0x30, 0x80, 0x83, 0x18, 0x08, 0x31, 0x00, 0x83, 0x31, 0x88,
  0x32, 0x7E, 0xC2, 0x6C, 0x26, 0xE4, 0xC3, 0x3C, 0xC8, 0x30, 0x18, 0x83,
  0x01, 0x08, 0x10, 0x30, 0x83, 0x02, 0x08, 0x30, 0x60, 0x83, 0x04, 0x0C,
  0x20, 0xC0, 0x46, 0x18, 0x03, 0xC0, 0x0F, 0x80, 0x07, 0x38, 0x03, 0x06,
  0x00, 0x80, 0xC0, 0x20, 0x30, 0x0C, 0x08, 0x03, 0x06, 0x00, 0x63, 0x00,
  0x0D, 0x80, 0x01, 0xC0, 0x01, 0xF0, 0x00, 0xC6, 0x02, 0x60, 0xC1, 0xB0,
  0x18, 0x6C, 0x03, 0x32, 0x00, 0x6C, 0x80, 0x0E, 0x30, 0x03, 0x8E, 0x01,
  0xB1, 0xC1, 0xC6, 0x3F, 0xC0, 0xC0, 0xFF, 0xFE, 0x0C, 0x61, 0x8C, 0x31,
  0x86, 0x18, 0x43, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC1, 0x06, 0x18, 0x60,
  0xC3, 0x06, 0x08, 0x30, 0xC1, 0x86, 0x0C, 0x30, 0x61, 0x82, 0x08, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x21, 0x86, 0x18, 0xC3, 0x18, 0x63, 0x00,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xC6, 0x3F, 0xFF, 0x0F, 0x00, 0xE0,
  0x09, 0x01, 0x98, 0x30, 0xC3, 0x0C, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x03, 0xFF, 0xE0, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x36, 0x66, 0x4C, 0xC0, 0xFF, 0xFC, 0x5F,
  0x80, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x06,
  0x01, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x06,
  0x01, 0x80, 0xC0, 0x00, 0x0F, 0x81, 0xEE, 0x18, 0x18, 0xC0, 0x6C, 0x03,
  0x60, 0x0B, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0F, 0x00, 0x78, 0x02, 0xC0, 0x32, 0x01, 0x98, 0x18, 0x71,
  0xC1, 0xF8, 0x00, 0x06, 0x1C, 0xFB, 0x3C, 0x70, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x1F, 0x83,
  0xDE, 0x30, 0x18, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x60, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x01, 0x00,
  0x18, 0x01, 0x80, 0x18, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xC1, 0xF7,
  0xC6, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00,
  0x30, 0x0F, 0x01, 0xFC, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0,
  0x03, 0x00, 0x08, 0x00, 0x68, 0x01, 0xB8, 0x1C, 0x7F, 0xC0, 0x00, 0x30,
  0x00, 0xE0, 0x03, 0xC0, 0x05, 0x80, 0x1B, 0x00, 0x66, 0x01, 0x8C, 0x02,
  0x18, 0x0C, 0x30, 0x30, 0x60, 0x40, 0xC1, 0x01, 0x86, 0x03, 0x18, 0x06,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x7F, 0xE3, 0xFF, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x00, 0x08, 0x00, 0x44, 0x03, 0xFE, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xA0, 0x0D, 0xC1, 0xC7, 0xF8,
  0x00, 0x03, 0xF0, 0x71, 0x86, 0x00, 0x60, 0x06, 0x00, 0x20, 0x03, 0x00,
  0x18, 0x00, 0xC7, 0x86, 0xFF, 0x28, 0x0D, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1B, 0x00, 0xD8, 0x0C, 0x70, 0xC0, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06,
  0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C,
  0x00, 0x1F, 0x81, 0xCF, 0x18, 0x0D, 0x80, 0x6C, 0x01, 0x60, 0x19, 0x00,
  0xCC, 0x0C, 0x38, 0xC0, 0xFC, 0x07, 0xE0, 0x61, 0xC6, 0x03, 0x60, 0x0A,
  0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x0C, 0xE0, 0xC3, 0xFC, 0x00,
  0x1F, 0x81, 0xEE, 0x18, 0x19, 0x80, 0x6C, 0x03, 0x40, 0x0A, 0x00, 0x70,
  0x03, 0x80, 0x1E, 0x01, 0xF0, 0x1E, 0xE1, 0xB3, 0xF9, 0x80, 0x08, 0x00,
  0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x31, 0x07, 0x07, 0xF0, 0x00, 0x5F,
  0x80, 0x00, 0x00, 0x00, 0xBF, 0x27, 0x70, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x66, 0x44, 0xC8, 0x00, 0x18, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x03, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x60, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x08, 0x00, 0x00, 0x7F,
  0x3F, 0xE8, 0x0C, 0x03, 0x00, 0x40, 0x10, 0x04, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x06, 0x01, 0x80, 0x60, 0x00, 0x00, 0x01, 0x00, 0x60,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x0F, 0xFE, 0x00, 0xE0, 0x0E, 0x06, 0x00,
  0x0C, 0x30, 0x00, 0x10, 0x80, 0x00, 0x66, 0x07, 0xE0, 0x90, 0x39, 0xC3,
  0xC1, 0x83, 0x06, 0x0C, 0x0C, 0x18, 0x20, 0x30, 0x60, 0x80, 0x81, 0x86,
  0x02, 0x06, 0x08, 0x08, 0x38, 0x20, 0x60, 0xE0, 0xC1, 0xC2, 0xC1, 0xD9,
  0xB3, 0x03, 0xC3, 0x84, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x04, 0x00, 0x7F, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x1E, 0x00, 0x05, 0x80, 0x03, 0x20, 0x00, 0xCC, 0x00, 0x23, 0x00,
  0x18, 0x40, 0x06, 0x18, 0x01, 0x02, 0x00, 0xC0, 0xC0, 0x20, 0x30, 0x1F,
  0xFC, 0x07, 0xFF, 0x81, 0x00, 0x60, 0xC0, 0x0C, 0x30, 0x03, 0x18, 0x00,
  0x46, 0x00, 0x19, 0x00, 0x06, 0xC0, 0x00, 0xC0, 0xFF, 0x03, 0xFF, 0x8C,
  0x03, 0x30, 0x06, 0xC0, 0x1B, 0x00, 0x6C, 0x01, 0xB0, 0x06, 0xC0, 0x33,
  0xFF, 0x8F, 0xFE, 0x30, 0x0C, 0xC0, 0x1B, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x6C, 0x03, 0xB0, 0xFC, 0xFF, 0xC0, 0x03, 0xF8, 0x1F,
  0xFC, 0x70, 0x09, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xF0, 0x70, 0x7F,
  0xC0, 0xFF, 0x00, 0xFF, 0xE0, 0xC0, 0x38, 0xC0, 0x1C, 0xC0, 0x0C, 0xC0,
  0x06, 0xC0, 0x06, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0C, 0xC0,
  0x1C, 0xC0, 0x38, 0xC7, 0xF0, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x00, 0x01, 0xFE, 0x07, 0xFF, 0xC7, 0x00, 0x46,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x06, 0x80, 0x03, 0x60, 0x01, 0x98, 0x00, 0xCE, 0x00, 0x61, 0xE0, 0xF0,
  0x7F, 0xF0, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x60, 0xFE, 0xF8, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x8F,
  0xE0, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x02,
  0x06, 0x8E, 0xFC, 0xC0, 0x0F, 0x00, 0x6C, 0x03, 0x30, 0x18, 0xC0, 0xC3,
  0x06, 0x0C, 0x30, 0x31, 0x80, 0xCC, 0x03, 0x70, 0x0F, 0xC0, 0x39, 0x80,
  0xC3, 0x03, 0x06, 0x0C, 0x18, 0x30, 0x30, 0xC0, 0x63, 0x01, 0xCC, 0x03,
  0x30, 0x06, 0xC0, 0x0C, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x7F, 0xFF, 0xFE, 0xE0, 0x00, 0x7C,
  0x00, 0x1E, 0x80, 0x03, 0xD8, 0x00, 0x5B, 0x00, 0x1B, 0x30, 0x02, 0x76,
  0x00, 0xCE, 0x40, 0x19, 0xCC, 0x02, 0x39, 0x80, 0xC7, 0x10, 0x10, 0xE3,
  0x06, 0x1C, 0x20, 0xC3, 0x86, 0x10, 0x70, 0xC6, 0x0E, 0x08, 0x81, 0xC1,
  0xB0, 0x38, 0x16, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x04, 0x02, 0xC0,
  0x03, 0xC0, 0x07, 0x80, 0x0D, 0x80, 0x1B, 0x80, 0x33, 0x00, 0x63, 0x00,
  0xC6, 0x01, 0xC6, 0x03, 0x86, 0x07, 0x0C, 0x0E, 0x0C, 0x1C, 0x0C, 0x38,
  0x18, 0x70, 0x18, 0xE0, 0x19, 0xC0, 0x33, 0x80, 0x37, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x60, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0x80, 0x70, 0xC0, 0x0E,
  0x60, 0x01, 0x98, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x0D, 0x00, 0x03, 0x60, 0x01, 0x8C, 0x00, 0x63, 0x80, 0x30, 0x78, 0x78,
  0x07, 0xF8, 0x00, 0xFE, 0x07, 0xFE, 0x30, 0x19, 0x80, 0x6C, 0x01, 0x60,
  0x0B, 0x00, 0x78, 0x02, 0xC0, 0x36, 0x01, 0xB0, 0x39, 0xFF, 0x8F, 0x80,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0x80, 0x70, 0xC0, 0x0E, 0x60,
  0x01, 0x98, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0D,
  0x00, 0x03, 0x60, 0x01, 0x8C, 0x00, 0x63, 0x80, 0x30, 0x78, 0x78, 0x07,
  0xF8, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0xFF, 0x03, 0xFF, 0x8C, 0x07, 0x30, 0x0C, 0xC0, 0x13, 0x00, 0x6C,
  0x01, 0xB0, 0x04, 0xC0, 0x33, 0x01, 0x8C, 0x3C, 0x3F, 0xC0, 0xC1, 0x83,
  0x06, 0x0C, 0x0C, 0x30, 0x10, 0xC0, 0x63, 0x00, 0xCC, 0x03, 0x30, 0x06,
  0xC0, 0x1C, 0x1F, 0xC3, 0xFF, 0x60, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0x60, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x60, 0x03, 0x00,
  0x30, 0x01, 0x00, 0x10, 0x03, 0x00, 0x7C, 0x1E, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFC, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x09,
  0x80, 0x31, 0xE1, 0xC1, 0xFE, 0x00, 0xC0, 0x01, 0xE0, 0x00, 0x98, 0x00,
  0xCC, 0x00, 0x62, 0x00, 0x21, 0x80, 0x30, 0xC0, 0x18, 0x20, 0x18, 0x18,
  0x0C, 0x0C, 0x06, 0x03, 0x06, 0x01, 0x83, 0x00, 0xC1, 0x00, 0x31, 0x80,
  0x18, 0xC0, 0x04, 0x40, 0x03, 0x60, 0x01, 0xB0, 0x00, 0x50, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x80, 0x18, 0x01, 0xC0, 0x18, 0x03, 0xC0, 0x38, 0x03,
  0x40, 0x3C, 0x03, 0x60, 0x2C, 0x02, 0x60, 0x24, 0x06, 0x60, 0x66, 0x06,
  0x20, 0x66, 0x06, 0x30, 0x42, 0x0C, 0x30, 0x43, 0x0C, 0x30, 0xC3, 0x0C,
  0x10, 0xC3, 0x08, 0x18, 0x81, 0x18, 0x19, 0x81, 0x98, 0x19, 0x81, 0x98,
  0x09, 0x00, 0x90, 0x0D, 0x00, 0xB0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0xF0,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x60, 0x06, 0x60, 0x06, 0x30, 0x0C,
  0x18, 0x18, 0x18, 0x18, 0x0C, 0x30, 0x04, 0x20, 0x06, 0x60, 0x03, 0xC0,
  0x03, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x06, 0x40, 0x06, 0x60, 0x0C, 0x30,
  0x08, 0x30, 0x18, 0x18, 0x30, 0x0C, 0x20, 0x0C, 0x60, 0x06, 0xC0, 0x03,
  0xC0, 0x03, 0x60, 0x06, 0x60, 0x0C, 0x30, 0x0C, 0x30, 0x18, 0x18, 0x18,
  0x18, 0x30, 0x0C, 0x30, 0x0C, 0x60, 0x06, 0x60, 0x02, 0xC0, 0x03, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x7F, 0xFC, 0xFF, 0xF8, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x60, 0x01, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xFF, 0xFC, 0xC0, 0x10, 0x06,
  0x00, 0x80, 0x30, 0x0C, 0x01, 0x00, 0x60, 0x18, 0x02, 0x00, 0xC0, 0x10,
  0x06, 0x01, 0x80, 0x20, 0x0C, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0,
  0xFF, 0xF0, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0xFF, 0xF0, 0x01, 0x00, 0x0C, 0x00,
  0x38, 0x01, 0x20, 0x04, 0xC0, 0x31, 0x00, 0x86, 0x06, 0x0C, 0x10, 0x30,
  0xC0, 0x62, 0x01, 0x98, 0x03, 0xC0, 0x0C, 0xFF, 0xF0, 0xE1, 0x83, 0x07,
  0x03, 0x03, 0xFE, 0x20, 0x70, 0x03, 0x00, 0x30, 0x01, 0x00, 0x10, 0x7F,
  0x3C, 0x16, 0x01, 0x40, 0x3C, 0x03, 0xC0, 0x34, 0x05, 0x70, 0xD3, 0xF9,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x1C, 0x13,
  0xF8, 0xA0, 0x66, 0x01, 0xB0, 0x0D, 0x00, 0x28, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1E, 0x00, 0xB0, 0x0D, 0xC0, 0xCB, 0x0E, 0x4F, 0xC0,
  0x07, 0x83, 0xFC, 0xC0, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80,
  0x10, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0E, 0x18, 0xFF, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x3C, 0x67, 0xFB, 0x70,
  0x7B, 0x01, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x0E, 0xC0, 0x77, 0x0D, 0x8F, 0xCC, 0x07, 0x01,
  0xFC, 0x70, 0x66, 0x03, 0xC0, 0x3C, 0x01, 0x80, 0x1F, 0xFF, 0x80, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x31, 0xFE, 0x07, 0xE1,
  0x88, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x07, 0xFC, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x00, 0x0F, 0x01, 0xFE, 0xDC, 0x1E, 0xC0, 0x7C,
  0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x03, 0xB0, 0x1C, 0xC3, 0x63, 0xF3, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x68, 0x03, 0x3F, 0xF0, 0xFE, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x87, 0x09, 0xFC, 0xA0, 0x6C, 0x03, 0xC0, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x03, 0xDC, 0x00, 0x12, 0x49, 0x24, 0x92, 0x49, 0x24,
  0x0C, 0x1C, 0x00, 0x00, 0x00, 0x01, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x0C, 0x1B, 0xF7,
  0xC0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x06,
  0x81, 0x90, 0x62, 0x18, 0x46, 0x09, 0x81, 0x70, 0x2B, 0x06, 0x60, 0x86,
  0x10, 0x62, 0x06, 0x40, 0xC8, 0x0D, 0x00, 0xC0, 0xFF, 0xFF, 0xFC, 0x07,
  0x03, 0x85, 0xFC, 0x7F, 0x28, 0x36, 0x0D, 0x80, 0xE0, 0x6C, 0x06, 0x01,
  0x40, 0x30, 0x0E, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x60, 0x1C, 0x03,
  0x00, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x30, 0x0E,
  0x01, 0x80, 0x70, 0x0C, 0x03, 0x07, 0x09, 0xFC, 0xA0, 0x6C, 0x03, 0xC0,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x07, 0x00, 0xFF, 0x1C, 0x1C, 0xC0, 0x6C,
  0x01, 0xE0, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80,
  0x3C, 0x01, 0xB0, 0x18, 0xE1, 0x83, 0xF8, 0x07, 0x04, 0xFE, 0x28, 0x19,
  0x80, 0x6C, 0x03, 0x40, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x80, 0x2C, 0x03, 0x70, 0x3A, 0xC3, 0x93, 0xF8, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x00, 0x0F, 0x01, 0xFE,
  0xDC, 0x1E, 0xC0, 0x7C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x80, 0x3C, 0x03, 0xB0, 0x1D, 0xC3, 0x63, 0xF3, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07,
  0x9F, 0xA0, 0xC0, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x0F, 0x87, 0xFD, 0x80, 0xA0, 0x04, 0x00, 0xC0, 0x1C,
  0x00, 0xF0, 0x07, 0x80, 0x18, 0x01, 0x80, 0x10, 0x02, 0x00, 0xF8, 0x33,
  0xFC, 0x10, 0x08, 0x04, 0x06, 0x0F, 0xF8, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x18, 0x0C, 0x03, 0xE0, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x06, 0x80, 0x76, 0x03, 0xB8, 0x6C, 0xFE, 0x60,
  0xC0, 0x1D, 0x00, 0x66, 0x01, 0x18, 0x0C, 0x30, 0x30, 0xC0, 0x81, 0x06,
  0x06, 0x18, 0x18, 0xC0, 0x23, 0x00, 0xC8, 0x01, 0x60, 0x07, 0x80, 0x1C,
  0x00, 0x30, 0x00, 0xC0, 0x30, 0x1B, 0x03, 0x80, 0x98, 0x16, 0x0C, 0x40,
  0xB0, 0x62, 0x0C, 0x83, 0x18, 0x66, 0x10, 0xC2, 0x31, 0x82, 0x30, 0x8C,
  0x19, 0x84, 0x60, 0xC8, 0x32, 0x06, 0xC0, 0xB0, 0x16, 0x05, 0x80, 0xE0,
  0x38, 0x07, 0x01, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x3B, 0x03, 0x0C, 0x18,
  0x31, 0x81, 0x98, 0x06, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x4C, 0x06,
  0x30, 0x60, 0x86, 0x06, 0x30, 0x1B, 0x00, 0x60, 0xC0, 0x0D, 0x80, 0x66,
  0x01, 0x88, 0x0C, 0x30, 0x30, 0xC0, 0x81, 0x06, 0x06, 0x18, 0x08, 0x40,
  0x33, 0x00, 0xC8, 0x01, 0x60, 0x07, 0x80, 0x1C, 0x00, 0x30, 0x00, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0xB8, 0x03, 0xC0, 0x00, 0x7F,
  0xE0, 0x0C, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x01, 0x80, 0x20, 0x0C, 0x03,
  0x00, 0xC0, 0x18, 0x06, 0x01, 0x80, 0x3F, 0xF8, 0x01, 0x0F, 0x0C, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x30, 0xE0, 0xE0, 0x30, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x0C, 0x0F, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x78, 0x06, 0x03, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x80, 0x78, 0x3C, 0x30, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x30, 0xF0, 0x40, 0x00,
  0x78, 0x0F, 0xF8, 0xE0, 0xFC,
};

const GFXglyph NotoSans_Light29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 3, 21, 7, 2, -21 },
  { 9, 7, 8, 11, 2, -21 },
  { 16, 17, 21, 19, 1, -21 },
  { 61, 12, 24, 17, 2, -22 },
  { 97, 20, 21, 24, 2, -21 },
  { 150, 18, 21, 21, 2, -21 },
  { 198, 2, 8, 6, 2, -21 },
  { 200, 6, 26, 8, 1, -21 },
  { 220, 6, 26, 8, 1, -21 },
  { 240, 12, 12, 16, 2, -22 },
  { 258, 13, 14, 17, 2, -17 },
  { 281, 4, 7, 7, 1, -3 },
  { 285, 7, 2, 9, 1, -9 },
  { 287, 3, 3, 7, 2, -3 },
  { 289, 10, 21, 10, 0, -21 },
  { 316, 13, 21, 17, 2, -21 },
  { 351, 7, 21, 17, 3, -21 },
  { 370, 13, 21, 17, 2, -21 },
  { 405, 14, 21, 17, 1, -21 },
  { 442, 15, 21, 17, 1, -21 },
  { 482, 13, 21, 17, 2, -21 },
  { 517, 13, 21, 17, 2, -21 },
  { 552, 14, 21, 17, 1, -21 },
  { 589, 13, 21, 17, 2, -21 },
  { 624, 13, 21, 17, 2, -21 },
  { 659, 3, 16, 7, 2, -16 },
  { 665, 4, 20, 7, 1, -16 },
  { 675, 13, 13, 17, 2, -17 },
  { 697, 13, 7, 17, 2, -14 },
  { 709, 13, 13, 17, 2, -17 },
  { 731, 10, 21, 12, 1, -21 },
  { 758, 22, 24, 26, 2, -21 },
  { 824, 18, 21, 18, 0, -21 },
  { 872, 14, 21, 18, 3, -21 },
  { 909, 15, 21, 18, 2, -21 },
  { 949, 16, 21, 21, 3, -21 },
  { 991, 11, 21, 16, 3, -21 },
  { 1020, 11, 21, 15, 3, -21 },
  { 1049, 17, 21, 21, 2, -21 },
  { 1094, 15, 21, 21, 3, -21 },
  { 1134, 7, 21, 9, 1, -21 },
  { 1153, 8, 26, 7, -3, -21 },
  { 1179, 14, 21, 17, 3, -21 },
  { 1216, 11, 21, 15, 3, -21 },
  { 1245, 19, 21, 25, 3, -21 },
  { 1295, 15, 21, 21, 3, -21 },
  { 1335, 18, 21, 22, 2, -21 },
  { 1383, 13, 21, 17, 3, -21 },
  { 1418, 18, 26, 22, 2, -21 },
  { 1477, 14, 21, 17, 3, -21 },
  { 1514, 12, 21, 16, 2, -21 },
  { 1546, 15, 21, 15, 0, -21 },
  { 1586, 15, 21, 21, 3, -21 },
  { 1626, 17, 21, 17, 0, -21 },
  { 1671, 24, 21, 26, 1, -21 },
  { 1734, 16, 21, 16, 0, -21 },
  { 1776, 16, 21, 16, 0, -21 },
  { 1818, 15, 21, 17, 1, -21 },
  { 1858, 7, 26, 9, 2, -21 },
  { 1881, 10, 21, 10, 0, -21 },
  { 1908, 6, 26, 9, 1, -21 },
  { 1928, 14, 13, 17, 1, -21 },
  { 1951, 12, 1, 12, 0, 3 },
  { 1953, 6, 4, 8, 1, -22 },
  { 1956, 12, 16, 16, 1, -16 },
  { 1980, 13, 22, 17, 3, -22 },
  { 2016, 11, 16, 14, 2, -16 },
  { 2038, 13, 22, 17, 2, -22 },
  { 2074, 12, 16, 16, 2, -16 },
  { 2098, 11, 22, 9, 0, -22 },
  { 2129, 13, 23, 17, 2, -16 },
  { 2167, 12, 22, 17, 3, -22 },
  { 2200, 3, 21, 7, 2, -21 },
  { 2208, 7, 28, 7, -2, -21 },
  { 2233, 11, 22, 14, 3, -22 },
  { 2264, 1, 22, 7, 3, -22 },
  { 2267, 21, 16, 26, 3, -16 },
  { 2309, 12, 16, 17, 3, -16 },
  { 2333, 13, 16, 17, 2, -16 },
  { 2359, 13, 23, 17, 3, -16 },
  { 2397, 13, 23, 17, 2, -16 },
  { 2435, 8, 16, 11, 3, -16 },
  { 2451, 11, 16, 14, 1, -16 },
  { 2473, 9, 19, 10, 0, -19 },
  { 2495, 13, 15, 17, 2, -15 },
  { 2520, 14, 15, 14, 0, -15 },
  { 2547, 21, 15, 21, 0, -15 },
  { 2587, 13, 15, 15, 1, -15 },
  { 2612, 14, 22, 14, 0, -15 },
  { 2651, 11, 15, 13, 1, -15 },
  { 2672, 8, 26, 10, 1, -21 },
  { 2698, 2, 29, 16, 7, -22 },
  { 2706, 9, 26, 10, 1, -21 },
  { 2736, 13, 3, 17, 2, -12 },
};

const GFXfont NotoSans_Light29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light29pt7bBitmaps,
  (GFXglyph *)NotoSans_Light29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_LIGHT29PT7B_H_
