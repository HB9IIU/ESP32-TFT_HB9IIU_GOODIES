#ifndef _NOTOSANS_LIGHT42PT7B_H_
#define _NOTOSANS_LIGHT42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light42pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x00, 0x00, 0x6F, 0xF7, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x38, 0x0C, 0x00,
  0x18, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x03, 0x00, 0x03, 0x01, 0x80,
  0x01, 0x80, 0xC0, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x60, 0x1F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xE0, 0x18, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x06,
  0x00, 0x06, 0x03, 0x00, 0x03, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x01, 0x80,
  0x60, 0x00, 0xC0, 0x60, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE0, 0x18,
  0x0C, 0x00, 0x1C, 0x06, 0x00, 0x0C, 0x07, 0x00, 0x06, 0x03, 0x00, 0x03,
  0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x30, 0x00,
  0x60, 0x30, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x1F, 0xE0,
  0x1F, 0xFF, 0x9F, 0x23, 0xC7, 0x08, 0x13, 0x82, 0x00, 0xC0, 0x80, 0x30,
  0x20, 0x0C, 0x08, 0x03, 0x02, 0x00, 0xE0, 0x80, 0x1C, 0x20, 0x07, 0xC8,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0B, 0xE0, 0x02, 0x3C,
  0x00, 0x83, 0x80, 0x20, 0x60, 0x08, 0x1C, 0x02, 0x07, 0x00, 0x81, 0xC0,
  0x20, 0x60, 0x08, 0x3A, 0x02, 0x1C, 0xFE, 0xBF, 0x3F, 0xFF, 0x00, 0x7E,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x1F, 0x80, 0x03, 0x80,
  0xF7, 0x00, 0x1C, 0x07, 0x06, 0x00, 0x60, 0x18, 0x18, 0x03, 0x80, 0x60,
  0x30, 0x0C, 0x01, 0x80, 0xC0, 0x60, 0x0C, 0x03, 0x01, 0x80, 0x30, 0x0C,
  0x0C, 0x00, 0xC0, 0x30, 0x30, 0x03, 0x00, 0xC1, 0x80, 0x0C, 0x03, 0x0E,
  0x00, 0x38, 0x0C, 0x30, 0x00, 0x60, 0x31, 0xC7, 0xE1, 0x80, 0xC6, 0x3F,
  0xC6, 0x06, 0x31, 0x83, 0x8C, 0x18, 0xC6, 0x06, 0x3F, 0xC6, 0x30, 0x18,
  0x7E, 0x18, 0xC0, 0x70, 0x00, 0xC3, 0x00, 0xC0, 0x07, 0x0C, 0x03, 0x00,
  0x18, 0x30, 0x0C, 0x00, 0xE0, 0xC0, 0x30, 0x03, 0x03, 0x00, 0xC0, 0x18,
  0x0C, 0x03, 0x00, 0x60, 0x30, 0x1C, 0x03, 0x00, 0xC0, 0x60, 0x0C, 0x01,
  0x81, 0x80, 0x60, 0x06, 0x0E, 0x03, 0x80, 0x0F, 0xF0, 0x0C, 0x00, 0x1F,
  0x80, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0xC0, 0x1C, 0x00, 0x38, 0x03, 0x80, 0x07, 0x00, 0x70,
  0x00, 0x60, 0x0E, 0x00, 0x0C, 0x01, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x1C,
  0x1C, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x1C, 0x1C, 0x01, 0xC7, 0x01,
  0xC0, 0x39, 0xC0, 0x1C, 0x06, 0x30, 0x01, 0xC1, 0xC6, 0x00, 0x1C, 0x31,
  0xC0, 0x01, 0xCE, 0x38, 0x00, 0x1D, 0x87, 0x00, 0x01, 0xF0, 0x60, 0x00,
  0x1C, 0x0E, 0x00, 0x07, 0xC1, 0xE0, 0x03, 0xDC, 0x1E, 0x01, 0xF1, 0xC1,
  0xFF, 0xF8, 0x1C, 0x0F, 0xFC, 0x01, 0xC0, 0xFB, 0x6D, 0xB6, 0xDB, 0x00,
  0x07, 0x06, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0x30, 0x70, 0x60, 0x60, 0xE0,
  0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0,
  0xE0, 0xE0, 0x60, 0x60, 0x70, 0x30, 0x38, 0x18, 0x1C, 0x0C, 0x0E, 0x06,
  0x03, 0xE0, 0x38, 0x0E, 0x03, 0x01, 0xC0, 0x60, 0x38, 0x0C, 0x06, 0x03,
  0x80, 0xC0, 0x60, 0x30, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x60, 0x70, 0x38,
  0x18, 0x1C, 0x0C, 0x0C, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x18, 0x10, 0x37,
  0xE2, 0x3F, 0x7F, 0xFF, 0xC0, 0x7F, 0x00, 0x03, 0x80, 0x00, 0xD8, 0x00,
  0x3B, 0x80, 0x0E, 0x38, 0x01, 0x83, 0x00, 0x70, 0x70, 0x1C, 0x07, 0x00,
  0x80, 0x80, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x39, 0x8C, 0xE7, 0x31, 0x9C, 0xC6, 0x00, 0xFF,
  0xFF, 0xF0, 0x6F, 0xF7, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00,
  0x30, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00,
  0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00,
  0x60, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0xFF, 0xF0, 0x1E, 0x07, 0x81, 0x80, 0x18, 0x38, 0x01, 0xC3, 0x00, 0x0C,
  0x70, 0x00, 0xE7, 0x00, 0x0E, 0x60, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00,
  0x6E, 0x00, 0x06, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x66, 0x00, 0x06, 0x60,
  0x00, 0x66, 0x00, 0x06, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x30, 0x00, 0xC3,
  0x80, 0x1C, 0x1C, 0x03, 0x80, 0xE0, 0x78, 0x0F, 0xFF, 0x00, 0x3F, 0xC0,
  0x00, 0xC0, 0xF0, 0x7C, 0x3B, 0x3C, 0xDC, 0x3E, 0x0D, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x07, 0xFC, 0x03, 0xFF, 0xC1, 0xE0, 0x1C, 0x38, 0x01, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFC, 0x07, 0xFF, 0xE3, 0xE0, 0x1E, 0x30, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x0F, 0xF8, 0x01,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x3A, 0x00, 0x07, 0x70, 0x03, 0xCF, 0xFF, 0xF0, 0x7F,
  0xF8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x60, 0x00, 0x0D, 0x80, 0x00, 0x66, 0x00, 0x03, 0x98, 0x00, 0x1C, 0x60,
  0x00, 0x61, 0x80, 0x03, 0x06, 0x00, 0x1C, 0x18, 0x00, 0xE0, 0x60, 0x03,
  0x01, 0x80, 0x18, 0x06, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x01,
  0x80, 0xE0, 0x06, 0x07, 0x00, 0x18, 0x18, 0x00, 0x60, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0x82, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x68,
  0x00, 0x3B, 0x80, 0x3C, 0xFF, 0xFE, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x7F, 0xF0, 0x3C, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x70, 0x0C, 0x7F, 0xE1, 0x9E, 0x7E, 0x36, 0x00, 0xE7, 0x80, 0x0E, 0xE0,
  0x00, 0xDC, 0x00, 0x1B, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x3B, 0x00, 0x06, 0x60, 0x00, 0xCE, 0x00, 0x38, 0xE0,
  0x0E, 0x0E, 0x03, 0x80, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x1C, 0x03, 0x83, 0x80, 0x1C, 0x30, 0x00,
  0xC7, 0x00, 0x0C, 0x70, 0x00, 0xE7, 0x00, 0x0C, 0x30, 0x00, 0xC3, 0x80,
  0x1C, 0x38, 0x03, 0x81, 0xE0, 0x70, 0x07, 0x9E, 0x00, 0x3F, 0x80, 0x01,
  0xF8, 0x00, 0x7B, 0xE0, 0x1E, 0x07, 0x83, 0x80, 0x3C, 0x70, 0x00, 0xE6,
  0x00, 0x0E, 0x60, 0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00, 0x7E, 0x00, 0x06,
  0x60, 0x00, 0x67, 0x00, 0x0E, 0x70, 0x00, 0xC3, 0xC0, 0x3C, 0x1F, 0xFF,
  0x80, 0x7F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0xF0, 0x1C, 0x1C, 0x01,
  0xC7, 0x00, 0x1C, 0xC0, 0x01, 0x98, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x36, 0x00, 0x0E, 0xC0, 0x01,
  0xDC, 0x00, 0x79, 0xC0, 0x1B, 0x1F, 0x1E, 0x61, 0xFF, 0x8C, 0x03, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x0F, 0x03, 0xFF, 0x80,
  0x7F, 0xE0, 0x00, 0x6F, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x06, 0xFF, 0x70, 0x18, 0xF3, 0xCF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x8E, 0x38, 0xE3, 0x0C, 0x71, 0x86, 0x38,
  0x00, 0x00, 0x10, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00,
  0xE0, 0x00, 0x08, 0x00, 0x00, 0x3F, 0xF1, 0xFF, 0xF1, 0x80, 0x70, 0x00,
  0x70, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x40, 0x03, 0x18, 0x03, 0xFF, 0x81, 0x8C, 0x03, 0xC3, 0xC0, 0xCC,
  0x03, 0x80, 0xE0, 0x36, 0x03, 0x80, 0x70, 0x1B, 0x01, 0x80, 0x30, 0x0D,
  0x81, 0xC0, 0x18, 0x07, 0xC0, 0xC0, 0x0C, 0x03, 0xC0, 0x60, 0x06, 0x01,
  0xE0, 0x30, 0x03, 0x00, 0xF0, 0x18, 0x01, 0x80, 0x78, 0x0C, 0x00, 0xC0,
  0x6E, 0x06, 0x00, 0xE0, 0x33, 0x03, 0x80, 0x70, 0x19, 0x80, 0xE0, 0x6C,
  0x18, 0xC0, 0x3D, 0xE7, 0xB8, 0x60, 0x0F, 0xE1, 0xF8, 0x18, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x02, 0x00, 0x03, 0xC0,
  0x0F, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x37, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x01, 0x86,
  0x00, 0x00, 0xE1, 0x80, 0x00, 0x30, 0x70, 0x00, 0x0C, 0x0C, 0x00, 0x07,
  0x03, 0x00, 0x01, 0x80, 0xE0, 0x00, 0xE0, 0x18, 0x00, 0x38, 0x07, 0x00,
  0x0C, 0x00, 0xC0, 0x07, 0x00, 0x30, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x0C, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x01, 0x80,
  0x00, 0xE0, 0x60, 0x00, 0x38, 0x38, 0x00, 0x06, 0x0C, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x31, 0xC0, 0x00, 0x0E, 0x60, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0x70, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xE0, 0x0F, 0xCE, 0x00, 0x1C, 0xE0,
  0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00, 0x6E,
  0x00, 0x06, 0xE0, 0x00, 0xEE, 0x00, 0x1C, 0xE0, 0x03, 0x8F, 0xFF, 0xF0,
  0xFF, 0xFE, 0x0E, 0x01, 0xF8, 0xE0, 0x01, 0xCE, 0x00, 0x0E, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0E, 0xE0, 0x01, 0xEE, 0x00, 0x7C, 0xFF,
  0xFF, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0xF0, 0x7C, 0x01,
  0x83, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x06, 0x03, 0xFF, 0xF8,
  0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x03, 0x80, 0x3F, 0x07,
  0x00, 0x0F, 0x0E, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x38, 0x00, 0x06, 0x70,
  0x00, 0x0E, 0xE0, 0x00, 0x0D, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x70, 0x00, 0x1C,
  0xE0, 0x00, 0x79, 0xC0, 0x01, 0xE3, 0x80, 0x07, 0x87, 0x00, 0xFE, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0xFF, 0xFB,
  0xFF, 0xFD, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xFF, 0xFE, 0xFF, 0xFF, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFF, 0x07, 0xC0, 0x0E, 0x0F,
  0x00, 0x02, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0x60, 0x00, 0x03, 0x70, 0x00, 0x03, 0x70,
  0x00, 0x03, 0x38, 0x00, 0x03, 0x1C, 0x00, 0x03, 0x1E, 0x00, 0x03, 0x07,
  0xC0, 0x07, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x30, 0xFF, 0xFF, 0xC7, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x8F, 0xFF, 0xFC, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x06, 0x00, 0xC0, 0x38, 0x07, 0x7F, 0xCF, 0xF0, 0x70, 0x00, 0xE0, 0x00,
  0x77, 0x00, 0x07, 0x38, 0x00, 0x71, 0xC0, 0x07, 0x0E, 0x00, 0x70, 0x70,
  0x07, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x00, 0xE0, 0x70, 0x07, 0x07, 0x00,
  0x38, 0x70, 0x01, 0xC7, 0x00, 0x0E, 0x70, 0x00, 0x73, 0xC0, 0x03, 0xBE,
  0x00, 0x1F, 0x38, 0x00, 0xF0, 0xE0, 0x07, 0x03, 0x80, 0x38, 0x1C, 0x01,
  0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x07, 0x03, 0x80, 0x38, 0x1C, 0x00,
  0xE0, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x00, 0x71, 0xC0, 0x01, 0xCE,
  0x00, 0x07, 0x70, 0x00, 0x3C, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFD, 0x80, 0x00, 0x1F, 0xDC,
  0x00, 0x01, 0xBC, 0xC0, 0x00, 0x1B, 0xCC, 0x00, 0x03, 0x3E, 0xE0, 0x00,
  0x33, 0xE6, 0x00, 0x07, 0x3E, 0x70, 0x00, 0x63, 0xE3, 0x00, 0x06, 0x3E,
  0x30, 0x00, 0xE3, 0xE3, 0x80, 0x0C, 0x3E, 0x18, 0x01, 0xC3, 0xE1, 0xC0,
  0x18, 0x3E, 0x0C, 0x01, 0x83, 0xE0, 0xC0, 0x38, 0x3E, 0x0E, 0x03, 0x03,
  0xE0, 0x60, 0x70, 0x3E, 0x07, 0x06, 0x03, 0xE0, 0x70, 0x60, 0x3E, 0x03,
  0x0E, 0x03, 0xE0, 0x38, 0xC0, 0x3E, 0x01, 0x9C, 0x03, 0xE0, 0x1D, 0x80,
  0x3E, 0x01, 0xD8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xE0,
  0x07, 0x00, 0x3E, 0x00, 0x60, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xDC, 0x00, 0x0F, 0x30, 0x00, 0x3C, 0xE0,
  0x00, 0xF1, 0xC0, 0x03, 0xC3, 0x00, 0x0F, 0x0E, 0x00, 0x3E, 0x1C, 0x00,
  0xF8, 0x30, 0x03, 0xE0, 0xE0, 0x0F, 0x81, 0xC0, 0x3E, 0x03, 0x00, 0xF8,
  0x0E, 0x03, 0xE0, 0x1C, 0x0F, 0x80, 0x30, 0x3E, 0x00, 0xE0, 0xF8, 0x01,
  0xC3, 0xE0, 0x07, 0x0F, 0x80, 0x0E, 0x3E, 0x00, 0x1C, 0xF8, 0x00, 0x33,
  0xE0, 0x00, 0xEF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x70, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00,
  0x3E, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x70, 0x70, 0x00,
  0x06, 0x1C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x03, 0x60, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x63, 0x80,
  0x00, 0x1C, 0x38, 0x00, 0x07, 0x07, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x78,
  0x07, 0xC0, 0x1E, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x3F, 0xFF, 0x8E, 0x01, 0xF3, 0x80, 0x0E, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xEE, 0x00, 0x73, 0x83, 0xF8, 0xFF,
  0xFC, 0x3F, 0xF0, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x00, 0x3E, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x70,
  0x70, 0x00, 0x06, 0x1C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0C, 0x60, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x03, 0x60, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0x70,
  0x00, 0x00, 0x6E, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0x63, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x07, 0x80, 0x00, 0xE0, 0x78,
  0x00, 0x78, 0x07, 0xC0, 0x1E, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0xE0, 0x1F, 0x0E, 0x00, 0x38, 0xE0, 0x01,
  0xCE, 0x00, 0x1C, 0xE0, 0x00, 0xCE, 0x00, 0x0C, 0xE0, 0x00, 0xCE, 0x00,
  0x0C, 0xE0, 0x00, 0xCE, 0x00, 0x1C, 0xE0, 0x01, 0x8E, 0x00, 0x38, 0xE0,
  0x0F, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x0E, 0x03, 0x80, 0xE0, 0x18, 0x0E,
  0x01, 0xC0, 0xE0, 0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0x07, 0x0E, 0x00, 0x30,
  0xE0, 0x03, 0x8E, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x0E, 0xE0, 0x00,
  0x6E, 0x00, 0x07, 0x07, 0xFF, 0x03, 0xFF, 0xF8, 0xF0, 0x07, 0x1C, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x70, 0x03, 0xCF, 0xFF, 0xF0,
  0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x70, 0x00, 0x19, 0xC0,
  0x00, 0xE3, 0x80, 0x07, 0x07, 0x80, 0x78, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0xE0, 0x00, 0x03, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0x70, 0x00,
  0x06, 0x30, 0x00, 0x0E, 0x38, 0x00, 0x0C, 0x38, 0x00, 0x1C, 0x18, 0x00,
  0x1C, 0x1C, 0x00, 0x18, 0x1C, 0x00, 0x38, 0x0C, 0x00, 0x38, 0x0E, 0x00,
  0x30, 0x06, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x03, 0x00,
  0xE0, 0x03, 0x80, 0xC0, 0x03, 0x81, 0xC0, 0x01, 0x81, 0xC0, 0x01, 0xC1,
  0x80, 0x00, 0xC3, 0x80, 0x00, 0xC3, 0x80, 0x00, 0xE3, 0x00, 0x00, 0x67,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x76, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x7E,
  0x00, 0x0E, 0x00, 0x06, 0x60, 0x00, 0xF0, 0x00, 0x66, 0x00, 0x0F, 0x00,
  0x0E, 0x70, 0x01, 0xB0, 0x00, 0xE7, 0x00, 0x1B, 0x80, 0x0C, 0x30, 0x01,
  0x98, 0x00, 0xC3, 0x00, 0x39, 0x80, 0x1C, 0x38, 0x03, 0x18, 0x01, 0xC1,
  0x80, 0x31, 0xC0, 0x18, 0x18, 0x03, 0x0C, 0x01, 0x81, 0xC0, 0x70, 0xC0,
  0x38, 0x1C, 0x06, 0x0E, 0x03, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x0C, 0x0E,
  0x06, 0x07, 0x00, 0xE0, 0xC0, 0x70, 0x70, 0x0E, 0x0C, 0x07, 0x06, 0x00,
  0x60, 0xC0, 0x30, 0x60, 0x06, 0x1C, 0x03, 0x0E, 0x00, 0x71, 0x80, 0x38,
  0xE0, 0x07, 0x18, 0x01, 0x8C, 0x00, 0x33, 0x80, 0x18, 0xC0, 0x03, 0x38,
  0x01, 0xDC, 0x00, 0x3B, 0x00, 0x1D, 0xC0, 0x01, 0xB0, 0x00, 0xD8, 0x00,
  0x1B, 0x00, 0x0D, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x1C, 0x70, 0x00, 0x30, 0xE0, 0x00, 0xE0, 0xE0, 0x03, 0x80, 0xC0, 0x06,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x70, 0x01, 0x80, 0xC0, 0x03, 0x83, 0x80,
  0x03, 0x86, 0x00, 0x03, 0x1C, 0x00, 0x07, 0x70, 0x00, 0x06, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x6C, 0x00, 0x01,
  0xDC, 0x00, 0x07, 0x1C, 0x00, 0x0C, 0x18, 0x00, 0x38, 0x38, 0x00, 0x60,
  0x38, 0x01, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0C, 0x00, 0x60, 0x38, 0x00,
  0xE0, 0xE0, 0x00, 0xE1, 0x80, 0x00, 0xC7, 0x00, 0x01, 0xDC, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x0E, 0xC0, 0x00, 0x39, 0xC0, 0x00, 0xE1, 0xC0, 0x01,
  0xC3, 0x80, 0x07, 0x03, 0x80, 0x0E, 0x03, 0x00, 0x38, 0x07, 0x00, 0x60,
  0x06, 0x01, 0xC0, 0x0E, 0x03, 0x00, 0x0C, 0x0E, 0x00, 0x1C, 0x18, 0x00,
  0x18, 0x70, 0x00, 0x38, 0xC0, 0x00, 0x33, 0x80, 0x00, 0x76, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x80, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF,
  0xE0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80,
  0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0xE0, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80,
  0x06, 0x00, 0x1C, 0x00, 0x30, 0xFF, 0xFF, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x7F, 0xFF, 0xF8, 0x00,
  0x60, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1B, 0x80, 0x01, 0x98, 0x00,
  0x31, 0xC0, 0x03, 0x0C, 0x00, 0x60, 0xE0, 0x06, 0x06, 0x00, 0xC0, 0x70,
  0x0C, 0x03, 0x01, 0xC0, 0x38, 0x18, 0x01, 0x83, 0x80, 0x1C, 0x30, 0x00,
  0xC7, 0x00, 0x0E, 0x60, 0x00, 0x6E, 0x00, 0x07, 0xC0, 0x00, 0x30, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0x80, 0x01,
  0xE0, 0x07, 0xFE, 0x0F, 0xC7, 0xC2, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x7F, 0xE1, 0xFF,
  0xF3, 0xE0, 0x1B, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x01, 0xFC, 0x00, 0xF7, 0x01, 0xD9, 0xFF, 0xCC, 0x7F, 0x86,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x3E, 0x03,
  0x1F, 0xF8, 0x67, 0x8F, 0x8D, 0x80, 0x79, 0xE0, 0x07, 0x38, 0x00, 0x77,
  0x00, 0x0E, 0xE0, 0x00, 0xD8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xDC,
  0x00, 0x1B, 0x80, 0x07, 0x70, 0x00, 0xCF, 0x00, 0x39, 0xB0, 0x0E, 0x33,
  0xFF, 0x86, 0x3F, 0xE0, 0x00, 0x7C, 0x01, 0xFF, 0xC3, 0xF3, 0xC3, 0xC0,
  0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xE0,
  0x10, 0x7F, 0xF8, 0x0F, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x0F, 0x07, 0x07, 0xFE, 0x70, 0xF0, 0xF7, 0x1C,
  0x03, 0xF3, 0x80, 0x1F, 0x30, 0x00, 0xF7, 0x00, 0x0F, 0x60, 0x00, 0x76,
  0x00, 0x07, 0x60, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x76, 0x00, 0x07, 0x60, 0x00, 0x76, 0x00, 0x07, 0x70, 0x00,
  0xF3, 0x00, 0x0F, 0x38, 0x01, 0xF1, 0xC0, 0x37, 0x0F, 0xFE, 0x70, 0x7F,
  0xC3, 0x00, 0xF0, 0x00, 0xFF, 0xC0, 0x3C, 0x3C, 0x0E, 0x01, 0xC3, 0x80,
  0x1C, 0x60, 0x03, 0x9C, 0x00, 0x33, 0x00, 0x07, 0x60, 0x00, 0xEC, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x0C, 0x1F, 0xFF, 0x80, 0xFF, 0xE0, 0x01, 0xFC, 0x0F, 0xF0,
  0x70, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x0F, 0xFE, 0x3F, 0xF8, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xCC, 0x3E, 0x3D, 0x8E,
  0x01, 0xF3, 0x80, 0x1E, 0x60, 0x01, 0xDC, 0x00, 0x3B, 0x00, 0x03, 0x60,
  0x00, 0x6C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xD8, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x6E, 0x00, 0x1C, 0xC0,
  0x03, 0x9C, 0x00, 0xF1, 0xC0, 0x36, 0x1F, 0xFC, 0xC1, 0xFF, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x40, 0x03, 0x8E, 0x01, 0xE1, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x7C, 0x0C, 0x7F, 0xE3,
  0x38, 0x7C, 0xD8, 0x07, 0x3C, 0x00, 0xEE, 0x00, 0x1B, 0x80, 0x06, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x4E,
  0xF6, 0x00, 0x00, 0x06, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x60, 0x02, 0x03, 0x81, 0xE0, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x38, 0x39, 0xFC,
  0xF8, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0xB0,
  0x03, 0x98, 0x03, 0x8C, 0x03, 0x86, 0x01, 0x83, 0x01, 0x81, 0x81, 0xC0,
  0xC1, 0xC0, 0x61, 0xC0, 0x31, 0xC0, 0x19, 0xC0, 0x0D, 0xF0, 0x07, 0xDC,
  0x03, 0xC7, 0x01, 0xC3, 0x80, 0xC0, 0xE0, 0x60, 0x38, 0x30, 0x0E, 0x18,
  0x07, 0x0C, 0x01, 0xC6, 0x00, 0x73, 0x00, 0x1D, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x07, 0x83, 0x3F, 0xE0,
  0xFF, 0xCD, 0xE3, 0xE7, 0xCF, 0xB6, 0x03, 0xB8, 0x0E, 0xF0, 0x07, 0xC0,
  0x1F, 0x80, 0x1E, 0x00, 0x7E, 0x00, 0x38, 0x00, 0xF0, 0x00, 0xC0, 0x03,
  0xC0, 0x03, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x30, 0x00, 0xF0,
  0x00, 0xC0, 0x03, 0xC0, 0x03, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x3C, 0x00,
  0x30, 0x00, 0xF0, 0x00, 0xC0, 0x03, 0xC0, 0x03, 0x00, 0x0F, 0x00, 0x0C,
  0x00, 0x3C, 0x00, 0x30, 0x00, 0xF0, 0x00, 0xC0, 0x03, 0xC0, 0x03, 0x00,
  0x0F, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0xF0, 0x31,
  0xFF, 0x8C, 0xE1, 0xF3, 0x60, 0x1E, 0xF0, 0x03, 0xB8, 0x00, 0x6E, 0x00,
  0x1B, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1C, 0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x0F, 0x8F, 0x81, 0xC0, 0x1C, 0x38,
  0x00, 0xE3, 0x00, 0x0E, 0x70, 0x00, 0x76, 0x00, 0x07, 0x60, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0x60, 0x00, 0x36, 0x00, 0x07, 0x70, 0x00, 0x77, 0x00, 0x06, 0x38, 0x00,
  0xE3, 0x80, 0x1C, 0x1E, 0x03, 0xC0, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x01,
  0xF0, 0x18, 0xFF, 0xC3, 0x3C, 0x7C, 0x6C, 0x03, 0xCF, 0x00, 0x39, 0xC0,
  0x03, 0xB8, 0x00, 0x37, 0x00, 0x06, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x06, 0xE0, 0x00, 0xDC, 0x00, 0x3B, 0xC0, 0x06, 0x78, 0x01, 0xCD, 0xC0,
  0x71, 0x9F, 0xFC, 0x31, 0xFF, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0x8C, 0x3C,
  0x3D, 0x8E, 0x01, 0xF3, 0x80, 0x1E, 0x60, 0x01, 0xDC, 0x00, 0x3B, 0x00,
  0x03, 0x60, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x6E, 0x00,
  0x1C, 0xC0, 0x03, 0x9C, 0x00, 0xF1, 0xC0, 0x36, 0x1F, 0xFC, 0xC1, 0xFF,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x01, 0xEC, 0x7F, 0xCF, 0x7D, 0x80, 0xF0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00,
  0x03, 0xF0, 0x1F, 0xFE, 0x3C, 0x3E, 0x70, 0x02, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x06, 0xC0, 0x0E, 0xFF, 0xFC, 0x7F, 0xF0, 0x08, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x00,
  0xC0, 0x0F, 0xF0, 0x7F, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x07, 0x60, 0x01, 0xD8, 0x00, 0x77, 0x00, 0x3C, 0xE0,
  0x3B, 0x3F, 0xFC, 0xC3, 0xFC, 0x30, 0xE0, 0x00, 0x76, 0x00, 0x0E, 0x70,
  0x00, 0xE7, 0x00, 0x0C, 0x30, 0x01, 0xC3, 0x80, 0x18, 0x18, 0x01, 0x81,
  0xC0, 0x38, 0x1C, 0x03, 0x00, 0xC0, 0x70, 0x0E, 0x07, 0x00, 0x60, 0x60,
  0x06, 0x0E, 0x00, 0x70, 0xC0, 0x03, 0x0C, 0x00, 0x31, 0xC0, 0x03, 0x98,
  0x00, 0x19, 0x80, 0x01, 0xB0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0xC0, 0x07, 0x00, 0x1F, 0x00, 0x38, 0x01, 0xF8, 0x01, 0xE0, 0x0E,
  0xC0, 0x1B, 0x00, 0x66, 0x00, 0xD8, 0x03, 0x38, 0x06, 0xE0, 0x38, 0xC0,
  0x63, 0x01, 0x86, 0x03, 0x18, 0x0C, 0x38, 0x18, 0xE0, 0x61, 0xC1, 0xC3,
  0x07, 0x06, 0x0C, 0x18, 0x30, 0x30, 0x60, 0xE1, 0x81, 0xC7, 0x03, 0x1C,
  0x0E, 0x30, 0x18, 0xE0, 0x31, 0x80, 0xE6, 0x01, 0x9C, 0x03, 0x30, 0x0E,
  0xC0, 0x1B, 0x80, 0x36, 0x00, 0xD8, 0x01, 0xB0, 0x03, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0xF0, 0x01, 0xE6,
  0x00, 0x30, 0xE0, 0x0E, 0x0E, 0x03, 0x80, 0xC0, 0x60, 0x1C, 0x1C, 0x01,
  0xC7, 0x00, 0x1D, 0xC0, 0x01, 0xB0, 0x00, 0x3E, 0x00, 0x03, 0x80, 0x00,
  0xF8, 0x00, 0x1B, 0x00, 0x07, 0x70, 0x01, 0xC7, 0x00, 0x30, 0x70, 0x0E,
  0x06, 0x03, 0x80, 0xE0, 0xE0, 0x0E, 0x18, 0x00, 0xC7, 0x00, 0x1D, 0xC0,
  0x01, 0xC0, 0xE0, 0x00, 0x76, 0x00, 0x0E, 0x70, 0x00, 0xE3, 0x00, 0x0C,
  0x30, 0x01, 0xC3, 0x80, 0x1C, 0x18, 0x01, 0x81, 0xC0, 0x38, 0x0C, 0x03,
  0x00, 0xC0, 0x70, 0x0E, 0x07, 0x00, 0x60, 0x60, 0x07, 0x0E, 0x00, 0x70,
  0xC0, 0x03, 0x0C, 0x00, 0x39, 0xC0, 0x01, 0x98, 0x00, 0x19, 0x80, 0x01,
  0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFF,
  0x7F, 0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x60, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x0F, 0xC0, 0xF0, 0x0E,
  0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x1C, 0x07, 0xC0, 0x3C,
  0x00, 0xF8, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0xFC, 0x01, 0xF0, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x07, 0xE0, 0x07, 0x80, 0x0E,
  0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0xC0,
  0x1E, 0x03, 0xE0, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00,
  0x70, 0x1F, 0x81, 0xF0, 0x0C, 0x00, 0x00, 0x3F, 0x80, 0x17, 0xFE, 0x03,
  0xE0, 0xFF, 0xF8, 0x03, 0xFC,
};

const GFXglyph NotoSans_Light42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 4, 30, 10, 3, -30 },
  { 16, 9, 11, 15, 3, -30 },
  { 29, 25, 30, 27, 1, -30 },
  { 123, 18, 34, 24, 3, -32 },
  { 200, 30, 30, 34, 2, -30 },
  { 313, 27, 30, 30, 2, -30 },
  { 415, 3, 11, 8, 3, -30 },
  { 420, 8, 37, 12, 2, -30 },
  { 457, 9, 37, 12, 1, -30 },
  { 499, 19, 18, 23, 2, -32 },
  { 542, 20, 20, 24, 2, -25 },
  { 592, 5, 10, 9, 2, -5 },
  { 599, 10, 2, 14, 2, -12 },
  { 602, 4, 4, 10, 3, -4 },
  { 604, 14, 30, 15, 0, -30 },
  { 657, 20, 30, 24, 2, -30 },
  { 732, 10, 30, 24, 4, -30 },
  { 770, 19, 30, 24, 2, -30 },
  { 842, 19, 30, 24, 2, -30 },
  { 914, 22, 30, 24, 1, -30 },
  { 997, 18, 30, 24, 3, -30 },
  { 1065, 19, 30, 24, 3, -30 },
  { 1137, 20, 30, 24, 2, -30 },
  { 1212, 20, 30, 24, 2, -30 },
  { 1287, 19, 30, 24, 2, -30 },
  { 1359, 4, 23, 10, 3, -23 },
  { 1371, 6, 28, 10, 1, -23 },
  { 1392, 20, 20, 24, 2, -25 },
  { 1442, 20, 10, 24, 2, -20 },
  { 1467, 20, 20, 24, 2, -25 },
  { 1517, 15, 30, 18, 1, -30 },
  { 1574, 33, 34, 37, 2, -30 },
  { 1715, 26, 30, 26, 0, -30 },
  { 1813, 20, 30, 27, 4, -30 },
  { 1888, 22, 30, 26, 3, -30 },
  { 1971, 23, 30, 30, 4, -30 },
  { 2058, 17, 30, 23, 4, -30 },
  { 2122, 17, 30, 21, 4, -30 },
  { 2186, 24, 30, 30, 3, -30 },
  { 2276, 22, 30, 30, 4, -30 },
  { 2359, 9, 30, 13, 2, -30 },
  { 2393, 11, 38, 11, -4, -30 },
  { 2446, 21, 30, 25, 4, -30 },
  { 2525, 17, 30, 22, 4, -30 },
  { 2589, 28, 30, 37, 4, -30 },
  { 2694, 22, 30, 31, 4, -30 },
  { 2777, 27, 30, 32, 3, -30 },
  { 2879, 18, 30, 25, 4, -30 },
  { 2947, 27, 37, 32, 3, -30 },
  { 3072, 20, 30, 25, 4, -30 },
  { 3147, 19, 30, 23, 2, -30 },
  { 3219, 22, 30, 22, 0, -30 },
  { 3302, 22, 30, 30, 4, -30 },
  { 3385, 24, 30, 24, 0, -30 },
  { 3475, 36, 30, 38, 1, -30 },
  { 3610, 23, 30, 23, 0, -30 },
  { 3697, 23, 30, 23, 0, -30 },
  { 3784, 21, 30, 24, 2, -30 },
  { 3863, 8, 37, 13, 4, -30 },
  { 3900, 14, 30, 15, 0, -30 },
  { 3953, 9, 37, 13, 1, -30 },
  { 3995, 20, 19, 24, 2, -30 },
  { 4043, 18, 2, 18, 0, 4 },
  { 4048, 7, 7, 11, 2, -32 },
  { 4055, 17, 23, 23, 2, -23 },
  { 4104, 19, 32, 25, 4, -32 },
  { 4180, 17, 23, 20, 2, -23 },
  { 4229, 20, 32, 25, 2, -32 },
  { 4309, 19, 23, 23, 2, -23 },
  { 4364, 14, 32, 13, 1, -32 },
  { 4420, 19, 33, 25, 2, -23 },
  { 4499, 18, 32, 25, 4, -32 },
  { 4571, 4, 31, 10, 3, -31 },
  { 4587, 9, 41, 10, -2, -31 },
  { 4634, 17, 32, 21, 4, -32 },
  { 4702, 2, 32, 10, 4, -32 },
  { 4710, 30, 23, 38, 4, -23 },
  { 4797, 18, 23, 25, 4, -23 },
  { 4849, 20, 23, 25, 2, -23 },
  { 4907, 19, 33, 25, 4, -23 },
  { 4986, 19, 33, 25, 2, -23 },
  { 5065, 12, 23, 17, 4, -23 },
  { 5100, 16, 23, 20, 2, -23 },
  { 5146, 12, 28, 14, 1, -28 },
  { 5188, 18, 22, 25, 3, -22 },
  { 5238, 20, 22, 20, 0, -22 },
  { 5293, 29, 22, 31, 1, -22 },
  { 5373, 19, 22, 21, 1, -22 },
  { 5426, 20, 32, 20, 0, -22 },
  { 5506, 16, 22, 19, 2, -22 },
  { 5550, 13, 37, 15, 1, -30 },
  { 5611, 2, 42, 23, 10, -32 },
  { 5622, 13, 37, 15, 1, -30 },
  { 5683, 20, 4, 24, 2, -17 },
};

const GFXfont NotoSans_Light42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light42pt7bBitmaps,
  (GFXglyph *)NotoSans_Light42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_LIGHT42PT7B_H_
