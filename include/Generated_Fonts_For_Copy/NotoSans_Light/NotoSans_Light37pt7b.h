#ifndef _NOTOSANS_LIGHT37PT7B_H_
#define _NOTOSANS_LIGHT37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light37pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFB, 0x6D, 0xB6, 0x92, 0x49, 0x00, 0x07, 0xFC, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x83, 0x83, 0x00, 0xC0, 0xC0, 0x03,
  0x03, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x00, 0x80, 0x80, 0x06, 0x02,
  0x00, 0x18, 0x18, 0x00, 0x60, 0x60, 0x7F, 0xFF, 0xFC, 0x04, 0x06, 0x00,
  0x30, 0x10, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x20,
  0x30, 0x01, 0x80, 0x80, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0x60, 0x60,
  0x01, 0x01, 0x80, 0x04, 0x04, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x03,
  0x03, 0x00, 0x0C, 0x0C, 0x00, 0x60, 0x20, 0x00, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x0F, 0xFC, 0x3F, 0xBE, 0x71, 0x82, 0x61, 0x80, 0xE1, 0x80,
  0xC1, 0x80, 0xE1, 0x80, 0x61, 0x80, 0x71, 0x80, 0x39, 0x80, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x01, 0xBE, 0x01, 0x8E, 0x01, 0x83, 0x01, 0x83,
  0x01, 0x83, 0x01, 0x83, 0x01, 0x83, 0x01, 0x87, 0xE1, 0x9E, 0xFF, 0xF8,
  0x1F, 0xE0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x0E, 0x00, 0x00, 0x0F,
  0xE0, 0x06, 0x06, 0x18, 0x03, 0x01, 0x83, 0x00, 0xC0, 0xC0, 0xC0, 0x60,
  0x30, 0x30, 0x18, 0x0C, 0x04, 0x0C, 0x03, 0x01, 0x83, 0x00, 0xC0, 0x61,
  0x80, 0x30, 0x18, 0xC0, 0x0C, 0x04, 0x30, 0x03, 0x03, 0x18, 0xF8, 0xC0,
  0xC6, 0x77, 0x18, 0x33, 0x38, 0x66, 0x18, 0xCC, 0x08, 0xFC, 0x63, 0x03,
  0x0E, 0x18, 0xC0, 0xC0, 0x0C, 0x20, 0x30, 0x06, 0x18, 0x0C, 0x01, 0x86,
  0x03, 0x00, 0xC0, 0x80, 0xC0, 0x30, 0x20, 0x30, 0x18, 0x0C, 0x0C, 0x06,
  0x03, 0x02, 0x03, 0x00, 0xC1, 0x80, 0xC0, 0x1C, 0xC0, 0x60, 0x03, 0xF0,
  0x01, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x06, 0x00,
  0x18, 0x06, 0x00, 0x18, 0x06, 0x00, 0x18, 0x06, 0x00, 0x18, 0x06, 0x00,
  0x1C, 0x0E, 0x00, 0x0C, 0x1C, 0x00, 0x06, 0x38, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1C, 0xE0, 0x0E, 0x38, 0x70, 0x0C,
  0x70, 0x38, 0x0C, 0x60, 0x1C, 0x0C, 0xE0, 0x06, 0x18, 0xC0, 0x03, 0x38,
  0xC0, 0x01, 0xB0, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0x60, 0x01, 0xF0,
  0x78, 0x07, 0x18, 0x3F, 0xFE, 0x0C, 0x0F, 0xF8, 0x07, 0xFF, 0xFE, 0x80,
  0x0E, 0x38, 0x61, 0x83, 0x0E, 0x18, 0x30, 0xE1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x30, 0x60, 0xC0, 0xC1,
  0x81, 0x83, 0x03, 0x03, 0xE0, 0x30, 0x30, 0x18, 0x18, 0x0C, 0x0C, 0x0E,
  0x06, 0x06, 0x06, 0x06, 0x07, 0x03, 0x03, 0x03, 0x03, 0x03, 0x07, 0x07,
  0x06, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0x60, 0xE0,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xC1, 0x83,
  0xF9, 0x9F, 0x7F, 0xFE, 0x01, 0xC0, 0x03, 0xC0, 0x06, 0x60, 0x06, 0x70,
  0x0C, 0x30, 0x1C, 0x18, 0x38, 0x1C, 0x08, 0x10, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x39,
  0xCC, 0x63, 0x31, 0x8C, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x30,
  0x03, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80,
  0x18, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x18, 0x01, 0x80, 0x38, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0E,
  0x00, 0x03, 0xE0, 0x07, 0xFC, 0x07, 0x07, 0x07, 0x01, 0xC3, 0x00, 0x63,
  0x00, 0x19, 0x80, 0x0C, 0xC0, 0x06, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x6C, 0x00, 0x76, 0x00, 0x33, 0x00, 0x19,
  0xC0, 0x1C, 0x60, 0x0C, 0x18, 0x0E, 0x0F, 0xBE, 0x01, 0xFC, 0x00, 0x07,
  0x87, 0xC7, 0xE7, 0x7E, 0x3E, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0x03, 0xC0, 0x0F, 0xFC, 0x1E, 0x0F, 0x0C,
  0x01, 0xC4, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xC0, 0x1F, 0xFC, 0x1E, 0x07, 0x18, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x03, 0x80, 0x03, 0x80, 0xFF, 0x00, 0x7F, 0x80, 0x01, 0xF0, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x80, 0x0E, 0x7F, 0xFE, 0x1F, 0xFC,
  0x00, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x36, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x0C, 0x60, 0x01, 0x86, 0x00,
  0x38, 0x60, 0x03, 0x06, 0x00, 0x60, 0x60, 0x0C, 0x06, 0x00, 0xC0, 0x60,
  0x18, 0x06, 0x03, 0x00, 0x60, 0x70, 0x06, 0x06, 0x00, 0x60, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x7F, 0xFC, 0x7F,
  0xFC, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0xDF, 0xE0, 0xFF, 0xF8, 0x40, 0x3C, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x80, 0x1C, 0xFF, 0xF8, 0x7F,
  0xE0, 0x00, 0x7E, 0x01, 0xFF, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0xFF, 0x0C, 0xF3, 0xE6, 0xC0, 0x3B, 0xC0, 0x0D, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x0C,
  0xC0, 0x0E, 0x60, 0x06, 0x1C, 0x06, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x03, 0xE0, 0x07, 0xFE, 0x0F,
  0x07, 0x86, 0x00, 0xC6, 0x00, 0x33, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x06,
  0x60, 0x03, 0x18, 0x03, 0x06, 0x03, 0x01, 0xC7, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x78, 0xF0, 0x70, 0x1C, 0x70, 0x07, 0x30, 0x01, 0xB0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x0E, 0xC0, 0x06, 0x70, 0x07,
  0x1F, 0xBF, 0x03, 0xFE, 0x00, 0x03, 0xC0, 0x0F, 0xFC, 0x0F, 0x07, 0x0E,
  0x01, 0xC6, 0x00, 0x67, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x76, 0x00, 0x3B, 0x80, 0x2C, 0xE0,
  0x76, 0x3F, 0xF3, 0x07, 0xE3, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x19, 0xF8,
  0x0F, 0xF0, 0x00, 0xFF, 0xA0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x39,
  0xCE, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x39, 0x8C, 0x66,
  0x31, 0x88, 0xC0, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x00,
  0xC0, 0x00, 0x00, 0x0F, 0x07, 0xFF, 0x38, 0x1D, 0x00, 0x70, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x0E,
  0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0xF0, 0x01, 0xC0, 0x0E, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x01,
  0xC6, 0x00, 0xFE, 0x06, 0x60, 0x1F, 0xF8, 0x33, 0x01, 0x80, 0xC0, 0xD8,
  0x18, 0x04, 0x07, 0x81, 0x80, 0x20, 0x3C, 0x0C, 0x03, 0x01, 0xE0, 0x60,
  0x18, 0x0F, 0x03, 0x00, 0xC0, 0x78, 0x18, 0x06, 0x03, 0xC0, 0xC0, 0x30,
  0x16, 0x06, 0x01, 0x81, 0xB0, 0x30, 0x1C, 0x0D, 0x80, 0xC1, 0xB0, 0xC6,
  0x07, 0xF8, 0xFC, 0x30, 0x0F, 0x83, 0xC1, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x01,
  0x00, 0x07, 0xC0, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00,
  0x19, 0x80, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00, 0x01, 0x86, 0x00, 0x03,
  0x06, 0x00, 0x0E, 0x0C, 0x00, 0x18, 0x1C, 0x00, 0x30, 0x18, 0x00, 0xC0,
  0x30, 0x01, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x70, 0x01, 0x80, 0xC0, 0x03, 0x81, 0x80, 0x03, 0x06, 0x00, 0x06,
  0x0C, 0x00, 0x06, 0x38, 0x00, 0x0C, 0x60, 0x00, 0x1C, 0xC0, 0x00, 0x1B,
  0x00, 0x00, 0x38, 0xFF, 0xF8, 0x60, 0xFF, 0x30, 0x03, 0xD8, 0x00, 0x6C,
  0x00, 0x36, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x03,
  0xB0, 0x03, 0x9F, 0xFF, 0x0F, 0xFF, 0x86, 0x00, 0xF3, 0x00, 0x1D, 0x80,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x1D, 0x80, 0x1E, 0xFF, 0xFC, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x1F, 0xFF, 0x07, 0xC0, 0xF0, 0xE0, 0x01, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0x00, 0x20, 0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x0C, 0x1F, 0xE0,
  0xC0, 0x0F, 0x0C, 0x00, 0x38, 0xC0, 0x01, 0xCC, 0x00, 0x0E, 0xC0, 0x00,
  0x6C, 0x00, 0x06, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x0E, 0xC0, 0x01, 0xCC,
  0x00, 0x18, 0xC0, 0x07, 0x8C, 0x01, 0xE0, 0xFF, 0xFC, 0x0F, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x07,
  0xFF, 0xF0, 0x3C, 0x07, 0x83, 0xC0, 0x02, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x0D, 0x80, 0x00, 0x36, 0x00, 0x00,
  0xD8, 0x00, 0x03, 0x70, 0x00, 0x0C, 0xE0, 0x00, 0x31, 0x80, 0x00, 0xC7,
  0x80, 0x03, 0x0F, 0x00, 0x0C, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0C, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x7E, 0xFF, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x30,
  0x1A, 0x3D, 0xFC, 0x78, 0x00, 0xC0, 0x03, 0xB0, 0x01, 0xCC, 0x00, 0xE3,
  0x00, 0x70, 0xC0, 0x38, 0x30, 0x1C, 0x0C, 0x0E, 0x03, 0x07, 0x00, 0xC3,
  0x80, 0x31, 0xC0, 0x0C, 0xE0, 0x03, 0x78, 0x00, 0xDF, 0x00, 0x3C, 0xE0,
  0x0E, 0x18, 0x03, 0x07, 0x00, 0xC0, 0xE0, 0x30, 0x1C, 0x0C, 0x03, 0x03,
  0x00, 0xE0, 0xC0, 0x1C, 0x30, 0x03, 0x8C, 0x00, 0x63, 0x00, 0x1C, 0xC0,
  0x03, 0xB0, 0x00, 0x70, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0x7F,
  0x00, 0x01, 0xFD, 0x80, 0x01, 0xBE, 0xC0, 0x00, 0xDF, 0x30, 0x00, 0x6F,
  0x98, 0x00, 0x67, 0xCC, 0x00, 0x33, 0xE3, 0x00, 0x31, 0xF1, 0x80, 0x18,
  0xF8, 0xE0, 0x0C, 0x7C, 0x30, 0x0C, 0x3E, 0x18, 0x06, 0x1F, 0x06, 0x06,
  0x0F, 0x83, 0x03, 0x07, 0xC1, 0xC1, 0x83, 0xE0, 0x61, 0x81, 0xF0, 0x30,
  0xC0, 0xF8, 0x0C, 0xC0, 0x7C, 0x06, 0x60, 0x3E, 0x03, 0xB0, 0x1F, 0x00,
  0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x1C, 0x03, 0xE0, 0x0C, 0x01, 0xC0,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3D, 0x80, 0x07,
  0xB8, 0x00, 0xF3, 0x80, 0x1E, 0x30, 0x03, 0xC7, 0x00, 0x78, 0x70, 0x0F,
  0x06, 0x01, 0xE0, 0xE0, 0x3C, 0x0E, 0x07, 0x80, 0xC0, 0xF0, 0x1C, 0x1E,
  0x01, 0xC3, 0xC0, 0x18, 0x78, 0x03, 0x8F, 0x00, 0x39, 0xE0, 0x03, 0x3C,
  0x00, 0x77, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x0C, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0x81, 0xF0, 0x0E,
  0x00, 0x38, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x0C, 0x30, 0x00, 0x0E, 0x70,
  0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x07, 0x60, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60,
  0x00, 0x06, 0x70, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x38, 0x00, 0x1C, 0x1C,
  0x00, 0x38, 0x0F, 0x00, 0x70, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0xFF,
  0xF0, 0xC3, 0xFC, 0xC0, 0x1C, 0xC0, 0x0E, 0xC0, 0x06, 0xC0, 0x07, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0E, 0xC0,
  0x3C, 0xFF, 0xF8, 0xFF, 0xE0, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0x81, 0xF0,
  0x0E, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x0C, 0x30, 0x00, 0x0E,
  0x70, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x07, 0x60, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07,
  0x60, 0x00, 0x06, 0x70, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x38, 0x00, 0x1C,
  0x1C, 0x00, 0x38, 0x0F, 0x00, 0x70, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0xFF, 0xF0, 0x60, 0xFE, 0x30, 0x07,
  0x98, 0x00, 0xCC, 0x00, 0x76, 0x00, 0x3B, 0x00, 0x0D, 0x80, 0x06, 0xC0,
  0x07, 0x60, 0x03, 0x30, 0x03, 0x98, 0x03, 0x8C, 0x07, 0x87, 0xFF, 0x83,
  0xFF, 0x01, 0x80, 0xC0, 0xC0, 0x70, 0x60, 0x18, 0x30, 0x0E, 0x18, 0x03,
  0x0C, 0x00, 0xC6, 0x00, 0x73, 0x00, 0x19, 0x80, 0x0E, 0xC0, 0x03, 0xE0,
  0x00, 0xC0, 0x03, 0xF0, 0x1F, 0xFF, 0x3C, 0x0E, 0x70, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x07, 0x80, 0x0E, 0xFF, 0xFC, 0x7F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03,
  0x60, 0x00, 0x77, 0x00, 0x06, 0x38, 0x00, 0xE1, 0xC0, 0x1C, 0x0F, 0xFF,
  0x80, 0x7F, 0xE0, 0xE0, 0x00, 0x1D, 0x80, 0x00, 0x66, 0x00, 0x03, 0x1C,
  0x00, 0x0C, 0x30, 0x00, 0x70, 0xC0, 0x01, 0x81, 0x80, 0x06, 0x06, 0x00,
  0x38, 0x1C, 0x00, 0xC0, 0x30, 0x03, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x60,
  0x06, 0x01, 0x80, 0x18, 0x0C, 0x00, 0x70, 0x30, 0x00, 0xC1, 0xC0, 0x03,
  0x06, 0x00, 0x06, 0x18, 0x00, 0x18, 0xE0, 0x00, 0x73, 0x00, 0x00, 0xCC,
  0x00, 0x03, 0x70, 0x00, 0x0D, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0xC0, 0x03, 0x80, 0x07, 0xC0, 0x07, 0x00, 0x0D, 0x80,
  0x0B, 0x00, 0x3B, 0x00, 0x36, 0x00, 0x66, 0x00, 0x6C, 0x00, 0xCE, 0x00,
  0xD8, 0x01, 0x8C, 0x03, 0x98, 0x07, 0x18, 0x06, 0x30, 0x0C, 0x30, 0x0C,
  0x60, 0x18, 0x30, 0x18, 0xE0, 0x30, 0x60, 0x60, 0xC0, 0xE0, 0xC0, 0xC1,
  0x81, 0x81, 0xC1, 0x83, 0x03, 0x01, 0x83, 0x03, 0x06, 0x03, 0x0C, 0x06,
  0x18, 0x06, 0x18, 0x0C, 0x30, 0x0E, 0x30, 0x1C, 0x60, 0x0C, 0xC0, 0x19,
  0xC0, 0x19, 0x80, 0x33, 0x00, 0x33, 0x00, 0x66, 0x00, 0x76, 0x00, 0x6C,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0,
  0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x70, 0x00, 0x73, 0x00,
  0x0C, 0x18, 0x01, 0xC1, 0xC0, 0x18, 0x0C, 0x03, 0x00, 0x60, 0x30, 0x07,
  0x06, 0x00, 0x30, 0xE0, 0x03, 0x8C, 0x00, 0x19, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xD8, 0x00, 0x19, 0xC0,
  0x03, 0x0C, 0x00, 0x70, 0xE0, 0x06, 0x06, 0x00, 0xE0, 0x30, 0x0C, 0x03,
  0x81, 0x80, 0x18, 0x38, 0x00, 0xC3, 0x00, 0x0E, 0x60, 0x00, 0x6E, 0x00,
  0x07, 0x60, 0x00, 0x76, 0x00, 0x0E, 0x30, 0x00, 0xC3, 0x00, 0x1C, 0x18,
  0x01, 0x81, 0xC0, 0x38, 0x0C, 0x03, 0x00, 0xE0, 0x70, 0x06, 0x06, 0x00,
  0x70, 0xC0, 0x03, 0x0C, 0x00, 0x39, 0x80, 0x01, 0x98, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xFF, 0xFF, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x30, 0x01,
  0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x30, 0x03, 0x00, 0x38, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x06, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0xFF, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0xFF, 0xFF, 0x00, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0D, 0x80,
  0x03, 0x60, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x30, 0x60, 0x0C, 0x18, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0xC0, 0x18, 0x30, 0x06, 0x18, 0x00, 0xC6, 0x00,
  0x33, 0x00, 0x06, 0xC0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x60,
  0x60, 0x60, 0x60, 0x40, 0x07, 0xE0, 0x7F, 0xF0, 0xC0, 0x70, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x1F, 0xFC, 0xF8,
  0x1B, 0x80, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F,
  0xC0, 0x6D, 0xF7, 0x99, 0xFE, 0x30, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC3,
  0xF0, 0x67, 0xFE, 0x36, 0x03, 0x9E, 0x00, 0xEE, 0x00, 0x37, 0x00, 0x1B,
  0x80, 0x0F, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0D, 0xC0, 0x06, 0xF0, 0x07, 0x6C,
  0x07, 0x33, 0xDF, 0x18, 0xFF, 0x00, 0x03, 0xF8, 0x3F, 0xF1, 0xC0, 0x4E,
  0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xE0, 0x11, 0xFF, 0xC1, 0xFF, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x07, 0xF1,
  0x87, 0xFC, 0xCF, 0x03, 0x66, 0x00, 0xF7, 0x00, 0x3B, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x0D, 0x80, 0x0E, 0xC0, 0x07, 0x70, 0x07, 0x9C, 0x06,
  0xC7, 0xDE, 0x61, 0xFE, 0x30, 0x03, 0xF0, 0x0F, 0xF8, 0x1C, 0x0C, 0x30,
  0x06, 0x70, 0x07, 0x60, 0x03, 0x60, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x38, 0x01, 0x1F, 0xBF, 0x07, 0xFE, 0x01, 0xF8, 0x3F,
  0xC1, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1F, 0xE7,
  0xFF, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x07, 0xF1, 0x8F, 0xFC, 0xCF,
  0x03, 0x66, 0x00, 0xF7, 0x00, 0x3B, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x0D, 0x80, 0x0E, 0xC0, 0x07, 0x70, 0x07, 0x9C, 0x06, 0xC7, 0xDE, 0x61,
  0xFE, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x03, 0x9C, 0x03, 0x8F, 0xFF, 0x80, 0xFF, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC3, 0xF0, 0xCF, 0xFC, 0xD8, 0x0E, 0xF0, 0x06, 0xE0, 0x07, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xDF, 0x80, 0x06, 0xDB, 0x6D, 0xB6, 0xDB,
  0x6D, 0xB6, 0xDB, 0x00, 0x06, 0x07, 0x07, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x0E, 0xFC, 0xF8, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x0F, 0x80, 0x33, 0x00,
  0xE6, 0x03, 0x8C, 0x0E, 0x18, 0x38, 0x30, 0xE0, 0x63, 0x80, 0xCE, 0x01,
  0x9C, 0x03, 0x6C, 0x07, 0x9C, 0x0E, 0x1C, 0x18, 0x18, 0x30, 0x18, 0x60,
  0x38, 0xC0, 0x39, 0x80, 0x33, 0x00, 0x36, 0x00, 0x70, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xE0, 0x3F, 0x19, 0xFF, 0x1F, 0xF3, 0x60,
  0x76, 0x07, 0x78, 0x07, 0x80, 0x7E, 0x00, 0xE0, 0x07, 0xC0, 0x1C, 0x00,
  0xF8, 0x01, 0x80, 0x1E, 0x00, 0x30, 0x03, 0xC0, 0x06, 0x00, 0x78, 0x00,
  0xC0, 0x0F, 0x00, 0x18, 0x01, 0xE0, 0x03, 0x00, 0x3C, 0x00, 0x60, 0x07,
  0x80, 0x0C, 0x00, 0xF0, 0x01, 0x80, 0x1E, 0x00, 0x30, 0x03, 0xC0, 0x06,
  0x00, 0x78, 0x00, 0xC0, 0x0F, 0x00, 0x18, 0x01, 0xE0, 0x03, 0x00, 0x30,
  0xC3, 0xF0, 0xCF, 0xFC, 0xD8, 0x0E, 0xF0, 0x06, 0xE0, 0x07, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xC0, 0xE0, 0xC0,
  0x1C, 0x70, 0x03, 0x98, 0x00, 0x66, 0x00, 0x1B, 0x80, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x66,
  0x00, 0x19, 0x80, 0x0E, 0x30, 0x03, 0x0E, 0x01, 0x81, 0xF7, 0xE0, 0x1F,
  0xE0, 0xC3, 0xF0, 0x67, 0xFE, 0x37, 0x03, 0x9A, 0x00, 0xEE, 0x00, 0x37,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x06, 0xF0,
  0x07, 0x6C, 0x07, 0x33, 0xDF, 0x18, 0xFF, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0xE1, 0x8F, 0xFC, 0xCF, 0x03, 0x66, 0x00, 0xF7,
  0x00, 0x3B, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x1D, 0x80, 0x0E, 0xC0,
  0x07, 0x70, 0x07, 0x9C, 0x06, 0xC7, 0xDE, 0x61, 0xFE, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0xC3, 0xF9, 0xFF, 0x70, 0x68, 0x0F, 0x01,
  0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x00, 0x1F, 0xE0, 0xFF,
  0xE6, 0x01, 0xB0, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0,
  0x03, 0x00, 0x1A, 0x00, 0xEF, 0x9F, 0x1F, 0xF8, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x3F, 0xFF, 0xFF, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0x30, 0x7F, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x0F, 0x70, 0x1B, 0x3E, 0xF3, 0x1F, 0xE3,
  0xC0, 0x01, 0xF0, 0x00, 0xD8, 0x00, 0xEC, 0x00, 0x63, 0x00, 0x31, 0x80,
  0x30, 0xE0, 0x18, 0x30, 0x1C, 0x18, 0x0C, 0x06, 0x06, 0x03, 0x06, 0x01,
  0x83, 0x00, 0x61, 0x80, 0x31, 0x80, 0x1C, 0xC0, 0x06, 0xE0, 0x03, 0x60,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0xC0, 0x0C, 0x01, 0xF0, 0x07,
  0x00, 0x6C, 0x01, 0xE0, 0x1B, 0x80, 0x78, 0x06, 0x60, 0x36, 0x03, 0x98,
  0x0D, 0xC0, 0xC6, 0x03, 0x30, 0x30, 0xC1, 0x8C, 0x0C, 0x30, 0x63, 0x07,
  0x0C, 0x18, 0x61, 0x83, 0x0C, 0x18, 0x60, 0x63, 0x06, 0x18, 0x18, 0xC0,
  0xCC, 0x06, 0x60, 0x33, 0x00, 0xD8, 0x0C, 0xC0, 0x36, 0x01, 0xB0, 0x0D,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xE0,
  0xE0, 0x03, 0x30, 0x03, 0x8C, 0x03, 0x87, 0x01, 0x81, 0xC1, 0x80, 0x61,
  0xC0, 0x18, 0xC0, 0x0E, 0xC0, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x7C, 0x00, 0x66, 0x00, 0x71, 0x80, 0x30, 0xE0, 0x30, 0x38, 0x38, 0x0C,
  0x18, 0x03, 0x18, 0x01, 0xDC, 0x00, 0x70, 0xC0, 0x01, 0xF0, 0x00, 0xD8,
  0x00, 0xEC, 0x00, 0x63, 0x00, 0x31, 0x80, 0x30, 0xE0, 0x18, 0x30, 0x1C,
  0x18, 0x0C, 0x06, 0x06, 0x03, 0x06, 0x01, 0xC3, 0x00, 0x61, 0x80, 0x31,
  0x80, 0x0C, 0xC0, 0x06, 0x60, 0x03, 0x60, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x03, 0x80, 0x03, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x00, 0x7F, 0xFE, 0xFF,
  0xFC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70,
  0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x07,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xE0, 0xF8, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x0E, 0x07, 0x00, 0xF8, 0x03, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x07, 0x00, 0x60, 0x0E, 0x00, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x0F, 0x80, 0x30, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0E,
  0x00, 0xE0, 0x07, 0x03, 0xE0, 0x60, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x38, 0x3E, 0x07,
  0x00, 0x3F, 0x00, 0xFF, 0xE0, 0xF0, 0x3F, 0xF0, 0x07, 0xC0,
};

const GFXglyph NotoSans_Light37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 3, 26, 9, 3, -26 },
  { 11, 8, 9, 13, 3, -26 },
  { 20, 22, 26, 24, 1, -26 },
  { 92, 16, 30, 21, 2, -28 },
  { 152, 26, 27, 30, 2, -27 },
  { 240, 24, 27, 27, 2, -27 },
  { 321, 2, 9, 7, 3, -26 },
  { 324, 7, 32, 10, 2, -26 },
  { 352, 8, 32, 10, 1, -26 },
  { 384, 16, 16, 20, 2, -28 },
  { 416, 17, 18, 21, 2, -22 },
  { 455, 5, 9, 8, 1, -4 },
  { 461, 9, 2, 12, 1, -11 },
  { 464, 3, 3, 9, 3, -3 },
  { 466, 12, 26, 13, 0, -26 },
  { 505, 17, 27, 21, 2, -27 },
  { 563, 9, 26, 21, 4, -26 },
  { 593, 17, 27, 21, 2, -27 },
  { 651, 17, 27, 21, 2, -27 },
  { 709, 20, 27, 21, 1, -27 },
  { 777, 16, 26, 21, 3, -26 },
  { 829, 17, 27, 21, 2, -27 },
  { 887, 17, 26, 21, 2, -26 },
  { 943, 17, 27, 21, 2, -27 },
  { 1001, 17, 27, 21, 2, -27 },
  { 1059, 3, 20, 9, 3, -20 },
  { 1067, 5, 25, 9, 1, -20 },
  { 1083, 17, 17, 21, 2, -22 },
  { 1120, 17, 10, 21, 2, -18 },
  { 1142, 17, 17, 21, 2, -22 },
  { 1179, 13, 27, 16, 1, -27 },
  { 1223, 29, 29, 33, 2, -26 },
  { 1329, 23, 27, 23, 0, -27 },
  { 1407, 17, 26, 23, 4, -26 },
  { 1463, 20, 27, 23, 2, -27 },
  { 1531, 20, 26, 26, 4, -26 },
  { 1596, 14, 26, 20, 4, -26 },
  { 1642, 14, 26, 19, 4, -26 },
  { 1688, 22, 27, 27, 2, -27 },
  { 1763, 19, 26, 27, 4, -26 },
  { 1825, 8, 26, 12, 2, -26 },
  { 1851, 9, 33, 9, -3, -26 },
  { 1889, 18, 26, 22, 4, -26 },
  { 1948, 14, 26, 19, 4, -26 },
  { 1994, 25, 26, 32, 4, -26 },
  { 2076, 19, 26, 27, 4, -26 },
  { 2138, 24, 27, 28, 2, -27 },
  { 2219, 16, 26, 22, 4, -26 },
  { 2271, 24, 33, 28, 2, -27 },
  { 2370, 17, 26, 22, 4, -26 },
  { 2426, 16, 27, 20, 2, -27 },
  { 2480, 19, 26, 20, 0, -26 },
  { 2542, 20, 26, 27, 3, -26 },
  { 2607, 22, 26, 22, 0, -26 },
  { 2679, 31, 26, 33, 1, -26 },
  { 2780, 20, 26, 20, 0, -26 },
  { 2845, 20, 26, 20, 0, -26 },
  { 2910, 19, 26, 21, 1, -26 },
  { 2972, 8, 32, 12, 3, -26 },
  { 3004, 12, 26, 13, 0, -26 },
  { 3043, 8, 32, 12, 1, -26 },
  { 3075, 18, 17, 21, 2, -27 },
  { 3114, 16, 2, 15, 0, 3 },
  { 3118, 7, 6, 10, 1, -28 },
  { 3124, 15, 20, 20, 2, -20 },
  { 3162, 17, 28, 22, 3, -28 },
  { 3222, 14, 20, 18, 2, -20 },
  { 3257, 17, 28, 22, 2, -28 },
  { 3317, 16, 20, 20, 2, -20 },
  { 3357, 13, 28, 11, 0, -28 },
  { 3403, 17, 29, 22, 2, -20 },
  { 3465, 16, 28, 22, 3, -28 },
  { 3521, 3, 27, 9, 3, -27 },
  { 3532, 8, 36, 9, -2, -27 },
  { 3568, 15, 28, 18, 3, -28 },
  { 3621, 2, 28, 9, 3, -28 },
  { 3628, 27, 20, 33, 3, -20 },
  { 3696, 16, 20, 22, 3, -20 },
  { 3736, 18, 20, 22, 2, -20 },
  { 3781, 17, 29, 22, 3, -20 },
  { 3843, 17, 29, 22, 2, -20 },
  { 3905, 11, 20, 15, 3, -20 },
  { 3933, 14, 20, 17, 2, -20 },
  { 3968, 12, 24, 13, 0, -24 },
  { 4004, 16, 20, 22, 3, -20 },
  { 4044, 17, 20, 17, 0, -20 },
  { 4087, 26, 20, 27, 1, -20 },
  { 4152, 17, 20, 19, 1, -20 },
  { 4195, 17, 29, 17, 0, -20 },
  { 4257, 15, 20, 17, 1, -20 },
  { 4295, 11, 32, 13, 1, -26 },
  { 4339, 2, 37, 20, 9, -28 },
  { 4349, 11, 32, 13, 1, -26 },
  { 4393, 17, 4, 21, 2, -15 },
};

const GFXfont NotoSans_Light37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light37pt7bBitmaps,
  (GFXglyph *)NotoSans_Light37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_LIGHT37PT7B_H_
