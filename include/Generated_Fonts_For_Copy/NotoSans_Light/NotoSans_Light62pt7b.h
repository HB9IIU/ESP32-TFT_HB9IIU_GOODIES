#ifndef _NOTOSANS_LIGHT62PT7B_H_
#define _NOTOSANS_LIGHT62PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light62pt7bBitmaps[] PROGMEM = {
  0x00, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xF7, 0x00, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1D, 0xC0, 0x77, 0x01, 0xDC, 0x07, 0x70, 0x1D, 0xC0, 0x77,
  0x01, 0xDC, 0x07, 0x70, 0x1D, 0x80, 0x76, 0x01, 0xD8, 0x07, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x30, 0x00,
  0x00, 0xE0, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x70, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x0E, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x1C,
  0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x0E, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00,
  0x78, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xEF, 0xFC, 0x3E, 0x0C, 0x07, 0x0F, 0x81,
  0x80, 0x21, 0xE0, 0x30, 0x00, 0x78, 0x06, 0x00, 0x0F, 0x00, 0xC0, 0x01,
  0xC0, 0x18, 0x00, 0x38, 0x03, 0x00, 0x07, 0x00, 0x60, 0x00, 0xF0, 0x0C,
  0x00, 0x1E, 0x01, 0x80, 0x01, 0xE0, 0x30, 0x00, 0x3E, 0x06, 0x00, 0x03,
  0xE0, 0xC0, 0x00, 0x3F, 0x18, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x06, 0x7F, 0x00, 0x00, 0xC1, 0xF8, 0x00, 0x18, 0x1F, 0x00, 0x03, 0x00,
  0xF0, 0x00, 0x60, 0x1E, 0x00, 0x0C, 0x01, 0xC0, 0x01, 0x80, 0x3C, 0x00,
  0x30, 0x07, 0x80, 0x06, 0x00, 0xF0, 0x00, 0xC0, 0x1C, 0x00, 0x18, 0x07,
  0x80, 0x03, 0x00, 0xF0, 0x00, 0x60, 0x3C, 0xC0, 0x0C, 0x0F, 0x9F, 0xC1,
  0x8F, 0xE3, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xE0, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x00, 0x3C, 0x07, 0x00, 0x01, 0xC0,
  0x03, 0x80, 0x78, 0x00, 0x38, 0x00, 0x70, 0x03, 0x80, 0x03, 0x80, 0x07,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x03, 0xC0, 0x07, 0x00, 0x07, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0xF0, 0x01, 0xC0, 0x1E, 0x00, 0x0F, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0xE0, 0x01, 0xC0, 0x3C, 0x00, 0x0E, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0xE0, 0x01, 0xC0, 0x78, 0x00, 0x0E, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0xF0, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0x70, 0x01, 0xC1, 0xC0, 0xFE, 0x07, 0x00, 0x3C, 0x3C, 0x3F, 0xF0, 0x70,
  0x03, 0x83, 0x87, 0xFF, 0x87, 0x80, 0x38, 0x78, 0xF0, 0x3C, 0x38, 0x07,
  0x87, 0x0E, 0x01, 0xC3, 0xC0, 0x70, 0xF0, 0xE0, 0x0E, 0x1E, 0x0F, 0x0E,
  0x1C, 0x00, 0xE0, 0xFF, 0xE1, 0xC1, 0xC0, 0x0E, 0x07, 0xFC, 0x1C, 0x1C,
  0x00, 0xF0, 0x3F, 0x03, 0x81, 0xC0, 0x07, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x70, 0x00, 0x07, 0x03, 0x80, 0x07, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x70,
  0x00, 0x0E, 0x03, 0x80, 0x07, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x70, 0x00,
  0x1C, 0x03, 0x80, 0x07, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x70, 0x00, 0x38,
  0x01, 0xC0, 0x07, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xF0, 0x01,
  0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x0E, 0x00, 0x1C, 0x00, 0x0E, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0xF0, 0x3C,
  0x00, 0x38, 0x00, 0x07, 0x87, 0x80, 0x07, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0x81, 0xF0, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0xF0,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x01,
  0xE0, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0x03, 0xE1, 0xF0,
  0x00, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x38,
  0x3E, 0x03, 0xE0, 0x00, 0xF0, 0xF0, 0x03, 0xE0, 0x01, 0xE3, 0xC0, 0x03,
  0xE0, 0x03, 0x87, 0x80, 0x03, 0xE0, 0x0F, 0x1E, 0x00, 0x03, 0xE0, 0x1E,
  0x3C, 0x00, 0x03, 0xE0, 0x78, 0x70, 0x00, 0x03, 0xE0, 0xF0, 0xE0, 0x00,
  0x03, 0xE3, 0xC1, 0xC0, 0x00, 0x03, 0xE7, 0x83, 0x80, 0x00, 0x03, 0xFE,
  0x07, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x1E, 0x00,
  0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0x1F, 0xE0, 0x3C, 0x00, 0x00, 0xFB,
  0xE0, 0x3E, 0x00, 0x03, 0xE3, 0xE0, 0x7F, 0x00, 0x1F, 0x83, 0xE0, 0x7F,
  0xFF, 0xFE, 0x03, 0xE0, 0x3F, 0xFF, 0xF0, 0x03, 0xE0, 0x1F, 0xFF, 0x80,
  0x03, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF7, 0x77, 0x77,
  0x77, 0x76, 0x66, 0x00, 0xF0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x70,
  0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80,
  0x78, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00,
  0x78, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1E, 0x01, 0xE0,
  0x0F, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00,
  0xF0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80,
  0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0x70,
  0x07, 0x80, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x60, 0x00, 0x80, 0x06, 0x00, 0x27,
  0x00, 0x60, 0x0E, 0x7E, 0x06, 0x07, 0xEF, 0xFC, 0x63, 0xFF, 0x3F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3B, 0xC0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0F,
  0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0x3C,
  0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x10, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x38, 0x38, 0x78,
  0x70, 0x70, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xB8, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x80, 0x07, 0xE0, 0xFE, 0x00, 0x7C, 0x00, 0xF0, 0x07, 0x80, 0x03,
  0xC0, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x1E,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7B, 0x80, 0x00,
  0x03, 0xDC, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x07,
  0xB8, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x0E, 0x78,
  0x00, 0x00, 0xF1, 0xC0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x3C, 0x78, 0x00,
  0x01, 0xC3, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x00,
  0xFF, 0x7F, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x7C, 0x03, 0xF8, 0x0F, 0xF0, 0x3C, 0xE1,
  0xF1, 0xC7, 0xC7, 0x9F, 0x0F, 0xF8, 0x1F, 0xE0, 0x3D, 0x80, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x01,
  0xFE, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0xF8, 0x10, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x03, 0xFE, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x7C,
  0x20, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0xC0,
  0x00, 0x07, 0xCF, 0x80, 0x01, 0xF8, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x78,
  0xE0, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x07,
  0x80, 0x01, 0xC0, 0x07, 0x80, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x70, 0x03,
  0xC0, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x07, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x81, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x87, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0,
  0x3F, 0x81, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x8C, 0x00, 0x01, 0xF8, 0xF8, 0x00,
  0x3F, 0x0F, 0xFE, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xE0, 0x08, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x3F, 0xF8, 0x0F, 0x0F,
  0xFF, 0xE0, 0xF3, 0xFD, 0xFF, 0x0E, 0x78, 0x00, 0xF8, 0xEF, 0x00, 0x07,
  0xCE, 0xC0, 0x00, 0x3C, 0xF8, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x0E, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x38, 0x00,
  0x00, 0xE3, 0xC0, 0x00, 0x1E, 0x1C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C,
  0x0F, 0x00, 0x07, 0x80, 0x7C, 0x01, 0xF8, 0x03, 0xFD, 0xFF, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00,
  0xFC, 0x07, 0xF0, 0x1F, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x3C, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x1C,
  0x70, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x01, 0xC7, 0x80,
  0x00, 0x3C, 0x38, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x0F,
  0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0x3F, 0x9F, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0x3F,
  0x80, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0x7C, 0x78, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0E, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3C, 0x7C, 0x00, 0x07,
  0xC3, 0xF0, 0x01, 0xF8, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0xF8, 0x01, 0xF0,
  0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x78,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x01,
  0xDE, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x77, 0x80, 0x00, 0x03, 0xDC,
  0x00, 0x00, 0x3E, 0xF0, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x1F, 0x9E, 0x00,
  0x00, 0xFC, 0xF0, 0x00, 0x0F, 0xE3, 0xC0, 0x01, 0xEE, 0x0F, 0x80, 0x3E,
  0x70, 0x3F, 0xFF, 0xE3, 0x80, 0xFF, 0xFC, 0x1C, 0x01, 0xFF, 0x80, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0xC0, 0x07, 0x87, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x27, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xDC, 0x04, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x3C,
  0x3C, 0x3C, 0x38, 0x38, 0x78, 0x70, 0x70, 0x60, 0xE0, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x3F,
  0x83, 0xFC, 0xE0, 0x01, 0xFA, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x70,
  0x70, 0x00, 0xFF, 0xFF, 0x80, 0x1C, 0x78, 0x00, 0xFC, 0x03, 0xC0, 0x0E,
  0x38, 0x00, 0xF8, 0x00, 0xE0, 0x07, 0x1C, 0x00, 0xF0, 0x00, 0x70, 0x03,
  0x9C, 0x00, 0x78, 0x00, 0x78, 0x01, 0xCE, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x77, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x3B, 0x80, 0x1C, 0x00, 0x0E, 0x00,
  0x1D, 0xC0, 0x1E, 0x00, 0x07, 0x00, 0x0E, 0xE0, 0x0E, 0x00, 0x03, 0x80,
  0x07, 0xF0, 0x07, 0x00, 0x01, 0xC0, 0x03, 0xF8, 0x03, 0x80, 0x00, 0xE0,
  0x03, 0xBC, 0x01, 0xC0, 0x00, 0x70, 0x01, 0xDE, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0xEF, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x73, 0x80, 0x3C, 0x00, 0x1E,
  0x00, 0x39, 0xC0, 0x0E, 0x00, 0x0F, 0x00, 0x38, 0xE0, 0x07, 0x00, 0x0F,
  0xC0, 0x1C, 0x70, 0x03, 0xC0, 0x0E, 0xE0, 0x1C, 0x38, 0x00, 0xF0, 0x0F,
  0x38, 0x1E, 0x1E, 0x00, 0x3F, 0x3F, 0x1F, 0x7E, 0x07, 0x00, 0x0F, 0xFF,
  0x07, 0xFE, 0x03, 0x80, 0x03, 0xFE, 0x01, 0xFC, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x00, 0x0E, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0E,
  0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0xE0,
  0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x70, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0x0F, 0x0E, 0x00,
  0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x00, 0x01,
  0xE7, 0x00, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x3C, 0x00, 0x07,
  0xF0, 0xF0, 0x00, 0x07, 0xE3, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x0F,
  0x3C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x01, 0xCF,
  0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x73, 0xC0,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x38, 0xF0, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xF8, 0x3F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0x00, 0x0F, 0xF8,
  0x3C, 0x00, 0x01, 0xF8, 0xF0, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1F,
  0x3C, 0x00, 0x01, 0xF8, 0xF0, 0x00, 0x3F, 0xC3, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFC, 0x1F, 0xE0,
  0x0F, 0xC0, 0x00, 0xF0, 0x1F, 0x80, 0x00, 0x08, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x07,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xC0, 0x00, 0xFF, 0x80, 0xF0, 0x00,
  0x07, 0xF0, 0x3C, 0x00, 0x00, 0x7E, 0x0F, 0x00, 0x00, 0x07, 0xC3, 0xC0,
  0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x07, 0xCF,
  0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x0F, 0x3C, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x00, 0xF8, 0xF0, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x3E, 0x0F, 0x00,
  0x00, 0x3F, 0x03, 0xC0, 0x00, 0x3F, 0x80, 0xF0, 0x00, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x1F,
  0x80, 0x00, 0x04, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x00, 0x77, 0x80, 0x00, 0x00, 0x07,
  0x78, 0x00, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00,
  0x00, 0x73, 0xE0, 0x00, 0x00, 0x07, 0x1F, 0x00, 0x00, 0x00, 0x70, 0xF0,
  0x00, 0x00, 0x07, 0x0F, 0x80, 0x00, 0x00, 0x70, 0x7E, 0x00, 0x00, 0x07,
  0x03, 0xF8, 0x00, 0x00, 0x70, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xC7, 0xF0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x01,
  0xFF, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x3C, 0x00, 0x78, 0x01, 0xE4, 0x0F, 0xCF, 0xFF, 0x1F, 0xFC, 0x3F, 0xE0,
  0x00, 0xF0, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x7C, 0x01,
  0xE0, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x0F,
  0x00, 0x7C, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x07, 0x8F, 0xC0, 0x00, 0x0F, 0x3F, 0x80, 0x00, 0x1E, 0xF7,
  0x80, 0x00, 0x3F, 0xCF, 0x80, 0x00, 0x7F, 0x0F, 0x80, 0x00, 0xFC, 0x0F,
  0x00, 0x01, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x07, 0x80, 0x1F,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x7C,
  0x03, 0xC0, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xEF, 0x00, 0x00, 0x00, 0x1F,
  0xFB, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x70, 0x00, 0x00, 0x03, 0xBF, 0xDE,
  0x00, 0x00, 0x01, 0xEF, 0xF7, 0x80, 0x00, 0x00, 0x73, 0xFC, 0xE0, 0x00,
  0x00, 0x1C, 0xFF, 0x3C, 0x00, 0x00, 0x0F, 0x3F, 0xC7, 0x00, 0x00, 0x03,
  0x8F, 0xF1, 0xE0, 0x00, 0x01, 0xE3, 0xFC, 0x78, 0x00, 0x00, 0x70, 0xFF,
  0x0E, 0x00, 0x00, 0x1C, 0x3F, 0xC3, 0xC0, 0x00, 0x0F, 0x0F, 0xF0, 0x70,
  0x00, 0x03, 0x83, 0xFC, 0x1E, 0x00, 0x01, 0xE0, 0xFF, 0x07, 0x80, 0x00,
  0x70, 0x3F, 0xC0, 0xE0, 0x00, 0x1C, 0x0F, 0xF0, 0x3C, 0x00, 0x0F, 0x03,
  0xFC, 0x07, 0x00, 0x03, 0x80, 0xFF, 0x01, 0xE0, 0x01, 0xE0, 0x3F, 0xC0,
  0x78, 0x00, 0x70, 0x0F, 0xF0, 0x0E, 0x00, 0x1C, 0x03, 0xFC, 0x03, 0xC0,
  0x0F, 0x00, 0xFF, 0x00, 0x70, 0x03, 0x80, 0x3F, 0xC0, 0x1E, 0x01, 0xE0,
  0x0F, 0xF0, 0x07, 0x80, 0x70, 0x03, 0xFC, 0x00, 0xE0, 0x1C, 0x00, 0xFF,
  0x00, 0x3C, 0x0F, 0x00, 0x3F, 0xC0, 0x07, 0x03, 0x80, 0x0F, 0xF0, 0x01,
  0xE1, 0xE0, 0x03, 0xFC, 0x00, 0x78, 0x78, 0x00, 0xFF, 0x00, 0x0E, 0x1C,
  0x00, 0x3F, 0xC0, 0x03, 0xCF, 0x00, 0x0F, 0xF0, 0x00, 0xF3, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0x78, 0x00,
  0x00, 0x1F, 0xBE, 0x00, 0x00, 0x0F, 0xCF, 0x00, 0x00, 0x07, 0xE3, 0xC0,
  0x00, 0x03, 0xF1, 0xF0, 0x00, 0x01, 0xF8, 0x78, 0x00, 0x00, 0xFE, 0x1E,
  0x00, 0x00, 0x7F, 0x0F, 0x80, 0x00, 0x3F, 0x83, 0xC0, 0x00, 0x1F, 0xC0,
  0xF0, 0x00, 0x0F, 0xE0, 0x7C, 0x00, 0x07, 0xF0, 0x1E, 0x00, 0x03, 0xF8,
  0x07, 0x80, 0x01, 0xFC, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0xF0, 0x00, 0x7F,
  0x00, 0x3C, 0x00, 0x3F, 0x80, 0x1F, 0x00, 0x1F, 0xC0, 0x07, 0x80, 0x0F,
  0xE0, 0x01, 0xE0, 0x07, 0xF0, 0x00, 0xF8, 0x03, 0xF8, 0x00, 0x3C, 0x01,
  0xFC, 0x00, 0x0F, 0x00, 0xFE, 0x00, 0x07, 0x80, 0x7F, 0x00, 0x01, 0xE0,
  0x3F, 0x80, 0x00, 0x78, 0x1F, 0xC0, 0x00, 0x3C, 0x0F, 0xE0, 0x00, 0x0F,
  0x07, 0xF0, 0x00, 0x03, 0xC3, 0xF8, 0x00, 0x01, 0xE1, 0xFC, 0x00, 0x00,
  0x78, 0xFE, 0x00, 0x00, 0x1E, 0x7F, 0x00, 0x00, 0x0F, 0x3F, 0x80, 0x00,
  0x03, 0xDF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x00,
  0x1C, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00,
  0x00, 0x0E, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0E, 0xF0,
  0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x3E, 0x00,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF8, 0x78, 0x00, 0x3F, 0x8F, 0x00, 0x01, 0xF9, 0xE0, 0x00,
  0x0F, 0xBC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x7E, 0x3C, 0x00, 0xFF, 0x87, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x70, 0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x01,
  0xE0, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x3C, 0x00, 0x1F, 0xC0, 0xF0, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x1F,
  0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x1F, 0x03, 0xC0, 0x07, 0xF8,
  0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0xF8, 0x03, 0xC0, 0x01, 0xE0, 0x0F, 0x00, 0x03, 0xC0, 0x3C, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1F, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0x83,
  0xFC, 0x1F, 0x80, 0x03, 0xC3, 0xE0, 0x00, 0x04, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x80, 0x00, 0x0F, 0x8F, 0x80,
  0x03, 0xF8, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0xF0, 0x3F, 0x00, 0x01, 0xF0, 0x0F, 0xE0, 0x03,
  0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF7, 0x00,
  0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x07, 0x80, 0xE0,
  0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x1E, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x3C, 0x00,
  0x00, 0x1C, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x78, 0x00, 0x03, 0xC3, 0x80,
  0x00, 0x3B, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0xCE, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x1C, 0x70, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xE3, 0xC0, 0x00,
  0x78, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x78, 0x70,
  0x00, 0x3C, 0x07, 0x80, 0x03, 0x83, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x1C,
  0x1E, 0x00, 0x0E, 0x00, 0xE0, 0x01, 0xE0, 0x70, 0x00, 0xF0, 0x07, 0x80,
  0x0F, 0x03, 0x80, 0x07, 0x80, 0x3C, 0x00, 0x70, 0x1E, 0x00, 0x3C, 0x01,
  0xE0, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x03, 0x80, 0x1E,
  0x00, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x01, 0xE0, 0x0E, 0x00, 0xF0,
  0x07, 0x80, 0x07, 0x00, 0xF0, 0x03, 0x80, 0x38, 0x00, 0x38, 0x07, 0x80,
  0x1C, 0x03, 0xC0, 0x01, 0xE0, 0x38, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x01,
  0xC0, 0x03, 0x80, 0xE0, 0x00, 0x38, 0x1E, 0x00, 0x1C, 0x0F, 0x00, 0x01,
  0xE0, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x78, 0x78, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0xE1,
  0xE0, 0x00, 0x0F, 0x1C, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x78, 0xE0, 0x00,
  0x1C, 0x78, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0E, 0x78,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x03,
  0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00,
  0x70, 0x78, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x07, 0x80, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x70,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x1E,
  0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x1C, 0x07,
  0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x03, 0xCE, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x78, 0x70, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x01,
  0xE0, 0x1C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0xE0,
  0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0xF0, 0x00,
  0x38, 0x03, 0x80, 0x00, 0xE0, 0x1E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07,
  0x03, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x03, 0xC0, 0x3E, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0x3F, 0xC0, 0xF0, 0x03, 0xE0,
  0x40, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x3F, 0xFF, 0x01, 0xFF,
  0xFF, 0x83, 0xFF, 0xE1, 0xC7, 0xF0, 0x00, 0xE7, 0xC0, 0x00, 0x77, 0xC0,
  0x00, 0x3B, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFB, 0xC0, 0x01, 0xDD, 0xF0, 0x03, 0xCE, 0x7F, 0x8F, 0xC7,
  0x1F, 0xFF, 0xC3, 0x83, 0xFF, 0x81, 0xC0, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x01, 0x80,
  0x03, 0xC1, 0xFF, 0xE0, 0x1E, 0x1F, 0xFF, 0xC0, 0xF3, 0xFD, 0xFF, 0x07,
  0xBE, 0x00, 0x7C, 0x3D, 0xC0, 0x01, 0xF1, 0xFC, 0x00, 0x07, 0x8F, 0xC0,
  0x00, 0x1E, 0x7E, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x03, 0xDF, 0x00, 0x00,
  0x1E, 0xF8, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x1D,
  0xE0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xBC, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F,
  0x7C, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x03, 0x9F, 0x00, 0x00, 0x3C, 0xFC,
  0x00, 0x03, 0xE7, 0xF0, 0x00, 0x1E, 0x3F, 0xC0, 0x01, 0xE1, 0xEF, 0x00,
  0x3F, 0x0E, 0x3F, 0x9F, 0xF0, 0x70, 0xFF, 0xFE, 0x03, 0x81, 0xFF, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xFC, 0x01, 0xFF,
  0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xC0, 0x06, 0x1F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0,
  0x06, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0xF0, 0x0F, 0x00, 0xFF, 0xE0, 0xF0, 0x3F, 0xFF, 0x8F, 0x07, 0xF9, 0xFC,
  0xF0, 0xF8, 0x01, 0xEF, 0x1F, 0x00, 0x07, 0xF3, 0xC0, 0x00, 0x7F, 0x3C,
  0x00, 0x03, 0xF7, 0x80, 0x00, 0x1F, 0x78, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0x70, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x1F, 0x78, 0x00, 0x03,
  0xF3, 0xC0, 0x00, 0x3F, 0x3E, 0x00, 0x06, 0xF1, 0xF8, 0x01, 0xE7, 0x0F,
  0xF9, 0xFC, 0x70, 0x7F, 0xFF, 0x87, 0x01, 0xFF, 0xE0, 0x70, 0x00, 0xF0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03,
  0xF8, 0xFE, 0x00, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0x1E, 0x0F, 0x80, 0x01,
  0xE1, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x79, 0xC0,
  0x00, 0x07, 0x78, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x83, 0xF0, 0x00, 0xE0, 0x3F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0F, 0xFE, 0x07, 0x03, 0xFF, 0xF8, 0x70, 0x7F, 0xBF, 0xC7,
  0x0F, 0x80, 0x1E, 0xF1, 0xF0, 0x00, 0x7F, 0x3E, 0x00, 0x03, 0xF3, 0xC0,
  0x00, 0x3F, 0x78, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xF7, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x3F,
  0x3C, 0x00, 0x07, 0xF1, 0xE0, 0x00, 0xEF, 0x1F, 0x80, 0x1E, 0xF0, 0xFF,
  0xBF, 0xCF, 0x03, 0xFF, 0xF8, 0xF0, 0x1F, 0xFE, 0x0F, 0x00, 0x0C, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC4, 0x00, 0x00, 0x7C, 0x38, 0x00, 0x0F, 0x83,
  0xF8, 0x07, 0xF0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x06,
  0x00, 0x3C, 0x0F, 0xFE, 0x07, 0x87, 0xFF, 0xF0, 0xF3, 0xFC, 0xFF, 0x1E,
  0xF0, 0x01, 0xF3, 0xDC, 0x00, 0x1E, 0x7F, 0x00, 0x01, 0xEF, 0xC0, 0x00,
  0x3D, 0xF0, 0x00, 0x03, 0xBE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x78, 0xF7, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B,
  0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x00, 0x00, 0xF0,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x3C, 0x83, 0xE7, 0xFE, 0x3F, 0xE0, 0xFC, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x0F, 0x00,
  0x0F, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0x3C, 0x01, 0xF0, 0x0F,
  0x00, 0xF8, 0x03, 0xC0, 0x7C, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x0F, 0x00,
  0x0F, 0x07, 0x80, 0x03, 0xC3, 0xC0, 0x00, 0xF1, 0xF0, 0x00, 0x3C, 0xFC,
  0x00, 0x0F, 0x7F, 0x80, 0x03, 0xFC, 0xF0, 0x00, 0xFE, 0x3E, 0x00, 0x3F,
  0x07, 0x80, 0x0F, 0x80, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0,
  0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00,
  0xF8, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0xF0,
  0x00, 0x1F, 0x3C, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x7C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x07, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x38, 0x7F, 0xFE, 0x07,
  0xFF, 0xF1, 0xE7, 0xF7, 0xF8, 0x7F, 0xBF, 0xCF, 0x78, 0x03, 0xE7, 0x80,
  0x1F, 0x7F, 0x00, 0x0F, 0x38, 0x00, 0x7B, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFF, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x3C, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x1C, 0x07, 0xFF, 0x03, 0x83, 0xFF, 0xF8, 0x79, 0xFE, 0x7F, 0x8F, 0x78,
  0x00, 0xF9, 0xEE, 0x00, 0x0F, 0x3F, 0x80, 0x00, 0xF7, 0xE0, 0x00, 0x1E,
  0xF8, 0x00, 0x01, 0xDF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0xF8, 0x01, 0xF8, 0x0F, 0x80,
  0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x78, 0x78, 0x00, 0x03, 0xC3, 0xE0, 0x00,
  0x3C, 0x0F, 0x80, 0x03, 0xE0, 0x3E, 0x00, 0x7E, 0x00, 0xFF, 0xBF, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x07, 0x01, 0xFF, 0xC0, 0x38, 0x3F, 0xFF, 0x81, 0xE3, 0xFB,
  0xFE, 0x0F, 0x3C, 0x00, 0xF8, 0x7B, 0x80, 0x03, 0xE3, 0xF8, 0x00, 0x0F,
  0x1F, 0x80, 0x00, 0x3C, 0xFC, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x07, 0xBE,
  0x00, 0x00, 0x3D, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0x78, 0x00,
  0x00, 0x3B, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x03, 0xDF, 0x00,
  0x00, 0x1E, 0xF8, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x07, 0x3F, 0x00, 0x00,
  0x79, 0xF8, 0x00, 0x07, 0xCF, 0xE0, 0x00, 0x3C, 0x7B, 0x80, 0x03, 0xE3,
  0xDE, 0x00, 0x7E, 0x1E, 0x7F, 0xBF, 0xE0, 0xF1, 0xFF, 0xFC, 0x07, 0x83,
  0xFF, 0xC0, 0x3C, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0xFF, 0x81, 0xC0, 0x7F, 0xFF, 0x0E, 0x07, 0xF9, 0xFC, 0x70,
  0x7C, 0x00, 0xF7, 0x87, 0x80, 0x03, 0xFC, 0x78, 0x00, 0x0F, 0xE7, 0xC0,
  0x00, 0x3F, 0x3C, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x07, 0xDE, 0x00, 0x00,
  0x3E, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x3D,
  0xC0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x07, 0xB8, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x3E, 0x78,
  0x00, 0x03, 0xF1, 0xE0, 0x00, 0x3F, 0x8F, 0x80, 0x03, 0xBC, 0x3F, 0x00,
  0x3D, 0xE0, 0xFF, 0xBF, 0xCF, 0x03, 0xFF, 0xF8, 0x78, 0x07, 0xFF, 0x83,
  0xC0, 0x03, 0x80, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x02, 0x3C, 0x0F, 0xFB,
  0xC3, 0xFF, 0x78, 0xFF, 0xEF, 0x3C, 0x01, 0xEE, 0x00, 0x3F, 0x80, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF1, 0xFF, 0x1F, 0xE3, 0xC0, 0x01, 0xCF, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xB8, 0x00, 0x1F, 0x7F, 0x87, 0xFC,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0xFE, 0x78, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x03,
  0xC0, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xF7, 0x80, 0x00, 0x7D, 0xE0, 0x00, 0x3F, 0x7C, 0x00, 0x1D, 0xCF,
  0x80, 0x1E, 0x71, 0xFE, 0x7F, 0x1C, 0x3F, 0xFF, 0x87, 0x03, 0xFF, 0x80,
  0xC0, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x0E, 0x1E, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x38, 0x1E, 0x00, 0x03,
  0xC0, 0x70, 0x00, 0x1C, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x00,
  0x70, 0x00, 0x70, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78,
  0x01, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x78, 0x0F,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x78, 0x3C, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xF0, 0x00, 0x0E, 0x70, 0x00, 0x1F, 0x80, 0x00, 0xE7, 0x80, 0x01, 0xF8,
  0x00, 0x1E, 0x78, 0x00, 0x1F, 0x80, 0x01, 0xE7, 0x80, 0x01, 0xFC, 0x00,
  0x1C, 0x38, 0x00, 0x39, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0x9C, 0x00, 0x3C,
  0x3C, 0x00, 0x39, 0xE0, 0x03, 0x81, 0xC0, 0x07, 0x8E, 0x00, 0x38, 0x1C,
  0x00, 0x70, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0x0F, 0x00, 0x78, 0x1E, 0x00,
  0xF0, 0xF0, 0x07, 0x00, 0xE0, 0x0E, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0,
  0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x07, 0x01, 0xC0, 0x38,
  0x0E, 0x00, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x07, 0x83, 0xC0, 0x3C, 0x1E,
  0x00, 0x78, 0x38, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x1C, 0x1C, 0x00,
  0x38, 0x78, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x00, 0x0E, 0x3C, 0x00, 0x3C,
  0x70, 0x00, 0xE3, 0x80, 0x01, 0xCF, 0x00, 0x0F, 0x38, 0x00, 0x1C, 0xE0,
  0x00, 0x77, 0x80, 0x01, 0xEE, 0x00, 0x07, 0x78, 0x00, 0x0E, 0xE0, 0x00,
  0x77, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x78,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x38, 0x00, 0x78, 0x03, 0xC0, 0x01,
  0xE0, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x38,
  0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xC0, 0x1E,
  0x00, 0x1E, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x1E, 0xF8, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0x7B, 0x80, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0E,
  0x1E, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x38, 0x1E,
  0x00, 0x03, 0xC0, 0x70, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xE0, 0x0E, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x70, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xC0, 0x01, 0xC0, 0x1E, 0x00, 0x0F, 0x00, 0xE0, 0x00,
  0x78, 0x0F, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x78,
  0x3C, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x38, 0xF0,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x3B, 0xC0, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x08, 0x3E, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x07, 0xF0, 0x07, 0xFC, 0x03, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x3F,
  0x80, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFF,
  0x00, 0x1F, 0xC0, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x03, 0xF0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x09, 0xFF, 0xF0, 0x00, 0xDF, 0xFF, 0xE0,
  0x0F, 0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x40, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x10, 0x00,
};

const GFXglyph NotoSans_Light62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 5, 45, 15, 5, -44 },
  { 30, 14, 16, 23, 4, -44 },
  { 58, 36, 44, 40, 2, -44 },
  { 256, 27, 51, 35, 4, -47 },
  { 429, 44, 46, 50, 3, -45 },
  { 682, 39, 46, 44, 4, -45 },
  { 907, 4, 16, 12, 4, -44 },
  { 915, 12, 54, 17, 3, -44 },
  { 996, 13, 54, 17, 2, -44 },
  { 1084, 28, 26, 34, 3, -47 },
  { 1175, 29, 30, 35, 3, -37 },
  { 1284, 8, 15, 14, 2, -7 },
  { 1299, 15, 3, 20, 2, -18 },
  { 1305, 5, 6, 15, 5, -5 },
  { 1309, 20, 44, 22, 1, -44 },
  { 1419, 29, 46, 35, 3, -45 },
  { 1586, 15, 44, 35, 6, -44 },
  { 1669, 28, 45, 35, 3, -45 },
  { 1827, 28, 46, 35, 3, -45 },
  { 1988, 33, 45, 35, 1, -45 },
  { 2174, 28, 45, 35, 4, -44 },
  { 2332, 28, 46, 35, 4, -45 },
  { 2493, 29, 44, 35, 3, -44 },
  { 2653, 28, 46, 35, 4, -45 },
  { 2814, 29, 46, 35, 3, -45 },
  { 2981, 5, 35, 15, 5, -34 },
  { 3003, 8, 42, 15, 2, -34 },
  { 3045, 29, 29, 35, 3, -37 },
  { 3151, 29, 16, 35, 3, -30 },
  { 3209, 29, 29, 35, 3, -37 },
  { 3315, 22, 46, 26, 2, -45 },
  { 3442, 49, 50, 55, 3, -44 },
  { 3749, 38, 44, 38, 0, -44 },
  { 3958, 30, 44, 39, 6, -44 },
  { 4123, 33, 46, 39, 4, -45 },
  { 4313, 34, 44, 44, 6, -44 },
  { 4500, 25, 44, 34, 6, -44 },
  { 4638, 25, 44, 31, 6, -44 },
  { 4776, 36, 46, 45, 4, -45 },
  { 4983, 33, 44, 45, 6, -44 },
  { 5165, 13, 44, 19, 3, -44 },
  { 5237, 15, 55, 16, -5, -44 },
  { 5341, 31, 44, 37, 6, -44 },
  { 5512, 25, 44, 32, 6, -44 },
  { 5650, 42, 44, 54, 6, -44 },
  { 5881, 33, 44, 45, 6, -44 },
  { 6063, 40, 46, 48, 4, -45 },
  { 6293, 27, 44, 37, 6, -44 },
  { 6442, 40, 56, 48, 4, -45 },
  { 6722, 30, 44, 37, 6, -44 },
  { 6887, 28, 46, 34, 3, -45 },
  { 7048, 32, 44, 33, 0, -44 },
  { 7224, 33, 45, 45, 6, -44 },
  { 7410, 36, 44, 36, 0, -44 },
  { 7608, 53, 44, 56, 1, -44 },
  { 7900, 34, 44, 34, 0, -44 },
  { 8087, 33, 44, 33, 0, -44 },
  { 8269, 31, 44, 36, 2, -44 },
  { 8440, 13, 54, 20, 5, -44 },
  { 8528, 20, 44, 22, 1, -44 },
  { 8638, 13, 54, 20, 2, -44 },
  { 8726, 30, 28, 35, 3, -45 },
  { 8831, 26, 2, 26, 0, 6 },
  { 8838, 12, 9, 16, 2, -47 },
  { 8852, 25, 35, 33, 3, -34 },
  { 8962, 29, 48, 37, 5, -47 },
  { 9136, 24, 35, 30, 4, -34 },
  { 9241, 28, 48, 37, 4, -47 },
  { 9409, 27, 35, 34, 4, -34 },
  { 9528, 22, 47, 19, 1, -47 },
  { 9658, 28, 49, 37, 4, -34 },
  { 9830, 27, 47, 37, 5, -47 },
  { 9989, 5, 45, 14, 5, -45 },
  { 10018, 13, 60, 14, -3, -45 },
  { 10116, 26, 47, 31, 5, -47 },
  { 10269, 4, 47, 14, 5, -47 },
  { 10293, 45, 34, 55, 5, -34 },
  { 10485, 27, 34, 37, 5, -34 },
  { 10600, 29, 35, 37, 4, -34 },
  { 10727, 29, 49, 37, 5, -34 },
  { 10905, 29, 49, 37, 3, -34 },
  { 11083, 19, 34, 24, 5, -34 },
  { 11164, 23, 35, 29, 3, -34 },
  { 11265, 19, 42, 21, 1, -41 },
  { 11365, 26, 34, 37, 5, -33 },
  { 11476, 29, 33, 29, 0, -33 },
  { 11596, 44, 33, 46, 1, -33 },
  { 11778, 29, 33, 31, 1, -33 },
  { 11898, 29, 48, 29, 0, -33 },
  { 12072, 24, 33, 29, 2, -33 },
  { 12171, 18, 54, 22, 2, -44 },
  { 12293, 3, 62, 34, 15, -47 },
  { 12317, 19, 54, 22, 2, -44 },
  { 12446, 29, 7, 35, 3, -25 },
};

const GFXfont NotoSans_Light62pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light62pt7bBitmaps,
  (GFXglyph *)NotoSans_Light62pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _NOTOSANS_LIGHT62PT7B_H_
