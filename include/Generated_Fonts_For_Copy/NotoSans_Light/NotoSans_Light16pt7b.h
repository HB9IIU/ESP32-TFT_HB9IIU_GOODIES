#ifndef _NOTOSANS_LIGHT16PT7B_H_
#define _NOTOSANS_LIGHT16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light16pt7bBitmaps[] PROGMEM = {
  0x00, 0xEA, 0xAA, 0x0C, 0x99, 0x99, 0x09, 0x02, 0x41, 0x11, 0xFF, 0x11,
  0x04, 0x81, 0x23, 0xFE, 0x22, 0x08, 0x82, 0x40, 0x10, 0xFA, 0x44, 0x89,
  0x0E, 0x06, 0x0B, 0x12, 0x27, 0x71, 0x81, 0x00, 0x60, 0x12, 0x12, 0x44,
  0x44, 0x88, 0xA1, 0x2B, 0xA5, 0x4B, 0x49, 0x0A, 0x22, 0x24, 0x44, 0x90,
  0xE0, 0x18, 0x19, 0x04, 0x21, 0x10, 0x24, 0x0E, 0x07, 0x86, 0x32, 0x86,
  0xA0, 0xC8, 0x39, 0xF3, 0xF0, 0x6A, 0x49, 0x24, 0x92, 0x24, 0x40, 0x89,
  0x22, 0x49, 0x29, 0x29, 0x00, 0x10, 0x23, 0x59, 0xC2, 0x89, 0x11, 0x00,
  0x10, 0x20, 0x47, 0xF1, 0x02, 0x04, 0x00, 0xEA, 0xF0, 0xC0, 0x08, 0x44,
  0x21, 0x10, 0x88, 0x42, 0x20, 0x38, 0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x05, 0x11, 0xE0, 0x76, 0x92, 0x49, 0x24, 0x80, 0x31, 0x98, 0x10,
  0x10, 0x40, 0x82, 0x0C, 0x30, 0x41, 0x07, 0xF0, 0x39, 0x88, 0x08, 0x10,
  0x41, 0x9F, 0x01, 0x02, 0x04, 0x0F, 0xE0, 0x06, 0x03, 0x02, 0x82, 0x42,
  0x21, 0x11, 0x09, 0xFF, 0x02, 0x01, 0x00, 0x80, 0x7C, 0x81, 0x04, 0x0F,
  0x80, 0xC0, 0x81, 0x02, 0x0F, 0xF0, 0x0C, 0x61, 0x04, 0x08, 0x17, 0xB0,
  0xC1, 0x83, 0x05, 0x09, 0xE0, 0xFE, 0x04, 0x10, 0x20, 0x81, 0x02, 0x08,
  0x10, 0x40, 0x80, 0x38, 0x8A, 0x0C, 0x14, 0x47, 0x1B, 0x41, 0x83, 0x06,
  0x0B, 0xE0, 0x30, 0x9A, 0x0C, 0x18, 0x30, 0x51, 0x9D, 0x02, 0x08, 0x13,
  0xC0, 0xB0, 0x00, 0xC0, 0xB0, 0x02, 0xA8, 0x02, 0x0C, 0x63, 0x0C, 0x06,
  0x03, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x81, 0x80, 0xC0, 0x60, 0x23, 0x98,
  0x40, 0x33, 0x30, 0x41, 0x04, 0x21, 0x08, 0x20, 0x00, 0x08, 0x1F, 0xC2,
  0x02, 0x40, 0x18, 0xF9, 0x88, 0x99, 0x09, 0x90, 0x99, 0x19, 0x8E, 0xE8,
  0x00, 0x40, 0x03, 0x18, 0x0E, 0x00, 0x0C, 0x03, 0x01, 0x20, 0x48, 0x12,
  0x08, 0x43, 0xF1, 0x04, 0x40, 0x90, 0x28, 0x04, 0xFD, 0x06, 0x0C, 0x18,
  0xDF, 0xA0, 0xC1, 0x83, 0x07, 0xF0, 0x0E, 0x31, 0x40, 0x40, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x40, 0x60, 0x3F, 0xFC, 0x82, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x86, 0xF8, 0xFE, 0x08, 0x20, 0x83, 0xF8, 0x20, 0x82,
  0x0F, 0xC0, 0xFE, 0x08, 0x20, 0x83, 0xF8, 0x20, 0x82, 0x08, 0x00, 0x0F,
  0x18, 0x50, 0x08, 0x08, 0x04, 0x02, 0x1F, 0x01, 0x80, 0xA0, 0x58, 0x23,
  0xF0, 0x81, 0x81, 0x81, 0x81, 0x81, 0xFF, 0x81, 0x81, 0x81, 0x81, 0x81,
  0xE9, 0x24, 0x92, 0x4B, 0x80, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x2C,
  0x87, 0x12, 0x45, 0x8E, 0x1C, 0x24, 0x44, 0x8D, 0x0A, 0x08, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x0F, 0xC0, 0x80, 0x70, 0x3C, 0x0E, 0x85,
  0xA1, 0x68, 0x59, 0x26, 0x49, 0x8C, 0x63, 0x18, 0xC4, 0x81, 0xC1, 0xE1,
  0xA1, 0x91, 0x99, 0x89, 0x85, 0x87, 0x83, 0x81, 0x0E, 0x0C, 0x44, 0x0A,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x50, 0x16, 0x08, 0xFC, 0xFD,
  0x0A, 0x0C, 0x18, 0x5F, 0x20, 0x40, 0x81, 0x02, 0x00, 0x0E, 0x0C, 0x44,
  0x0A, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x50, 0x16, 0x08, 0xFC,
  0x02, 0x00, 0x40, 0x08, 0xFD, 0x0A, 0x0C, 0x28, 0x5F, 0x26, 0x44, 0x85,
  0x0A, 0x08, 0x38, 0x8E, 0x04, 0x08, 0x0C, 0x06, 0x03, 0x02, 0x04, 0x1F,
  0xE0, 0xFF, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x40, 0xA0, 0x8F,
  0x80, 0x80, 0xA0, 0x50, 0x48, 0x22, 0x11, 0x10, 0x48, 0x28, 0x14, 0x06,
  0x02, 0x00, 0xC3, 0x05, 0x0C, 0x14, 0x28, 0x90, 0xA2, 0x24, 0x88, 0x92,
  0x42, 0x45, 0x0A, 0x14, 0x18, 0x50, 0x60, 0x81, 0x02, 0x00, 0xC1, 0x11,
  0x08, 0x82, 0x81, 0x80, 0x40, 0x50, 0x44, 0x22, 0x20, 0xA0, 0x60, 0xC1,
  0xA0, 0x88, 0x84, 0x81, 0x40, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00,
  0xFE, 0x02, 0x04, 0x08, 0x18, 0x10, 0x20, 0x60, 0x40, 0x80, 0xFF, 0xF8,
  0x88, 0x88, 0x88, 0x88, 0x88, 0x8F, 0x82, 0x10, 0x42, 0x10, 0x42, 0x10,
  0x42, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1F, 0x10, 0x20, 0xA1, 0x44,
  0x48, 0xA0, 0xC1, 0xFE, 0x8C, 0x39, 0x10, 0x41, 0x7E, 0x18, 0x61, 0xFC,
  0x80, 0x80, 0x80, 0x98, 0xA6, 0xC2, 0x81, 0x81, 0x81, 0x82, 0xC2, 0xBC,
  0x19, 0x98, 0x20, 0x82, 0x08, 0x10, 0x7C, 0x02, 0x04, 0x09, 0xD4, 0x70,
  0x60, 0xC1, 0x83, 0x07, 0x0B, 0xF0, 0x38, 0x8A, 0x0C, 0x1F, 0xF0, 0x20,
  0x20, 0x3E, 0x3C, 0x82, 0x3E, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x3A,
  0x8E, 0x0C, 0x18, 0x30, 0x60, 0xE1, 0x7E, 0x04, 0x0C, 0x37, 0x80, 0x81,
  0x02, 0x04, 0xCA, 0x78, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x10, 0xB2, 0xAA,
  0xAA, 0x23, 0x02, 0x22, 0x22, 0x22, 0x22, 0x22, 0x2E, 0x81, 0x02, 0x04,
  0x38, 0x51, 0x24, 0x50, 0xD1, 0x12, 0x14, 0x30, 0xFF, 0xF0, 0x98, 0xCE,
  0x53, 0xC2, 0x18, 0x21, 0x82, 0x18, 0x21, 0x82, 0x18, 0x21, 0x82, 0x10,
  0x99, 0x4F, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x82, 0x38, 0x46, 0x82, 0x82,
  0x81, 0x81, 0x82, 0x42, 0x3C, 0x98, 0xA6, 0xC2, 0x81, 0x81, 0x81, 0xC2,
  0xC2, 0xBC, 0x80, 0x80, 0x80, 0x80, 0x3A, 0x8E, 0x0C, 0x18, 0x30, 0x60,
  0xE1, 0x7E, 0x04, 0x08, 0x10, 0x20, 0x9D, 0x31, 0x08, 0x42, 0x10, 0x80,
  0x7A, 0x18, 0x20, 0x70, 0x20, 0x41, 0xF8, 0x22, 0x3E, 0x84, 0x21, 0x08,
  0x41, 0x0E, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xA3, 0x7A, 0x81, 0x82,
  0x42, 0x44, 0x24, 0x24, 0x28, 0x18, 0x10, 0x84, 0x18, 0x62, 0x46, 0x24,
  0xA2, 0x49, 0x22, 0x94, 0x31, 0x43, 0x0C, 0x30, 0x80, 0xC3, 0x42, 0x24,
  0x18, 0x18, 0x18, 0x24, 0x42, 0xC3, 0x81, 0x82, 0x42, 0x44, 0x24, 0x24,
  0x28, 0x18, 0x10, 0x10, 0x10, 0x20, 0xC0, 0xFC, 0x20, 0x84, 0x20, 0x84,
  0x20, 0xFC, 0x19, 0x08, 0x42, 0x13, 0x04, 0x21, 0x08, 0x41, 0x04, 0xFF,
  0xFF, 0xC4, 0x44, 0x42, 0x12, 0x44, 0x44, 0x48, 0x61, 0x3C,
};

const GFXglyph NotoSans_Light16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 11, 4, 1, -11 },
  { 4, 4, 4, 6, 1, -11 },
  { 6, 10, 11, 10, 0, -11 },
  { 20, 7, 13, 9, 1, -12 },
  { 32, 11, 12, 13, 1, -12 },
  { 49, 10, 12, 11, 1, -12 },
  { 64, 1, 4, 3, 1, -11 },
  { 65, 3, 14, 4, 1, -11 },
  { 71, 3, 14, 4, 1, -11 },
  { 77, 7, 7, 9, 1, -12 },
  { 84, 7, 7, 9, 1, -9 },
  { 91, 2, 4, 4, 1, -2 },
  { 92, 4, 1, 5, 1, -5 },
  { 93, 2, 1, 4, 1, -1 },
  { 94, 5, 11, 6, 0, -11 },
  { 101, 7, 12, 9, 1, -12 },
  { 112, 3, 11, 9, 2, -11 },
  { 117, 7, 12, 9, 1, -12 },
  { 128, 7, 12, 9, 1, -12 },
  { 139, 9, 11, 9, 0, -11 },
  { 152, 7, 11, 9, 1, -11 },
  { 162, 7, 12, 9, 1, -12 },
  { 173, 7, 11, 9, 1, -11 },
  { 183, 7, 12, 9, 1, -12 },
  { 194, 7, 12, 9, 1, -12 },
  { 205, 2, 9, 4, 1, -9 },
  { 208, 2, 11, 4, 1, -9 },
  { 211, 7, 8, 9, 1, -10 },
  { 218, 7, 4, 9, 1, -8 },
  { 222, 7, 8, 9, 1, -10 },
  { 229, 6, 12, 7, 0, -12 },
  { 238, 12, 13, 14, 1, -11 },
  { 258, 10, 11, 10, 0, -11 },
  { 272, 7, 11, 10, 2, -11 },
  { 282, 8, 12, 10, 1, -12 },
  { 294, 8, 11, 11, 2, -11 },
  { 305, 6, 11, 9, 2, -11 },
  { 314, 6, 11, 8, 2, -11 },
  { 323, 9, 12, 12, 1, -12 },
  { 337, 8, 11, 12, 2, -11 },
  { 348, 3, 11, 5, 1, -11 },
  { 353, 4, 14, 4, -1, -11 },
  { 360, 7, 11, 9, 2, -11 },
  { 370, 6, 11, 8, 2, -11 },
  { 379, 10, 11, 14, 2, -11 },
  { 393, 8, 11, 12, 2, -11 },
  { 404, 10, 12, 12, 1, -12 },
  { 419, 7, 11, 9, 2, -11 },
  { 429, 10, 15, 12, 1, -12 },
  { 448, 7, 11, 10, 2, -11 },
  { 458, 7, 12, 9, 1, -12 },
  { 469, 8, 11, 9, 0, -11 },
  { 480, 9, 11, 12, 1, -11 },
  { 493, 9, 11, 9, 0, -11 },
  { 506, 14, 11, 14, 0, -11 },
  { 526, 9, 11, 9, 0, -11 },
  { 539, 9, 11, 9, 0, -11 },
  { 552, 8, 11, 9, 1, -11 },
  { 563, 4, 14, 5, 1, -11 },
  { 570, 5, 11, 6, 0, -11 },
  { 577, 4, 14, 5, 0, -11 },
  { 584, 7, 8, 9, 1, -12 },
  { 591, 7, 1, 7, 0, 1 },
  { 592, 3, 2, 4, 1, -12 },
  { 593, 6, 9, 9, 1, -9 },
  { 600, 8, 12, 10, 1, -12 },
  { 612, 6, 9, 8, 1, -9 },
  { 619, 7, 12, 10, 1, -12 },
  { 630, 7, 9, 9, 1, -9 },
  { 638, 6, 12, 5, 0, -12 },
  { 647, 7, 13, 10, 1, -9 },
  { 659, 7, 12, 10, 1, -12 },
  { 670, 2, 12, 4, 1, -12 },
  { 673, 4, 16, 4, -1, -12 },
  { 681, 7, 12, 8, 1, -12 },
  { 692, 1, 12, 4, 1, -12 },
  { 694, 12, 9, 14, 1, -9 },
  { 708, 7, 9, 10, 1, -9 },
  { 716, 8, 9, 9, 1, -9 },
  { 725, 8, 13, 10, 1, -9 },
  { 738, 7, 13, 10, 1, -9 },
  { 750, 5, 9, 6, 1, -9 },
  { 756, 6, 9, 8, 1, -9 },
  { 763, 5, 11, 5, 0, -11 },
  { 770, 7, 9, 10, 1, -9 },
  { 778, 8, 9, 8, 0, -9 },
  { 787, 12, 9, 12, 0, -9 },
  { 801, 8, 9, 8, 0, -9 },
  { 810, 8, 13, 8, 0, -9 },
  { 823, 6, 9, 7, 1, -9 },
  { 830, 5, 14, 6, 0, -11 },
  { 839, 1, 16, 9, 4, -12 },
  { 841, 4, 14, 6, 1, -11 },
  { 848, 7, 2, 9, 1, -7 },
};

const GFXfont NotoSans_Light16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light16pt7bBitmaps,
  (GFXglyph *)NotoSans_Light16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_LIGHT16PT7B_H_
