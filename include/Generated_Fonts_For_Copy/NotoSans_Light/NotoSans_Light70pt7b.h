#ifndef _NOTOSANS_LIGHT70PT7B_H_
#define _NOTOSANS_LIGHT70PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light70pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xF9, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7B, 0xEF,
  0xFF, 0xFF, 0xE7, 0x00, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F,
  0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E,
  0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0x70, 0x0E, 0x60, 0x0E,
  0x60, 0x0E, 0x60, 0x0E, 0x00, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x03, 0xC0,
  0x03, 0x80, 0x00, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x01, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0x80, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x01,
  0xC0, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0x80, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00,
  0x01, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x80, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x07, 0x80, 0x00, 0x01, 0xC0,
  0x03, 0x80, 0x00, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFB, 0xBF, 0xF0, 0x3F, 0x07, 0x01, 0xE0,
  0xF8, 0x0E, 0x00, 0x83, 0xE0, 0x1C, 0x00, 0x07, 0x80, 0x38, 0x00, 0x0F,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x78, 0x01, 0xC0, 0x00, 0xF0,
  0x03, 0x80, 0x01, 0xE0, 0x07, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x03, 0xC0,
  0x1C, 0x00, 0x07, 0xC0, 0x38, 0x00, 0x07, 0xC0, 0x70, 0x00, 0x0F, 0xC0,
  0xE0, 0x00, 0x0F, 0xE1, 0xC0, 0x00, 0x0F, 0xF3, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xC7,
  0xF8, 0x00, 0x03, 0x83, 0xF8, 0x00, 0x07, 0x01, 0xF0, 0x00, 0x0E, 0x01,
  0xF0, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x70, 0x07,
  0x80, 0x00, 0xE0, 0x0F, 0x80, 0x01, 0xC0, 0x1F, 0x00, 0x03, 0x80, 0x3C,
  0x00, 0x07, 0x00, 0x78, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x1C, 0x03, 0xE0,
  0x00, 0x38, 0x0F, 0x8C, 0x00, 0x70, 0x3E, 0x1F, 0x00, 0xE1, 0xFC, 0x3F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0x80, 0x03, 0xE3, 0xF0, 0x00,
  0x03, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xC0, 0x01, 0xE0, 0x1E, 0x00,
  0x01, 0xE0, 0x01, 0xE0, 0x07, 0x00, 0x01, 0xE0, 0x00, 0xE0, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x70, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x1C, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x1E, 0x00, 0x01, 0xC0, 0x01,
  0xE0, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x78, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x0E, 0x03, 0x80, 0x38, 0x07, 0x80,
  0x07, 0x03, 0xC1, 0xFF, 0x83, 0xC0, 0x03, 0x81, 0xC1, 0xFF, 0xE0, 0xE0,
  0x03, 0xC1, 0xE1, 0xF9, 0xF8, 0x70, 0x01, 0xE1, 0xE1, 0xF0, 0x3E, 0x3C,
  0x00, 0xE0, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x70, 0x03, 0xC7,
  0xC0, 0xF0, 0x78, 0x78, 0x01, 0xE1, 0xFB, 0xF8, 0x78, 0x38, 0x00, 0x70,
  0x7F, 0xF8, 0x38, 0x1C, 0x00, 0x38, 0x1F, 0xF0, 0x3C, 0x1E, 0x00, 0x1E,
  0x01, 0xC0, 0x1C, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x07,
  0x80, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x1E, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x07, 0x80,
  0x07, 0x80, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x3C, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x3F,
  0x00, 0x00, 0x00, 0x3C, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x03, 0xC0, 0xFC,
  0x07, 0xC0, 0x00, 0x3C, 0x0F, 0x80, 0x1F, 0x00, 0x01, 0xE0, 0xF8, 0x00,
  0x7C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xF0, 0x00, 0xF0, 0x7C, 0x00, 0x07,
  0xC0, 0x07, 0x83, 0xC0, 0x00, 0x1F, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x7C,
  0x03, 0xC1, 0xF0, 0x00, 0x01, 0xF0, 0x1E, 0x0F, 0x00, 0x00, 0x07, 0xC1,
  0xE0, 0x78, 0x00, 0x00, 0x1F, 0x1F, 0x03, 0xC0, 0x00, 0x00, 0x7E, 0xF0,
  0x1E, 0x00, 0x00, 0x01, 0xFF, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x1E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x1F, 0x00,
  0x00, 0x1F, 0x9F, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x7C, 0x01, 0xFC, 0x00,
  0xFF, 0x01, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x1F, 0xFF, 0xFE,
  0x00, 0x1F, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x76, 0x66, 0x00,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01,
  0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0xF8, 0x00,
  0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00,
  0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x01, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x01, 0x00, 0x07, 0x00, 0x0B, 0xC0, 0x0E, 0x00, 0x77,
  0xF0, 0x1C, 0x07, 0xEF, 0xFC, 0x38, 0xFF, 0xFF, 0xFF, 0x6F, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x03,
  0x87, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF8,
  0x0F, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x38, 0x00, 0x70, 0x00, 0x10, 0x00,
  0x40, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x1F, 0x1F, 0x1E, 0x1E, 0x1E, 0x3E, 0x3C, 0x3C, 0x3C,
  0x78, 0x78, 0x78, 0x70, 0xF0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7B, 0xEF, 0xFF, 0xFF, 0xE7, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0x80,
  0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x78, 0x3E, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x78, 0x00,
  0x00, 0x3C, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x80,
  0x01, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F,
  0xF8, 0x1F, 0xBC, 0x1F, 0x1E, 0x3F, 0x0F, 0x3F, 0x07, 0xBE, 0x03, 0xFE,
  0x01, 0xEE, 0x00, 0xF6, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFC,
  0x1F, 0x00, 0x00, 0x7C, 0x18, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x00, 0xF8, 0x30,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x80, 0x00, 0x00, 0xFC, 0xF0,
  0x00, 0x01, 0xF8, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x1E, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x9F, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F, 0xE0,
  0x10, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x88, 0x00, 0x00, 0x3F, 0x1C, 0x00, 0x00,
  0xFC, 0x3F, 0x80, 0x0F, 0xF0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x7F, 0x00, 0x08, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x07, 0xFC, 0x00, 0x78, 0x3F, 0xFF,
  0x80, 0x78, 0x7F, 0xFF, 0xE0, 0x71, 0xFE, 0x0F, 0xF0, 0x73, 0xE0, 0x01,
  0xF8, 0xF7, 0x80, 0x00, 0x7C, 0xF7, 0x00, 0x00, 0x3C, 0xFE, 0x00, 0x00,
  0x3E, 0xFC, 0x00, 0x00, 0x1E, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x0F, 0x3C, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0x1E, 0x1F, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x7C, 0x07, 0xE0, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x00,
  0xF8, 0x3E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x3C, 0x3E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x01,
  0xF0, 0x0F, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xF8, 0x1F,
  0x80, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x03, 0xF0, 0x3F,
  0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0x80, 0x03, 0xF0, 0x1F, 0x00, 0x00,
  0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00,
  0x1E, 0xF8, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00,
  0x7C, 0x1F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xF0, 0x07, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0B, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x07,
  0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00,
  0xF8, 0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0x78, 0x00, 0x00,
  0x3F, 0x7C, 0x00, 0x00, 0x7F, 0x3C, 0x00, 0x00, 0xEF, 0x3E, 0x00, 0x01,
  0xCF, 0x1F, 0x80, 0x07, 0xCF, 0x0F, 0xF0, 0x7F, 0x9E, 0x07, 0xFF, 0xFE,
  0x1E, 0x01, 0xFF, 0xF8, 0x1E, 0x00, 0x3F, 0xE0, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x10, 0x00, 0xFE,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x73, 0xEF, 0xFF, 0xFF, 0xE7, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7B, 0xEF, 0xFF, 0xFF, 0xE7, 0x00, 0x07,
  0x03, 0xE0, 0xFC, 0x7F, 0x0F, 0xC3, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x3E, 0x0F, 0x03, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0,
  0xF0, 0x3C, 0x0F, 0x03, 0x81, 0xE0, 0x78, 0x1C, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xE0, 0x0F, 0xE3, 0x80, 0x01,
  0xF9, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x07, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0x00,
  0x1E, 0x3C, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x38, 0xF0, 0x00, 0x7F, 0x01,
  0xF8, 0x00, 0xE3, 0x80, 0x03, 0xE0, 0x01, 0xE0, 0x03, 0xDE, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x0F, 0x78, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x1D, 0xC0,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x77, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x01,
  0xFC, 0x00, 0x78, 0x00, 0x07, 0x00, 0x07, 0xF0, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x1F, 0xC0, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x7F, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x07, 0xE0, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x1F, 0x80, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x7E,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x03, 0xF8, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x0F, 0xE0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x3B, 0x80, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0xEF, 0x00, 0x1C, 0x00, 0x07, 0xC0, 0x07, 0xBC, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x1C, 0xF0, 0x01, 0xE0, 0x00, 0xEE, 0x00, 0xF1, 0xC0,
  0x03, 0xC0, 0x07, 0x38, 0x07, 0x87, 0x00, 0x0F, 0xC0, 0x7C, 0xF0, 0x3E,
  0x1E, 0x00, 0x1F, 0xFF, 0xE1, 0xFF, 0xF0, 0x78, 0x00, 0x3F, 0xFF, 0x03,
  0xFF, 0x80, 0xE0, 0x00, 0x3F, 0xF0, 0x07, 0xF8, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x7C, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00,
  0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xF0, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x1F, 0x00, 0x00,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0x00, 0x00, 0x7C, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F,
  0x00, 0x00, 0x3F, 0x87, 0x80, 0x00, 0x07, 0xE3, 0xC0, 0x00, 0x01, 0xF9,
  0xE0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0F,
  0xBC, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00,
  0x3E, 0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x0F, 0x1E, 0x00, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x1F, 0x87, 0x80, 0x00,
  0x3F, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x3C, 0x00, 0x00, 0xFE, 0x1E, 0x00,
  0x00, 0x0F, 0x8F, 0x00, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x00, 0xFB, 0xC0,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x07,
  0xE7, 0x80, 0x00, 0x1F, 0xE3, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x00, 0x38, 0x03, 0xF0, 0x00, 0x00, 0x40, 0x3F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x40,
  0x0F, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x00, 0x07, 0xFC, 0x03, 0xC0,
  0x00, 0x03, 0xF8, 0x0F, 0x00, 0x00, 0x03, 0xF0, 0x3C, 0x00, 0x00, 0x07,
  0xE0, 0xF0, 0x00, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x00, 0x0F, 0x8F, 0x00,
  0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x00, 0x0F, 0xBC, 0x00,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0x00, 0x3E, 0xF0, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x07, 0xCF,
  0x00, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00,
  0x07, 0xC3, 0xC0, 0x00, 0x00, 0x3F, 0x0F, 0x00, 0x00, 0x01, 0xF8, 0x3C,
  0x00, 0x00, 0x1F, 0xC0, 0xF0, 0x00, 0x01, 0xFE, 0x03, 0xC0, 0x00, 0x3F,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFB, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x78,
  0x03, 0xF8, 0x00, 0x00, 0x08, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x00, 0x03, 0xDF,
  0x00, 0x00, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x00, 0x00, 0x79, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x87,
  0xC0, 0x00, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0xFC, 0x00,
  0x00, 0x00, 0xF0, 0x3F, 0x00, 0x00, 0x00, 0x78, 0x0F, 0xE0, 0x00, 0x00,
  0x3C, 0x03, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x20, 0x3F, 0x9F, 0xFF, 0x8F,
  0xFF, 0x87, 0xFF, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xCF, 0x00, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x01, 0xF0, 0xF0,
  0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x3E, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x03, 0xE0,
  0x0F, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x0F,
  0x80, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x0F, 0x01,
  0xF0, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0x3C,
  0x3E, 0x00, 0x00, 0x0F, 0x1F, 0xC0, 0x00, 0x03, 0xCF, 0xF8, 0x00, 0x00,
  0xF7, 0xDF, 0x00, 0x00, 0x3F, 0xE7, 0xC0, 0x00, 0x0F, 0xF0, 0xF8, 0x00,
  0x03, 0xF8, 0x1F, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x0F,
  0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x03, 0xE0,
  0x3C, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x01,
  0xF0, 0xF0, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x0F, 0x8F, 0x00, 0x00,
  0x01, 0xF3, 0xC0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x0F, 0xBC, 0x00,
  0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFD, 0xE0, 0x00,
  0x00, 0x00, 0xF7, 0xFB, 0xC0, 0x00, 0x00, 0x01, 0xEF, 0xF7, 0xC0, 0x00,
  0x00, 0x03, 0x9F, 0xE7, 0x80, 0x00, 0x00, 0x0F, 0x3F, 0xCF, 0x00, 0x00,
  0x00, 0x1E, 0x7F, 0x8F, 0x00, 0x00, 0x00, 0x78, 0xFF, 0x1E, 0x00, 0x00,
  0x00, 0xF1, 0xFE, 0x3C, 0x00, 0x00, 0x01, 0xC3, 0xFC, 0x3C, 0x00, 0x00,
  0x07, 0x87, 0xF8, 0x78, 0x00, 0x00, 0x0F, 0x0F, 0xF0, 0x78, 0x00, 0x00,
  0x3C, 0x1F, 0xE0, 0xF0, 0x00, 0x00, 0x78, 0x3F, 0xC1, 0xE0, 0x00, 0x00,
  0xE0, 0x7F, 0x81, 0xE0, 0x00, 0x03, 0xC0, 0xFF, 0x03, 0xC0, 0x00, 0x07,
  0x81, 0xFE, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xFC, 0x07, 0x80, 0x00, 0x3C,
  0x07, 0xF8, 0x0F, 0x00, 0x00, 0x70, 0x0F, 0xF0, 0x0F, 0x00, 0x01, 0xE0,
  0x1F, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x3F, 0xC0, 0x3E, 0x00, 0x0F, 0x00,
  0x7F, 0x80, 0x3C, 0x00, 0x1E, 0x00, 0xFF, 0x00, 0x78, 0x00, 0x3C, 0x01,
  0xFE, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xFC, 0x00, 0xF0, 0x01, 0xE0, 0x07,
  0xF8, 0x01, 0xF0, 0x07, 0x80, 0x0F, 0xF0, 0x01, 0xE0, 0x0F, 0x00, 0x1F,
  0xE0, 0x03, 0xC0, 0x1E, 0x00, 0x3F, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0x7F,
  0x80, 0x07, 0x80, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x83, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0x07, 0x80, 0x03, 0xFC, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0xF8,
  0x00, 0x1E, 0x3C, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x1F, 0xE0,
  0x00, 0x79, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7B, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xF7, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF7, 0xC0, 0x00, 0x00, 0x7F, 0x9F, 0x00,
  0x00, 0x03, 0xFC, 0xF8, 0x00, 0x00, 0x1F, 0xE3, 0xE0, 0x00, 0x00, 0xFF,
  0x0F, 0x80, 0x00, 0x07, 0xF8, 0x7C, 0x00, 0x00, 0x3F, 0xC1, 0xF0, 0x00,
  0x01, 0xFE, 0x07, 0xC0, 0x00, 0x0F, 0xF0, 0x3E, 0x00, 0x00, 0x7F, 0x80,
  0xF8, 0x00, 0x03, 0xFC, 0x03, 0xE0, 0x00, 0x1F, 0xE0, 0x1F, 0x00, 0x00,
  0xFF, 0x00, 0x7C, 0x00, 0x07, 0xF8, 0x01, 0xF0, 0x00, 0x3F, 0xC0, 0x0F,
  0x80, 0x01, 0xFE, 0x00, 0x3E, 0x00, 0x0F, 0xF0, 0x00, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x00, 0x1F, 0xE0, 0x00, 0x7C,
  0x00, 0xFF, 0x00, 0x03, 0xE0, 0x07, 0xF8, 0x00, 0x0F, 0x80, 0x3F, 0xC0,
  0x00, 0x3E, 0x01, 0xFE, 0x00, 0x01, 0xF0, 0x0F, 0xF0, 0x00, 0x07, 0xC0,
  0x7F, 0x80, 0x00, 0x1F, 0x03, 0xFC, 0x00, 0x00, 0xF8, 0x1F, 0xE0, 0x00,
  0x03, 0xE0, 0xFF, 0x00, 0x00, 0x0F, 0x87, 0xF8, 0x00, 0x00, 0x7C, 0x3F,
  0xC0, 0x00, 0x01, 0xF1, 0xFE, 0x00, 0x00, 0x07, 0xCF, 0xF0, 0x00, 0x00,
  0x3E, 0x7F, 0x80, 0x00, 0x00, 0xFB, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x00,
  0x00, 0x1E, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x40, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x1F, 0xE3, 0xC0, 0x00, 0x0F, 0xCF,
  0x00, 0x00, 0x1F, 0xBC, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xEF,
  0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0xFC, 0xF0, 0x00, 0x0F, 0xE3, 0xC0,
  0x01, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xD0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x7C, 0x00, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC7, 0x80, 0x00,
  0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3D, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x0F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x0F,
  0xE0, 0x3C, 0x00, 0x00, 0xFC, 0x0F, 0x00, 0x00, 0x0F, 0x83, 0xC0, 0x00,
  0x03, 0xE0, 0xF0, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07,
  0xC3, 0xC0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x3F, 0x03, 0xC0, 0x00, 0x1F, 0x80, 0xF0, 0x00,
  0x3F, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00,
  0x3E, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x01, 0xF0, 0x3C, 0x00,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x01, 0xF0, 0xF0,
  0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x0F,
  0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x90, 0x00, 0x00, 0x3E, 0x38,
  0x00, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x7E, 0x00,
  0x00, 0x0F, 0x81, 0xF8, 0x00, 0x00, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x1F,
  0x00, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x01,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x00, 0x07, 0xC0, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC7, 0x80, 0x00,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x70,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF7, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0x9F, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x0E, 0x78, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x03, 0xC7, 0x00, 0x00,
  0x3E, 0x0F, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0E,
  0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x07,
  0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0xF0, 0x0F, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x78, 0x0E, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xF0,
  0x03, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x78, 0x07,
  0x80, 0x03, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0,
  0x01, 0xE0, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x38, 0x01, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x7C, 0x01, 0xE0,
  0x03, 0xC0, 0x1F, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x78, 0x03, 0xC0, 0x00,
  0xF0, 0x0F, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0xF0,
  0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x07,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0xF0, 0x78, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3C, 0x7C,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x71, 0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x03, 0xC1, 0xF0,
  0x00, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x03,
  0xC0, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x0F, 0x00,
  0x00, 0x07, 0xC0, 0x78, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0x00, 0xF3, 0xE0, 0x00,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x00, 0x1F, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x1F, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x78,
  0x00, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x00,
  0x3E, 0x78, 0x00, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x07, 0x80, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x00, 0x01, 0xE3, 0xE0, 0x00, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x00, 0x0F,
  0x7C, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x07, 0x00, 0x01, 0xE0,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x07, 0x80, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x1E,
  0x07, 0x00, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00,
  0x1C, 0x78, 0x00, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x00, 0xEF, 0x00, 0x00,
  0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80,
  0x7C, 0x00, 0x7E, 0x03, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0xF0, 0xFE, 0x00,
  0x07, 0x8F, 0xC0, 0x00, 0x3C, 0xF8, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xEF, 0x00, 0x00, 0x7F, 0x7C, 0x00, 0x07, 0x7B, 0xF0, 0x00, 0x7B,
  0xCF, 0xC0, 0x0F, 0x9E, 0x3F, 0xFF, 0xF8, 0xF0, 0xFF, 0xFF, 0x03, 0x81,
  0xFF, 0xF0, 0x1C, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x07, 0xF8, 0x00, 0xF0,
  0x3F, 0xFF, 0x00, 0xF0, 0xFF, 0xFF, 0x80, 0xF1, 0xFF, 0xFF, 0xE0, 0xF3,
  0xE0, 0x07, 0xF0, 0xF7, 0x80, 0x01, 0xF0, 0xF7, 0x00, 0x00, 0xF8, 0xFE,
  0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0x3C, 0xFC, 0x00, 0x00, 0x3C, 0xF8,
  0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x1E, 0xF8,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x1E, 0xF8,
  0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3C, 0xFC, 0x00, 0x00, 0x7C, 0xFE,
  0x00, 0x00, 0xF8, 0xFF, 0x00, 0x00, 0xF8, 0xF7, 0x80, 0x03, 0xF0, 0xF3,
  0xE0, 0x0F, 0xE0, 0xE1, 0xFF, 0xFF, 0xC0, 0xE0, 0xFF, 0xFF, 0x80, 0xE0,
  0x3F, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0x80, 0x0C,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x04, 0x1F, 0xE0, 0x07, 0x81, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x0F, 0x00,
  0x7F, 0xFC, 0x0F, 0x01, 0xFF, 0xFF, 0x0F, 0x03, 0xFF, 0xFF, 0x8F, 0x07,
  0xE0, 0x03, 0xCF, 0x0F, 0x80, 0x01, 0xEF, 0x1F, 0x00, 0x00, 0xFF, 0x1E,
  0x00, 0x00, 0x7F, 0x3E, 0x00, 0x00, 0x3F, 0x3C, 0x00, 0x00, 0x3F, 0x7C,
  0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x1F, 0x7C,
  0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x3F, 0x3E,
  0x00, 0x00, 0x7F, 0x1F, 0x00, 0x00, 0xEF, 0x0F, 0x80, 0x01, 0xEF, 0x07,
  0xE0, 0x07, 0xCF, 0x03, 0xFF, 0xFF, 0x8F, 0x01, 0xFF, 0xFF, 0x0F, 0x00,
  0x7F, 0xFC, 0x07, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x7E,
  0x00, 0x7E, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0x7C, 0x3E, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF9, 0xF0, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x07, 0xBE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x30, 0x1F, 0xE0, 0x03, 0xE0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x7C, 0x03, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0xFE, 0x0F, 0x01, 0xFF, 0xFF, 0x0F, 0x03, 0xFF, 0xFF,
  0x8F, 0x07, 0xE0, 0x03, 0xCF, 0x0F, 0x80, 0x01, 0xEF, 0x1F, 0x00, 0x00,
  0xFF, 0x1E, 0x00, 0x00, 0x7F, 0x3E, 0x00, 0x00, 0x3F, 0x3C, 0x00, 0x00,
  0x3F, 0x7C, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00,
  0x1F, 0x78, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00,
  0x1F, 0x7C, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00,
  0x3F, 0x3E, 0x00, 0x00, 0x7F, 0x1F, 0x00, 0x00, 0xEF, 0x0F, 0x80, 0x01,
  0xEF, 0x07, 0xE0, 0x07, 0xCF, 0x03, 0xFF, 0xFF, 0x8F, 0x01, 0xFF, 0xFF,
  0x0F, 0x00, 0x7F, 0xFC, 0x0F, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x20, 0x00, 0x00,
  0x7C, 0x38, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xF0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x01, 0xFE,
  0x00, 0xF0, 0x3F, 0xFF, 0x03, 0xC3, 0xFF, 0xFF, 0x0F, 0x1F, 0xFF, 0xFE,
  0x3C, 0xF8, 0x01, 0xFC, 0xF7, 0x80, 0x01, 0xF3, 0xFC, 0x00, 0x03, 0xEF,
  0xE0, 0x00, 0x07, 0xBF, 0x00, 0x00, 0x1E, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3C, 0x79, 0xFF, 0xFF, 0x7D,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x9E, 0x79, 0xE7, 0x9E, 0x79,
  0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79,
  0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x80, 0x00,
  0x3C, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0xFF,
  0xF1, 0xFF, 0xE3, 0xFF, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x7C, 0xF0, 0x00,
  0x0F, 0x8F, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0xC0,
  0xF0, 0x00, 0xF8, 0x0F, 0x00, 0x1F, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x00,
  0x7C, 0x00, 0xF0, 0x07, 0x80, 0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x1E, 0x00,
  0x0F, 0x03, 0xE0, 0x00, 0xF0, 0x7C, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF1,
  0xF8, 0x00, 0x0F, 0x3F, 0xC0, 0x00, 0xF7, 0xFE, 0x00, 0x0F, 0x79, 0xE0,
  0x00, 0xFF, 0x1F, 0x00, 0x0F, 0xE0, 0xF8, 0x00, 0xFC, 0x07, 0xC0, 0x0F,
  0x80, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x00, 0x1F, 0x00, 0xF0, 0x00,
  0xF8, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x7C, 0x0F, 0x00, 0x03, 0xE0,
  0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x8F, 0x00,
  0x00, 0x7C, 0xF0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x1C, 0x0F,
  0xFF, 0x80, 0x1F, 0xFF, 0x03, 0xC3, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x78,
  0xFF, 0xFF, 0xC3, 0xFE, 0xFF, 0x8F, 0x3C, 0x01, 0xF8, 0xF8, 0x01, 0xF9,
  0xEE, 0x00, 0x0F, 0x9E, 0x00, 0x1F, 0x3F, 0x80, 0x00, 0xF7, 0x00, 0x01,
  0xF7, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1E, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xDF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xF8, 0x03, 0x80,
  0xFF, 0xFC, 0x0F, 0x0F, 0xFF, 0xFC, 0x3C, 0x7F, 0xFF, 0xF8, 0xF3, 0xE0,
  0x07, 0xF3, 0xDE, 0x00, 0x07, 0xCF, 0x70, 0x00, 0x0F, 0xBF, 0x80, 0x00,
  0x1E, 0xFC, 0x00, 0x00, 0x7B, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x3C,
  0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x0F, 0x9F,
  0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0xFB,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x00, 0xF0, 0xF8, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x7C, 0x07, 0xE0,
  0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0xF0, 0x3F, 0xFF, 0x00, 0xF0, 0xFF, 0xFF, 0x80, 0xF1,
  0xFF, 0xFF, 0xE0, 0xF3, 0xE0, 0x07, 0xF0, 0xF7, 0x80, 0x01, 0xF8, 0xF7,
  0x00, 0x00, 0xF8, 0xFE, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0x3C, 0xFC,
  0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x1E, 0xF8,
  0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x1E, 0xF8,
  0x00, 0x00, 0x1E, 0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3C, 0xFE,
  0x00, 0x00, 0x7C, 0xFE, 0x00, 0x00, 0xF8, 0xF7, 0x00, 0x01, 0xF8, 0xF7,
  0x80, 0x03, 0xF0, 0xF3, 0xE0, 0x0F, 0xE0, 0xF1, 0xFF, 0xFF, 0xC0, 0xF0,
  0xFF, 0xFF, 0x80, 0xF0, 0x3F, 0xFE, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x0F, 0x01,
  0xFF, 0xFF, 0x0F, 0x03, 0xFF, 0xFF, 0x8F, 0x07, 0xE0, 0x07, 0xCF, 0x0F,
  0x80, 0x01, 0xEF, 0x1F, 0x00, 0x00, 0xEF, 0x1E, 0x00, 0x00, 0x7F, 0x3E,
  0x00, 0x00, 0x3F, 0x3C, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x1F, 0x78,
  0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0x78,
  0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x3F, 0x7C,
  0x00, 0x00, 0x3F, 0x3C, 0x00, 0x00, 0x7F, 0x3E, 0x00, 0x00, 0x7F, 0x1F,
  0x00, 0x00, 0xEF, 0x0F, 0x80, 0x01, 0xCF, 0x0F, 0xE0, 0x07, 0xCF, 0x07,
  0xFF, 0xFF, 0x8F, 0x01, 0xFF, 0xFE, 0x0F, 0x00, 0x7F, 0xF8, 0x0F, 0x00,
  0x07, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0xEF, 0x81, 0xFF,
  0xBC, 0x3F, 0xFD, 0xE3, 0xFF, 0xEF, 0x3E, 0x00, 0x7B, 0xC0, 0x03, 0xDC,
  0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x0F, 0xFC, 0xFF,
  0xC3, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x01, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x80,
  0x00, 0x07, 0xDC, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0xFC, 0x7F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x02, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFD, 0xE0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x77, 0x3E,
  0x00, 0x0F, 0x39, 0xFC, 0x01, 0xF1, 0xC7, 0xFF, 0xFF, 0x0E, 0x1F, 0xFF,
  0xF0, 0x70, 0x3F, 0xFE, 0x03, 0x80, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0xBC, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x03, 0xCF, 0x80, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x01, 0xF0, 0x78, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x78, 0x07, 0x80,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xC0, 0x00, 0xF0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x7C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0x7C, 0x1E, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0xF1, 0xC0,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x78, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0x0F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x73, 0x80,
  0x00, 0xF0, 0xF0, 0x00, 0x1C, 0xF0, 0x00, 0x78, 0x3E, 0x00, 0x0F, 0x3C,
  0x00, 0x1E, 0x07, 0x80, 0x03, 0xCF, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xE1,
  0xE0, 0x01, 0xE0, 0x78, 0x00, 0x78, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0x1E,
  0x1E, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0x03, 0x80, 0x0F, 0x00, 0xF0, 0x03,
  0xC0, 0xF0, 0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0x07, 0x80,
  0x38, 0x07, 0x00, 0x78, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0x78,
  0x07, 0x80, 0x78, 0x0F, 0x00, 0x0F, 0x01, 0xC0, 0x0E, 0x03, 0xC0, 0x03,
  0xC0, 0xF0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x3C, 0x00,
  0x3C, 0x0E, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x07, 0x87, 0x80,
  0x01, 0xE1, 0xE0, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x70, 0x00, 0x78, 0x78,
  0x00, 0x0E, 0x3C, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xCF, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0xF3, 0xC0, 0x00, 0x3C, 0xE0, 0x00, 0x1C,
  0xE0, 0x00, 0x07, 0x78, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x7C, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF8, 0x1E, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x03, 0xE0, 0x07, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x03, 0xE0, 0x0F, 0x80, 0x01, 0xF0,
  0x1F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x7C,
  0x7C, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1E,
  0xF8, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x03, 0xE0,
  0x0F, 0x80, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x03, 0xC0, 0x0F, 0x80,
  0x03, 0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x3E, 0x00,
  0x00, 0x78, 0x7C, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0x3E, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x78, 0x1F,
  0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0xE0,
  0x00, 0xF0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x07, 0x07, 0x80, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x0E,
  0xF0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x03, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x01,
  0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0x7F, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x07, 0xF8, 0x0F, 0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0xFE, 0x80,
  0x00, 0x7F, 0xFC, 0x80, 0x00, 0x0F, 0xF0,
};

const GFXglyph NotoSans_Light70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 6, 51, 17, 6, -50 },
  { 40, 16, 18, 25, 5, -50 },
  { 76, 41, 50, 45, 2, -50 },
  { 333, 31, 57, 40, 4, -53 },
  { 554, 49, 52, 57, 4, -51 },
  { 873, 45, 52, 50, 4, -51 },
  { 1166, 4, 18, 14, 5, -50 },
  { 1175, 14, 61, 19, 3, -50 },
  { 1282, 15, 61, 19, 2, -50 },
  { 1397, 31, 30, 39, 4, -53 },
  { 1514, 32, 33, 40, 4, -41 },
  { 1646, 8, 17, 16, 3, -8 },
  { 1663, 17, 4, 23, 3, -21 },
  { 1672, 6, 7, 17, 6, -6 },
  { 1678, 23, 50, 24, 1, -50 },
  { 1822, 32, 52, 40, 4, -51 },
  { 2030, 17, 50, 40, 7, -50 },
  { 2137, 31, 51, 40, 4, -51 },
  { 2335, 32, 52, 40, 3, -51 },
  { 2543, 37, 50, 40, 2, -50 },
  { 2775, 31, 51, 40, 5, -50 },
  { 2973, 32, 52, 40, 4, -51 },
  { 3181, 32, 50, 40, 4, -50 },
  { 3381, 32, 52, 40, 4, -51 },
  { 3589, 32, 52, 40, 4, -51 },
  { 3797, 6, 39, 17, 6, -38 },
  { 3827, 10, 47, 17, 2, -38 },
  { 3886, 32, 33, 40, 4, -42 },
  { 4018, 32, 17, 40, 4, -33 },
  { 4086, 32, 33, 40, 4, -42 },
  { 4218, 25, 52, 30, 2, -51 },
  { 4381, 54, 57, 62, 4, -50 },
  { 4766, 43, 50, 43, 0, -50 },
  { 5035, 33, 50, 44, 7, -50 },
  { 5242, 37, 52, 44, 4, -51 },
  { 5483, 38, 50, 50, 7, -50 },
  { 5721, 27, 50, 39, 7, -50 },
  { 5890, 28, 50, 35, 7, -50 },
  { 6065, 41, 52, 51, 4, -51 },
  { 6332, 37, 50, 51, 7, -50 },
  { 6564, 14, 50, 22, 4, -50 },
  { 6652, 17, 63, 18, -6, -50 },
  { 6786, 34, 50, 41, 7, -50 },
  { 6999, 28, 50, 36, 7, -50 },
  { 7174, 47, 50, 61, 7, -50 },
  { 7468, 37, 50, 51, 7, -50 },
  { 7700, 45, 52, 54, 4, -51 },
  { 7993, 30, 50, 41, 7, -50 },
  { 8181, 45, 63, 54, 4, -51 },
  { 8536, 34, 50, 42, 7, -50 },
  { 8749, 31, 52, 38, 4, -51 },
  { 8951, 37, 50, 37, 0, -50 },
  { 9183, 37, 51, 51, 7, -50 },
  { 9419, 41, 50, 41, 0, -50 },
  { 9676, 59, 50, 63, 2, -50 },
  { 10045, 38, 50, 38, 0, -50 },
  { 10283, 38, 50, 38, 0, -50 },
  { 10521, 35, 50, 40, 3, -50 },
  { 10740, 15, 61, 22, 6, -50 },
  { 10855, 23, 50, 24, 1, -50 },
  { 10999, 15, 61, 22, 2, -50 },
  { 11114, 34, 31, 40, 3, -50 },
  { 11246, 29, 3, 29, 0, 6 },
  { 11257, 13, 12, 19, 3, -54 },
  { 11277, 29, 39, 38, 3, -38 },
  { 11419, 32, 54, 42, 6, -53 },
  { 11635, 27, 39, 33, 4, -38 },
  { 11767, 32, 54, 42, 4, -53 },
  { 11983, 31, 39, 39, 4, -38 },
  { 12135, 24, 54, 22, 1, -54 },
  { 12297, 32, 55, 42, 4, -38 },
  { 12517, 30, 53, 42, 6, -53 },
  { 12716, 6, 51, 16, 5, -51 },
  { 12755, 15, 68, 16, -4, -51 },
  { 12883, 28, 53, 35, 6, -53 },
  { 13069, 4, 53, 16, 6, -53 },
  { 13096, 51, 38, 63, 6, -38 },
  { 13339, 30, 38, 42, 6, -38 },
  { 13482, 33, 39, 41, 4, -38 },
  { 13643, 32, 55, 42, 6, -38 },
  { 13863, 32, 55, 42, 4, -38 },
  { 14083, 21, 38, 28, 6, -38 },
  { 14183, 27, 39, 33, 3, -38 },
  { 14315, 21, 47, 24, 1, -46 },
  { 14439, 29, 38, 42, 6, -37 },
  { 14577, 33, 37, 33, 0, -37 },
  { 14730, 50, 37, 52, 1, -37 },
  { 14962, 32, 37, 35, 2, -37 },
  { 15110, 33, 54, 33, 0, -37 },
  { 15333, 27, 37, 32, 3, -37 },
  { 15458, 21, 61, 25, 2, -50 },
  { 15619, 4, 70, 38, 17, -53 },
  { 15654, 21, 61, 25, 2, -50 },
  { 15815, 32, 8, 40, 4, -29 },
};

const GFXfont NotoSans_Light70pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light70pt7bBitmaps,
  (GFXglyph *)NotoSans_Light70pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _NOTOSANS_LIGHT70PT7B_H_
