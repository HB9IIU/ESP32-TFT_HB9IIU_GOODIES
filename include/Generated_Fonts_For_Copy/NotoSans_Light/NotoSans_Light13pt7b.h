#ifndef _NOTOSANS_LIGHT13PT7B_H_
#define _NOTOSANS_LIGHT13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light13pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0x80, 0xB6, 0x80, 0x12, 0x12, 0x5F, 0x24, 0x24, 0xFF, 0x24,
  0x24, 0x48, 0x23, 0xE9, 0x4E, 0x18, 0xA5, 0xAB, 0x88, 0xE2, 0x4A, 0x25,
  0x15, 0x6A, 0xCA, 0xA4, 0x52, 0x49, 0x43, 0x00, 0x78, 0x48, 0x48, 0x30,
  0x50, 0x89, 0x86, 0x86, 0x79, 0xE0, 0x6A, 0xAA, 0xA4, 0xC8, 0x92, 0x49,
  0x2B, 0x00, 0x21, 0x3E, 0x45, 0x2C, 0x20, 0x82, 0x3F, 0x20, 0x80, 0xF0,
  0xE0, 0x80, 0x11, 0x22, 0x24, 0x44, 0x80, 0x7A, 0x28, 0x61, 0x86, 0x18,
  0x62, 0x70, 0x3C, 0x92, 0x49, 0x20, 0xF8, 0x20, 0x82, 0x10, 0x84, 0x20,
  0xFC, 0xF8, 0x20, 0x82, 0x70, 0x20, 0x42, 0xF8, 0x0C, 0x28, 0x51, 0x24,
  0x48, 0xBF, 0x82, 0x04, 0xFA, 0x08, 0x3C, 0x08, 0x10, 0x42, 0xF8, 0x7A,
  0x08, 0x3C, 0x8A, 0x18, 0x61, 0x78, 0xFC, 0x20, 0x84, 0x10, 0x42, 0x08,
  0x40, 0xFA, 0x28, 0x94, 0x72, 0x28, 0x61, 0x78, 0xFA, 0x28, 0x61, 0x9D,
  0x90, 0x82, 0xF0, 0x82, 0x40, 0x15, 0x80, 0x04, 0x66, 0x20, 0x60, 0x70,
  0xFC, 0x0F, 0xC0, 0x81, 0x81, 0x03, 0x33, 0x00, 0xF8, 0x42, 0x32, 0x10,
  0x80, 0x20, 0x3F, 0x10, 0x28, 0xE6, 0x49, 0xA2, 0x68, 0x9A, 0x26, 0x76,
  0x40, 0x0F, 0x80, 0x18, 0x18, 0x24, 0x24, 0x24, 0x7E, 0x42, 0x82, 0x81,
  0xFD, 0x0A, 0x14, 0x2F, 0xD0, 0xA0, 0xC2, 0xF8, 0x7F, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x20, 0x3C, 0xFD, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC2, 0xF8,
  0xFC, 0x21, 0x0F, 0xC2, 0x10, 0xF8, 0xFC, 0x21, 0x0F, 0xC2, 0x10, 0x80,
  0x3E, 0x82, 0x04, 0x08, 0xF0, 0x60, 0xA1, 0x3E, 0x83, 0x06, 0x0C, 0x1F,
  0xF0, 0x60, 0xC1, 0x82, 0xD5, 0x55, 0xC0, 0x24, 0x92, 0x49, 0x27, 0x80,
  0x87, 0x12, 0x45, 0x0E, 0x12, 0x22, 0x42, 0x86, 0x84, 0x21, 0x08, 0x42,
  0x10, 0xF8, 0xC0, 0xE0, 0xE8, 0x74, 0x5A, 0x2C, 0xA6, 0x53, 0x19, 0x88,
  0x80, 0xC3, 0x86, 0x8C, 0x99, 0x31, 0x61, 0xC3, 0x82, 0x7E, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x42, 0x3C, 0xFA, 0x18, 0x61, 0xFA, 0x08, 0x20,
  0x80, 0x7E, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x42, 0x3C, 0x04, 0x02,
  0xF9, 0x0A, 0x14, 0x2F, 0x92, 0x22, 0x42, 0x86, 0xFC, 0x21, 0x83, 0x04,
  0x21, 0xF8, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xA1, 0x7C, 0x83, 0x42, 0x42, 0x44, 0x24, 0x24,
  0x28, 0x18, 0x10, 0x84, 0x28, 0xC5, 0x28, 0xA5, 0x24, 0x94, 0x52, 0x8C,
  0x51, 0x84, 0x10, 0x80, 0xC6, 0x88, 0xA0, 0x81, 0x05, 0x09, 0x22, 0x82,
  0x82, 0x89, 0x11, 0x43, 0x02, 0x04, 0x08, 0x10, 0x7E, 0x08, 0x20, 0x41,
  0x04, 0x08, 0x20, 0xFE, 0xF2, 0x49, 0x24, 0x93, 0x80, 0x84, 0x44, 0x22,
  0x11, 0x10, 0xE4, 0x92, 0x49, 0x27, 0x80, 0x21, 0x44, 0xA2, 0x84, 0xF8,
  0x90, 0xF0, 0x42, 0xF8, 0xC7, 0xE0, 0x82, 0x08, 0x3E, 0x86, 0x18, 0x61,
  0x87, 0xE0, 0x7C, 0x21, 0x08, 0x41, 0xE0, 0x04, 0x10, 0x5D, 0x8E, 0x18,
  0x61, 0x85, 0xF0, 0x74, 0x63, 0xF8, 0x41, 0xE0, 0x3A, 0x11, 0xE4, 0x21,
  0x08, 0x42, 0x00, 0x76, 0x38, 0x61, 0x86, 0x17, 0xC1, 0x07, 0xE0, 0x82,
  0x08, 0x3E, 0x86, 0x18, 0x61, 0x86, 0x10, 0xBF, 0x80, 0x20, 0x92, 0x49,
  0x24, 0xF0, 0x84, 0x21, 0x19, 0x53, 0x92, 0x94, 0x40, 0xFF, 0xC0, 0xFB,
  0xA3, 0x18, 0x86, 0x21, 0x88, 0x62, 0x18, 0x84, 0xFA, 0x18, 0x61, 0x86,
  0x18, 0x40, 0x7A, 0x18, 0x61, 0x86, 0x17, 0x80, 0xFA, 0x18, 0x61, 0x86,
  0x1F, 0xA0, 0x82, 0x00, 0x76, 0x38, 0x61, 0x86, 0x37, 0x41, 0x04, 0x10,
  0xF8, 0x88, 0x88, 0x80, 0xF4, 0x20, 0xC1, 0x07, 0xC0, 0x44, 0xF4, 0x44,
  0x44, 0x30, 0x86, 0x18, 0x61, 0x86, 0x37, 0x40, 0x86, 0x14, 0x92, 0x28,
  0xC3, 0x00, 0x88, 0xC6, 0x53, 0x2A, 0x95, 0x31, 0x18, 0x84, 0xC5, 0x23,
  0x04, 0x29, 0x2C, 0x40, 0x86, 0x14, 0x92, 0x28, 0xC1, 0x08, 0x23, 0x00,
  0xF1, 0x22, 0x48, 0xF0, 0x32, 0x22, 0x2C, 0x22, 0x22, 0x30, 0xFF, 0xF8,
  0xC2, 0x22, 0x21, 0x22, 0x22, 0xC0, 0xFC,
};

const GFXglyph NotoSans_Light13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 9, 3, 1, -9 },
  { 3, 3, 3, 5, 1, -9 },
  { 5, 8, 9, 8, 0, -9 },
  { 14, 5, 11, 7, 1, -10 },
  { 21, 9, 9, 11, 1, -9 },
  { 32, 8, 9, 9, 1, -9 },
  { 41, 1, 3, 3, 1, -9 },
  { 42, 2, 11, 4, 1, -9 },
  { 45, 3, 11, 4, 0, -9 },
  { 50, 5, 6, 7, 1, -10 },
  { 54, 6, 6, 7, 1, -8 },
  { 59, 1, 4, 3, 1, -2 },
  { 60, 3, 1, 4, 1, -4 },
  { 61, 1, 1, 3, 1, -1 },
  { 62, 4, 9, 5, 0, -9 },
  { 67, 6, 9, 7, 1, -9 },
  { 74, 3, 9, 7, 1, -9 },
  { 78, 6, 9, 7, 1, -9 },
  { 85, 6, 9, 7, 1, -9 },
  { 92, 7, 9, 7, 0, -9 },
  { 100, 6, 9, 7, 1, -9 },
  { 107, 6, 9, 7, 1, -9 },
  { 114, 6, 9, 7, 1, -9 },
  { 121, 6, 9, 7, 1, -9 },
  { 128, 6, 9, 7, 1, -9 },
  { 135, 1, 7, 3, 1, -7 },
  { 136, 2, 9, 3, 0, -7 },
  { 139, 6, 6, 7, 1, -8 },
  { 144, 6, 3, 7, 1, -6 },
  { 147, 6, 6, 7, 1, -8 },
  { 152, 5, 9, 6, 0, -9 },
  { 158, 10, 10, 12, 1, -9 },
  { 171, 8, 9, 8, 0, -9 },
  { 180, 7, 9, 8, 1, -9 },
  { 188, 7, 9, 8, 1, -9 },
  { 196, 7, 9, 9, 1, -9 },
  { 204, 5, 9, 7, 1, -9 },
  { 210, 5, 9, 7, 1, -9 },
  { 216, 7, 9, 9, 1, -9 },
  { 224, 7, 9, 9, 1, -9 },
  { 232, 2, 9, 4, 1, -9 },
  { 235, 3, 11, 3, -1, -9 },
  { 240, 7, 9, 8, 1, -9 },
  { 248, 5, 9, 7, 1, -9 },
  { 254, 9, 9, 11, 1, -9 },
  { 265, 7, 9, 9, 1, -9 },
  { 273, 8, 9, 10, 1, -9 },
  { 282, 6, 9, 8, 1, -9 },
  { 289, 8, 11, 10, 1, -9 },
  { 300, 7, 9, 8, 1, -9 },
  { 308, 5, 9, 7, 1, -9 },
  { 314, 7, 9, 7, 0, -9 },
  { 322, 7, 9, 9, 1, -9 },
  { 330, 8, 9, 8, 0, -9 },
  { 339, 11, 9, 12, 0, -9 },
  { 352, 7, 9, 7, 0, -9 },
  { 360, 7, 9, 7, 0, -9 },
  { 368, 7, 9, 7, 0, -9 },
  { 376, 3, 11, 4, 1, -9 },
  { 381, 4, 9, 5, 0, -9 },
  { 386, 3, 11, 4, 0, -9 },
  { 391, 6, 5, 7, 1, -9 },
  { 395, 5, 1, 5, 0, 1 },
  { 396, 2, 2, 3, 1, -10 },
  { 397, 5, 7, 7, 1, -7 },
  { 402, 6, 10, 8, 1, -10 },
  { 410, 5, 7, 6, 1, -7 },
  { 415, 6, 10, 8, 1, -10 },
  { 423, 5, 7, 7, 1, -7 },
  { 428, 5, 10, 4, 0, -10 },
  { 435, 6, 10, 8, 1, -7 },
  { 443, 6, 10, 8, 1, -10 },
  { 451, 1, 9, 3, 1, -9 },
  { 453, 3, 12, 3, -1, -9 },
  { 458, 5, 10, 6, 1, -10 },
  { 465, 1, 10, 3, 1, -10 },
  { 467, 10, 7, 12, 1, -7 },
  { 476, 6, 7, 8, 1, -7 },
  { 482, 6, 7, 8, 1, -7 },
  { 488, 6, 10, 8, 1, -7 },
  { 496, 6, 10, 8, 1, -7 },
  { 504, 4, 7, 5, 1, -7 },
  { 508, 5, 7, 6, 1, -7 },
  { 513, 4, 9, 4, 0, -9 },
  { 518, 6, 7, 8, 1, -7 },
  { 524, 6, 7, 6, 0, -7 },
  { 530, 9, 7, 10, 0, -7 },
  { 538, 6, 7, 7, 0, -7 },
  { 544, 6, 10, 6, 0, -7 },
  { 552, 4, 7, 6, 1, -7 },
  { 556, 4, 11, 5, 0, -9 },
  { 562, 1, 13, 7, 3, -10 },
  { 564, 4, 11, 5, 0, -9 },
  { 570, 6, 1, 7, 1, -5 },
};

const GFXfont NotoSans_Light13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light13pt7bBitmaps,
  (GFXglyph *)NotoSans_Light13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_LIGHT13PT7B_H_
