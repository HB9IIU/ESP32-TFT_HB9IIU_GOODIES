#ifndef _NOTOSANS_LIGHT26PT7B_H_
#define _NOTOSANS_LIGHT26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light26pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFD, 0x55, 0x50, 0x3C, 0x8E, 0x38, 0xE3, 0x8E, 0x28, 0x80,
  0x02, 0x18, 0x0C, 0x20, 0x18, 0x40, 0x20, 0x80, 0x41, 0x00, 0x86, 0x1F,
  0xFF, 0x86, 0x10, 0x08, 0x20, 0x10, 0x40, 0x21, 0x80, 0x43, 0x0F, 0xFF,
  0xC2, 0x08, 0x04, 0x10, 0x08, 0x60, 0x10, 0xC0, 0x61, 0x00, 0xC2, 0x00,
  0x04, 0x00, 0x80, 0x7C, 0x3B, 0xEC, 0x41, 0x08, 0x21, 0x04, 0x20, 0xC4,
  0x0E, 0x80, 0x78, 0x03, 0xC0, 0x4C, 0x08, 0xC1, 0x18, 0x23, 0x04, 0x50,
  0xBB, 0xFC, 0x02, 0x00, 0x40, 0x08, 0x00, 0x1C, 0x02, 0x0C, 0xC0, 0xC1,
  0x08, 0x10, 0x21, 0x86, 0x0C, 0x30, 0x81, 0x86, 0x30, 0x30, 0xC4, 0x06,
  0x19, 0x80, 0x43, 0x27, 0x88, 0x49, 0x09, 0x9B, 0x21, 0x0C, 0x4C, 0x30,
  0x19, 0x86, 0x02, 0x30, 0xC0, 0xC6, 0x18, 0x10, 0xC3, 0x06, 0x08, 0x40,
  0x81, 0x98, 0x20, 0x1E, 0x00, 0x0F, 0x00, 0x39, 0x80, 0x20, 0xC0, 0x60,
  0x40, 0x60, 0x40, 0x20, 0xC0, 0x30, 0x80, 0x1B, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x63, 0x02, 0xC1, 0x86, 0x80, 0xC6, 0x80, 0x64, 0x80, 0x3C, 0x80,
  0x18, 0xC0, 0x3C, 0x60, 0xE6, 0x3F, 0x83, 0xFE, 0x08, 0xCC, 0x46, 0x31,
  0x08, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0x42, 0x18, 0x43, 0x08, 0x60, 0x82,
  0x18, 0x43, 0x08, 0x43, 0x18, 0x42, 0x10, 0x84, 0x63, 0x18, 0x8C, 0x62,
  0x33, 0x00, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x62, 0x7F, 0xFE, 0x06,
  0x00, 0xF0, 0x09, 0x81, 0x88, 0x30, 0xC0, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x0F, 0xFF, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x6D, 0xAD, 0x80, 0xFF, 0xF0, 0xF0, 0x01, 0x80, 0x80, 0xC0, 0x60,
  0x20, 0x30, 0x10, 0x08, 0x0C, 0x04, 0x06, 0x03, 0x01, 0x01, 0x80, 0xC0,
  0x40, 0x60, 0x20, 0x30, 0x00, 0x0F, 0x81, 0xDC, 0x30, 0x66, 0x02, 0x60,
  0x34, 0x01, 0x40, 0x14, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x40,
  0x14, 0x03, 0x40, 0x36, 0x03, 0x20, 0x63, 0x8C, 0x0F, 0x80, 0x06, 0x1C,
  0x7B, 0xBC, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x0F, 0x03, 0xFC, 0x60, 0x60, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0xFF, 0xF0, 0x0F, 0x07, 0xFC, 0xC0,
  0x60, 0x02, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x03, 0xC1, 0xF8, 0x00,
  0xE0, 0x03, 0x00, 0x30, 0x01, 0x00, 0x30, 0x03, 0x00, 0x2C, 0x0E, 0x7F,
  0x80, 0x00, 0x40, 0x06, 0x00, 0x70, 0x02, 0x80, 0x24, 0x03, 0x20, 0x31,
  0x01, 0x08, 0x10, 0x41, 0x82, 0x18, 0x10, 0x80, 0x8C, 0x04, 0x7F, 0xFC,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x7F, 0xCF, 0xF9, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0xFF, 0x88, 0x38, 0x01, 0x80,
  0x30, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x58, 0x3B, 0xFC, 0x00, 0x07,
  0xC1, 0xE4, 0x30, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x20, 0x9F,
  0x8A, 0x04, 0xC0, 0x68, 0x02, 0x80, 0x28, 0x03, 0x80, 0x2C, 0x02, 0x60,
  0x63, 0x0C, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x03, 0x00, 0x20,
  0x06, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00,
  0x20, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18, 0x00, 0x0F, 0x83, 0xDC,
  0x20, 0x66, 0x03, 0x60, 0x36, 0x03, 0x20, 0x23, 0x0C, 0x0D, 0x80, 0xF8,
  0x38, 0xC6, 0x06, 0x40, 0x34, 0x01, 0xC0, 0x14, 0x01, 0x60, 0x33, 0x06,
  0x1F, 0xC0, 0x0F, 0x03, 0xDC, 0x60, 0x64, 0x02, 0x40, 0x3C, 0x01, 0xC0,
  0x1C, 0x01, 0x40, 0x36, 0x07, 0x38, 0xD1, 0xF1, 0x00, 0x30, 0x03, 0x00,
  0x20, 0x06, 0x00, 0xC0, 0x18, 0x3F, 0x00, 0xF4, 0x00, 0x00, 0xF0, 0x6C,
  0x80, 0x00, 0x00, 0x36, 0x96, 0x80, 0x00, 0x10, 0x03, 0x00, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0x00, 0x10, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x07, 0x01,
  0xC0, 0x60, 0x38, 0x0E, 0x00, 0x80, 0x00, 0x3C, 0x7F, 0x80, 0x60, 0x10,
  0x08, 0x04, 0x06, 0x02, 0x06, 0x06, 0x06, 0x02, 0x01, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x1C, 0x0C, 0x00, 0x03, 0xFF, 0x00, 0x30, 0x0E, 0x06, 0x00,
  0x18, 0x20, 0x00, 0x42, 0x00, 0x03, 0x30, 0x7F, 0x09, 0x06, 0x08, 0x48,
  0x60, 0xC3, 0x42, 0x06, 0x1E, 0x10, 0x30, 0xF0, 0x81, 0x87, 0x84, 0x0C,
  0x24, 0x20, 0x61, 0x21, 0x85, 0x11, 0x07, 0xC7, 0x8C, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x80, 0x0F, 0xFC, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x02, 0x40, 0x06, 0x60, 0x04, 0x20,
  0x04, 0x20, 0x0C, 0x30, 0x08, 0x10, 0x18, 0x18, 0x1F, 0xF8, 0x1F, 0xF8,
  0x30, 0x0C, 0x20, 0x0C, 0x60, 0x04, 0x60, 0x06, 0x40, 0x02, 0xC0, 0x03,
  0xF8, 0x0F, 0xFC, 0x80, 0x68, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x06,
  0x83, 0xCF, 0xF8, 0x80, 0xE8, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x68, 0x1C, 0xFF, 0x80, 0x03, 0xE0, 0x7F, 0xCE, 0x02, 0xC0, 0x06,
  0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x43, 0xFE,
  0xF8, 0x03, 0xFF, 0x08, 0x0E, 0x20, 0x0C, 0x80, 0x1A, 0x00, 0x28, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x28, 0x01, 0xA0, 0x0C, 0x80, 0x72, 0x0F, 0x0F, 0xF0, 0x00, 0xFF, 0xFF,
  0xF8, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x3F, 0xE8, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x0F, 0xFC, 0xFF, 0xFF,
  0xF8, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x3F, 0xEF, 0xFA,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x00, 0x03, 0xF0,
  0x1F, 0xFC, 0xE0, 0x11, 0x80, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x03, 0xFC, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xB0, 0x03, 0x30, 0x06, 0x38, 0x1C, 0x3F, 0xF0, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0F, 0xFF, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x02, 0xFD, 0xE3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xCF, 0xC0, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x0C,
  0x3F, 0xB8, 0x80, 0x38, 0x06, 0x80, 0xC8, 0x18, 0x83, 0x08, 0x60, 0x8C,
  0x08, 0x80, 0x98, 0x0A, 0x80, 0xCC, 0x08, 0x60, 0x83, 0x08, 0x30, 0x81,
  0x88, 0x0C, 0x80, 0x48, 0x06, 0x80, 0x30, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x0F, 0xFC, 0xC0, 0x01, 0xE0, 0x01, 0xF8,
  0x00, 0xB4, 0x00, 0x5A, 0x00, 0x6D, 0x80, 0x26, 0x40, 0x33, 0x30, 0x11,
  0x88, 0x08, 0xC4, 0x0C, 0x63, 0x04, 0x30, 0x86, 0x18, 0x62, 0x0C, 0x31,
  0x06, 0x09, 0x83, 0x06, 0x81, 0x81, 0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x20,
  0x80, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x1B, 0x00, 0xCC, 0x06, 0x60, 0x31,
  0x81, 0x86, 0x0C, 0x30, 0x60, 0xC3, 0x03, 0x18, 0x18, 0xC0, 0x66, 0x01,
  0xB0, 0x0D, 0x80, 0x3C, 0x00, 0xE0, 0x06, 0x07, 0xE0, 0x1F, 0xF8, 0x30,
  0x0C, 0x60, 0x06, 0x40, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x03, 0xC0,
  0x02, 0x60, 0x06, 0x30, 0x0C, 0x18, 0x18, 0x0F, 0xF0, 0xFC, 0x1F, 0xF2,
  0x03, 0x40, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x50, 0x3B, 0xFC,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x00,
  0x07, 0xE0, 0x1F, 0xF8, 0x30, 0x0C, 0x60, 0x06, 0x40, 0x02, 0xC0, 0x03,
  0xC0, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x03, 0xC0, 0x03, 0xC0, 0x02, 0x60, 0x06, 0x30, 0x0C, 0x18, 0x18,
  0x0F, 0xF0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0xFC, 0x0F,
  0xF8, 0x80, 0xC8, 0x06, 0x80, 0x68, 0x06, 0x80, 0x68, 0x06, 0x80, 0xC8,
  0x38, 0xFE, 0x08, 0x30, 0x83, 0x08, 0x18, 0x80, 0x88, 0x0C, 0x80, 0x68,
  0x06, 0x80, 0x30, 0x0F, 0x83, 0xFE, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x60, 0x06, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x2C, 0x0E, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xF0,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x14, 0x00, 0x58, 0x03, 0x60, 0x18,
  0xE0, 0xC0, 0xFE, 0x00, 0xC0, 0x07, 0x80, 0x0D, 0x00, 0x13, 0x00, 0x66,
  0x00, 0xC4, 0x01, 0x0C, 0x06, 0x08, 0x0C, 0x18, 0x10, 0x30, 0x60, 0x20,
  0x80, 0x63, 0x00, 0xC6, 0x00, 0x88, 0x01, 0xB0, 0x01, 0x60, 0x02, 0x80,
  0x07, 0x00, 0x06, 0x00, 0x80, 0x20, 0x0E, 0x00, 0xC0, 0x3C, 0x07, 0x00,
  0xB0, 0x14, 0x06, 0x40, 0x58, 0x19, 0x83, 0x60, 0x46, 0x0C, 0x81, 0x18,
  0x22, 0x0C, 0x20, 0x8C, 0x30, 0xC6, 0x10, 0x83, 0x10, 0x42, 0x04, 0x41,
  0x98, 0x13, 0x06, 0x60, 0x6C, 0x09, 0x01, 0xA0, 0x2C, 0x02, 0x80, 0xF0,
  0x0E, 0x01, 0x80, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x00, 0x40, 0x0D, 0x80,
  0x63, 0x01, 0x0C, 0x0C, 0x18, 0x20, 0x21, 0x80, 0xCC, 0x01, 0xA0, 0x03,
  0x80, 0x0C, 0x00, 0x78, 0x01, 0x20, 0x0C, 0xC0, 0x21, 0x81, 0x82, 0x0C,
  0x0C, 0x20, 0x19, 0x80, 0x2C, 0x00, 0xC0, 0xC0, 0x0D, 0x00, 0x26, 0x01,
  0x88, 0x04, 0x30, 0x30, 0x40, 0x81, 0x86, 0x02, 0x30, 0x0C, 0xC0, 0x16,
  0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0x40,
  0x06, 0x00, 0x60, 0x02, 0x00, 0x30, 0x03, 0x00, 0x10, 0x01, 0x80, 0x18,
  0x00, 0x80, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x06, 0x00, 0x3F, 0xFE,
  0xFF, 0xFC, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0F, 0xC0, 0xC0, 0x20, 0x18, 0x0C, 0x02, 0x01,
  0x80, 0x40, 0x20, 0x18, 0x04, 0x03, 0x01, 0x80, 0x40, 0x30, 0x08, 0x04,
  0x03, 0x00, 0x80, 0x60, 0xFF, 0xC2, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x87, 0xE0, 0x02, 0x00, 0x30, 0x01, 0x40,
  0x1A, 0x00, 0x88, 0x0C, 0x60, 0x41, 0x06, 0x0C, 0x20, 0x23, 0x01, 0x90,
  0x05, 0x80, 0x30, 0xFF, 0xFF, 0xFC, 0xC3, 0x0C, 0x30, 0x1F, 0x86, 0x18,
  0x01, 0x00, 0x30, 0x06, 0x00, 0xC3, 0xF9, 0x83, 0x60, 0x78, 0x0F, 0x01,
  0xE0, 0x76, 0x1A, 0x7E, 0x40, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xCF, 0x8F, 0x0C, 0xE0, 0x6C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x06, 0xF0, 0xC9, 0xF8, 0x0F,
  0xE3, 0x08, 0xC0, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0x40, 0x08,
  0x01, 0x80, 0x30, 0x03, 0x84, 0x1F, 0x80, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x0F, 0x93, 0x8D, 0x20, 0x36, 0x03, 0x40, 0x14,
  0x01, 0xC0, 0x1C, 0x01, 0x40, 0x14, 0x01, 0x60, 0x36, 0x03, 0x30, 0x51,
  0xF9, 0x0F, 0x83, 0x8C, 0x20, 0x66, 0x02, 0x40, 0x34, 0x03, 0xFF, 0xFC,
  0x00, 0x40, 0x04, 0x00, 0x60, 0x06, 0x00, 0x38, 0x20, 0xFE, 0x07, 0x86,
  0x46, 0x03, 0x01, 0x00, 0x83, 0xFC, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00, 0x0F, 0x93, 0x8D,
  0x20, 0x36, 0x03, 0x40, 0x14, 0x01, 0xC0, 0x1C, 0x01, 0x40, 0x14, 0x01,
  0x60, 0x36, 0x03, 0x30, 0x51, 0xF9, 0x00, 0x10, 0x01, 0x00, 0x30, 0x03,
  0x60, 0x63, 0xFC, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x33,
  0xE7, 0x86, 0xE0, 0x78, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x10, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC,
  0x18, 0xC0, 0x00, 0x0C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x8C, 0x62, 0xF0, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x36, 0x0C, 0xC3, 0x18, 0xC3, 0x10, 0x64, 0x0D, 0x81, 0xD8, 0x31,
  0x86, 0x10, 0xC3, 0x18, 0x33, 0x03, 0x60, 0x30, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xCF, 0x8F, 0x9E, 0x3B, 0x1B, 0x83, 0x81, 0xE0, 0x30, 0x1C, 0x06,
  0x03, 0x80, 0x80, 0x70, 0x10, 0x0E, 0x02, 0x01, 0xC0, 0x40, 0x38, 0x08,
  0x07, 0x01, 0x00, 0xE0, 0x20, 0x1C, 0x04, 0x03, 0x80, 0x80, 0x40, 0xCF,
  0x9A, 0x1B, 0x81, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x40, 0x0F, 0xC1, 0xC3, 0x08, 0x0C,
  0xC0, 0x24, 0x01, 0xA0, 0x0F, 0x00, 0x78, 0x03, 0x40, 0x1A, 0x00, 0xD8,
  0x04, 0x40, 0x63, 0x06, 0x07, 0xE0, 0xCF, 0x8D, 0x0C, 0xE0, 0x6C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x06,
  0xF0, 0xCD, 0xF8, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0x0F, 0x93, 0x8D, 0x60, 0x36, 0x03, 0x40, 0x14, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x14, 0x01, 0x60, 0x36, 0x03, 0x30, 0xD1, 0xF9, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0xCF, 0xD9, 0xE0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x3F, 0xD8, 0x24, 0x03,
  0x00, 0x40, 0x1C, 0x03, 0xC0, 0x1C, 0x01, 0x80, 0x30, 0x04, 0x03, 0xC1,
  0x9F, 0xC0, 0x10, 0x10, 0x30, 0xFF, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x18, 0x0F, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x36,
  0x1A, 0x7E, 0x40, 0xC0, 0x34, 0x03, 0x40, 0x26, 0x06, 0x20, 0x63, 0x04,
  0x30, 0xC1, 0x08, 0x18, 0x80, 0x98, 0x09, 0x00, 0xF0, 0x06, 0x00, 0x60,
  0xC0, 0x60, 0x68, 0x1C, 0x09, 0x82, 0x81, 0x30, 0x58, 0x62, 0x0B, 0x0C,
  0x43, 0x21, 0x0C, 0x44, 0x21, 0x88, 0xCC, 0x13, 0x09, 0x82, 0x41, 0x20,
  0x68, 0x34, 0x07, 0x03, 0x80, 0xC0, 0x60, 0x18, 0x0C, 0x00, 0xC0, 0x68,
  0x09, 0x83, 0x18, 0xC1, 0xB0, 0x14, 0x03, 0x80, 0x70, 0x1B, 0x02, 0x20,
  0xC6, 0x30, 0x64, 0x05, 0x80, 0xC0, 0xC0, 0x14, 0x03, 0x40, 0x26, 0x06,
  0x20, 0x63, 0x04, 0x10, 0xC1, 0x08, 0x18, 0x80, 0x98, 0x0D, 0x00, 0xF0,
  0x07, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x18, 0x0F, 0x00,
  0x7F, 0xC0, 0x30, 0x18, 0x04, 0x03, 0x01, 0x80, 0x40, 0x30, 0x18, 0x0C,
  0x02, 0x01, 0x80, 0xC0, 0x3F, 0xF0, 0x02, 0x1C, 0x60, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0xC7, 0x0E, 0x06, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x03, 0x81, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0xE0,
  0x30, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x08, 0x07, 0x0E, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x10, 0x30, 0xE0, 0x10, 0x07, 0xE1,
  0x83, 0xF0,
};

const GFXglyph NotoSans_Light26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 19, 6, 2, -19 },
  { 6, 6, 7, 9, 2, -19 },
  { 12, 15, 19, 17, 1, -19 },
  { 48, 11, 22, 15, 2, -20 },
  { 79, 19, 19, 21, 1, -19 },
  { 125, 16, 19, 19, 2, -19 },
  { 163, 1, 7, 5, 2, -19 },
  { 164, 5, 23, 7, 1, -19 },
  { 179, 5, 23, 7, 1, -19 },
  { 194, 12, 11, 14, 1, -20 },
  { 211, 12, 12, 15, 1, -15 },
  { 229, 3, 6, 6, 1, -3 },
  { 232, 6, 2, 8, 1, -8 },
  { 234, 2, 2, 6, 2, -2 },
  { 235, 9, 19, 9, 0, -19 },
  { 257, 12, 19, 15, 1, -19 },
  { 286, 7, 19, 15, 2, -19 },
  { 303, 12, 19, 15, 1, -19 },
  { 332, 12, 19, 15, 1, -19 },
  { 361, 13, 19, 15, 1, -19 },
  { 392, 11, 19, 15, 2, -19 },
  { 419, 12, 19, 15, 2, -19 },
  { 448, 12, 19, 15, 1, -19 },
  { 477, 12, 19, 15, 1, -19 },
  { 506, 12, 19, 15, 1, -19 },
  { 535, 2, 14, 6, 2, -14 },
  { 539, 3, 17, 6, 1, -14 },
  { 546, 12, 13, 15, 1, -16 },
  { 566, 12, 6, 15, 1, -12 },
  { 575, 12, 13, 15, 1, -16 },
  { 595, 9, 19, 11, 1, -19 },
  { 617, 21, 20, 23, 1, -18 },
  { 670, 16, 19, 16, 0, -19 },
  { 708, 12, 19, 16, 3, -19 },
  { 737, 13, 19, 16, 2, -19 },
  { 768, 14, 19, 18, 3, -19 },
  { 802, 10, 19, 14, 3, -19 },
  { 826, 10, 19, 13, 3, -19 },
  { 850, 15, 19, 19, 2, -19 },
  { 886, 13, 19, 19, 3, -19 },
  { 917, 6, 19, 8, 1, -19 },
  { 932, 6, 24, 7, -2, -19 },
  { 950, 12, 19, 15, 3, -19 },
  { 979, 10, 19, 13, 3, -19 },
  { 1003, 17, 19, 23, 3, -19 },
  { 1044, 13, 19, 19, 3, -19 },
  { 1075, 16, 19, 20, 2, -19 },
  { 1113, 11, 19, 15, 3, -19 },
  { 1140, 16, 23, 20, 2, -19 },
  { 1186, 12, 19, 16, 3, -19 },
  { 1215, 12, 19, 14, 1, -19 },
  { 1244, 14, 19, 14, 0, -19 },
  { 1278, 14, 19, 19, 2, -19 },
  { 1312, 15, 19, 15, 0, -19 },
  { 1348, 22, 19, 23, 1, -19 },
  { 1401, 14, 19, 14, 0, -19 },
  { 1435, 14, 19, 14, 0, -19 },
  { 1469, 13, 19, 15, 1, -19 },
  { 1500, 6, 23, 8, 2, -19 },
  { 1518, 9, 19, 9, 0, -19 },
  { 1540, 5, 23, 8, 1, -19 },
  { 1555, 13, 12, 15, 1, -19 },
  { 1575, 11, 2, 11, 0, 2 },
  { 1578, 5, 4, 7, 1, -20 },
  { 1581, 11, 14, 14, 1, -14 },
  { 1601, 12, 20, 16, 2, -20 },
  { 1631, 11, 14, 12, 1, -14 },
  { 1651, 12, 20, 16, 1, -20 },
  { 1681, 12, 14, 14, 1, -14 },
  { 1702, 9, 20, 8, 0, -20 },
  { 1725, 12, 20, 16, 1, -14 },
  { 1755, 11, 20, 16, 2, -20 },
  { 1783, 2, 19, 6, 2, -19 },
  { 1788, 5, 25, 6, -1, -19 },
  { 1804, 11, 20, 13, 2, -20 },
  { 1832, 2, 20, 6, 2, -20 },
  { 1837, 19, 14, 23, 2, -14 },
  { 1871, 11, 14, 16, 2, -14 },
  { 1891, 13, 14, 15, 1, -14 },
  { 1914, 12, 20, 16, 2, -14 },
  { 1944, 12, 20, 16, 1, -14 },
  { 1974, 8, 14, 10, 2, -14 },
  { 1988, 10, 14, 12, 1, -14 },
  { 2006, 8, 17, 9, 0, -17 },
  { 2023, 11, 14, 16, 2, -14 },
  { 2043, 12, 14, 12, 0, -14 },
  { 2064, 19, 14, 19, 0, -14 },
  { 2098, 11, 14, 13, 1, -14 },
  { 2118, 12, 20, 12, 0, -14 },
  { 2148, 10, 14, 12, 1, -14 },
  { 2166, 7, 23, 9, 1, -19 },
  { 2187, 2, 26, 14, 6, -20 },
  { 2194, 8, 23, 9, 1, -19 },
  { 2217, 12, 3, 15, 1, -11 },
};

const GFXfont NotoSans_Light26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light26pt7bBitmaps,
  (GFXglyph *)NotoSans_Light26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_LIGHT26PT7B_H_
