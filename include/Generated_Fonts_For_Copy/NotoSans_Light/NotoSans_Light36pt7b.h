#ifndef _NOTOSANS_LIGHT36PT7B_H_
#define _NOTOSANS_LIGHT36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light36pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xDB, 0x24, 0x92, 0x49, 0x00, 0x07, 0xFC, 0xE3,
  0xB1, 0xD8, 0x6C, 0x26, 0x12, 0x09, 0x04, 0x82, 0x41, 0x20, 0x80, 0x00,
  0xC0, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x20, 0x01, 0x01, 0x00, 0x18, 0x18,
  0x00, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x30, 0x7F, 0xFF, 0xFB, 0xFF,
  0xFF, 0xC0, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x30, 0x01, 0x01, 0x00,
  0x08, 0x18, 0x00, 0xC0, 0xC0, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x81, 0x81,
  0x00, 0x08, 0x18, 0x00, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x30, 0x01,
  0x81, 0x00, 0x08, 0x18, 0x00, 0xC0, 0xC0, 0x00, 0x01, 0x80, 0x01, 0x80,
  0x07, 0xE0, 0x1F, 0xFE, 0x39, 0x8C, 0x61, 0x80, 0xE1, 0x80, 0xC1, 0x80,
  0xC1, 0x80, 0xE1, 0x80, 0x61, 0x80, 0x71, 0x80, 0x3F, 0x80, 0x0F, 0xC0,
  0x03, 0xF0, 0x01, 0xFC, 0x01, 0x8E, 0x01, 0x86, 0x01, 0x87, 0x01, 0x83,
  0x01, 0x83, 0x01, 0x87, 0x01, 0x86, 0xE1, 0x9C, 0xFF, 0xF8, 0x1F, 0xE0,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x1E, 0x00, 0x18, 0x1F, 0xC0, 0x18,
  0x18, 0x60, 0x0C, 0x08, 0x18, 0x0C, 0x0C, 0x0C, 0x0C, 0x06, 0x06, 0x06,
  0x03, 0x03, 0x06, 0x01, 0x81, 0x83, 0x00, 0xC0, 0xC3, 0x00, 0x60, 0x61,
  0x80, 0x30, 0x31, 0x87, 0x18, 0x18, 0xCF, 0xC4, 0x0C, 0xCC, 0x33, 0x0C,
  0xC6, 0x0C, 0xFE, 0x66, 0x06, 0x3C, 0x63, 0x03, 0x00, 0x31, 0x81, 0x80,
  0x30, 0xC0, 0xC0, 0x18, 0x60, 0x60, 0x18, 0x30, 0x30, 0x0C, 0x18, 0x18,
  0x0C, 0x0C, 0x0C, 0x0C, 0x02, 0x06, 0x06, 0x01, 0x86, 0x06, 0x00, 0xE7,
  0x03, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x70, 0x30,
  0x00, 0xC0, 0x70, 0x01, 0x80, 0x60, 0x03, 0x00, 0xC0, 0x06, 0x01, 0x80,
  0x0C, 0x06, 0x00, 0x0C, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x1D, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xDC, 0x00, 0x0E, 0x1C, 0x03, 0x38,
  0x1C, 0x0E, 0x60, 0x1C, 0x19, 0xC0, 0x1C, 0x33, 0x00, 0x1C, 0xC6, 0x00,
  0x1F, 0x8C, 0x00, 0x1E, 0x1C, 0x00, 0x3C, 0x18, 0x00, 0xFC, 0x38, 0x03,
  0x9C, 0x3F, 0xFE, 0x1C, 0x1F, 0xF0, 0x1C, 0xED, 0xB6, 0x92, 0x48, 0x03,
  0x06, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x70, 0x60, 0x60, 0x60, 0x60,
  0x60, 0xE0, 0xE0, 0xE0, 0xE0, 0x60, 0x60, 0x60, 0x60, 0x60, 0x70, 0x30,
  0x30, 0x18, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0xC0, 0x60, 0x30, 0x30, 0x18,
  0x18, 0x0C, 0x0C, 0x0E, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x07, 0x07,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x1C, 0x18, 0x30,
  0x30, 0x60, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0xE1, 0x87, 0xFD, 0xBF, 0x0F, 0xF0, 0x03, 0x80, 0x02, 0xC0, 0x06,
  0x60, 0x0C, 0x70, 0x1C, 0x30, 0x38, 0x18, 0x08, 0x10, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x39, 0x8C,
  0x67, 0x31, 0x88, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x30, 0x03,
  0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x18,
  0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x18, 0x01, 0x80, 0x38, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0E, 0x00,
  0x07, 0xE0, 0x0F, 0xFC, 0x06, 0x07, 0x06, 0x01, 0xC7, 0x00, 0x63, 0x00,
  0x39, 0x80, 0x0D, 0xC0, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xB0, 0x00, 0xD8,
  0x00, 0x6C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x06, 0xC0, 0x03,
  0x60, 0x01, 0xB0, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x33, 0x00, 0x30, 0xC0,
  0x18, 0x70, 0x18, 0x1F, 0x78, 0x03, 0xF8, 0x00, 0x01, 0x81, 0xC3, 0xE3,
  0xB3, 0x9F, 0x8D, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x0F, 0xE0, 0x3F, 0xF8, 0xF0, 0x1C, 0x40, 0x0C, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xE0, 0x3F, 0xF8, 0xF0, 0x1C,
  0x40, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x0F, 0xC0, 0x0F, 0xF8, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x07, 0x00, 0x06, 0x80, 0x0E, 0xFD, 0xFC, 0x7F, 0xF0, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1B, 0x00, 0x07, 0x60, 0x00, 0xCC,
  0x00, 0x31, 0x80, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x60, 0xC0, 0x18, 0x18,
  0x07, 0x03, 0x00, 0xC0, 0x60, 0x30, 0x0C, 0x0C, 0x01, 0x81, 0x80, 0x30,
  0x60, 0x06, 0x18, 0x00, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x3F, 0xFE, 0x3F, 0xFE, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x61, 0x00, 0x7F, 0xF8,
  0x30, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0xC0, 0x1C,
  0xFE, 0xF8, 0x3F, 0xF0, 0x00, 0xFE, 0x03, 0xFF, 0x03, 0x80, 0x03, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0xFC, 0x19, 0xFF, 0x8D, 0xC0, 0xE7, 0x80, 0x3B, 0x80, 0x0D,
  0xC0, 0x06, 0xC0, 0x01, 0xE0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x76, 0x00,
  0x33, 0x80, 0x18, 0xC0, 0x1C, 0x30, 0x1C, 0x0F, 0x7C, 0x03, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xFC,
  0x38, 0x0E, 0x70, 0x06, 0x60, 0x06, 0x60, 0x03, 0x60, 0x07, 0x60, 0x06,
  0x70, 0x06, 0x38, 0x0C, 0x1C, 0x38, 0x0F, 0xF0, 0x03, 0xE0, 0x0E, 0xF8,
  0x38, 0x1C, 0x70, 0x0E, 0x60, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0x60, 0x07, 0x70, 0x0E, 0x3E, 0x7C, 0x0F, 0xF8,
  0x07, 0xE0, 0x1F, 0xF8, 0x38, 0x1C, 0x60, 0x0C, 0x60, 0x06, 0xC0, 0x06,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0x60, 0x07, 0x70, 0x0F, 0x3E, 0xFB, 0x0F, 0xE3, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38,
  0x23, 0xE0, 0x3F, 0xC0, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x39, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x31, 0x9C,
  0xC6, 0x31, 0x18, 0x00, 0x01, 0x80, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x01, 0xE0, 0x03, 0xC0, 0x01, 0x80, 0x00, 0x3F, 0x87, 0xFF, 0x30, 0x1C,
  0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x1E, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xE0, 0x1E,
  0x00, 0x78, 0x00, 0x70, 0x0E, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x60, 0x1F, 0xF0, 0x66, 0x03, 0x83,
  0x03, 0x60, 0x60, 0x30, 0x3C, 0x0C, 0x03, 0x03, 0xC0, 0xC0, 0x30, 0x3C,
  0x18, 0x03, 0x03, 0xC1, 0x80, 0x30, 0x3C, 0x18, 0x03, 0x03, 0xC1, 0x80,
  0x30, 0x3C, 0x18, 0x07, 0x02, 0xC0, 0xC0, 0x70, 0x6C, 0x0C, 0x0F, 0x06,
  0x40, 0x7F, 0x9F, 0xC6, 0x03, 0xF0, 0xF8, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x08,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x30,
  0x00, 0x0C, 0xC0, 0x00, 0x61, 0x80, 0x01, 0x86, 0x00, 0x0E, 0x0C, 0x00,
  0x30, 0x30, 0x00, 0xC0, 0xC0, 0x06, 0x01, 0x80, 0x18, 0x06, 0x00, 0xE0,
  0x1C, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x60, 0x03, 0x81, 0x80, 0x06,
  0x06, 0x00, 0x18, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC7, 0x00, 0x03, 0x98,
  0x00, 0x06, 0x60, 0x00, 0x1B, 0x00, 0x00, 0x70, 0xFF, 0x80, 0x7F, 0xFC,
  0x30, 0x0F, 0x98, 0x00, 0xCC, 0x00, 0x76, 0x00, 0x1B, 0x00, 0x0D, 0x80,
  0x06, 0xC0, 0x03, 0x60, 0x03, 0x30, 0x03, 0x98, 0x0F, 0x0F, 0xFE, 0x06,
  0x07, 0xE3, 0x00, 0x39, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1B, 0x00, 0x1D, 0x80, 0x3C, 0xFF,
  0xFC, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x1E, 0x01, 0x87,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78,
  0x01, 0x07, 0xFF, 0xE0, 0x3F, 0xF8, 0xFF, 0x80, 0x1F, 0xFF, 0x03, 0x00,
  0xF8, 0x60, 0x03, 0x8C, 0x00, 0x39, 0x80, 0x03, 0xB0, 0x00, 0x36, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x6C, 0x00, 0x1D, 0x80, 0x07, 0x30, 0x01,
  0xC6, 0x00, 0xF0, 0xFF, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xFF, 0xFB, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0xFF, 0xEF, 0xFF, 0xB0, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0xC1, 0xE0, 0x0E,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x1B, 0x00, 0x00, 0xD8, 0x00, 0x06, 0xE0, 0x00, 0x33, 0x00, 0x01, 0x9C,
  0x00, 0x0C, 0x70, 0x00, 0x61, 0xE0, 0x03, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0x00, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x30,
  0xFF, 0xFC, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x7D, 0xFC, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x30, 0x3A, 0x39, 0xF8, 0x70,
  0x00, 0xC0, 0x03, 0xE0, 0x03, 0xB0, 0x03, 0x98, 0x03, 0x8C, 0x03, 0x86,
  0x03, 0x83, 0x03, 0x81, 0x83, 0x80, 0xC3, 0x80, 0x61, 0x80, 0x31, 0x80,
  0x19, 0xC0, 0x0D, 0xE0, 0x07, 0xB8, 0x03, 0x8E, 0x01, 0x83, 0x80, 0xC0,
  0xC0, 0x60, 0x70, 0x30, 0x1C, 0x18, 0x06, 0x0C, 0x01, 0x86, 0x00, 0xE3,
  0x00, 0x39, 0x80, 0x0C, 0xC0, 0x03, 0x60, 0x01, 0xC0, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xB0, 0x00, 0x0F, 0xB0, 0x00, 0x1B, 0xF0, 0x00, 0x1B, 0xD8, 0x00,
  0x1B, 0xD8, 0x00, 0x33, 0xCC, 0x00, 0x33, 0xCC, 0x00, 0x63, 0xCC, 0x00,
  0x63, 0xC6, 0x00, 0x63, 0xC6, 0x00, 0xC3, 0xC7, 0x00, 0xC3, 0xC3, 0x01,
  0x83, 0xC3, 0x01, 0x83, 0xC1, 0x81, 0x83, 0xC1, 0x83, 0x03, 0xC1, 0xC3,
  0x03, 0xC0, 0xC6, 0x03, 0xC0, 0xC6, 0x03, 0xC0, 0x66, 0x03, 0xC0, 0x6C,
  0x03, 0xC0, 0x7C, 0x03, 0xC0, 0x38, 0x03, 0xC0, 0x38, 0x03, 0xC0, 0x18,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3B, 0x80,
  0x07, 0x30, 0x00, 0xF7, 0x00, 0x1E, 0x70, 0x03, 0xC6, 0x00, 0x78, 0xE0,
  0x0F, 0x0E, 0x01, 0xE0, 0xC0, 0x3C, 0x1C, 0x07, 0x81, 0xC0, 0xF0, 0x18,
  0x1E, 0x03, 0x83, 0xC0, 0x38, 0x78, 0x03, 0x0F, 0x00, 0x71, 0xE0, 0x07,
  0x3C, 0x00, 0x67, 0x80, 0x0E, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x1C, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x3C, 0x03, 0xC0,
  0xE0, 0x01, 0x83, 0x80, 0x01, 0x86, 0x00, 0x03, 0x9C, 0x00, 0x03, 0x30,
  0x00, 0x07, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x3B, 0x80, 0x00,
  0x63, 0x00, 0x01, 0xC7, 0x00, 0x03, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x78,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0xE3, 0x01, 0xE6,
  0x00, 0xEC, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x6C, 0x01, 0xD8, 0x1F, 0x3F, 0xF8, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x3C, 0x03, 0xC0, 0xE0, 0x01, 0x83, 0x80, 0x01, 0x86, 0x00, 0x03,
  0x9C, 0x00, 0x03, 0x30, 0x00, 0x07, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80,
  0x00, 0x3B, 0x80, 0x00, 0x63, 0x00, 0x01, 0xC7, 0x00, 0x03, 0x07, 0x00,
  0x0E, 0x07, 0x00, 0x78, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x3C, 0xFF, 0x80, 0x7F, 0xF8, 0x30, 0x1F, 0x18, 0x01, 0x8C,
  0x00, 0xE6, 0x00, 0x33, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x06, 0x60, 0x03,
  0x30, 0x03, 0x98, 0x01, 0x8C, 0x03, 0x87, 0xFF, 0x83, 0xFF, 0x01, 0x81,
  0x80, 0xC0, 0x60, 0x60, 0x38, 0x30, 0x0C, 0x18, 0x03, 0x0C, 0x01, 0xC6,
  0x00, 0x63, 0x00, 0x39, 0x80, 0x0C, 0xC0, 0x07, 0x60, 0x01, 0xC0, 0x07,
  0xF8, 0x1F, 0xFE, 0x38, 0x06, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x80, 0x1C, 0xFF,
  0xF8, 0x7F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0x00, 0x76, 0x00, 0x06, 0x60, 0x00, 0x67, 0x00, 0x0E,
  0x30, 0x00, 0xC3, 0xC0, 0x38, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0xC0, 0x00,
  0x1F, 0x00, 0x01, 0xD8, 0x00, 0x0C, 0xC0, 0x00, 0x63, 0x00, 0x06, 0x18,
  0x00, 0x30, 0xC0, 0x03, 0x83, 0x00, 0x18, 0x18, 0x00, 0xC0, 0xE0, 0x0E,
  0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0xE0, 0x30, 0x03, 0x01, 0x80, 0x18,
  0x0C, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x1C, 0x70, 0x00, 0x63, 0x00,
  0x03, 0x18, 0x00, 0x1D, 0xC0, 0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x03, 0x00, 0x0F, 0x80,
  0x07, 0x00, 0x1B, 0x80, 0x1E, 0x00, 0x33, 0x00, 0x3C, 0x00, 0x66, 0x00,
  0x78, 0x01, 0x8C, 0x00, 0xD8, 0x03, 0x1C, 0x03, 0x30, 0x06, 0x18, 0x06,
  0x60, 0x0C, 0x30, 0x0C, 0x60, 0x30, 0x60, 0x30, 0xC0, 0x60, 0x60, 0x61,
  0x80, 0xC0, 0xC0, 0xC3, 0x03, 0x81, 0x81, 0x83, 0x06, 0x03, 0x06, 0x06,
  0x0C, 0x03, 0x0C, 0x0C, 0x18, 0x06, 0x18, 0x0C, 0x60, 0x0C, 0x60, 0x18,
  0xC0, 0x1C, 0xC0, 0x31, 0x80, 0x19, 0x80, 0x63, 0x00, 0x33, 0x00, 0x6C,
  0x00, 0x6C, 0x00, 0xD8, 0x00, 0x78, 0x01, 0xB0, 0x00, 0xF0, 0x01, 0x60,
  0x01, 0xE0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x03, 0x00, 0x0E, 0x00,
  0x60, 0x00, 0x63, 0x00, 0x0C, 0x30, 0x01, 0xC1, 0x80, 0x18, 0x1C, 0x03,
  0x00, 0xC0, 0x30, 0x06, 0x06, 0x00, 0x70, 0xC0, 0x03, 0x0C, 0x00, 0x19,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x60, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x19, 0x80, 0x03, 0x1C, 0x00, 0x70, 0xC0, 0x06, 0x06, 0x00,
  0xC0, 0x70, 0x0C, 0x03, 0x01, 0x80, 0x38, 0x38, 0x01, 0x83, 0x00, 0x0C,
  0x60, 0x00, 0xEE, 0x00, 0x07, 0xC0, 0x00, 0x6C, 0x00, 0x1D, 0x80, 0x03,
  0x18, 0x00, 0xE3, 0x80, 0x18, 0x30, 0x06, 0x07, 0x00, 0xC0, 0x60, 0x30,
  0x0E, 0x06, 0x00, 0xC1, 0x80, 0x0C, 0x30, 0x01, 0x8C, 0x00, 0x1B, 0x80,
  0x03, 0x60, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF0,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xFF, 0xFF, 0xE0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x00, 0x18,
  0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03,
  0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0x60, 0x06, 0x00, 0x70, 0x03, 0xFF, 0xFF, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0xFF,
  0xFF, 0x01, 0x80, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x6C, 0x00, 0x66, 0x00,
  0x31, 0x80, 0x30, 0xC0, 0x18, 0x30, 0x18, 0x18, 0x0C, 0x06, 0x0C, 0x03,
  0x06, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x03, 0xFF,
  0xFF, 0xFF, 0xFC, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0x1F, 0xF0, 0xF1,
  0xE2, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x07,
  0xFC, 0xFE, 0x37, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x07, 0xE0, 0x35, 0xE7, 0x93, 0xFC, 0x40, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x81, 0x00,
  0xC7, 0xF8, 0x6E, 0x1E, 0x34, 0x03, 0x9E, 0x00, 0xCE, 0x00, 0x37, 0x00,
  0x1B, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xF0, 0x00, 0xD8,
  0x00, 0x6C, 0x00, 0x37, 0x00, 0x1B, 0x80, 0x1D, 0xE0, 0x0C, 0xD0, 0x0E,
  0x6F, 0x3E, 0x31, 0xFC, 0x00, 0x00, 0x40, 0x1F, 0xF1, 0xF1, 0xCE, 0x00,
  0x30, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xFF, 0xC1, 0xFE, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x83, 0x0F, 0xF3, 0x1E, 0x3B,
  0x38, 0x0F, 0x70, 0x07, 0x60, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03,
  0x60, 0x03, 0x70, 0x07, 0x38, 0x0D, 0x1E, 0x79, 0x0F, 0xF1, 0x00, 0x80,
  0x0F, 0xF0, 0x1E, 0x3C, 0x38, 0x0C, 0x70, 0x06, 0x60, 0x06, 0x60, 0x07,
  0xC0, 0x03, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x02, 0x1F, 0x3E,
  0x07, 0xFC, 0x00, 0x40, 0x1F, 0xC1, 0xC2, 0x0C, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x07, 0xFF, 0x3F, 0xF8, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x0F, 0xF1, 0x1E, 0x39, 0x38, 0x0F, 0x70, 0x07, 0x60, 0x03,
  0x60, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0x60, 0x03, 0x70, 0x07, 0x38, 0x0F,
  0x1E, 0x7B, 0x0F, 0xF3, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x07, 0x40, 0x06, 0x78, 0x1C, 0x3F, 0xF8, 0x05, 0xC0, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x40, 0xC7, 0xF9, 0xB8, 0x7B, 0x40, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x18, 0xDF, 0x00, 0x06, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xD8, 0x06,
  0x07, 0x06, 0x00, 0x00, 0x00, 0x00, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x8E, 0xFC, 0x70, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x1D, 0x80, 0x73, 0x01, 0xC6, 0x07, 0x0C, 0x1C, 0x18, 0x70,
  0x31, 0xC0, 0x63, 0x00, 0xCE, 0x01, 0xBE, 0x03, 0xCC, 0x07, 0x0C, 0x0C,
  0x1C, 0x18, 0x1C, 0x30, 0x18, 0x60, 0x18, 0xC0, 0x39, 0x80, 0x3B, 0x00,
  0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x80, 0x08, 0x33,
  0xFC, 0x3F, 0xCD, 0xC7, 0x9C, 0x7B, 0xC0, 0x7C, 0x07, 0xE0, 0x0E, 0x00,
  0xF8, 0x03, 0x80, 0x3C, 0x00, 0xC0, 0x0F, 0x00, 0x30, 0x03, 0xC0, 0x0C,
  0x00, 0xF0, 0x03, 0x00, 0x3C, 0x00, 0xC0, 0x0F, 0x00, 0x30, 0x03, 0xC0,
  0x0C, 0x00, 0xF0, 0x03, 0x00, 0x3C, 0x00, 0xC0, 0x0F, 0x00, 0x30, 0x03,
  0xC0, 0x0C, 0x00, 0xF0, 0x03, 0x00, 0x3C, 0x00, 0xC0, 0x0F, 0x00, 0x30,
  0x03, 0x00, 0xC1, 0x8F, 0xF3, 0x78, 0xF6, 0x80, 0x7E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x30, 0x00, 0x80, 0x07, 0xFC, 0x07, 0x87, 0x07, 0x00, 0xC7,
  0x00, 0x33, 0x00, 0x19, 0x80, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0D, 0x80, 0x0E, 0xC0,
  0x06, 0x30, 0x07, 0x1C, 0x07, 0x07, 0xDF, 0x00, 0xFF, 0x00, 0x00, 0x80,
  0x63, 0xFC, 0x33, 0x0F, 0x1B, 0x01, 0xCF, 0x00, 0x67, 0x00, 0x1B, 0x80,
  0x0D, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x36, 0x00, 0x1B, 0x80, 0x0D, 0xC0, 0x0E, 0xF0, 0x06, 0x6C, 0x07,
  0x33, 0xDF, 0x18, 0xFE, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x80, 0x0F, 0xF1, 0x1E, 0x39, 0x38, 0x0F, 0x70, 0x07, 0x60, 0x03,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0x60, 0x07, 0x70, 0x07, 0x38, 0x0F,
  0x1E, 0x7B, 0x0F, 0xF3, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0xC7, 0xFB,
  0xCB, 0x60, 0x78, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x00, 0x03, 0x01, 0xFF, 0xDC, 0x1D, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x1C, 0x00, 0x78, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x1C, 0x01, 0xFE, 0x7C, 0xFF, 0x80, 0x08, 0x01,
  0x00, 0x20, 0x0C, 0x01, 0x81, 0xFF, 0xFF, 0xF8, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0xC0, 0x18, 0x03, 0xC8, 0x3F, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xF0,
  0x07, 0x60, 0x1E, 0xF9, 0xEC, 0x7F, 0x08, 0xC0, 0x03, 0xB0, 0x01, 0x98,
  0x00, 0xCE, 0x00, 0xE3, 0x00, 0x61, 0x80, 0x30, 0x60, 0x30, 0x30, 0x18,
  0x18, 0x1C, 0x06, 0x0C, 0x03, 0x06, 0x01, 0xC6, 0x00, 0x63, 0x00, 0x31,
  0x80, 0x0D, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0xE0, 0x0E, 0x00, 0xD8, 0x03, 0x80, 0x76, 0x00, 0xE0, 0x18, 0xC0, 0x6C,
  0x06, 0x30, 0x1B, 0x01, 0x8C, 0x04, 0xC0, 0xC3, 0x03, 0x18, 0x30, 0x60,
  0xC6, 0x0C, 0x18, 0x31, 0x83, 0x06, 0x18, 0x31, 0x80, 0xC6, 0x0C, 0x60,
  0x31, 0x83, 0x18, 0x0C, 0xC0, 0xC6, 0x03, 0x30, 0x1B, 0x00, 0x6C, 0x06,
  0xC0, 0x1E, 0x01, 0xB0, 0x07, 0x80, 0x38, 0x01, 0xE0, 0x0E, 0x00, 0x30,
  0x03, 0x80, 0xE0, 0x07, 0x70, 0x0E, 0x30, 0x0C, 0x18, 0x18, 0x1C, 0x38,
  0x0C, 0x30, 0x06, 0x60, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0xC0,
  0x06, 0x60, 0x0E, 0x70, 0x0C, 0x30, 0x18, 0x18, 0x38, 0x1C, 0x30, 0x0E,
  0x60, 0x06, 0xC0, 0x03, 0xC0, 0x03, 0xB0, 0x01, 0x98, 0x00, 0xCE, 0x00,
  0xE3, 0x00, 0x61, 0x80, 0x30, 0x60, 0x30, 0x30, 0x18, 0x1C, 0x1C, 0x06,
  0x0C, 0x03, 0x06, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x31, 0x80, 0x0D, 0x80,
  0x06, 0xC0, 0x01, 0x60, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x3F,
  0x00, 0x0E, 0x00, 0x00, 0x7F, 0xFD, 0xFF, 0xF0, 0x01, 0x80, 0x0E, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x01,
  0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x60, 0x7C, 0x1C, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x07, 0x80,
  0xF0, 0x03, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x00, 0x70, 0x06,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x00, 0xC0, 0x0F, 0x01, 0xE0, 0x60, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x38,
  0x3E, 0x06, 0x00, 0x1C, 0x00, 0xBF, 0xC0, 0xF0, 0xFD, 0xF0, 0x0F, 0xC0,
};

const GFXglyph NotoSans_Light36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 26, 9, 3, -26 },
  { 11, 9, 10, 13, 2, -26 },
  { 23, 21, 26, 23, 1, -26 },
  { 92, 16, 29, 21, 2, -27 },
  { 150, 25, 26, 29, 2, -26 },
  { 232, 23, 26, 26, 2, -26 },
  { 307, 3, 10, 7, 2, -26 },
  { 311, 8, 32, 10, 1, -26 },
  { 343, 8, 32, 10, 1, -26 },
  { 375, 16, 15, 20, 2, -27 },
  { 405, 17, 17, 21, 2, -21 },
  { 442, 5, 9, 8, 1, -4 },
  { 448, 9, 2, 12, 1, -11 },
  { 451, 3, 3, 9, 3, -3 },
  { 453, 12, 26, 12, 0, -26 },
  { 492, 17, 26, 21, 2, -26 },
  { 548, 9, 26, 21, 3, -26 },
  { 578, 16, 26, 21, 2, -26 },
  { 630, 16, 26, 21, 2, -26 },
  { 682, 19, 26, 21, 1, -26 },
  { 744, 16, 26, 21, 2, -26 },
  { 796, 17, 26, 21, 2, -26 },
  { 852, 17, 26, 21, 2, -26 },
  { 908, 16, 26, 21, 2, -26 },
  { 960, 16, 26, 21, 2, -26 },
  { 1012, 3, 19, 9, 3, -19 },
  { 1020, 5, 24, 9, 1, -19 },
  { 1035, 17, 16, 21, 2, -21 },
  { 1069, 17, 9, 21, 2, -17 },
  { 1089, 17, 16, 21, 2, -21 },
  { 1123, 13, 26, 15, 1, -26 },
  { 1166, 28, 29, 32, 2, -26 },
  { 1268, 22, 26, 22, 0, -26 },
  { 1340, 17, 26, 23, 4, -26 },
  { 1396, 19, 26, 22, 2, -26 },
  { 1458, 19, 26, 26, 4, -26 },
  { 1520, 14, 26, 20, 4, -26 },
  { 1566, 14, 26, 18, 4, -26 },
  { 1612, 21, 26, 26, 2, -26 },
  { 1681, 18, 26, 26, 4, -26 },
  { 1740, 7, 26, 11, 2, -26 },
  { 1763, 9, 33, 9, -3, -26 },
  { 1801, 17, 26, 21, 4, -26 },
  { 1857, 14, 26, 19, 4, -26 },
  { 1903, 24, 26, 31, 4, -26 },
  { 1981, 19, 26, 26, 4, -26 },
  { 2043, 23, 26, 28, 2, -26 },
  { 2118, 15, 26, 21, 4, -26 },
  { 2167, 23, 32, 28, 2, -26 },
  { 2259, 17, 26, 22, 4, -26 },
  { 2315, 16, 26, 20, 2, -26 },
  { 2367, 19, 26, 19, 0, -26 },
  { 2429, 20, 26, 26, 3, -26 },
  { 2494, 21, 26, 21, 0, -26 },
  { 2563, 31, 26, 32, 1, -26 },
  { 2664, 20, 26, 20, 0, -26 },
  { 2729, 19, 26, 19, 0, -26 },
  { 2791, 18, 26, 21, 1, -26 },
  { 2850, 8, 32, 12, 3, -26 },
  { 2882, 12, 26, 12, 0, -26 },
  { 2921, 8, 32, 12, 1, -26 },
  { 2953, 17, 16, 21, 2, -26 },
  { 2987, 15, 2, 15, 0, 3 },
  { 2991, 7, 6, 10, 1, -28 },
  { 2997, 14, 19, 19, 2, -19 },
  { 3031, 17, 27, 22, 3, -27 },
  { 3089, 14, 20, 17, 2, -20 },
  { 3124, 16, 27, 22, 2, -27 },
  { 3178, 16, 20, 20, 2, -20 },
  { 3218, 13, 28, 11, 0, -28 },
  { 3264, 16, 29, 22, 2, -20 },
  { 3322, 15, 27, 21, 3, -27 },
  { 3373, 3, 26, 8, 3, -26 },
  { 3383, 8, 35, 8, -2, -26 },
  { 3418, 15, 27, 18, 3, -27 },
  { 3469, 2, 27, 8, 3, -27 },
  { 3476, 26, 20, 32, 3, -20 },
  { 3541, 15, 20, 21, 3, -20 },
  { 3579, 17, 20, 21, 2, -20 },
  { 3622, 17, 29, 22, 3, -20 },
  { 3684, 16, 29, 22, 2, -20 },
  { 3742, 11, 19, 14, 3, -19 },
  { 3769, 13, 20, 17, 2, -20 },
  { 3802, 11, 24, 12, 0, -24 },
  { 3835, 15, 19, 21, 3, -19 },
  { 3871, 17, 19, 17, 0, -19 },
  { 3912, 26, 19, 27, 0, -19 },
  { 3974, 16, 19, 18, 1, -19 },
  { 4012, 17, 28, 17, 0, -19 },
  { 4072, 14, 19, 17, 1, -19 },
  { 4106, 11, 32, 13, 1, -26 },
  { 4150, 2, 36, 20, 9, -27 },
  { 4159, 11, 32, 13, 1, -26 },
  { 4203, 17, 4, 21, 2, -15 },
};

const GFXfont NotoSans_Light36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light36pt7bBitmaps,
  (GFXglyph *)NotoSans_Light36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_LIGHT36PT7B_H_
