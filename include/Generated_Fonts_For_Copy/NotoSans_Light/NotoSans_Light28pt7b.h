#ifndef _NOTOSANS_LIGHT28PT7B_H_
#define _NOTOSANS_LIGHT28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light28pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x90, 0x03, 0xF0, 0xC7, 0x1C, 0x71,
  0x86, 0x18, 0x40, 0x03, 0x0C, 0x02, 0x08, 0x02, 0x08, 0x02, 0x08, 0x06,
  0x18, 0x06, 0x18, 0x7F, 0xFF, 0x04, 0x10, 0x04, 0x10, 0x0C, 0x10, 0x0C,
  0x30, 0x08, 0x20, 0x08, 0x20, 0xFF, 0xFE, 0x18, 0x20, 0x18, 0x60, 0x10,
  0x60, 0x10, 0x40, 0x10, 0x40, 0x30, 0xC0, 0x04, 0x00, 0x40, 0x3F, 0xC7,
  0x46, 0xC4, 0x08, 0x40, 0x84, 0x0C, 0x40, 0xC4, 0x07, 0x40, 0x1E, 0x00,
  0x78, 0x04, 0xE0, 0x46, 0x04, 0x30, 0x43, 0x04, 0x30, 0x46, 0xE5, 0xEF,
  0xF8, 0x04, 0x00, 0x40, 0x04, 0x00, 0x7C, 0x03, 0x18, 0xC0, 0xC2, 0x08,
  0x10, 0x41, 0x06, 0x08, 0x20, 0x81, 0x04, 0x30, 0x20, 0x84, 0x04, 0x11,
  0x80, 0x82, 0x67, 0x90, 0x49, 0x8B, 0x1B, 0x21, 0xBE, 0x4C, 0x10, 0x19,
  0x82, 0x02, 0x30, 0x40, 0xC6, 0x08, 0x10, 0xC1, 0x06, 0x18, 0x21, 0x81,
  0x0C, 0x20, 0x31, 0x0C, 0x03, 0xC0, 0x1F, 0x80, 0x0E, 0x30, 0x03, 0x06,
  0x00, 0x80, 0x80, 0x20, 0x60, 0x0C, 0x18, 0x03, 0x0C, 0x00, 0x66, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0x30, 0x19, 0x86, 0x04, 0xC0, 0xC3, 0x20,
  0x18, 0xC8, 0x03, 0x62, 0x00, 0x78, 0xC0, 0x0C, 0x30, 0x0F, 0x87, 0x0E,
  0x30, 0xFF, 0x07, 0xFF, 0xA8, 0x0C, 0x61, 0x0C, 0x21, 0x86, 0x10, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x41, 0x06, 0x18, 0x30, 0xC1, 0x83, 0xC1,
  0x82, 0x0C, 0x10, 0x61, 0x86, 0x08, 0x20, 0xC3, 0x0C, 0x30, 0xC2, 0x08,
  0x61, 0x84, 0x30, 0xC6, 0x30, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x07,
  0x23, 0xDF, 0xF8, 0x0C, 0x00, 0xB0, 0x0C, 0x80, 0xC6, 0x0E, 0x18, 0x20,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x6D, 0xA5, 0xA0, 0xFE, 0xFC, 0x00, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x10,
  0x18, 0x0C, 0x04, 0x06, 0x02, 0x01, 0x01, 0x80, 0x80, 0xC0, 0x60, 0x20,
  0x30, 0x18, 0x18, 0x00, 0x1F, 0x83, 0x0C, 0x60, 0x64, 0x02, 0xC0, 0x3C,
  0x03, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0xC0, 0x3C, 0x03, 0x40, 0x26, 0x06, 0x30, 0xC1, 0xF8, 0x0C, 0x73,
  0x79, 0x84, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x3F, 0x8F, 0x1C, 0x80, 0x60, 0x06, 0x00, 0x20, 0x02, 0x00, 0x60,
  0x06, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x01,
  0x00, 0x20, 0x06, 0x00, 0xC0, 0x0F, 0xFF, 0x1F, 0xC7, 0x83, 0x10, 0x0C,
  0x00, 0x20, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0xE0, 0xF8, 0x00,
  0x78, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01,
  0xB8, 0x18, 0xFF, 0x80, 0x00, 0x60, 0x01, 0xC0, 0x02, 0x80, 0x0D, 0x00,
  0x32, 0x00, 0x44, 0x01, 0x08, 0x06, 0x10, 0x18, 0x20, 0x20, 0x40, 0xC0,
  0x83, 0x01, 0x0C, 0x02, 0x10, 0x04, 0x3F, 0xFF, 0x80, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x7F, 0xE6, 0x00, 0x60, 0x06, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x7F, 0x8E, 0x1E, 0x00, 0x60, 0x03,
  0x00, 0x30, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x06, 0xC1, 0xC7, 0xF8,
  0x07, 0xE0, 0xE0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18,
  0x00, 0x9F, 0xC5, 0x83, 0x38, 0x0D, 0x80, 0x28, 0x01, 0x40, 0x0F, 0x00,
  0x78, 0x02, 0x40, 0x33, 0x01, 0x8E, 0x38, 0x3F, 0x80, 0xFF, 0xF8, 0x00,
  0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x40,
  0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06,
  0x00, 0x20, 0x03, 0x00, 0x30, 0x00, 0x1F, 0x87, 0x0E, 0x40, 0x2C, 0x03,
  0xC0, 0x3C, 0x03, 0x40, 0x67, 0x0C, 0x1D, 0x80, 0xF0, 0x39, 0xC6, 0x06,
  0xC0, 0x38, 0x01, 0x80, 0x18, 0x01, 0x80, 0x3C, 0x03, 0x70, 0xE3, 0xFC,
  0x1F, 0xC1, 0xC3, 0x18, 0x0C, 0xC0, 0x24, 0x01, 0xE0, 0x0F, 0x00, 0x28,
  0x01, 0x40, 0x1B, 0x01, 0xCC, 0x1A, 0x3F, 0x90, 0x01, 0x80, 0x0C, 0x00,
  0x40, 0x06, 0x00, 0x30, 0x03, 0x00, 0x70, 0x7E, 0x00, 0xFD, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x67, 0x20, 0x00, 0x00, 0x00, 0x00, 0x66, 0x64, 0x4C,
  0x80, 0x00, 0x04, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0x80,
  0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x7F, 0x30,
  0xE0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x18, 0x04, 0x01, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x60, 0x00,
  0xFC, 0x00, 0x3E, 0x7C, 0x03, 0x00, 0x30, 0x30, 0x00, 0xC2, 0x00, 0x03,
  0x30, 0x00, 0x09, 0x03, 0xF8, 0x78, 0x30, 0x41, 0x83, 0x02, 0x0C, 0x10,
  0x10, 0x61, 0x81, 0x83, 0x0C, 0x0C, 0x18, 0x60, 0x60, 0xC3, 0x03, 0x0E,
  0x08, 0x38, 0x50, 0x63, 0x66, 0xC1, 0xF1, 0xE2, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x10, 0x03, 0xFF, 0x80, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x50, 0x00, 0x6C, 0x00, 0x32, 0x00, 0x11,
  0x00, 0x18, 0xC0, 0x0C, 0x20, 0x04, 0x18, 0x06, 0x0C, 0x02, 0x02, 0x03,
  0x01, 0x81, 0xFF, 0xC0, 0x80, 0x30, 0xC0, 0x18, 0x40, 0x04, 0x60, 0x03,
  0x30, 0x01, 0x90, 0x00, 0x58, 0x00, 0x30, 0xFF, 0x84, 0x1F, 0x20, 0x0D,
  0x00, 0x28, 0x01, 0xC0, 0x0E, 0x00, 0x50, 0x06, 0x80, 0xE7, 0xFC, 0x20,
  0x39, 0x00, 0x68, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01,
  0xA0, 0x79, 0xFF, 0x00, 0x07, 0xFE, 0x3C, 0x18, 0xE0, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x78, 0x30, 0x3F, 0xE0, 0xFF, 0x81, 0x07, 0xC2, 0x00, 0xE4,
  0x00, 0xC8, 0x00, 0xD0, 0x00, 0xA0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x40, 0x06,
  0x80, 0x19, 0x00, 0x62, 0x0F, 0x87, 0xFC, 0x00, 0xFF, 0xF0, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x1F, 0xFA, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x7F, 0xF0,
  0xFF, 0xF0, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x03, 0xFF, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x00, 0x03, 0xFE, 0x0E, 0x07, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00,
  0x80, 0x7F, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x60, 0x03,
  0x60, 0x03, 0x38, 0x03, 0x1E, 0x07, 0x07, 0xFE, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x07,
  0xFF, 0xF8, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0xFC, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x3F, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x30, 0xEE, 0xF0, 0x80, 0x1C, 0x01, 0xA0, 0x19, 0x01, 0x88,
  0x18, 0x41, 0x82, 0x18, 0x11, 0x80, 0x98, 0x05, 0xE0, 0x39, 0x81, 0x8C,
  0x08, 0x30, 0x40, 0xC2, 0x06, 0x10, 0x18, 0x80, 0x64, 0x01, 0xA0, 0x0D,
  0x00, 0x30, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x7F, 0xF0, 0xC0, 0x00, 0xFC, 0x00, 0x1E, 0x80,
  0x07, 0xD8, 0x00, 0xBB, 0x00, 0x37, 0x20, 0x06, 0xE6, 0x00, 0x9C, 0x40,
  0x33, 0x8C, 0x04, 0x71, 0x81, 0x8E, 0x10, 0x31, 0xC3, 0x04, 0x38, 0x21,
  0x87, 0x06, 0x20, 0xE0, 0xCC, 0x1C, 0x09, 0x83, 0x81, 0xA0, 0x70, 0x3C,
  0x0E, 0x03, 0x01, 0xC0, 0x60, 0x30, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1D,
  0x80, 0x39, 0x80, 0x73, 0x00, 0xE3, 0x01, 0xC3, 0x03, 0x86, 0x07, 0x06,
  0x0E, 0x06, 0x1C, 0x0C, 0x38, 0x0C, 0x70, 0x0C, 0xE0, 0x19, 0xC0, 0x1B,
  0x80, 0x17, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x30, 0x07, 0xF8, 0x07, 0x07,
  0x03, 0x00, 0x71, 0x80, 0x0C, 0x60, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x0B,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x2C, 0x00, 0x19, 0x80, 0x06, 0x60, 0x03, 0x0C, 0x01,
  0x81, 0xC1, 0xC0, 0x1F, 0xE0, 0xFF, 0x08, 0x7C, 0x80, 0x68, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x28, 0x06, 0xFF, 0xCF, 0xE0, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x07,
  0xF8, 0x07, 0x07, 0x03, 0x00, 0x71, 0x80, 0x0C, 0x60, 0x01, 0xB0, 0x00,
  0x6C, 0x00, 0x0B, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x2C, 0x00, 0x19, 0x80, 0x06, 0x60,
  0x03, 0x0C, 0x01, 0x81, 0xC1, 0xC0, 0x1F, 0xE0, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0xFF, 0x84, 0x3E, 0x20,
  0x19, 0x00, 0x68, 0x03, 0x40, 0x1A, 0x00, 0xD0, 0x06, 0x80, 0x64, 0x06,
  0x3F, 0xE1, 0x06, 0x08, 0x18, 0x40, 0xC2, 0x03, 0x10, 0x08, 0x80, 0x64,
  0x01, 0xA0, 0x0D, 0x00, 0x30, 0x3F, 0xE7, 0x06, 0xC0, 0x0C, 0x00, 0x80,
  0x08, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00,
  0x60, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x06, 0xC1, 0xCF, 0xF8, 0xFF,
  0xFE, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0x60, 0x02, 0xC0, 0x0C, 0xC0, 0x30, 0xE1,
  0xC0, 0xFF, 0x00, 0xC0, 0x03, 0x40, 0x03, 0x60, 0x02, 0x60, 0x06, 0x20,
  0x06, 0x30, 0x04, 0x30, 0x0C, 0x10, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x0C,
  0x10, 0x0C, 0x30, 0x04, 0x30, 0x06, 0x20, 0x06, 0x60, 0x02, 0x60, 0x03,
  0x40, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x80, 0x18, 0x03, 0xC0, 0x38,
  0x06, 0xC0, 0x28, 0x06, 0x40, 0x28, 0x06, 0x60, 0x6C, 0x04, 0x60, 0x6C,
  0x0C, 0x60, 0x44, 0x0C, 0x20, 0x46, 0x0C, 0x30, 0xC6, 0x08, 0x30, 0xC2,
  0x18, 0x30, 0x82, 0x18, 0x11, 0x83, 0x10, 0x19, 0x83, 0x10, 0x19, 0x01,
  0x30, 0x09, 0x01, 0xB0, 0x0B, 0x01, 0xA0, 0x0F, 0x00, 0xA0, 0x0E, 0x00,
  0xE0, 0x06, 0x00, 0xE0, 0x06, 0x00, 0xC0, 0x60, 0x06, 0x40, 0x18, 0xC0,
  0x60, 0xC0, 0xC1, 0x83, 0x01, 0x84, 0x01, 0x98, 0x03, 0x60, 0x03, 0x80,
  0x03, 0x00, 0x0E, 0x00, 0x36, 0x00, 0x66, 0x01, 0x8C, 0x02, 0x0C, 0x0C,
  0x08, 0x30, 0x18, 0x40, 0x19, 0x80, 0x16, 0x00, 0x30, 0xC0, 0x06, 0xC0,
  0x19, 0x80, 0x31, 0x80, 0xC3, 0x01, 0x83, 0x06, 0x02, 0x08, 0x06, 0x30,
  0x04, 0x40, 0x0D, 0x80, 0x0A, 0x00, 0x1C, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x7F,
  0xFC, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x20, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01,
  0x80, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x3F, 0xFF, 0xFF, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x3F, 0xC0, 0x20, 0x18, 0x04, 0x03, 0x01, 0x80, 0x40,
  0x30, 0x08, 0x04, 0x03, 0x00, 0x80, 0x60, 0x30, 0x08, 0x06, 0x01, 0x00,
  0x80, 0x60, 0x10, 0xFC, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xFF, 0x03, 0x00, 0x0C,
  0x00, 0x78, 0x01, 0x20, 0x0C, 0xC0, 0x21, 0x01, 0x86, 0x04, 0x08, 0x30,
  0x30, 0x80, 0x46, 0x01, 0xB0, 0x03, 0xFF, 0xF0, 0xE1, 0x04, 0x10, 0x1F,
  0xC3, 0x0E, 0x00, 0x20, 0x03, 0x00, 0x30, 0x03, 0x01, 0xF3, 0xFF, 0x70,
  0x34, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x76, 0x1B, 0x3F, 0x30, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x3F, 0x1B, 0x1C, 0xE0,
  0x37, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x78, 0x03,
  0xC0, 0x1F, 0x00, 0xF8, 0x0D, 0xB0, 0xCC, 0xFC, 0x00, 0x1F, 0xCE, 0x16,
  0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x0C, 0x03, 0x00,
  0x60, 0x0C, 0x11, 0xFC, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x1F, 0x93, 0x8D, 0x60, 0x7C, 0x03, 0xC0, 0x3C, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0xC0, 0x3C, 0x03, 0x60, 0x37, 0x0D, 0x1F, 0x90,
  0x1F, 0x83, 0x0C, 0x60, 0x6C, 0x02, 0xC0, 0x38, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x06, 0x1F, 0xE0, 0x07,
  0xC3, 0x01, 0x80, 0x60, 0x18, 0x06, 0x0F, 0xF0, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x00, 0x1F, 0x93, 0x0D, 0x60, 0x7C, 0x03, 0xC0, 0x38, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x3C, 0x03, 0x60, 0x37, 0x0D, 0x1F,
  0x90, 0x01, 0x00, 0x10, 0x03, 0x00, 0x38, 0x06, 0x7F, 0xC0, 0xF0, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xCF, 0xCD, 0x86, 0xE0,
  0x3E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x10, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x18, 0xC0, 0x00, 0x0C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x8C, 0x63, 0x1F, 0xB0, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x6C, 0x0C, 0xC1, 0x8C, 0x30, 0xC6, 0x0C, 0xC0, 0xD8,
  0x0D, 0xC0, 0xE6, 0x0C, 0x30, 0xC1, 0x0C, 0x18, 0xC0, 0xCC, 0x06, 0xC0,
  0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xCF, 0x87, 0xE6, 0xC6, 0x63,
  0xB8, 0x1E, 0x0D, 0xC0, 0x60, 0x3C, 0x03, 0x01, 0xE0, 0x10, 0x0F, 0x00,
  0x80, 0x78, 0x04, 0x03, 0xC0, 0x20, 0x1E, 0x01, 0x00, 0xF0, 0x08, 0x07,
  0x80, 0x40, 0x3C, 0x02, 0x01, 0xE0, 0x10, 0x0F, 0x00, 0x80, 0x60, 0xCF,
  0xCD, 0x86, 0xE0, 0x3E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x10, 0x1F, 0x81,
  0xC7, 0x18, 0x0D, 0x80, 0x6C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xF0, 0x07, 0x80, 0x66, 0x03, 0x18, 0x70, 0x7F, 0x00, 0xCF,
  0xC6, 0xC7, 0x3C, 0x0D, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x03, 0x6C, 0x33, 0x3F, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0x1F,
  0x93, 0x8D, 0x60, 0x7C, 0x03, 0xC0, 0x38, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0xC0, 0x3C, 0x03, 0x60, 0x77, 0x0D, 0x3F, 0x90, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0xCF, 0xEE, 0x7C, 0x1C,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x00, 0x1F, 0xEE, 0x19, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x0F, 0x00, 0x78,
  0x01, 0xC0, 0x0C, 0x01, 0x80, 0x30, 0x07, 0x81, 0x9F, 0xE0, 0x10, 0x08,
  0x04, 0x1F, 0xF1, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x18, 0x07, 0xC0, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C,
  0x03, 0x60, 0x77, 0x0D, 0x3F, 0x90, 0xC0, 0x1A, 0x00, 0xD8, 0x04, 0xC0,
  0x62, 0x02, 0x18, 0x30, 0xC1, 0x82, 0x08, 0x18, 0xC0, 0x46, 0x03, 0x20,
  0x1B, 0x00, 0x50, 0x03, 0x80, 0x0C, 0x00, 0x40, 0x60, 0x34, 0x07, 0x03,
  0x60, 0x50, 0x36, 0x0D, 0x02, 0x20, 0xD8, 0x63, 0x09, 0x86, 0x30, 0x88,
  0x43, 0x18, 0xC4, 0x11, 0x0C, 0xC1, 0x90, 0x4C, 0x1B, 0x06, 0x80, 0xA0,
  0x68, 0x0A, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x36, 0x06,
  0x20, 0x43, 0x0C, 0x19, 0x80, 0xD0, 0x0F, 0x00, 0x60, 0x0F, 0x00, 0x98,
  0x19, 0x83, 0x0C, 0x60, 0x66, 0x02, 0xC0, 0x30, 0xC0, 0x1A, 0x00, 0xD8,
  0x04, 0xC0, 0x62, 0x02, 0x18, 0x30, 0x41, 0x83, 0x08, 0x18, 0xC0, 0x46,
  0x03, 0x20, 0x0B, 0x00, 0x50, 0x03, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x18, 0x0F, 0x80, 0x70, 0x00, 0x7F, 0xE0, 0x0C, 0x03,
  0x00, 0xC0, 0x10, 0x06, 0x01, 0x80, 0x20, 0x0C, 0x03, 0x00, 0xC0, 0x18,
  0x06, 0x01, 0x80, 0x3F, 0xF8, 0x07, 0x0E, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x30, 0xF0, 0xE0, 0x30, 0x10, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x0C, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x70, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x0C, 0x0F, 0x07, 0x0C, 0x08,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x30, 0xE0, 0x7E, 0x07, 0x0F,
  0xE8, 0x06, 0x00,
};

const GFXglyph NotoSans_Light28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 20, 7, 2, -20 },
  { 9, 6, 7, 10, 2, -20 },
  { 15, 16, 20, 18, 1, -20 },
  { 55, 12, 23, 16, 2, -21 },
  { 90, 19, 20, 23, 2, -20 },
  { 138, 18, 20, 20, 2, -20 },
  { 183, 2, 7, 6, 2, -20 },
  { 185, 6, 24, 8, 1, -20 },
  { 203, 6, 24, 8, 1, -20 },
  { 221, 13, 12, 15, 1, -21 },
  { 241, 14, 13, 16, 1, -16 },
  { 264, 3, 7, 6, 1, -3 },
  { 267, 7, 1, 9, 1, -8 },
  { 268, 3, 2, 7, 2, -2 },
  { 269, 9, 20, 10, 0, -20 },
  { 292, 12, 20, 16, 2, -20 },
  { 322, 6, 20, 16, 3, -20 },
  { 337, 12, 20, 16, 2, -20 },
  { 367, 13, 20, 16, 1, -20 },
  { 400, 15, 20, 16, 1, -20 },
  { 438, 12, 20, 16, 2, -20 },
  { 468, 13, 20, 16, 2, -20 },
  { 501, 13, 20, 16, 1, -20 },
  { 534, 12, 20, 16, 2, -20 },
  { 564, 13, 20, 16, 1, -20 },
  { 597, 3, 15, 7, 2, -15 },
  { 603, 4, 19, 7, 1, -15 },
  { 613, 14, 13, 16, 1, -17 },
  { 636, 12, 7, 16, 2, -13 },
  { 647, 14, 13, 16, 1, -17 },
  { 670, 10, 20, 12, 1, -20 },
  { 695, 21, 23, 25, 2, -20 },
  { 756, 17, 20, 17, 0, -20 },
  { 799, 13, 20, 18, 3, -20 },
  { 832, 15, 20, 17, 2, -20 },
  { 870, 15, 20, 20, 3, -20 },
  { 908, 11, 20, 15, 3, -20 },
  { 936, 11, 20, 14, 3, -20 },
  { 964, 16, 20, 20, 2, -20 },
  { 1004, 14, 20, 20, 3, -20 },
  { 1039, 6, 20, 9, 1, -20 },
  { 1054, 6, 25, 7, -2, -20 },
  { 1073, 13, 20, 16, 3, -20 },
  { 1106, 11, 20, 14, 3, -20 },
  { 1134, 19, 20, 24, 3, -20 },
  { 1182, 15, 20, 20, 3, -20 },
  { 1220, 18, 20, 22, 2, -20 },
  { 1265, 12, 20, 16, 3, -20 },
  { 1295, 18, 25, 22, 2, -20 },
  { 1352, 13, 20, 17, 3, -20 },
  { 1385, 12, 20, 15, 2, -20 },
  { 1415, 15, 20, 15, 0, -20 },
  { 1453, 15, 20, 20, 3, -20 },
  { 1491, 16, 20, 16, 0, -20 },
  { 1531, 24, 20, 25, 1, -20 },
  { 1591, 15, 20, 15, 0, -20 },
  { 1629, 15, 20, 15, 0, -20 },
  { 1667, 14, 20, 16, 1, -20 },
  { 1702, 6, 24, 9, 2, -20 },
  { 1720, 9, 20, 10, 0, -20 },
  { 1743, 6, 24, 9, 1, -20 },
  { 1761, 14, 12, 16, 1, -20 },
  { 1782, 12, 1, 12, 0, 3 },
  { 1784, 5, 4, 7, 1, -21 },
  { 1787, 12, 15, 15, 1, -15 },
  { 1810, 13, 21, 17, 2, -21 },
  { 1845, 10, 15, 13, 2, -15 },
  { 1864, 12, 21, 17, 2, -21 },
  { 1896, 12, 15, 15, 2, -15 },
  { 1919, 10, 21, 9, 0, -21 },
  { 1946, 12, 22, 17, 2, -15 },
  { 1979, 12, 21, 17, 2, -21 },
  { 2011, 2, 20, 7, 2, -20 },
  { 2016, 5, 27, 7, -1, -20 },
  { 2033, 12, 21, 14, 2, -21 },
  { 2065, 2, 21, 7, 2, -21 },
  { 2071, 21, 15, 25, 2, -15 },
  { 2111, 12, 15, 17, 2, -15 },
  { 2134, 13, 15, 17, 2, -15 },
  { 2159, 13, 22, 17, 2, -15 },
  { 2195, 12, 22, 17, 2, -15 },
  { 2228, 9, 15, 11, 2, -15 },
  { 2245, 11, 15, 13, 1, -15 },
  { 2266, 9, 18, 10, 0, -18 },
  { 2287, 12, 15, 17, 2, -15 },
  { 2310, 13, 15, 13, 0, -15 },
  { 2335, 20, 15, 21, 0, -15 },
  { 2373, 12, 15, 14, 1, -15 },
  { 2396, 13, 22, 13, 0, -15 },
  { 2432, 11, 15, 13, 1, -15 },
  { 2453, 8, 24, 10, 1, -20 },
  { 2477, 1, 28, 15, 7, -21 },
  { 2481, 8, 24, 10, 1, -20 },
  { 2505, 14, 3, 16, 1, -11 },
};

const GFXfont NotoSans_Light28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light28pt7bBitmaps,
  (GFXglyph *)NotoSans_Light28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_LIGHT28PT7B_H_
