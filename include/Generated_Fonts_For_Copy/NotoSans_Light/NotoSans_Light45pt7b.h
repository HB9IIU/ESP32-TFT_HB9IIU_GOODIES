#ifndef _NOTOSANS_LIGHT45PT7B_H_
#define _NOTOSANS_LIGHT45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light45pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0x66, 0x66,
  0x66, 0x00, 0x00, 0xEE, 0xFE, 0x40, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0x60, 0xD0, 0x34, 0x0C, 0x00, 0x38, 0x0E, 0x00,
  0x06, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x60, 0x18, 0x00, 0x0C, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xF0, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x06,
  0x03, 0x80, 0x01, 0xC0, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x01, 0x80,
  0x00, 0xC0, 0x30, 0x0F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x00, 0xC0,
  0x30, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x38, 0x00,
  0x1C, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x03,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0xF8, 0x7D, 0x9F, 0x9C, 0x30,
  0x27, 0x06, 0x00, 0xE0, 0xC0, 0x18, 0x18, 0x03, 0x03, 0x00, 0x70, 0x60,
  0x0E, 0x0C, 0x01, 0xE1, 0x80, 0x1E, 0x30, 0x01, 0xF6, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x6F, 0xC0, 0x0C, 0x7C, 0x01, 0x83,
  0x80, 0x30, 0x38, 0x06, 0x07, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x03,
  0x80, 0x60, 0x70, 0x0C, 0x1D, 0x81, 0x87, 0xBF, 0xFF, 0xE3, 0xFF, 0xF0,
  0x01, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xC0, 0x3C, 0xE0, 0x01, 0xC0,
  0x30, 0x70, 0x01, 0x80, 0x70, 0x30, 0x03, 0x00, 0x60, 0x38, 0x07, 0x00,
  0x60, 0x18, 0x06, 0x00, 0x60, 0x18, 0x0E, 0x00, 0xE0, 0x18, 0x0C, 0x00,
  0xE0, 0x18, 0x1C, 0x00, 0xE0, 0x18, 0x18, 0x00, 0xE0, 0x18, 0x38, 0x00,
  0x60, 0x18, 0x30, 0x00, 0x60, 0x18, 0x60, 0xE0, 0x60, 0x18, 0xE3, 0xF8,
  0x60, 0x38, 0xC7, 0x1C, 0x70, 0x31, 0xC6, 0x0E, 0x30, 0x71, 0x8C, 0x06,
  0x3C, 0xE3, 0x8C, 0x07, 0x1F, 0xC3, 0x0C, 0x03, 0x02, 0x07, 0x1C, 0x03,
  0x00, 0x06, 0x1C, 0x03, 0x00, 0x0C, 0x1C, 0x03, 0x00, 0x1C, 0x1C, 0x03,
  0x00, 0x18, 0x1C, 0x03, 0x00, 0x38, 0x1C, 0x03, 0x00, 0x30, 0x1C, 0x03,
  0x00, 0x70, 0x0C, 0x07, 0x00, 0x60, 0x0C, 0x07, 0x00, 0xE0, 0x0E, 0x06,
  0x00, 0xC0, 0x06, 0x0E, 0x01, 0x80, 0x07, 0xFC, 0x03, 0x80, 0x03, 0xF8,
  0x00, 0x70, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x18, 0x00, 0xC0,
  0x01, 0x80, 0x0C, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x0C,
  0x03, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x3B, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xF7, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0xE7, 0x81, 0xE0, 0x0E, 0x70, 0x0F,
  0x00, 0xCE, 0x00, 0x78, 0x1C, 0xE0, 0x03, 0xC1, 0x8C, 0x00, 0x1E, 0x38,
  0xC0, 0x00, 0x77, 0x0C, 0x00, 0x03, 0xF0, 0xE0, 0x00, 0x1E, 0x0E, 0x00,
  0x01, 0xE0, 0xE0, 0x00, 0x3F, 0x07, 0x00, 0x0F, 0x38, 0x3C, 0x03, 0xE1,
  0xC1, 0xFF, 0xF8, 0x0E, 0x07, 0xFE, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0x69,
  0x00, 0x03, 0x83, 0x83, 0x81, 0xC1, 0xC0, 0xC0, 0xE0, 0x70, 0x30, 0x38,
  0x1C, 0x0C, 0x06, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x0C, 0x07, 0x03, 0x80, 0xC0,
  0x70, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0xF0, 0x0C, 0x03,
  0x80, 0x70, 0x0C, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xC0, 0x38, 0x0E,
  0x03, 0x80, 0x60, 0x18, 0x06, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x70,
  0x1C, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x38, 0x0C, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x40, 0x60, 0x37, 0x86, 0x1F, 0xFF, 0xEF, 0xF0, 0xFF, 0xF0, 0x00,
  0x70, 0x00, 0x0F, 0x80, 0x01, 0xD8, 0x00, 0x38, 0xC0, 0x03, 0x0E, 0x00,
  0x70, 0x70, 0x0E, 0x07, 0x01, 0xE0, 0x38, 0x04, 0x01, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x39, 0xCE, 0x67, 0x39,
  0x8C, 0xE6, 0x30, 0xFF, 0xFF, 0xFC, 0xEE, 0xFE, 0x40, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01,
  0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03,
  0x80, 0x0E, 0x00, 0x30, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xFF,
  0x01, 0xC0, 0x78, 0x38, 0x01, 0xC3, 0x00, 0x1C, 0x70, 0x00, 0xE6, 0x00,
  0x0E, 0xE0, 0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00,
  0xE7, 0x00, 0x0E, 0x30, 0x01, 0xC3, 0x80, 0x38, 0x1E, 0x07, 0x80, 0xFF,
  0xF0, 0x03, 0xFC, 0x00, 0x00, 0xE0, 0x3C, 0x0F, 0x87, 0xB1, 0xE6, 0x70,
  0xFC, 0x1B, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x20, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xE0, 0xF8, 0x07, 0x83, 0x00,
  0x1C, 0x10, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x70, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xE1, 0xF0,
  0x07, 0x86, 0x00, 0x0E, 0x20, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x40, 0x00, 0xF3, 0xC0, 0x0F,
  0x1F, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x0C, 0xE0,
  0x00, 0x1C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x30, 0xE0, 0x00, 0x70, 0xE0,
  0x00, 0xE0, 0xE0, 0x01, 0xC0, 0xE0, 0x01, 0x80, 0xE0, 0x03, 0x80, 0xE0,
  0x07, 0x00, 0xE0, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x00, 0xE0,
  0x38, 0x00, 0xE0, 0x30, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0xE0, 0x00, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x02, 0x00, 0x7C, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x80, 0x03, 0xCE, 0x00, 0xF8, 0xFF, 0xFF, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0x78, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x0F,
  0xC0, 0xE7, 0xFF, 0x0C, 0xF0, 0x7C, 0xDC, 0x01, 0xED, 0x00, 0x0E, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x36, 0x00, 0x03, 0x70, 0x00, 0x77, 0x00, 0x07,
  0x38, 0x00, 0xE1, 0xC0, 0x1E, 0x1E, 0x03, 0xC0, 0xFF, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x60, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x83, 0xC0, 0x3C, 0x70,
  0x01, 0xC7, 0x00, 0x0E, 0x60, 0x00, 0xE6, 0x00, 0x0E, 0x60, 0x00, 0xE6,
  0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x1C, 0x38, 0x03, 0x81, 0xE0, 0x70,
  0x0F, 0x9E, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0xF3, 0xF0, 0x1C, 0x07,
  0x83, 0x80, 0x3C, 0x70, 0x00, 0xEE, 0x00, 0x06, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0xE7, 0x00, 0x1E, 0x3C, 0x03, 0xC1, 0xFF, 0xF8, 0x07, 0xFE, 0x00,
  0x00, 0x20, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xE0, 0x3C, 0x07, 0x83, 0x80,
  0x1C, 0x18, 0x00, 0x71, 0xC0, 0x01, 0x8C, 0x00, 0x0E, 0x60, 0x00, 0x37,
  0x00, 0x01, 0xB8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xB0, 0x00,
  0x1D, 0x80, 0x00, 0xEE, 0x00, 0x0F, 0x38, 0x00, 0xF9, 0xE0, 0x0D, 0xC7,
  0xC3, 0xCE, 0x1F, 0xFC, 0x70, 0x1F, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x07, 0xFF, 0x80,
  0x3F, 0xF0, 0x00, 0x18, 0x00, 0x00, 0xEF, 0xEE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xEE, 0xFE, 0x40, 0x39, 0xCE, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x73, 0xB9, 0xCE, 0x63, 0x39,
  0x8C, 0x60, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x80, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x01, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x1F, 0xFC, 0x3F, 0xFF, 0x0C, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x78, 0x00,
  0x00, 0x70, 0x06, 0x00, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x00, 0x18, 0x1C,
  0x00, 0x00, 0x00, 0xC1, 0x80, 0x0F, 0xF4, 0x0C, 0x38, 0x03, 0xFF, 0x80,
  0xE3, 0x00, 0xF0, 0x18, 0x06, 0x70, 0x0E, 0x01, 0x80, 0x66, 0x01, 0xC0,
  0x18, 0x06, 0x60, 0x38, 0x01, 0x80, 0x66, 0x03, 0x80, 0x18, 0x07, 0x60,
  0x30, 0x01, 0x80, 0x7E, 0x03, 0x00, 0x18, 0x06, 0xE0, 0x30, 0x01, 0x80,
  0x6E, 0x03, 0x00, 0x18, 0x06, 0xE0, 0x30, 0x03, 0x80, 0x66, 0x03, 0x00,
  0x38, 0x0E, 0x60, 0x38, 0x03, 0x80, 0xC6, 0x03, 0x80, 0x68, 0x1C, 0x60,
  0x1C, 0x0C, 0xC3, 0x87, 0x00, 0xFF, 0x8F, 0xF0, 0x30, 0x07, 0xF0, 0x3E,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x20, 0x00, 0x1F, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x73,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x70, 0xC0, 0x00,
  0x0C, 0x1C, 0x00, 0x03, 0x81, 0x80, 0x00, 0x70, 0x38, 0x00, 0x0C, 0x07,
  0x00, 0x03, 0x80, 0x60, 0x00, 0x60, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x03,
  0x80, 0x18, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0x30, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x1C, 0x00, 0x0C, 0x03, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x38, 0x1C, 0x00, 0x03, 0x03, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E,
  0x18, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x0E, 0x00,
  0x7E, 0x38, 0x00, 0x3C, 0xE0, 0x00, 0x73, 0x80, 0x00, 0xEE, 0x00, 0x03,
  0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8,
  0x00, 0x1C, 0xE0, 0x00, 0xE3, 0x80, 0x0F, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0xE0, 0x07, 0xE3, 0x80, 0x03, 0xCE, 0x00, 0x03, 0xB8, 0x00, 0x0E,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xB8, 0x00, 0x1E, 0xE0, 0x00,
  0xF3, 0x80, 0x3F, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFF, 0x07, 0xE0, 0x0E, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0xC0, 0x0E, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFC,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x38, 0x03, 0xF8, 0x1C, 0x00, 0x1F,
  0x0E, 0x00, 0x03, 0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x39, 0xC0, 0x00,
  0x0E, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x01, 0xB8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x1D,
  0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x38, 0x00, 0x07,
  0x1C, 0x00, 0x0F, 0x0E, 0x00, 0x1F, 0x07, 0x00, 0xFF, 0x03, 0xFF, 0xFE,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F,
  0xFF, 0xFB, 0xFF, 0xFE, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEE, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFC, 0x0F, 0x80, 0x0E, 0x07, 0x80, 0x00, 0x83, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x70, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x1E,
  0x00, 0x01, 0xC3, 0xE0, 0x00, 0x70, 0x7E, 0x00, 0x3C, 0x07, 0xFF, 0xFF,
  0x00, 0x7F, 0xFE, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x0F, 0xFF, 0xFF, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1D, 0x0F,
  0xBF, 0xE7, 0xF0, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0xF3, 0x80, 0x03, 0xC7,
  0x00, 0x0F, 0x0E, 0x00, 0x3C, 0x1C, 0x00, 0x70, 0x38, 0x01, 0xC0, 0x70,
  0x07, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x70, 0x03, 0x81, 0xC0, 0x07, 0x07,
  0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x39, 0xF0, 0x00, 0x77, 0xE0,
  0x00, 0xFC, 0xE0, 0x01, 0xF0, 0xE0, 0x03, 0xC1, 0xE0, 0x07, 0x01, 0xC0,
  0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0xC0, 0x70, 0x03, 0x80,
  0xE0, 0x03, 0x81, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x07, 0x00, 0x07, 0x0E,
  0x00, 0x07, 0x1C, 0x00, 0x07, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x0F, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFE, 0xC0, 0x00, 0x06, 0xFD, 0xC0, 0x00, 0x0D, 0xFB, 0x80,
  0x00, 0x3B, 0xF3, 0x00, 0x00, 0x67, 0xE7, 0x00, 0x01, 0xCF, 0xC6, 0x00,
  0x03, 0x1F, 0x8E, 0x00, 0x06, 0x3F, 0x1C, 0x00, 0x1C, 0x7E, 0x18, 0x00,
  0x30, 0xFC, 0x38, 0x00, 0xE1, 0xF8, 0x30, 0x01, 0xC3, 0xF0, 0x70, 0x03,
  0x07, 0xE0, 0xE0, 0x0E, 0x0F, 0xC0, 0xC0, 0x18, 0x1F, 0x81, 0xC0, 0x70,
  0x3F, 0x01, 0x80, 0xE0, 0x7E, 0x03, 0x81, 0x80, 0xFC, 0x07, 0x07, 0x01,
  0xF8, 0x06, 0x0C, 0x03, 0xF0, 0x0E, 0x38, 0x07, 0xE0, 0x0C, 0x70, 0x0F,
  0xC0, 0x1C, 0xC0, 0x1F, 0x80, 0x3B, 0x80, 0x3F, 0x00, 0x36, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0xE0, 0x03, 0xF0,
  0x01, 0xC0, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xEE, 0x00, 0x03, 0xE7, 0x00, 0x03,
  0xE7, 0x00, 0x03, 0xE3, 0x80, 0x03, 0xE1, 0xC0, 0x03, 0xE1, 0xC0, 0x03,
  0xE0, 0xE0, 0x03, 0xE0, 0x70, 0x03, 0xE0, 0x70, 0x03, 0xE0, 0x38, 0x03,
  0xE0, 0x1C, 0x03, 0xE0, 0x1C, 0x03, 0xE0, 0x0E, 0x03, 0xE0, 0x07, 0x03,
  0xE0, 0x07, 0x03, 0xE0, 0x03, 0x83, 0xE0, 0x01, 0xC3, 0xE0, 0x01, 0xC3,
  0xE0, 0x00, 0xE3, 0xE0, 0x00, 0x73, 0xE0, 0x00, 0x73, 0xE0, 0x00, 0x3B,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x00, 0x78, 0x0E, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x03, 0x98, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x03, 0x70, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x1B, 0x80,
  0x00, 0x01, 0xCC, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x38, 0x78, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x38,
  0x07, 0x80, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xE0, 0x1F, 0xCE, 0x00,
  0x1E, 0xE0, 0x00, 0xEE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x0E, 0xE0, 0x01, 0xEE, 0x00, 0x3C, 0xE0, 0x7F, 0x8F, 0xFF, 0xE0,
  0xFF, 0xF0, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0x80,
  0x3E, 0x00, 0xF0, 0x00, 0x78, 0x0E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x03, 0x98,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x03, 0x70, 0x00,
  0x00, 0x1B, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x01, 0xCC, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x73, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x38, 0x78, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x38, 0x07, 0x80, 0x03, 0xC0,
  0x1F, 0x00, 0x78, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x0E, 0x00, 0xFC,
  0x38, 0x00, 0x78, 0xE0, 0x00, 0xE3, 0x80, 0x01, 0xCE, 0x00, 0x07, 0x38,
  0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xCE, 0x00, 0x07, 0x38, 0x00,
  0x1C, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x1C, 0x38, 0x03, 0xE0,
  0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0xE0,
  0x0E, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x70, 0x38, 0x00, 0xE0, 0xE0, 0x01,
  0xC3, 0x80, 0x07, 0x0E, 0x00, 0x0E, 0x38, 0x00, 0x38, 0xE0, 0x00, 0x73,
  0x80, 0x01, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x00, 0x70, 0x00, 0x7F,
  0xFC, 0x0F, 0xFF, 0xF1, 0xE0, 0x0E, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE8, 0x00, 0x1E, 0xF0,
  0x07, 0xCF, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x07, 0x70, 0x00,
  0x07, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x1E, 0x1C, 0x00, 0x3C, 0x1F, 0x00,
  0xF8, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0xE0, 0x00, 0x01, 0xD8, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x0E, 0x30, 0x00, 0x03, 0x8E,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0x70, 0x00, 0x18, 0x1C, 0x00, 0x0E,
  0x03, 0x00, 0x03, 0x80, 0xE0, 0x00, 0xC0, 0x38, 0x00, 0x70, 0x06, 0x00,
  0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0xC0, 0x03,
  0x80, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x1C, 0x06, 0x00, 0x07, 0x03, 0x80,
  0x00, 0xC0, 0xE0, 0x00, 0x38, 0x30, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0x87,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0x30, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00,
  0x39, 0x80, 0x01, 0xE0, 0x00, 0x73, 0x80, 0x03, 0xE0, 0x00, 0xE7, 0x00,
  0x0F, 0xC0, 0x01, 0x86, 0x00, 0x1D, 0x80, 0x07, 0x0C, 0x00, 0x33, 0x00,
  0x0E, 0x1C, 0x00, 0x67, 0x00, 0x18, 0x38, 0x01, 0xC6, 0x00, 0x70, 0x30,
  0x03, 0x8C, 0x00, 0xE0, 0x70, 0x06, 0x1C, 0x01, 0xC0, 0xE0, 0x1C, 0x38,
  0x03, 0x01, 0xC0, 0x38, 0x30, 0x0E, 0x01, 0x80, 0x60, 0x60, 0x1C, 0x03,
  0x80, 0xC0, 0xE0, 0x38, 0x07, 0x03, 0x80, 0xC0, 0x60, 0x0E, 0x07, 0x01,
  0x81, 0xC0, 0x0C, 0x0C, 0x03, 0x83, 0x80, 0x1C, 0x18, 0x07, 0x06, 0x00,
  0x38, 0x70, 0x06, 0x0C, 0x00, 0x30, 0xC0, 0x0C, 0x38, 0x00, 0x61, 0x80,
  0x1C, 0x70, 0x00, 0xE7, 0x00, 0x18, 0xC0, 0x01, 0xCE, 0x00, 0x33, 0x80,
  0x01, 0x98, 0x00, 0x77, 0x00, 0x03, 0x30, 0x00, 0xEE, 0x00, 0x07, 0xE0,
  0x00, 0xD8, 0x00, 0x0F, 0xC0, 0x01, 0xB0, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x07,
  0x03, 0x80, 0x03, 0x80, 0xE0, 0x03, 0x80, 0x30, 0x03, 0x80, 0x1C, 0x01,
  0xC0, 0x07, 0x01, 0xC0, 0x03, 0x80, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x38,
  0xE0, 0x00, 0x1C, 0x60, 0x00, 0x07, 0x70, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3B, 0x00, 0x00,
  0x19, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x0E, 0x00,
  0x0E, 0x03, 0x80, 0x06, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x18,
  0x03, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x83, 0x80, 0x01, 0xC1, 0x80, 0x00,
  0x71, 0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0x70, 0x00,
  0x0E, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x18, 0x00, 0x1C, 0x1C, 0x00,
  0x38, 0x0C, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x06, 0x00, 0x60, 0x07, 0x00,
  0xE0, 0x03, 0x80, 0xC0, 0x03, 0x81, 0xC0, 0x01, 0xC3, 0x80, 0x01, 0xC3,
  0x80, 0x00, 0xE7, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x07, 0xFF, 0xFE, 0xC0, 0x03, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x70,
  0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x03,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60,
  0x01, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x37, 0x00, 0x00, 0xCC, 0x00, 0x06, 0x38, 0x00, 0x18, 0x60, 0x00,
  0xC1, 0xC0, 0x03, 0x03, 0x00, 0x18, 0x0E, 0x00, 0x60, 0x18, 0x03, 0x00,
  0x70, 0x1C, 0x00, 0xC0, 0x60, 0x03, 0x83, 0x80, 0x06, 0x0C, 0x00, 0x1C,
  0x70, 0x00, 0x31, 0x80, 0x00, 0xEE, 0x00, 0x01, 0xB0, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x06, 0x03, 0x07,
  0xFE, 0x07, 0xFF, 0xC1, 0xC0, 0x78, 0x40, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x0F, 0xFC,
  0x1F, 0xFF, 0x1F, 0x00, 0xCE, 0x00, 0x37, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0x70, 0x07, 0xDE, 0x03,
  0xB3, 0xFF, 0xCC, 0x7F, 0xC3, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC3, 0xFE, 0x0C, 0x7F, 0xF8, 0xCE,
  0x03, 0xCD, 0x80, 0x1C, 0xF0, 0x00, 0xEF, 0x00, 0x06, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x00, 0xEF, 0x00, 0x0E, 0xD8, 0x01, 0xCD, 0xC0,
  0x38, 0xCF, 0xFF, 0x0C, 0x3F, 0xE0, 0x03, 0xFF, 0x07, 0xFF, 0xC7, 0xC0,
  0x47, 0x80, 0x07, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x0C, 0x3F, 0xFE, 0x07, 0xFE, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x07, 0xFC,
  0x70, 0xFF, 0xE3, 0x1E, 0x03, 0x33, 0x80, 0x1B, 0x70, 0x00, 0xF7, 0x00,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x60, 0x00, 0xF7, 0x00, 0x0F,
  0x78, 0x01, 0xB3, 0xC0, 0x33, 0x1F, 0xFE, 0x30, 0x7F, 0xC3, 0x03, 0xFC,
  0x01, 0xFF, 0xE0, 0x78, 0x1E, 0x1C, 0x01, 0xE7, 0x00, 0x1C, 0xE0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x01, 0x83, 0xFF, 0xF0, 0x1F, 0xFC, 0x01, 0xFE, 0x07, 0xFC, 0x1C,
  0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x01, 0xFF, 0xC7, 0xFF, 0x80, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x07,
  0xFC, 0x30, 0xFF, 0xF3, 0x1E, 0x03, 0xB3, 0x80, 0x1B, 0x70, 0x00, 0xF7,
  0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x60, 0x00, 0xF7, 0x00,
  0x0F, 0x38, 0x01, 0xB3, 0xC0, 0x37, 0x1F, 0xFE, 0x70, 0x7F, 0xC7, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x00, 0xE6, 0x00, 0x3C, 0x7F, 0x1F, 0x83, 0xFF, 0xF0,
  0x03, 0xF8, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x8F, 0xF8, 0x73, 0xFF, 0xCE, 0xE0, 0x3D, 0xB0, 0x03,
  0xBC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0C,
  0xDF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0x01, 0xC0, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0C, 0x06, 0x07, 0x4F,
  0xBF, 0x9F, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x3B, 0x00, 0x1C, 0xC0, 0x0E, 0x30, 0x07, 0x0C, 0x03,
  0x83, 0x01, 0xC0, 0xC0, 0xE0, 0x30, 0x70, 0x0C, 0x1C, 0x03, 0x0E, 0x00,
  0xC7, 0x00, 0x33, 0xE0, 0x0D, 0xDC, 0x03, 0xE7, 0x00, 0xF0, 0xE0, 0x38,
  0x1C, 0x0C, 0x07, 0x83, 0x00, 0xE0, 0xC0, 0x1C, 0x30, 0x03, 0x8C, 0x00,
  0xF3, 0x00, 0x1C, 0xC0, 0x03, 0xB0, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC3, 0xFC, 0x07,
  0xF8, 0x67, 0xFF, 0x0F, 0xFE, 0x37, 0x03, 0xCE, 0x07, 0x9B, 0x00, 0x7E,
  0x00, 0xEF, 0x00, 0x3E, 0x00, 0x77, 0x00, 0x0E, 0x00, 0x1B, 0x80, 0x07,
  0x00, 0x0D, 0xC0, 0x03, 0x80, 0x07, 0xE0, 0x01, 0xC0, 0x03, 0xF0, 0x00,
  0xE0, 0x01, 0xF8, 0x00, 0x70, 0x00, 0xFC, 0x00, 0x38, 0x00, 0x7E, 0x00,
  0x1C, 0x00, 0x3F, 0x00, 0x0E, 0x00, 0x1F, 0x80, 0x07, 0x00, 0x0F, 0xC0,
  0x03, 0x80, 0x07, 0xE0, 0x01, 0xC0, 0x03, 0xF0, 0x00, 0xE0, 0x01, 0xF8,
  0x00, 0x70, 0x00, 0xFC, 0x00, 0x38, 0x00, 0x7E, 0x00, 0x1C, 0x00, 0x3F,
  0x00, 0x0E, 0x00, 0x1F, 0x80, 0x07, 0x00, 0x0F, 0xC0, 0x03, 0x80, 0x07,
  0xC3, 0xFE, 0x18, 0xFF, 0xF3, 0x38, 0x0F, 0x6C, 0x00, 0xEF, 0x00, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0x03, 0xFE, 0x00,
  0x7F, 0xFC, 0x07, 0x80, 0xF0, 0x70, 0x03, 0xC7, 0x00, 0x0E, 0x38, 0x00,
  0x3B, 0x80, 0x01, 0xDC, 0x00, 0x06, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x37, 0x00, 0x03, 0x9C, 0x00, 0x1C, 0xE0,
  0x01, 0xC3, 0x80, 0x1E, 0x0F, 0x01, 0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0xC0,
  0xC3, 0xFE, 0x0C, 0x7F, 0xF8, 0xCE, 0x03, 0xCD, 0x80, 0x1C, 0xD0, 0x00,
  0xEF, 0x00, 0x06, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0xEF,
  0x00, 0x0E, 0xD8, 0x01, 0xCC, 0xE0, 0x38, 0xC7, 0xFF, 0x0E, 0x3F, 0xE0,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x30, 0xFF, 0xE3, 0x1E, 0x07, 0x33,
  0x80, 0x1B, 0x70, 0x00, 0xF7, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0xF7, 0x00, 0x0F, 0x78, 0x01, 0xF3, 0xC0, 0x77, 0x1F,
  0xFE, 0x70, 0x7F, 0xC7, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0xC3, 0xFE, 0x3F, 0xF3,
  0x81, 0xB0, 0x0D, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x0F,
  0xFE, 0x1F, 0xFF, 0xDE, 0x00, 0xCE, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x37, 0x00, 0x7B, 0xFF, 0xF8,
  0xFF, 0xF0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x03,
  0xFF, 0xFF, 0xFF, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00,
  0x7F, 0x81, 0xFC, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x07,
  0xF0, 0x00, 0xF7, 0x00, 0x3E, 0xF0, 0x1C, 0xCF, 0xFF, 0x18, 0xFF, 0xC3,
  0xE0, 0x00, 0x3B, 0x00, 0x01, 0xDC, 0x00, 0x1C, 0xE0, 0x00, 0xE3, 0x00,
  0x06, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x83, 0x80, 0x18, 0x1C, 0x01, 0xC0,
  0x60, 0x0C, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0x60, 0x30, 0x03, 0x83,
  0x80, 0x0C, 0x1C, 0x00, 0x70, 0xC0, 0x03, 0x8E, 0x00, 0x0C, 0x60, 0x00,
  0x73, 0x00, 0x03, 0xB8, 0x00, 0x0D, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0xC0, 0x03, 0x80, 0x07, 0xC0, 0x07, 0x80, 0x1F, 0x80,
  0x0F, 0x00, 0x3B, 0x00, 0x3E, 0x00, 0x77, 0x00, 0x6C, 0x00, 0xCE, 0x00,
  0xDC, 0x03, 0x9C, 0x03, 0x98, 0x07, 0x18, 0x07, 0x30, 0x0C, 0x38, 0x0C,
  0x70, 0x18, 0x70, 0x38, 0x60, 0x70, 0x60, 0x70, 0xC0, 0xE0, 0xC0, 0xC1,
  0xC1, 0x81, 0xC3, 0x81, 0x83, 0x03, 0x87, 0x03, 0x0E, 0x03, 0x0C, 0x07,
  0x1C, 0x07, 0x38, 0x0E, 0x30, 0x0E, 0x70, 0x0C, 0x60, 0x0C, 0xC0, 0x1D,
  0xC0, 0x19, 0x80, 0x3B, 0x00, 0x3F, 0x00, 0x36, 0x00, 0x7C, 0x00, 0x6C,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0,
  0xF0, 0x00, 0x73, 0x80, 0x07, 0x0E, 0x00, 0x70, 0x38, 0x03, 0x80, 0xC0,
  0x38, 0x07, 0x03, 0x80, 0x1C, 0x1C, 0x00, 0x71, 0xC0, 0x03, 0x9C, 0x00,
  0x0E, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0x70, 0x00, 0x71, 0xC0, 0x07, 0x0E, 0x00, 0x30, 0x38, 0x03,
  0x80, 0xE0, 0x38, 0x07, 0x03, 0x80, 0x1C, 0x1C, 0x00, 0x71, 0xC0, 0x01,
  0xDC, 0x00, 0x0F, 0xE0, 0x00, 0x3B, 0x00, 0x01, 0xDC, 0x00, 0x1C, 0xE0,
  0x00, 0xE3, 0x00, 0x06, 0x1C, 0x00, 0x70, 0x60, 0x03, 0x83, 0x80, 0x18,
  0x1C, 0x01, 0xC0, 0x60, 0x0E, 0x03, 0x80, 0xE0, 0x0C, 0x07, 0x00, 0x70,
  0x30, 0x03, 0x83, 0x80, 0x0C, 0x1C, 0x00, 0x70, 0xC0, 0x03, 0x8E, 0x00,
  0x0C, 0x60, 0x00, 0x73, 0x00, 0x01, 0xB8, 0x00, 0x0D, 0x80, 0x00, 0x7C,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x8F, 0x00, 0x07, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x7F,
  0xFF, 0xBF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x3C, 0x03, 0xF0, 0x1E, 0x00, 0xE0, 0x03, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x0F, 0xC0, 0x3C,
  0x00, 0xFC, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xF0, 0x03, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0,
  0x07, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x03, 0x00, 0x1C, 0x00, 0x7E, 0x00, 0xF0, 0x1F, 0x81, 0xC0, 0x0C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x03, 0xC0, 0x7C,
  0x03, 0xC0, 0x00, 0x3F, 0xC0, 0x0B, 0xFF, 0x80, 0xF8, 0x1F, 0xFF, 0x00,
  0x3F, 0xE0, 0x00, 0x38, 0x00,
};

const GFXglyph NotoSans_Light45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 4, 33, 11, 4, -32 },
  { 18, 10, 11, 16, 3, -32 },
  { 32, 27, 32, 29, 1, -32 },
  { 140, 19, 37, 26, 3, -34 },
  { 228, 32, 33, 37, 2, -33 },
  { 360, 28, 33, 32, 3, -33 },
  { 476, 3, 11, 9, 3, -32 },
  { 481, 9, 39, 13, 2, -32 },
  { 525, 10, 39, 13, 1, -32 },
  { 574, 20, 19, 25, 2, -34 },
  { 622, 21, 22, 26, 2, -27 },
  { 680, 5, 11, 10, 2, -5 },
  { 687, 11, 2, 14, 2, -13 },
  { 690, 4, 5, 11, 4, -4 },
  { 693, 14, 32, 16, 1, -32 },
  { 749, 20, 33, 26, 3, -33 },
  { 832, 11, 32, 26, 4, -32 },
  { 876, 21, 33, 26, 2, -33 },
  { 963, 21, 33, 26, 2, -33 },
  { 1050, 24, 32, 26, 1, -32 },
  { 1146, 20, 32, 26, 3, -32 },
  { 1226, 20, 33, 26, 3, -33 },
  { 1309, 21, 32, 26, 2, -32 },
  { 1393, 20, 33, 26, 3, -33 },
  { 1476, 21, 34, 26, 2, -33 },
  { 1566, 4, 25, 11, 4, -24 },
  { 1579, 5, 30, 11, 2, -24 },
  { 1598, 21, 21, 26, 2, -27 },
  { 1654, 20, 11, 26, 3, -21 },
  { 1682, 21, 21, 26, 2, -27 },
  { 1738, 17, 34, 19, 1, -33 },
  { 1811, 36, 36, 40, 2, -32 },
  { 1973, 27, 32, 27, 0, -32 },
  { 2081, 22, 32, 28, 4, -32 },
  { 2169, 24, 33, 28, 3, -33 },
  { 2268, 25, 32, 32, 4, -32 },
  { 2368, 18, 32, 25, 4, -32 },
  { 2440, 18, 32, 23, 4, -32 },
  { 2512, 26, 33, 33, 3, -33 },
  { 2620, 24, 32, 33, 4, -32 },
  { 2716, 10, 32, 14, 2, -32 },
  { 2756, 11, 40, 11, -4, -32 },
  { 2811, 23, 32, 27, 4, -32 },
  { 2903, 18, 32, 23, 4, -32 },
  { 2975, 31, 32, 39, 4, -32 },
  { 3099, 24, 32, 33, 4, -32 },
  { 3195, 29, 33, 35, 3, -33 },
  { 3315, 20, 32, 27, 4, -32 },
  { 3395, 29, 41, 35, 3, -33 },
  { 3544, 22, 32, 27, 4, -32 },
  { 3632, 20, 33, 25, 2, -33 },
  { 3715, 24, 32, 24, 0, -32 },
  { 3811, 24, 32, 32, 4, -32 },
  { 3907, 26, 32, 26, 0, -32 },
  { 4011, 39, 32, 41, 1, -32 },
  { 4167, 25, 32, 25, 0, -32 },
  { 4267, 24, 32, 24, 0, -32 },
  { 4363, 22, 32, 26, 2, -32 },
  { 4451, 9, 39, 14, 4, -32 },
  { 4495, 14, 32, 16, 1, -32 },
  { 4551, 10, 39, 14, 1, -32 },
  { 4600, 22, 20, 26, 2, -32 },
  { 4655, 19, 2, 19, 0, 4 },
  { 4660, 8, 7, 12, 2, -34 },
  { 4667, 18, 24, 24, 2, -24 },
  { 4721, 20, 34, 27, 4, -34 },
  { 4806, 17, 24, 21, 3, -24 },
  { 4857, 20, 34, 27, 3, -34 },
  { 4942, 19, 24, 25, 3, -24 },
  { 4999, 15, 34, 14, 1, -34 },
  { 5063, 20, 35, 27, 3, -24 },
  { 5151, 19, 34, 27, 4, -34 },
  { 5232, 3, 33, 10, 4, -33 },
  { 5245, 9, 44, 10, -2, -33 },
  { 5295, 18, 34, 22, 4, -34 },
  { 5372, 3, 34, 10, 4, -34 },
  { 5385, 33, 24, 40, 4, -24 },
  { 5484, 19, 24, 27, 4, -24 },
  { 5541, 21, 24, 27, 3, -24 },
  { 5604, 20, 35, 27, 4, -24 },
  { 5692, 20, 35, 27, 3, -24 },
  { 5780, 13, 24, 18, 4, -24 },
  { 5819, 17, 24, 21, 2, -24 },
  { 5870, 13, 30, 15, 1, -30 },
  { 5919, 19, 24, 27, 4, -24 },
  { 5976, 21, 24, 21, 0, -24 },
  { 6039, 31, 24, 33, 1, -24 },
  { 6132, 21, 24, 23, 1, -24 },
  { 6195, 21, 35, 21, 0, -24 },
  { 6287, 17, 24, 21, 2, -24 },
  { 6338, 14, 39, 16, 1, -32 },
  { 6407, 2, 45, 24, 11, -34 },
  { 6419, 13, 39, 16, 2, -32 },
  { 6483, 21, 5, 26, 2, -18 },
};

const GFXfont NotoSans_Light45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light45pt7bBitmaps,
  (GFXglyph *)NotoSans_Light45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_LIGHT45PT7B_H_
