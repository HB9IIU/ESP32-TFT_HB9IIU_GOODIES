#ifndef _NOTOSANS_LIGHT11PT7B_H_
#define _NOTOSANS_LIGHT11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light11pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xFC, 0x14, 0x49, 0xD9, 0x42, 0x9F, 0x92, 0x24, 0x7A, 0xAE,
  0x33, 0x3E, 0x20, 0xC5, 0x52, 0xA5, 0xBD, 0xA5, 0x4A, 0xA7, 0x71, 0x22,
  0x43, 0x0A, 0x52, 0xA2, 0x7B, 0xE0, 0x29, 0x49, 0x22, 0x44, 0x89, 0x12,
  0x4A, 0x50, 0x2B, 0x6F, 0x21, 0x3E, 0x42, 0x00, 0x60, 0xE0, 0x80, 0x12,
  0x22, 0x44, 0x88, 0x74, 0xA3, 0x18, 0xC6, 0x4E, 0x3C, 0x92, 0x49, 0xF0,
  0x84, 0x22, 0x22, 0x1F, 0x78, 0x20, 0x8E, 0x08, 0x10, 0x7E, 0x08, 0x62,
  0x8A, 0x4B, 0xF0, 0x82, 0xF4, 0x21, 0xE0, 0x84, 0x3E, 0x74, 0x21, 0xE8,
  0xC6, 0x2E, 0xF8, 0x84, 0x22, 0x11, 0x08, 0x74, 0x64, 0xC9, 0x46, 0x3E,
  0xE4, 0xA3, 0x1F, 0x84, 0x5C, 0x84, 0x40, 0x18, 0x09, 0xB1, 0x83, 0x04,
  0xFF, 0xC0, 0x82, 0x0C, 0x36, 0x40, 0xF1, 0x11, 0x24, 0x04, 0x3C, 0x42,
  0x99, 0xA5, 0xA5, 0xA5, 0x9A, 0x80, 0x7C, 0x10, 0x60, 0xA1, 0x44, 0x4F,
  0xA1, 0x41, 0xF4, 0x63, 0xE8, 0xC6, 0x3F, 0x7E, 0x08, 0x20, 0x82, 0x08,
  0x1E, 0xF2, 0x38, 0x61, 0x86, 0x18, 0x7E, 0xF8, 0x8F, 0x88, 0x8F, 0xF8,
  0x88, 0xF8, 0x88, 0x7E, 0x08, 0x20, 0x9E, 0x18, 0x5F, 0x86, 0x18, 0x7F,
  0x86, 0x18, 0x61, 0xEA, 0xAB, 0x24, 0x92, 0x49, 0x38, 0x8C, 0xA9, 0x8A,
  0x4A, 0x51, 0x88, 0x88, 0x88, 0x8F, 0x83, 0x87, 0x1D, 0x3A, 0x75, 0x66,
  0xC9, 0x87, 0x1C, 0x69, 0x96, 0x58, 0xE1, 0x79, 0x0A, 0x0C, 0x18, 0x30,
  0x61, 0x3C, 0xF4, 0x63, 0x1F, 0x42, 0x10, 0x79, 0x0A, 0x0C, 0x18, 0x30,
  0x61, 0x3C, 0x08, 0x08, 0xF4, 0x63, 0x1F, 0x4A, 0x31, 0xF8, 0x8C, 0x31,
  0x1F, 0xFC, 0x82, 0x08, 0x20, 0x82, 0x08, 0x86, 0x18, 0x61, 0x86, 0x18,
  0x5E, 0x86, 0x14, 0x52, 0x48, 0xA3, 0x04, 0x88, 0x63, 0x24, 0xC9, 0x52,
  0x52, 0x8C, 0xC2, 0x30, 0x84, 0x85, 0x23, 0x0C, 0x31, 0x24, 0xA1, 0x85,
  0x24, 0x8C, 0x30, 0x82, 0x08, 0x7C, 0x20, 0x84, 0x20, 0x84, 0x3F, 0xEA,
  0xAA, 0xB0, 0x88, 0x44, 0x22, 0x21, 0xE4, 0x92, 0x49, 0x3C, 0x10, 0xC4,
  0x92, 0xC4, 0xF8, 0xC0, 0xE1, 0x79, 0x9F, 0x84, 0x3D, 0x18, 0xC6, 0x3E,
  0x78, 0x88, 0x87, 0x08, 0x5F, 0x18, 0xC6, 0x3F, 0x79, 0xF8, 0x87, 0x74,
  0xE4, 0x44, 0x44, 0x7C, 0x63, 0x18, 0xFC, 0x22, 0xE0, 0x84, 0x3D, 0x18,
  0xC6, 0x31, 0xBF, 0x20, 0x92, 0x49, 0x27, 0x00, 0x88, 0x9A, 0xCA, 0xA9,
  0xFF, 0xF6, 0x99, 0x91, 0x91, 0x91, 0x91, 0xF4, 0x63, 0x18, 0xC4, 0x74,
  0x63, 0x18, 0xB8, 0xF4, 0x63, 0x18, 0xFA, 0x10, 0x80, 0x7C, 0x63, 0x18,
  0xFC, 0x21, 0x08, 0xF2, 0x49, 0x00, 0x7C, 0x18, 0x20, 0xF8, 0x5D, 0x24,
  0x98, 0x8C, 0x63, 0x18, 0xFC, 0x8C, 0x54, 0xA5, 0x10, 0x89, 0x99, 0x5A,
  0x66, 0x66, 0x24, 0x8A, 0x88, 0x45, 0x44, 0x8C, 0x54, 0xA3, 0x10, 0x88,
  0x80, 0x78, 0x88, 0x44, 0x7C, 0x34, 0x44, 0xC4, 0x44, 0x43, 0xFF, 0xE0,
  0xC2, 0x22, 0x32, 0x22, 0x4C, 0xF8,
};

const GFXglyph NotoSans_Light11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 8, 3, 1, -8 },
  { 2, 2, 3, 4, 1, -8 },
  { 3, 7, 8, 7, 0, -8 },
  { 10, 4, 9, 6, 1, -8 },
  { 15, 7, 8, 9, 1, -8 },
  { 22, 7, 8, 8, 1, -8 },
  { 29, 1, 3, 2, 1, -8 },
  { 30, 3, 10, 3, 0, -8 },
  { 34, 3, 10, 3, 0, -8 },
  { 38, 4, 4, 6, 1, -8 },
  { 40, 5, 5, 6, 1, -6 },
  { 44, 2, 2, 2, 0, -1 },
  { 45, 3, 1, 4, 0, -3 },
  { 46, 1, 1, 3, 1, -1 },
  { 47, 4, 8, 4, 0, -8 },
  { 51, 5, 8, 6, 1, -8 },
  { 56, 3, 8, 6, 1, -8 },
  { 59, 5, 8, 6, 1, -8 },
  { 64, 6, 8, 6, 0, -8 },
  { 70, 6, 8, 6, 0, -8 },
  { 76, 5, 8, 6, 1, -8 },
  { 81, 5, 8, 6, 1, -8 },
  { 86, 5, 8, 6, 1, -8 },
  { 91, 5, 8, 6, 1, -8 },
  { 96, 5, 8, 6, 1, -8 },
  { 101, 1, 6, 3, 1, -6 },
  { 102, 2, 7, 3, 0, -6 },
  { 104, 5, 6, 6, 1, -7 },
  { 108, 5, 2, 6, 1, -5 },
  { 110, 5, 6, 6, 1, -7 },
  { 114, 4, 8, 5, 0, -8 },
  { 118, 8, 9, 10, 1, -8 },
  { 127, 7, 8, 7, 0, -8 },
  { 134, 5, 8, 7, 1, -8 },
  { 139, 6, 8, 7, 1, -8 },
  { 145, 6, 8, 8, 1, -8 },
  { 151, 4, 8, 6, 1, -8 },
  { 155, 4, 8, 6, 1, -8 },
  { 159, 6, 8, 8, 1, -8 },
  { 165, 6, 8, 8, 1, -8 },
  { 171, 2, 8, 3, 1, -8 },
  { 173, 3, 10, 3, -1, -8 },
  { 177, 5, 8, 6, 1, -8 },
  { 182, 4, 8, 6, 1, -8 },
  { 186, 7, 8, 10, 1, -8 },
  { 193, 6, 8, 8, 1, -8 },
  { 199, 7, 8, 8, 1, -8 },
  { 206, 5, 8, 6, 1, -8 },
  { 211, 7, 10, 8, 1, -8 },
  { 220, 5, 8, 7, 1, -8 },
  { 225, 4, 8, 6, 1, -8 },
  { 229, 6, 8, 6, 0, -8 },
  { 235, 6, 8, 8, 1, -8 },
  { 241, 6, 8, 6, 0, -8 },
  { 247, 10, 8, 10, 0, -8 },
  { 257, 6, 8, 6, 0, -8 },
  { 263, 6, 8, 6, 0, -8 },
  { 269, 6, 8, 6, 0, -8 },
  { 275, 2, 10, 4, 1, -8 },
  { 278, 4, 8, 4, 0, -8 },
  { 282, 3, 10, 4, 0, -8 },
  { 286, 6, 5, 6, 0, -8 },
  { 290, 5, 1, 5, 0, 1 },
  { 291, 2, 1, 3, 0, -8 },
  { 292, 4, 6, 6, 1, -6 },
  { 295, 5, 8, 7, 1, -8 },
  { 300, 4, 6, 5, 1, -6 },
  { 303, 5, 8, 7, 1, -8 },
  { 308, 4, 6, 6, 1, -6 },
  { 311, 4, 8, 3, 0, -8 },
  { 315, 5, 9, 7, 1, -6 },
  { 321, 5, 8, 7, 1, -8 },
  { 326, 1, 8, 3, 1, -8 },
  { 327, 3, 11, 3, -1, -8 },
  { 332, 4, 8, 5, 1, -8 },
  { 336, 1, 8, 3, 1, -8 },
  { 337, 8, 6, 10, 1, -6 },
  { 343, 5, 6, 7, 1, -6 },
  { 347, 5, 6, 6, 1, -6 },
  { 351, 5, 9, 7, 1, -6 },
  { 357, 5, 9, 7, 1, -6 },
  { 363, 3, 6, 4, 1, -6 },
  { 366, 5, 6, 5, 0, -6 },
  { 370, 3, 7, 4, 0, -7 },
  { 373, 5, 6, 7, 1, -6 },
  { 377, 5, 6, 5, 0, -6 },
  { 381, 8, 6, 8, 0, -6 },
  { 387, 5, 6, 6, 0, -6 },
  { 391, 5, 9, 5, 0, -6 },
  { 397, 5, 6, 5, 0, -6 },
  { 401, 4, 10, 4, 0, -8 },
  { 406, 1, 11, 6, 2, -8 },
  { 408, 4, 10, 4, 0, -8 },
  { 413, 5, 1, 6, 1, -4 },
};

const GFXfont NotoSans_Light11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light11pt7bBitmaps,
  (GFXglyph *)NotoSans_Light11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_LIGHT11PT7B_H_
