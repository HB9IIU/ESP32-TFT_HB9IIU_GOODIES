#ifndef _NOTOSANS_LIGHT71PT7B_H_
#define _NOTOSANS_LIGHT71PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light71pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xEF, 0xBE, 0xF9, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xEF,
  0xFF, 0xFF, 0xFF, 0x9C, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E,
  0x70, 0x0E, 0x70, 0x0E, 0x60, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0x80, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x70, 0x00, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x07, 0x00, 0x00, 0x01,
  0xE0, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x03, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x78, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x01,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x80, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0x87, 0x07,
  0xE0, 0xFC, 0x0E, 0x00, 0xC1, 0xF0, 0x1C, 0x00, 0x07, 0xC0, 0x38, 0x00,
  0x0F, 0x00, 0x70, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x3C, 0x01, 0xC0, 0x00,
  0xF8, 0x03, 0x80, 0x01, 0xF0, 0x07, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x03,
  0xC0, 0x1C, 0x00, 0x07, 0x80, 0x38, 0x00, 0x0F, 0x80, 0x70, 0x00, 0x0F,
  0x80, 0xE0, 0x00, 0x0F, 0xC1, 0xC0, 0x00, 0x1F, 0xE3, 0x80, 0x00, 0x0F,
  0xF7, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xCF, 0xF0, 0x00, 0x03, 0x87, 0xF0, 0x00, 0x07, 0x03, 0xF0, 0x00, 0x0E,
  0x01, 0xF0, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x38, 0x03, 0xE0, 0x00, 0x70,
  0x03, 0xC0, 0x00, 0xE0, 0x07, 0x80, 0x01, 0xC0, 0x0F, 0x00, 0x03, 0x80,
  0x1E, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x1C, 0x01,
  0xE0, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x70, 0x0F, 0x18, 0x00, 0xE0, 0x7E,
  0x3F, 0x01, 0xC3, 0xF8, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0x80, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x1E, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x0E,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0xF0, 0x3C, 0x0F, 0xE0, 0x3C, 0x00, 0x3C, 0x1E, 0x0F, 0xFE,
  0x07, 0x00, 0x0E, 0x07, 0x87, 0xFF, 0xC1, 0xC0, 0x07, 0x83, 0xC3, 0xE0,
  0xF8, 0x78, 0x01, 0xE0, 0xE0, 0xF0, 0x1F, 0x1E, 0x00, 0x70, 0x78, 0x78,
  0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x1E, 0x00, 0x70, 0x78, 0x1E, 0x0F, 0x07,
  0x00, 0x1E, 0x1F, 0xFF, 0x87, 0x83, 0xC0, 0x07, 0x83, 0xFF, 0xC1, 0xE0,
  0xF0, 0x00, 0xE0, 0x3F, 0xC0, 0xF0, 0x38, 0x00, 0x38, 0x00, 0x00, 0x3C,
  0x0E, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x03, 0xC0, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x0E, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x03, 0x80, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x0E, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0x78, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x0E, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x3C, 0x00, 0x00, 0x7E,
  0xFE, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x8F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00,
  0x78, 0x0F, 0xC0, 0x3E, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x7C, 0x00, 0x07,
  0x83, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0xF0,
  0x7C, 0x00, 0x03, 0xE0, 0x07, 0xC1, 0xE0, 0x00, 0x07, 0xC0, 0x1E, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x78, 0x3E, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0xF0,
  0x00, 0x00, 0x3E, 0x1F, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x78, 0x0F, 0x00,
  0x00, 0x00, 0xFB, 0xE0, 0x3C, 0x00, 0x00, 0x01, 0xFF, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x07, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x1F, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0xBE, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x7C, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x01, 0xF0, 0x07, 0xFF, 0xFF, 0xF0,
  0x03, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x0F, 0xFF, 0xF0, 0x00,
  0x0F, 0xC0, 0x02, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0x77, 0x77, 0x60, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0,
  0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0x80, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0,
  0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x3F, 0xE0, 0x1C,
  0x03, 0xFF, 0xF8, 0x38, 0x3F, 0xFF, 0xFE, 0x73, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0x07, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x0F, 0x80, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1E, 0x1E, 0x3E, 0x3C, 0x3C, 0x3C, 0x38, 0x78, 0x78, 0x70, 0x70,
  0xF0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7B,
  0xFF, 0xFF, 0xFF, 0xE7, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0,
  0x1F, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x07, 0xC0,
  0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xBC, 0x1F, 0x9E, 0x1F, 0x8F,
  0x1F, 0x07, 0xBF, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xF6, 0x00, 0x79, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xC0,
  0x7F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x38, 0x00, 0x01, 0xF0,
  0x10, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFE, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x07, 0xE0, 0xE0, 0x00, 0x01,
  0xF0, 0x40, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xE6, 0x00, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x07, 0xE1, 0xFE, 0x00,
  0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x7C,
  0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x1E,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0xF4, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x1E, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x90, 0x00, 0x00,
  0x7E, 0x38, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x07, 0xF8, 0x01, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0xFF, 0xF0, 0x03, 0xC1, 0xFF, 0xFE, 0x01, 0xE3, 0xFF, 0xFF, 0xC0,
  0xF3, 0xF0, 0x07, 0xF0, 0x73, 0xE0, 0x00, 0xFC, 0x7B, 0xC0, 0x00, 0x3E,
  0x3D, 0xC0, 0x00, 0x0F, 0x9F, 0xC0, 0x00, 0x03, 0xCF, 0xC0, 0x00, 0x00,
  0xF7, 0xE0, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x00,
  0x1F, 0x78, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x00, 0x3C, 0xE0, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0x03, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x0F,
  0x80, 0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F,
  0xC0, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x7C, 0x3E,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3E, 0x3C,
  0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xFC, 0x7F, 0x80, 0x03, 0xF0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x1E, 0x00, 0x00, 0x7C, 0x3C,
  0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x1F, 0x78,
  0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xD0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07,
  0xF0, 0x1F, 0xC0, 0x0F, 0x80, 0x07, 0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x7C, 0x78,
  0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x3F, 0x7C,
  0x00, 0x00, 0x7F, 0x3E, 0x00, 0x00, 0xEF, 0x1F, 0x00, 0x03, 0xEF, 0x0F,
  0xC0, 0x0F, 0xCF, 0x07, 0xFF, 0xFF, 0x8F, 0x03, 0xFF, 0xFE, 0x0F, 0x00,
  0xFF, 0xF8, 0x0F, 0x00, 0x0F, 0xC0, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x10, 0x00, 0xFE, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFB, 0xFF, 0xFF, 0xFF, 0xE2, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7B, 0xFF, 0xFF, 0xFF, 0xE7, 0x00, 0x0F, 0x83, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xE0, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x3E, 0x0F, 0x03, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x3C,
  0x0F, 0x03, 0x81, 0xE0, 0x78, 0x1C, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC3, 0xFC, 0x07, 0xF8, 0x78, 0x00,
  0x3F, 0x10, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x3F, 0xFE, 0x00, 0x0E, 0x0F, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x1E,
  0x3C, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1C, 0x78, 0x00, 0x3F, 0x00, 0x3C,
  0x00, 0x38, 0xE0, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x7B, 0xC0, 0x03, 0xE0,
  0x00, 0x70, 0x00, 0xF7, 0x80, 0x07, 0x80, 0x00, 0xE0, 0x01, 0xEE, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x01, 0xDC, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x03,
  0xF8, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x07, 0xF0, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x0F, 0xE0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x1F, 0xC0, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x3F, 0x80, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x7E, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x03,
  0xF8, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x07, 0xF0, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x0E, 0xF0, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x1D, 0xE0, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x7B, 0xC0, 0x07, 0x80, 0x00, 0xF8, 0x00, 0xF7, 0x80,
  0x0F, 0x00, 0x03, 0xF0, 0x03, 0xCF, 0x00, 0x0F, 0x00, 0x0E, 0xE0, 0x07,
  0x8E, 0x00, 0x1F, 0x00, 0x3C, 0xE0, 0x1E, 0x1E, 0x00, 0x1F, 0x00, 0xF1,
  0xE0, 0x78, 0x3C, 0x00, 0x1F, 0xFF, 0xC1, 0xFF, 0xE0, 0x78, 0x00, 0x1F,
  0xFF, 0x03, 0xFF, 0x80, 0x78, 0x00, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x77,
  0x80, 0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0xC0, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x00, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x00, 0x00, 0x3E,
  0x78, 0x00, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x00,
  0x07, 0xFC, 0x3C, 0x00, 0x00, 0x3F, 0x0F, 0x00, 0x00, 0x07, 0xE3, 0xC0,
  0x00, 0x00, 0xFC, 0xF0, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x0F,
  0x3C, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x07, 0xCF, 0x00, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x7C, 0x3C, 0x00,
  0x00, 0x7E, 0x0F, 0x00, 0x01, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0x00, 0x00, 0xFF, 0x83,
  0xC0, 0x00, 0x03, 0xF0, 0xF0, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x07,
  0xCF, 0x00, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x00, 0x7C,
  0xF0, 0x00, 0x00, 0x3F, 0x3C, 0x00, 0x00, 0x1F, 0x8F, 0x00, 0x00, 0x3F,
  0xC3, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x03,
  0xFF, 0x00, 0x7F, 0x80, 0x00, 0x78, 0x03, 0xF8, 0x00, 0x00, 0x60, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0x80, 0x1F, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x00, 0xFF,
  0xC0, 0x1E, 0x00, 0x00, 0x3F, 0xC0, 0x3C, 0x00, 0x00, 0x0F, 0xE0, 0x78,
  0x00, 0x00, 0x0F, 0xC0, 0xF0, 0x00, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x00,
  0x07, 0xC3, 0xC0, 0x00, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x00, 0x0F, 0x8F,
  0x00, 0x00, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x78,
  0x00, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x00,
  0x0F, 0xC3, 0xC0, 0x00, 0x00, 0x3F, 0x07, 0x80, 0x00, 0x00, 0xFC, 0x0F,
  0x00, 0x00, 0x03, 0xF0, 0x1E, 0x00, 0x00, 0x1F, 0xC0, 0x3C, 0x00, 0x03,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xEF, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xDE, 0x00, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00,
  0x03, 0xDF, 0x00, 0x00, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xCF, 0x80,
  0x00, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00,
  0x00, 0x0F, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xC0, 0x7F, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x90, 0x0F, 0xCF, 0xFF, 0xC7, 0xFF,
  0xC3, 0xFF, 0xC0, 0xFF, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xDE, 0x00, 0x00,
  0x01, 0xF3, 0xC0, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0x1F, 0x0F, 0x00,
  0x00, 0x07, 0xC1, 0xE0, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x7C, 0x07,
  0x80, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x01, 0xF0,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x1F, 0x80, 0x0F, 0x00, 0x03,
  0xE0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x0F, 0x80, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x3E, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x0F, 0x03, 0xE0, 0x00,
  0x01, 0xE0, 0xF8, 0x00, 0x00, 0x3C, 0x3F, 0x00, 0x00, 0x07, 0x8F, 0xF0,
  0x00, 0x00, 0xF3, 0xFF, 0x00, 0x00, 0x1E, 0xFB, 0xE0, 0x00, 0x03, 0xFE,
  0x3E, 0x00, 0x00, 0x7F, 0x83, 0xE0, 0x00, 0x0F, 0xE0, 0x7C, 0x00, 0x01,
  0xF8, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x0F, 0xC0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x1F, 0x80, 0x0F, 0x00, 0x01, 0xF0, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x78, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x07, 0xC1, 0xE0, 0x00,
  0x00, 0x7C, 0x3C, 0x00, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x00, 0xF8, 0xF0,
  0x00, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xEF,
  0xF7, 0x80, 0x00, 0x00, 0x01, 0xEF, 0xF7, 0x80, 0x00, 0x00, 0x01, 0xEF,
  0xF7, 0xC0, 0x00, 0x00, 0x03, 0xCF, 0xF3, 0xC0, 0x00, 0x00, 0x03, 0xCF,
  0xF3, 0xC0, 0x00, 0x00, 0x03, 0x8F, 0xF1, 0xE0, 0x00, 0x00, 0x07, 0x8F,
  0xF1, 0xE0, 0x00, 0x00, 0x07, 0x8F, 0xF1, 0xF0, 0x00, 0x00, 0x0F, 0x0F,
  0xF0, 0xF0, 0x00, 0x00, 0x0F, 0x0F, 0xF0, 0xF0, 0x00, 0x00, 0x0F, 0x0F,
  0xF0, 0x78, 0x00, 0x00, 0x1E, 0x0F, 0xF0, 0x78, 0x00, 0x00, 0x1E, 0x0F,
  0xF0, 0x7C, 0x00, 0x00, 0x3C, 0x0F, 0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x0F,
  0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x0F, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x0F,
  0xF0, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x0F,
  0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x0F,
  0xF0, 0x0F, 0x80, 0x01, 0xE0, 0x0F, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x0F,
  0xF0, 0x07, 0x80, 0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x0F,
  0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F,
  0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0xF0, 0x01, 0xE0, 0x0F, 0x00, 0x0F,
  0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x0F,
  0xF0, 0x00, 0xF8, 0x1E, 0x00, 0x0F, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x0F,
  0xF0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F,
  0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0xF0, 0x00, 0x3E, 0x78, 0x00, 0x0F,
  0xF0, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xF7, 0xC0, 0x00, 0x00,
  0x3F, 0xCF, 0x80, 0x00, 0x00, 0xFF, 0x3E, 0x00, 0x00, 0x03, 0xFC, 0x7C,
  0x00, 0x00, 0x0F, 0xF0, 0xF8, 0x00, 0x00, 0x3F, 0xC3, 0xE0, 0x00, 0x00,
  0xFF, 0x07, 0xC0, 0x00, 0x03, 0xFC, 0x0F, 0x80, 0x00, 0x0F, 0xF0, 0x3E,
  0x00, 0x00, 0x3F, 0xC0, 0x7C, 0x00, 0x00, 0xFF, 0x00, 0xF8, 0x00, 0x03,
  0xFC, 0x03, 0xE0, 0x00, 0x0F, 0xF0, 0x07, 0xC0, 0x00, 0x3F, 0xC0, 0x0F,
  0x80, 0x00, 0xFF, 0x00, 0x3E, 0x00, 0x03, 0xFC, 0x00, 0x7C, 0x00, 0x0F,
  0xF0, 0x00, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xC0, 0x03, 0xFC, 0x00, 0x0F, 0x80, 0x0F, 0xF0, 0x00, 0x3E, 0x00, 0x3F,
  0xC0, 0x00, 0x7C, 0x00, 0xFF, 0x00, 0x00, 0xF8, 0x03, 0xFC, 0x00, 0x03,
  0xE0, 0x0F, 0xF0, 0x00, 0x07, 0xC0, 0x3F, 0xC0, 0x00, 0x0F, 0x80, 0xFF,
  0x00, 0x00, 0x3E, 0x03, 0xFC, 0x00, 0x00, 0x7C, 0x0F, 0xF0, 0x00, 0x00,
  0xF8, 0x3F, 0xC0, 0x00, 0x03, 0xE0, 0xFF, 0x00, 0x00, 0x07, 0xC3, 0xFC,
  0x00, 0x00, 0x0F, 0x8F, 0xF0, 0x00, 0x00, 0x3E, 0x3F, 0xC0, 0x00, 0x00,
  0x7C, 0xFF, 0x00, 0x00, 0x00, 0xFB, 0xFC, 0x00, 0x00, 0x03, 0xEF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x8F,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x79, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x00, 0x00, 0x7D, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x78, 0x00, 0x00, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xE7, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x05, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x0F,
  0x00, 0x03, 0xFE, 0x1E, 0x00, 0x00, 0xFE, 0x3C, 0x00, 0x00, 0x7E, 0x78,
  0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00,
  0x3E, 0x78, 0x00, 0x00, 0xFC, 0xF0, 0x00, 0x03, 0xF1, 0xE0, 0x00, 0x1F,
  0xC3, 0xC0, 0x0F, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFC, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x00, 0x07,
  0xDE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x00, 0x00, 0x79,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x05, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00,
  0x1F, 0xF0, 0x3C, 0x00, 0x00, 0xFC, 0x0F, 0x00, 0x00, 0x0F, 0x83, 0xC0,
  0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x0F, 0x8F, 0x00, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x7C, 0x3C, 0x00,
  0x00, 0x3E, 0x0F, 0x00, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x0F, 0xC0, 0xF0,
  0x00, 0x0F, 0xE0, 0x3C, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x01, 0xF0, 0x0F, 0x00,
  0x00, 0x3E, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x01, 0xF0, 0x3C,
  0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x01, 0xF0,
  0xF0, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00,
  0x03, 0xEF, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xE0, 0x7F, 0xC1, 0xFC, 0x00,
  0x07, 0x87, 0xE0, 0x00, 0x01, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xD0, 0x00, 0x00, 0x3F, 0x38, 0x00, 0x00, 0xFC, 0x7F, 0x80, 0x0F, 0xF0,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x00, 0x03, 0xEF, 0x00,
  0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x00, 0x7C,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x03, 0xC0,
  0x07, 0x80, 0x00, 0x03, 0xE0, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x01, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0x00, 0x7C, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x00, 0x01, 0xE3, 0xE0,
  0x00, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00, 0x03,
  0xBC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1E, 0x7C, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xE3, 0xC0, 0x00,
  0x03, 0xBC, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x78, 0x1F, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x0F, 0x80, 0xF0, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xF0, 0x07, 0x80, 0x01, 0xC0,
  0x78, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x3C, 0x03, 0x80, 0x01, 0xE0, 0x07,
  0x80, 0x03, 0xC0, 0x3C, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x3C, 0x03, 0xC0,
  0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x78, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x70, 0x01, 0xE0, 0x07, 0xC0, 0x01, 0xE0, 0x0F, 0x00,
  0x0E, 0x00, 0x78, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0xF0, 0x07, 0x80, 0x01,
  0xE0, 0x0F, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x07, 0x81, 0xF0,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xE7, 0x80,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0xF8, 0x00, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0xF8, 0x00, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00, 0x01, 0xE7, 0xC0,
  0x00, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x78, 0x00, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x00, 0x3E, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x01, 0xF0,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00,
  0x01, 0xCF, 0x00, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0x0E, 0x1E, 0x00,
  0x00, 0x03, 0xC1, 0xC0, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x1E, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x78, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x00, 0xE0, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x0E, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x78, 0x00, 0x3E, 0x02, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x0F,
  0xFC, 0x00, 0xF0, 0xFE, 0x00, 0x07, 0x8F, 0xC0, 0x00, 0x3C, 0xF8, 0x00,
  0x01, 0xEF, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7D, 0xE0, 0x00, 0x07, 0xEF, 0x00, 0x00, 0x7F, 0x7C, 0x00,
  0x07, 0xB9, 0xF0, 0x00, 0x79, 0xCF, 0xC0, 0x0F, 0x8E, 0x3F, 0xFF, 0xF8,
  0x70, 0xFF, 0xFF, 0x83, 0x81, 0xFF, 0xF0, 0x1C, 0x00, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x1F, 0xFE, 0x00, 0xF0, 0x7F, 0xFF, 0x80,
  0xF0, 0xFF, 0xFF, 0xC0, 0xF1, 0xF8, 0x0F, 0xF0, 0xF3, 0xC0, 0x01, 0xF0,
  0xF7, 0x80, 0x00, 0xF8, 0xFF, 0x00, 0x00, 0x7C, 0xFE, 0x00, 0x00, 0x3C,
  0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x1E,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1E, 0xFC, 0x00, 0x00, 0x1E,
  0xFC, 0x00, 0x00, 0x3E, 0xFE, 0x00, 0x00, 0x3C, 0xFE, 0x00, 0x00, 0x7C,
  0xF7, 0x00, 0x00, 0xF8, 0xF7, 0x80, 0x01, 0xF0, 0xF3, 0xE0, 0x07, 0xE0,
  0xF1, 0xFF, 0xFF, 0xC0, 0xE0, 0xFF, 0xFF, 0x80, 0xE0, 0x3F, 0xFE, 0x00,
  0x00, 0x05, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x3F, 0xE0, 0x7E, 0x07, 0xF0, 0x00, 0x60, 0xFC, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x02, 0x07, 0xF8, 0x01, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x3F, 0xFC, 0x0F, 0x00, 0xFF, 0xFF, 0x0F, 0x01, 0xFF, 0xFF,
  0x8F, 0x07, 0xF8, 0x0F, 0xCF, 0x0F, 0xE0, 0x01, 0xEF, 0x0F, 0x80, 0x00,
  0xF7, 0x1F, 0x00, 0x00, 0x77, 0x3E, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00,
  0x3F, 0x3C, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00,
  0x1F, 0x78, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00,
  0x1F, 0x3E, 0x00, 0x00, 0x3F, 0x1E, 0x00, 0x00, 0x77, 0x1F, 0x00, 0x00,
  0x77, 0x0F, 0xC0, 0x01, 0xE7, 0x07, 0xF0, 0x07, 0xC7, 0x03, 0xFF, 0xFF,
  0x87, 0x01, 0xFF, 0xFF, 0x07, 0x00, 0x7F, 0xFC, 0x07, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x7C, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x38, 0x1F, 0xE0, 0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xC0, 0x60, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x07, 0x00, 0xFF, 0xFF, 0x07, 0x01, 0xFF, 0xFF, 0x87, 0x07, 0xF8,
  0x07, 0xC7, 0x0F, 0xC0, 0x01, 0xE7, 0x0F, 0x80, 0x00, 0xFF, 0x1F, 0x00,
  0x00, 0x7F, 0x1E, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x1F, 0x3C, 0x00,
  0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x1F, 0x3E, 0x00,
  0x00, 0x3F, 0x1F, 0x00, 0x00, 0x7F, 0x1F, 0x00, 0x00, 0xFF, 0x0F, 0xC0,
  0x01, 0xEF, 0x07, 0xF0, 0x07, 0xCF, 0x03, 0xFF, 0xFF, 0x8F, 0x01, 0xFF,
  0xFF, 0x0F, 0x00, 0x7F, 0xFC, 0x0F, 0x00, 0x07, 0xA0, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x18, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x03, 0xF8, 0x1F, 0xFE,
  0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xF8, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x1F, 0xFE, 0x03, 0xC1, 0xFF, 0xFE, 0x0F, 0x0F, 0xFF,
  0xFE, 0x3C, 0x7C, 0x03, 0xFC, 0xF3, 0xC0, 0x01, 0xF3, 0xDC, 0x00, 0x03,
  0xEF, 0xE0, 0x00, 0x07, 0xBF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xF0, 0x77, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xDE, 0xF7,
  0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF,
  0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xE0, 0x00, 0x1C,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0xF9,
  0xEF, 0xF3, 0xFF, 0xC7, 0xFF, 0x07, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF7, 0x80, 0x00,
  0x1F, 0x3C, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xF0,
  0x78, 0x00, 0x1F, 0x03, 0xC0, 0x01, 0xF0, 0x1E, 0x00, 0x1F, 0x00, 0xF0,
  0x01, 0xF0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x01, 0xF0, 0x01, 0xE0, 0x1F,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0xF8, 0x00,
  0x1E, 0x0F, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x07, 0x8F, 0xE0, 0x00, 0x3C,
  0xFF, 0x00, 0x01, 0xEF, 0xFC, 0x00, 0x0F, 0x79, 0xF0, 0x00, 0x7F, 0x87,
  0xC0, 0x03, 0xF8, 0x1E, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0xF8, 0x03, 0xE0,
  0x07, 0x80, 0x0F, 0x80, 0x3C, 0x00, 0x3C, 0x01, 0xE0, 0x01, 0xF0, 0x0F,
  0x00, 0x07, 0xC0, 0x78, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0xF8, 0x1E, 0x00,
  0x03, 0xE0, 0xF0, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x3E, 0x3C, 0x00, 0x01,
  0xF1, 0xE0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x7C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x0F, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0xF1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0x3F,
  0x01, 0xF8, 0x7E, 0x03, 0xF8, 0xF7, 0x80, 0x07, 0xCF, 0x80, 0x0F, 0xCF,
  0x70, 0x00, 0x3E, 0xF0, 0x00, 0x7C, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xEF, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1E, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xEF, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xF0, 0x1F,
  0xFE, 0x03, 0xC1, 0xFF, 0xFE, 0x0F, 0x0F, 0xFF, 0xFE, 0x3C, 0x7E, 0x03,
  0xFC, 0xF3, 0xC0, 0x01, 0xF3, 0xDE, 0x00, 0x03, 0xEF, 0xE0, 0x00, 0x07,
  0xBF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xE0,
  0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x78, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x1F, 0x0F,
  0x00, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x0F,
  0x0F, 0x80, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x1F, 0xFE, 0x00, 0x78,
  0x3F, 0xFF, 0xC0, 0x3C, 0x3F, 0xFF, 0xF8, 0x1E, 0x3F, 0x01, 0xFE, 0x0F,
  0x3C, 0x00, 0x1F, 0x87, 0xBC, 0x00, 0x07, 0xC3, 0xDC, 0x00, 0x01, 0xF1,
  0xFC, 0x00, 0x00, 0x78, 0xFC, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x0F,
  0x3E, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00,
  0xF7, 0xC0, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x00, 0x1E, 0xF8, 0x00,
  0x00, 0x0F, 0x7C, 0x00, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x07, 0xDF, 0x00,
  0x00, 0x03, 0xCF, 0xC0, 0x00, 0x01, 0xE7, 0xE0, 0x00, 0x01, 0xF3, 0xF8,
  0x00, 0x01, 0xF1, 0xFE, 0x00, 0x00, 0xF8, 0xF7, 0x00, 0x00, 0xF8, 0x79,
  0xE0, 0x00, 0xF8, 0x3C, 0xFC, 0x01, 0xFC, 0x1E, 0x3F, 0xFF, 0xF8, 0x0F,
  0x07, 0xFF, 0xF8, 0x07, 0x81, 0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x07, 0x00, 0xFF,
  0xFF, 0x07, 0x03, 0xFF, 0xFF, 0x87, 0x07, 0xF8, 0x0F, 0xC7, 0x0F, 0xC0,
  0x01, 0xE7, 0x0F, 0x80, 0x00, 0xFF, 0x1F, 0x00, 0x00, 0x7F, 0x3E, 0x00,
  0x00, 0x3F, 0x3C, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x1F, 0x7C, 0x00,
  0x00, 0x1F, 0x78, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x1F, 0x7C, 0x00,
  0x00, 0x1F, 0x3C, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x3F, 0x3E, 0x00,
  0x00, 0x7F, 0x1F, 0x00, 0x00, 0xEF, 0x0F, 0x80, 0x01, 0xEF, 0x07, 0xE0,
  0x07, 0xCF, 0x03, 0xFF, 0xFF, 0x8F, 0x01, 0xFF, 0xFF, 0x0F, 0x00, 0x7F,
  0xFC, 0x0F, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x1F,
  0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xF0, 0x6F, 0x3C, 0x00, 0x7B,
  0xC0, 0x03, 0xDC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x0F, 0xE0, 0x0F, 0xC3, 0xE0, 0x00, 0x18, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x80, 0x00, 0x03, 0xDC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0xFE,
  0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x81, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x10, 0x0F, 0xFF,
  0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xDE, 0x00, 0x00, 0x7F, 0x7C, 0x00, 0x03, 0xBC,
  0xF8, 0x00, 0x1E, 0xF3, 0xF8, 0x03, 0xF3, 0xC7, 0xFF, 0xFF, 0x8F, 0x07,
  0xFF, 0xF8, 0x1C, 0x0F, 0xFF, 0xC0, 0x70, 0x01, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x03, 0xCF,
  0x80, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x00, 0xF0,
  0xF8, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x03,
  0xC0, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x7C, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x1E, 0x78, 0x00, 0x03, 0xF8, 0x00, 0x07, 0x9F, 0x00, 0x00, 0xEE, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x7B, 0xC0, 0x00, 0xF8, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x3C, 0x3E, 0x00, 0x07, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC7,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0xF1, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0x3C,
  0x78, 0x00, 0x78, 0x1F, 0x00, 0x1E, 0x0E, 0x00, 0x1E, 0x03, 0xC0, 0x07,
  0x83, 0xC0, 0x07, 0x80, 0xF0, 0x01, 0xE0, 0xF0, 0x03, 0xC0, 0x3C, 0x00,
  0xF0, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x1E,
  0x01, 0xE0, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0x78, 0x03, 0xC0, 0x78, 0x00,
  0xF0, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x0F, 0x00,
  0x07, 0x83, 0xC0, 0x07, 0x83, 0xC0, 0x01, 0xE1, 0xE0, 0x01, 0xE0, 0xF0,
  0x00, 0x78, 0x78, 0x00, 0x38, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x1E,
  0x00, 0x03, 0xC7, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x71,
  0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0x38, 0x00, 0x07,
  0xBC, 0x00, 0x01, 0xEE, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3B, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x7C, 0x1E, 0x00,
  0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0x80,
  0x03, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0x80, 0x01, 0xE0,
  0x0F, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x78,
  0x3E, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0x7C,
  0x3C, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x01, 0xF0,
  0x0F, 0x80, 0x03, 0xE0, 0x07, 0x80, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80,
  0x03, 0xE0, 0x0F, 0x80, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x3C, 0x78, 0x00,
  0x00, 0x3E, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x01, 0xF1, 0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x3C, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x03, 0xE0,
  0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x3C,
  0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x18, 0x7F, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00, 0x3F,
  0xF0, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x8F, 0xFF, 0x00, 0x00, 0x5F, 0xFF, 0xF0, 0x00,
  0xFF, 0xEF, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xF6, 0x00, 0x07, 0xFF,
  0xF2, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
};

const GFXglyph NotoSans_Light71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 6, 52, 17, 6, -51 },
  { 40, 16, 19, 26, 5, -51 },
  { 78, 42, 51, 46, 2, -51 },
  { 346, 31, 58, 41, 4, -54 },
  { 571, 50, 52, 58, 4, -51 },
  { 896, 46, 52, 51, 4, -51 },
  { 1195, 4, 19, 14, 5, -51 },
  { 1205, 14, 62, 20, 3, -51 },
  { 1314, 15, 62, 20, 2, -51 },
  { 1431, 31, 30, 39, 4, -54 },
  { 1548, 33, 34, 41, 4, -42 },
  { 1689, 8, 17, 16, 3, -8 },
  { 1706, 17, 4, 23, 3, -21 },
  { 1715, 6, 7, 17, 6, -6 },
  { 1721, 23, 51, 25, 1, -51 },
  { 1868, 33, 52, 41, 4, -51 },
  { 2083, 17, 51, 41, 7, -51 },
  { 2192, 32, 51, 41, 4, -51 },
  { 2396, 33, 52, 41, 3, -51 },
  { 2611, 37, 51, 41, 2, -51 },
  { 2847, 31, 52, 41, 5, -51 },
  { 3049, 33, 52, 41, 4, -51 },
  { 3264, 33, 51, 41, 4, -51 },
  { 3475, 32, 52, 41, 4, -51 },
  { 3683, 32, 52, 41, 4, -51 },
  { 3891, 6, 39, 17, 6, -38 },
  { 3921, 10, 47, 17, 2, -38 },
  { 3980, 33, 33, 41, 4, -42 },
  { 4117, 33, 18, 41, 4, -34 },
  { 4192, 33, 33, 41, 4, -42 },
  { 4329, 26, 52, 30, 2, -51 },
  { 4498, 55, 57, 63, 4, -50 },
  { 4890, 43, 51, 43, 0, -51 },
  { 5165, 34, 51, 45, 7, -51 },
  { 5382, 38, 52, 44, 4, -51 },
  { 5629, 39, 51, 50, 7, -51 },
  { 5878, 28, 51, 39, 7, -51 },
  { 6057, 28, 51, 36, 7, -51 },
  { 6236, 42, 52, 51, 4, -51 },
  { 6509, 37, 51, 51, 7, -51 },
  { 6745, 15, 51, 22, 4, -51 },
  { 6841, 17, 64, 18, -6, -51 },
  { 6977, 35, 51, 42, 7, -51 },
  { 7201, 28, 51, 37, 7, -51 },
  { 7380, 48, 51, 62, 7, -51 },
  { 7686, 38, 51, 52, 7, -51 },
  { 7929, 46, 52, 55, 4, -51 },
  { 8228, 31, 51, 42, 7, -51 },
  { 8426, 46, 63, 55, 4, -51 },
  { 8789, 34, 51, 43, 7, -51 },
  { 9006, 31, 52, 39, 4, -51 },
  { 9208, 37, 51, 38, 0, -51 },
  { 9444, 38, 52, 51, 7, -51 },
  { 9691, 41, 51, 41, 0, -51 },
  { 9953, 60, 51, 64, 2, -51 },
  { 10336, 39, 51, 39, 0, -51 },
  { 10585, 38, 51, 38, 0, -51 },
  { 10828, 35, 51, 41, 3, -51 },
  { 11052, 15, 62, 23, 6, -51 },
  { 11169, 23, 51, 25, 1, -51 },
  { 11316, 15, 62, 23, 2, -51 },
  { 11433, 35, 32, 41, 3, -51 },
  { 11573, 30, 4, 30, 0, 6 },
  { 11588, 13, 11, 19, 3, -54 },
  { 11606, 29, 39, 38, 3, -38 },
  { 11748, 32, 55, 43, 6, -54 },
  { 11968, 28, 39, 34, 4, -38 },
  { 12105, 32, 55, 43, 4, -54 },
  { 12325, 31, 39, 39, 4, -38 },
  { 12477, 25, 54, 22, 1, -54 },
  { 12646, 32, 55, 43, 4, -38 },
  { 12866, 30, 54, 42, 6, -54 },
  { 13069, 5, 52, 17, 6, -52 },
  { 13102, 15, 69, 17, -4, -52 },
  { 13232, 29, 54, 35, 6, -54 },
  { 13428, 4, 54, 17, 6, -54 },
  { 13455, 52, 38, 63, 6, -38 },
  { 13702, 30, 38, 42, 6, -38 },
  { 13845, 34, 39, 42, 4, -38 },
  { 14011, 33, 55, 43, 6, -38 },
  { 14238, 32, 55, 43, 4, -38 },
  { 14458, 21, 38, 28, 6, -38 },
  { 14558, 27, 39, 33, 3, -38 },
  { 14690, 21, 48, 24, 1, -47 },
  { 14816, 30, 39, 42, 6, -38 },
  { 14963, 33, 38, 33, 0, -38 },
  { 15120, 50, 38, 52, 1, -38 },
  { 15358, 32, 38, 36, 2, -38 },
  { 15510, 33, 55, 33, 0, -38 },
  { 15737, 27, 38, 33, 3, -38 },
  { 15866, 21, 62, 25, 2, -51 },
  { 16029, 4, 71, 39, 17, -54 },
  { 16065, 22, 62, 25, 2, -51 },
  { 16236, 33, 8, 41, 4, -29 },
};

const GFXfont NotoSans_Light71pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light71pt7bBitmaps,
  (GFXglyph *)NotoSans_Light71pt7bGlyphs,
  0x20, 0x7E, 97
};

#endif // _NOTOSANS_LIGHT71PT7B_H_
