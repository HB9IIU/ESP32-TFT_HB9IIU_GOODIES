#ifndef _NOTOSANS_LIGHT72PT7B_H_
#define _NOTOSANS_LIGHT72PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light72pt7bBitmaps[] PROGMEM = {
  0x00, 0xF9, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xC7, 0x1C, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xEF,
  0xFF, 0xFF, 0xFF, 0x9C, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0x70, 0x0F, 0x70, 0x0F, 0x70, 0x0F, 0x70, 0x07, 0x70, 0x07,
  0x70, 0x06, 0x70, 0x06, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x01, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03,
  0x80, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x3F, 0xCE, 0x1F, 0xE0, 0xFC, 0x1C, 0x03, 0xC3, 0xE0, 0x38,
  0x00, 0x87, 0x80, 0x70, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x3C, 0x01, 0xC0,
  0x00, 0x78, 0x03, 0x80, 0x00, 0xF0, 0x07, 0x00, 0x01, 0xE0, 0x0E, 0x00,
  0x03, 0xC0, 0x1C, 0x00, 0x07, 0x80, 0x38, 0x00, 0x0F, 0x00, 0x70, 0x00,
  0x1F, 0x00, 0xE0, 0x00, 0x1F, 0x01, 0xC0, 0x00, 0x3F, 0x03, 0x80, 0x00,
  0x3F, 0x87, 0x00, 0x00, 0x3F, 0xCE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0x1F, 0xE0, 0x00,
  0x0E, 0x0F, 0xE0, 0x00, 0x1C, 0x07, 0xE0, 0x00, 0x38, 0x07, 0xC0, 0x00,
  0x70, 0x07, 0xC0, 0x00, 0xE0, 0x07, 0x80, 0x01, 0xC0, 0x0F, 0x00, 0x03,
  0x80, 0x1E, 0x00, 0x07, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0xF0, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x70, 0x07, 0xC0, 0x00, 0xE0,
  0x0F, 0x20, 0x01, 0xC0, 0x3E, 0x60, 0x03, 0x81, 0xF8, 0xFE, 0x07, 0x0F,
  0xE1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x78, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x70, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x01, 0xC0, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x07, 0x01, 0xC0, 0x08, 0x01, 0xE0, 0x01, 0xE0, 0x78, 0x1F, 0xF0,
  0x3C, 0x00, 0x3C, 0x1E, 0x0F, 0xFF, 0x03, 0x80, 0x07, 0x83, 0xC3, 0xFF,
  0xF0, 0x78, 0x00, 0xE0, 0xF0, 0x78, 0x1F, 0x0F, 0x00, 0x3C, 0x1E, 0x1E,
  0x01, 0xE0, 0xF0, 0x07, 0x87, 0x83, 0xC0, 0x1E, 0x1E, 0x01, 0xE0, 0xF0,
  0xF0, 0x01, 0xC1, 0xF0, 0xF8, 0x3C, 0x1E, 0x00, 0x3C, 0x1F, 0xFF, 0x07,
  0x03, 0x80, 0x07, 0x81, 0xFF, 0xC1, 0xE0, 0xF0, 0x00, 0xF0, 0x0F, 0xE0,
  0x78, 0x1E, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xC0, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x38, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x03, 0xC0,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0x38, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x1F, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xEF, 0xC0, 0x00,
  0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xDF, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3C, 0x07,
  0xE0, 0x7E, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0xFC, 0x00, 0x07, 0xC1, 0xF0,
  0x01, 0xF8, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x78, 0x7C, 0x00,
  0x07, 0xE0, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0x07, 0x80, 0x00,
  0x1F, 0x80, 0x7C, 0x3E, 0x00, 0x00, 0x3F, 0x01, 0xE0, 0xF8, 0x00, 0x00,
  0x7E, 0x0F, 0x83, 0xE0, 0x00, 0x00, 0xFC, 0x3C, 0x0F, 0x80, 0x00, 0x01,
  0xF9, 0xF0, 0x3E, 0x00, 0x00, 0x03, 0xFF, 0x80, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x03, 0xF0, 0x00, 0x03, 0xF9, 0xF8,
  0x07, 0xF0, 0x00, 0x3F, 0xC3, 0xF0, 0x0F, 0xF0, 0x07, 0xFC, 0x07, 0xE0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0x80,
  0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x0B, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0x77, 0x77, 0x77, 0x00, 0x3E, 0x00, 0xF0,
  0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0xC0, 0x07, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00,
  0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0,
  0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x80, 0x03, 0x80, 0x02, 0xF8, 0x03,
  0x80, 0x1E, 0xFF, 0x03, 0x80, 0xFE, 0xFF, 0xE3, 0x87, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x03, 0xE0,
  0x0F, 0x80, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xC0,
  0x03, 0x80, 0x00, 0x80, 0x01, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0F, 0x1F, 0x1F, 0x1F, 0x1E, 0x1E, 0x3E, 0x3E, 0x3C,
  0x3C, 0x3C, 0x78, 0x78, 0x70, 0x70, 0xF0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7B, 0xFF, 0xFF, 0xFF, 0xE7, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x03,
  0xEF, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x83, 0xC0, 0x00,
  0x07, 0x81, 0xF0, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x1E, 0x00,
  0x03, 0xE0, 0x0F, 0xC0, 0x03, 0xE0, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x3D, 0x00, 0x00, 0x00, 0x07, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0,
  0x1F, 0xF8, 0x1F, 0xBC, 0x1F, 0x1E, 0x3F, 0x0F, 0x3F, 0x07, 0xBF, 0x03,
  0xFE, 0x01, 0xEE, 0x00, 0xF2, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFE, 0xFF, 0xC0, 0x3F, 0xC0, 0x07, 0xE0,
  0x7E, 0x00, 0x03, 0xF0, 0x3C, 0x00, 0x00, 0xF8, 0x10, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xC7, 0xFE,
  0x03, 0xFC, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xE0, 0x00, 0x01,
  0xF0, 0x60, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF3, 0x00, 0x00, 0x01, 0xF9, 0xF0, 0x00,
  0x03, 0xF8, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x1E, 0xE0, 0x00, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x00, 0x03, 0xCE,
  0x00, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x78,
  0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x07, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x3F, 0xF9, 0xFF, 0xE0, 0x18, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x80, 0x00, 0x01, 0xF0, 0xF0, 0x00,
  0x07, 0xE0, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07,
  0xFE, 0x07, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x3F, 0xC0,
  0x03, 0xC0, 0xFF, 0xFC, 0x01, 0xE1, 0xFF, 0xFF, 0x80, 0xF1, 0xFF, 0xFF,
  0xF0, 0x79, 0xF0, 0x01, 0xFC, 0x3D, 0xE0, 0x00, 0x3E, 0x1F, 0xE0, 0x00,
  0x0F, 0x9F, 0xE0, 0x00, 0x03, 0xEF, 0xE0, 0x00, 0x00, 0xF7, 0xE0, 0x00,
  0x00, 0x7B, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x01, 0xF0,
  0x07, 0xC0, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x01,
  0xF0, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x00, 0x7C, 0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x3E, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x03, 0xFC, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x3F, 0x87, 0xF8, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x7C, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00, 0xFC, 0x3C, 0x00, 0x00, 0x3E,
  0x3E, 0x00, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x01, 0xE7, 0xC0, 0x00,
  0x01, 0xF1, 0xE0, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x01, 0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xCF, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0x7C,
  0x3C, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00, 0x7E, 0xF0, 0x00,
  0x00, 0x3F, 0x7C, 0x00, 0x00, 0x3F, 0x9E, 0x00, 0x00, 0x3B, 0xCF, 0x80,
  0x00, 0x39, 0xE3, 0xF0, 0x00, 0x7D, 0xF0, 0xFE, 0x00, 0xFC, 0xF0, 0x3F,
  0xFF, 0xFC, 0x78, 0x07, 0xFF, 0xF8, 0x3C, 0x00, 0xFF, 0xF0, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x10, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7B, 0xFF, 0xFF, 0xFF, 0xF7, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xEF, 0xFF, 0xFF, 0xFF, 0x9C, 0x0F, 0x0F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x1F, 0x0F, 0x87, 0x87,
  0xC3, 0xE1, 0xE0, 0xF0, 0x78, 0x7C, 0x3C, 0x1E, 0x0F, 0x0F, 0x07, 0x83,
  0x81, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x40, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8,
  0x7C, 0x00, 0x7F, 0x18, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x3C, 0x1E, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x1C, 0x1E, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0xF0, 0x3F, 0x00, 0x1E, 0x3C, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x0E, 0x38, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x0F,
  0x78, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x0F, 0x78, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x0F, 0x70, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x0F, 0x70, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x0F, 0xF0,
  0x01, 0xE0, 0x00, 0x0E, 0x00, 0x0F, 0xF0, 0x01, 0xE0, 0x00, 0x0E, 0x00,
  0x0F, 0xF0, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x0F, 0xF0, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x0F, 0xF0, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x0F, 0xF0, 0x01,
  0xC0, 0x00, 0x1E, 0x00, 0x0F, 0xF0, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x0E,
  0xF0, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x0E, 0xF0, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x1E, 0xF0, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x1E, 0xF0, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x1C, 0xF0, 0x00, 0xF0, 0x00, 0x77, 0x00, 0x3C, 0x70,
  0x00, 0xF0, 0x00, 0x77, 0x00, 0x78, 0x70, 0x00, 0x78, 0x00, 0xE7, 0x80,
  0x78, 0x78, 0x00, 0x7E, 0x03, 0xE3, 0xC1, 0xF0, 0x78, 0x00, 0x3F, 0xFF,
  0x83, 0xFF, 0xE0, 0x38, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x3C, 0x00,
  0x07, 0xFC, 0x00, 0x7F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0xDF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x3D, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x81, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x00,
  0x00, 0x3C, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0x00,
  0x3E, 0x78, 0x00, 0x00, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x78, 0x00, 0x0F, 0xFE, 0x0F, 0x00, 0x00, 0x1F, 0xE1, 0xE0, 0x00,
  0x00, 0xFC, 0x3C, 0x00, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x00, 0xF8, 0xF0,
  0x00, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00,
  0x0F, 0x3C, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x7C, 0xF0, 0x00,
  0x00, 0x0F, 0x1E, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x07, 0xF0,
  0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xC0, 0x00, 0x0F, 0xF0, 0x78, 0x00,
  0x00, 0x3F, 0x0F, 0x00, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x00, 0x1F, 0x3C,
  0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x07, 0xDE,
  0x00, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x07,
  0xCF, 0x00, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x00, 0xFE, 0x3C, 0x00, 0x00,
  0x7F, 0x87, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x00,
  0x03, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0C, 0x00, 0x3F, 0xF0, 0x01, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFE, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x20,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0xDE, 0x00, 0x00, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0x78, 0x00, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0x00,
  0x7D, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x00, 0x01, 0xF3,
  0xC0, 0x00, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0x83, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x00, 0x3E,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x3F, 0x80, 0x00, 0x00, 0xF8, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xE0, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x07, 0xD0, 0x0F, 0xCF, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0xC0,
  0xFF, 0x80, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xF3, 0xC0,
  0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x07, 0xC1,
  0xE0, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x01, 0xF8, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0x07, 0x80, 0x1F, 0x80, 0x00,
  0xF0, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x3E, 0x00,
  0x00, 0x78, 0x0F, 0x80, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0xF8,
  0x00, 0x00, 0x3C, 0x3F, 0x80, 0x00, 0x07, 0x8F, 0xF0, 0x00, 0x00, 0xF3,
  0xFF, 0x00, 0x00, 0x1E, 0xF9, 0xF0, 0x00, 0x03, 0xFE, 0x3F, 0x00, 0x00,
  0x7F, 0x83, 0xE0, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x0F, 0x00, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x1F, 0x80,
  0x3C, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x01,
  0xF0, 0x1E, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x78, 0x00,
  0x00, 0x3E, 0x0F, 0x00, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x00, 0x7C, 0x3C,
  0x00, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x07,
  0xDE, 0x00, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x7F, 0xBC, 0x00,
  0x00, 0x00, 0x07, 0xBF, 0xDE, 0x00, 0x00, 0x00, 0x03, 0xDF, 0xEF, 0x80,
  0x00, 0x00, 0x03, 0xCF, 0xF3, 0xC0, 0x00, 0x00, 0x01, 0xEF, 0xF9, 0xE0,
  0x00, 0x00, 0x01, 0xE7, 0xFC, 0x78, 0x00, 0x00, 0x00, 0xF3, 0xFE, 0x3C,
  0x00, 0x00, 0x00, 0x79, 0xFF, 0x1F, 0x00, 0x00, 0x00, 0x78, 0xFF, 0x87,
  0x80, 0x00, 0x00, 0x3C, 0x7F, 0xC3, 0xC0, 0x00, 0x00, 0x3C, 0x3F, 0xE0,
  0xF0, 0x00, 0x00, 0x1E, 0x1F, 0xF0, 0x78, 0x00, 0x00, 0x0F, 0x0F, 0xF8,
  0x3E, 0x00, 0x00, 0x0F, 0x07, 0xFC, 0x0F, 0x00, 0x00, 0x07, 0x83, 0xFE,
  0x07, 0x80, 0x00, 0x07, 0x81, 0xFF, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0xFF,
  0x80, 0xF0, 0x00, 0x01, 0xE0, 0x7F, 0xC0, 0x7C, 0x00, 0x01, 0xE0, 0x3F,
  0xE0, 0x1E, 0x00, 0x00, 0xF0, 0x1F, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x0F,
  0xF8, 0x03, 0xC0, 0x00, 0x78, 0x07, 0xFC, 0x01, 0xE0, 0x00, 0x3C, 0x03,
  0xFE, 0x00, 0xF8, 0x00, 0x3C, 0x01, 0xFF, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0xFF, 0x80, 0x1E, 0x00, 0x1E, 0x00, 0x7F, 0xC0, 0x0F, 0x80, 0x0F, 0x00,
  0x3F, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0xF0, 0x01, 0xE0, 0x07, 0x80,
  0x0F, 0xF8, 0x00, 0x78, 0x03, 0xC0, 0x07, 0xFC, 0x00, 0x3C, 0x03, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0x01, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0xFF, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xF0, 0x78,
  0x00, 0x3F, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1F, 0xF0, 0x00, 0x3E, 0x3C,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0xFC, 0x00, 0x07, 0x9E,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xEF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFD, 0xF0, 0x00, 0x00, 0x0F, 0xF3, 0xE0, 0x00, 0x00, 0x3F, 0xCF,
  0x80, 0x00, 0x00, 0xFF, 0x1F, 0x00, 0x00, 0x03, 0xFC, 0x3E, 0x00, 0x00,
  0x0F, 0xF0, 0xF8, 0x00, 0x00, 0x3F, 0xC1, 0xF0, 0x00, 0x00, 0xFF, 0x03,
  0xE0, 0x00, 0x03, 0xFC, 0x0F, 0x80, 0x00, 0x0F, 0xF0, 0x1F, 0x00, 0x00,
  0x3F, 0xC0, 0x3E, 0x00, 0x00, 0xFF, 0x00, 0xF8, 0x00, 0x03, 0xFC, 0x01,
  0xF0, 0x00, 0x0F, 0xF0, 0x03, 0xE0, 0x00, 0x3F, 0xC0, 0x0F, 0x80, 0x00,
  0xFF, 0x00, 0x1F, 0x00, 0x03, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0xF0, 0x00,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xE0, 0x03,
  0xFC, 0x00, 0x0F, 0x80, 0x0F, 0xF0, 0x00, 0x1F, 0x00, 0x3F, 0xC0, 0x00,
  0x3E, 0x00, 0xFF, 0x00, 0x00, 0xF8, 0x03, 0xFC, 0x00, 0x01, 0xF0, 0x0F,
  0xF0, 0x00, 0x03, 0xE0, 0x3F, 0xC0, 0x00, 0x0F, 0x80, 0xFF, 0x00, 0x00,
  0x1F, 0x03, 0xFC, 0x00, 0x00, 0x3E, 0x0F, 0xF0, 0x00, 0x00, 0xF8, 0x3F,
  0xC0, 0x00, 0x01, 0xF0, 0xFF, 0x00, 0x00, 0x03, 0xE3, 0xFC, 0x00, 0x00,
  0x0F, 0x8F, 0xF0, 0x00, 0x00, 0x1F, 0x3F, 0xC0, 0x00, 0x00, 0x3E, 0xFF,
  0x00, 0x00, 0x00, 0xF9, 0xFC, 0x00, 0x00, 0x01, 0xF7, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xBC, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x00, 0x00, 0x03, 0xEF, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x79, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xE3, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x7D, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0xFF, 0xE0, 0xF0,
  0x00, 0x07, 0xF0, 0xF0, 0x00, 0x01, 0xF8, 0xF0, 0x00, 0x00, 0xFC, 0xF0,
  0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x3E, 0xF0,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x7C, 0xF0,
  0x00, 0x00, 0xF8, 0xF0, 0x00, 0x01, 0xF8, 0xF0, 0x00, 0x03, 0xF0, 0xF0,
  0x00, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xBC, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x00, 0x00, 0x03, 0xEF, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x79, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xE3, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x78, 0x00, 0x3F, 0xF8, 0x0F, 0x00, 0x00, 0x7F, 0x81, 0xE0, 0x00, 0x03,
  0xF0, 0x3C, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x00, 0x3E, 0x1E, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x3E,
  0x3C, 0x00, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0xF8, 0x78, 0x00,
  0x00, 0x1F, 0x0F, 0x00, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x00, 0x7E, 0x07, 0x80, 0x00, 0x1F, 0x80, 0xF0, 0x00, 0x0F, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x0F, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00,
  0xF8, 0x07, 0x80, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0x1F, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0x3E, 0x0F,
  0x00, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x07,
  0xC7, 0x80, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x0F, 0x9E, 0x00, 0x00,
  0x00, 0xFB, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x0F,
  0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x18, 0x3E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x80,
  0x00, 0x00, 0xF8, 0xF0, 0x00, 0x03, 0xF0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xDE,
  0x00, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x00,
  0x03, 0xE3, 0xC0, 0x00, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x78, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x39, 0xE0, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x78,
  0x78, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x01, 0xE0,
  0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x1E, 0x00, 0x7C, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xF0, 0x01, 0xE0, 0x01,
  0xE0, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x00,
  0x78, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x1E,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x78, 0x07, 0x80, 0x00, 0x78,
  0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03,
  0xCF, 0x80, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x03,
  0xC0, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x00, 0x1E, 0x00, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x00, 0x0F, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x00, 0x78, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x00, 0x0F,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x03, 0xE0,
  0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00,
  0x00, 0x7B, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x07, 0x80,
  0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x00,
  0x03, 0xC3, 0xE0, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0x07, 0x9F,
  0x00, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x00, 0xF0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x0F,
  0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x0F,
  0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07,
  0xC0, 0x07, 0xF0, 0x1C, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x07,
  0xFC, 0x00, 0x3C, 0x7F, 0x00, 0x00, 0xF3, 0xF0, 0x00, 0x03, 0xCF, 0x80,
  0x00, 0x0F, 0x7C, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xF7, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xDE, 0x00, 0x00, 0x7F, 0x78, 0x00, 0x01, 0xFD,
  0xF0, 0x00, 0x0E, 0xF3, 0xE0, 0x00, 0xF3, 0xCF, 0xE0, 0x0F, 0x8F, 0x1F,
  0xFF, 0xFC, 0x3C, 0x3F, 0xFF, 0xE0, 0xF0, 0x3F, 0xFE, 0x01, 0xC0, 0x0F,
  0xC0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x07, 0xFC, 0x00,
  0x78, 0x1F, 0xFF, 0xC0, 0x3C, 0x1F, 0xFF, 0xF0, 0x1E, 0x3F, 0xFF, 0xFE,
  0x0F, 0x3E, 0x00, 0x3F, 0x87, 0x9E, 0x00, 0x07, 0xC3, 0xDC, 0x00, 0x01,
  0xF1, 0xFC, 0x00, 0x00, 0x7C, 0xFE, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00,
  0x0F, 0x3F, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x01, 0xEF, 0x80, 0x00,
  0x00, 0xF7, 0xC0, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xDF,
  0x00, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00, 0xF3,
  0xF0, 0x00, 0x00, 0x79, 0xFC, 0x00, 0x00, 0x7C, 0xFE, 0x00, 0x00, 0x7C,
  0x7B, 0x80, 0x00, 0x7C, 0x3D, 0xF0, 0x00, 0x7E, 0x1E, 0x7E, 0x00, 0xFE,
  0x0F, 0x1F, 0xFF, 0xFE, 0x07, 0x83, 0xFF, 0xFC, 0x03, 0x80, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x03, 0xF8, 0x00, 0xE0, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x30, 0x3F, 0x80, 0x1F, 0x01,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0xF8, 0x07, 0x80,
  0x3F, 0xFF, 0x03, 0xC0, 0x7F, 0xFF, 0xE1, 0xE0, 0x7F, 0xFF, 0xF8, 0xF0,
  0x7F, 0x00, 0x3E, 0x78, 0x7E, 0x00, 0x07, 0xBC, 0x7E, 0x00, 0x01, 0xDE,
  0x3E, 0x00, 0x00, 0x7F, 0x3E, 0x00, 0x00, 0x3F, 0x9F, 0x00, 0x00, 0x0F,
  0xDF, 0x00, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x00,
  0xFB, 0xC0, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x03, 0xEF, 0x00,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0xFC, 0xF0,
  0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x7F, 0x1F, 0x00, 0x00, 0x3F, 0x8F,
  0xC0, 0x00, 0x3B, 0xC3, 0xF0, 0x00, 0x39, 0xE0, 0xFE, 0x00, 0xFC, 0xF0,
  0x3F, 0xFF, 0xFC, 0x78, 0x0F, 0xFF, 0xF8, 0x3C, 0x01, 0xFF, 0xF8, 0x1E,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x7F, 0xE0, 0x07, 0xF0, 0x03, 0xF0,
  0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C,
  0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1E,
  0x7C, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0C,
  0x03, 0xF8, 0x00, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xF1, 0xE0, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x03, 0xC0, 0x7F, 0xFF, 0xE1,
  0xE0, 0x7F, 0xFF, 0xF8, 0xF0, 0x7F, 0x00, 0x3E, 0x78, 0x7E, 0x00, 0x07,
  0xBC, 0x3E, 0x00, 0x01, 0xFE, 0x3E, 0x00, 0x00, 0x7F, 0x3E, 0x00, 0x00,
  0x1F, 0x9F, 0x00, 0x00, 0x0F, 0xCF, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x01, 0xF7, 0x80, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x00, 0x7D, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xDE,
  0x00, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0xFB,
  0xE0, 0x00, 0x00, 0xFC, 0xF0, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x7F,
  0x1F, 0x00, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x3B, 0xC3, 0xF0, 0x00, 0x79,
  0xE0, 0xFE, 0x00, 0xFC, 0xF0, 0x3F, 0xFF, 0xFC, 0x78, 0x0F, 0xFF, 0xF8,
  0x3C, 0x01, 0xFF, 0xF0, 0x1E, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x04, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x3F, 0x01, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x07, 0xFC, 0x01, 0xE0, 0x7F, 0xFF,
  0x03, 0xC1, 0xFF, 0xFF, 0x87, 0x8F, 0xFF, 0xFF, 0x8F, 0x3E, 0x00, 0x3F,
  0x1E, 0xF0, 0x00, 0x1F, 0x3D, 0xC0, 0x00, 0x1F, 0x7F, 0x00, 0x00, 0x3E,
  0xFE, 0x00, 0x00, 0x3D, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0x80, 0xFF, 0xFF, 0xFF, 0xB8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xDE, 0xF7,
  0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF,
  0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xE0, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x79,
  0x87, 0xF3, 0xFF, 0xC7, 0xFF, 0x0F, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0xBC, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0xF8,
  0x78, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0xF8, 0x1E, 0x00, 0x0F, 0x80, 0xF0,
  0x00, 0xF8, 0x07, 0x80, 0x0F, 0x80, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x0F,
  0x80, 0x0F, 0x00, 0xF8, 0x00, 0x78, 0x0F, 0x80, 0x03, 0xC0, 0x78, 0x00,
  0x1E, 0x07, 0xC0, 0x00, 0xF0, 0x7C, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x3C,
  0x7F, 0x00, 0x01, 0xE7, 0xFC, 0x00, 0x0F, 0x7D, 0xF0, 0x00, 0x7F, 0xCF,
  0x80, 0x03, 0xFC, 0x3E, 0x00, 0x1F, 0xC0, 0xF8, 0x00, 0xFC, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0x7C, 0x01, 0xE0, 0x01, 0xF0, 0x0F,
  0x00, 0x07, 0xC0, 0x78, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0xF8, 0x1E, 0x00,
  0x03, 0xE0, 0xF0, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x7C, 0x3C, 0x00, 0x01,
  0xF1, 0xE0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0xFB,
  0xC0, 0x00, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF8, 0x0F, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0xF0, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x8F, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0xF3, 0xE0,
  0x0F, 0xC7, 0xE0, 0x0F, 0xCF, 0x78, 0x00, 0x3E, 0x78, 0x00, 0x3E, 0xF7,
  0x00, 0x03, 0xEF, 0x00, 0x01, 0xEF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xFC, 0x01, 0xE0, 0x7F, 0xFF, 0x03, 0xC1, 0xFF, 0xFF, 0x87, 0x8F, 0xFF,
  0xFF, 0x8F, 0x3E, 0x00, 0x3F, 0x1E, 0x70, 0x00, 0x1F, 0x3D, 0xC0, 0x00,
  0x1F, 0x7F, 0x00, 0x00, 0x3E, 0xFE, 0x00, 0x00, 0x3D, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07,
  0xF0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00,
  0x7D, 0xE0, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x7C, 0x1F, 0x00,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x78, 0x1F, 0xFF, 0xC0, 0x3C, 0x1F, 0xFF, 0xF0, 0x1E, 0x1F, 0xFF, 0xFE,
  0x0F, 0x1F, 0x00, 0x3F, 0x87, 0x9E, 0x00, 0x07, 0xC3, 0xDC, 0x00, 0x01,
  0xF1, 0xEE, 0x00, 0x00, 0x7C, 0xFE, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00,
  0x0F, 0xBF, 0x00, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x01, 0xEF, 0x80, 0x00,
  0x00, 0xF7, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xDF,
  0x00, 0x00, 0x01, 0xEF, 0xC0, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00, 0xFB,
  0xF0, 0x00, 0x00, 0xF9, 0xFC, 0x00, 0x00, 0x7C, 0xFF, 0x00, 0x00, 0x7C,
  0x7B, 0xC0, 0x00, 0x7E, 0x3C, 0xF0, 0x00, 0x7E, 0x1E, 0x3E, 0x00, 0xFE,
  0x0F, 0x0F, 0xFF, 0xFE, 0x07, 0x83, 0xFF, 0xFE, 0x03, 0xC0, 0x7F, 0xFC,
  0x01, 0xE0, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x03, 0xC0, 0x7F, 0xFF, 0xE1, 0xE0,
  0x7F, 0xFF, 0xF8, 0xF0, 0x7F, 0x00, 0x3E, 0x78, 0x7E, 0x00, 0x07, 0xBC,
  0x7E, 0x00, 0x01, 0xDE, 0x3E, 0x00, 0x00, 0x7F, 0x3E, 0x00, 0x00, 0x3F,
  0x9E, 0x00, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x01,
  0xF7, 0x80, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xDE, 0x00,
  0x00, 0x03, 0xEF, 0x00, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x00, 0xFB, 0xE0,
  0x00, 0x00, 0xFC, 0xF0, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x7F, 0x1F,
  0x00, 0x00, 0x77, 0x8F, 0xC0, 0x00, 0x7B, 0xC3, 0xF0, 0x00, 0x79, 0xE0,
  0xFE, 0x00, 0xF8, 0xF0, 0x3F, 0xFF, 0xF8, 0x78, 0x0F, 0xFF, 0xF8, 0x3C,
  0x01, 0xFF, 0xF0, 0x1E, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x07, 0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xFF, 0xE3, 0xFF,
  0xFF, 0x1F, 0x00, 0x79, 0xE0, 0x03, 0xDE, 0x00, 0x1E, 0xE0, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x8F, 0xFE, 0xFF, 0xE1, 0xF0,
  0x00, 0x3C, 0x7C, 0x00, 0x01, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x1F, 0x7F, 0x00, 0x0F, 0xCF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0,
  0x01, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x01, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x01, 0xF8,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xDE, 0x00, 0x00, 0x3F,
  0xBE, 0x00, 0x00, 0xEF, 0x7C, 0x00, 0x03, 0xDE, 0x7E, 0x00, 0x0F, 0x3C,
  0x7E, 0x00, 0x7C, 0x78, 0xFF, 0xFF, 0xF0, 0xF0, 0x7F, 0xFF, 0xC1, 0xE0,
  0x3F, 0xFE, 0x03, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xDE, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x07, 0xC1, 0xE0, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x01, 0xE0, 0x07,
  0x80, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0xF0, 0x03,
  0xC0, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x01, 0xE0,
  0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x00, 0x07, 0x78, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7D, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3C, 0x78, 0x00,
  0x07, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xEF, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x3C, 0xE0, 0x00, 0x3C, 0x3E, 0x00, 0x07, 0x9E, 0x00, 0x0F, 0x83,
  0xC0, 0x00, 0xE3, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C,
  0x0F, 0x80, 0x07, 0x87, 0x80, 0x07, 0x80, 0xF0, 0x00, 0xE0, 0xF0, 0x01,
  0xF0, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0x81, 0xE0,
  0x07, 0x80, 0x7C, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x07,
  0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x07, 0x80, 0x1E, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0x3C, 0x07,
  0x80, 0x1E, 0x07, 0x80, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0xF0, 0x00, 0xF8,
  0x3C, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x07, 0xC0, 0x01,
  0xE0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x00,
  0x03, 0xC7, 0x80, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0xF0,
  0x00, 0x0F, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF3,
  0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xDC, 0x00, 0x01,
  0xEE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x1E, 0x00, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x3E,
  0x03, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x7C, 0x3E, 0x00,
  0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x1F, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00,
  0x3C, 0x0F, 0x80, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x07, 0xC7, 0x80, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0x07, 0xDE, 0x00,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00,
  0x78, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x01, 0xF0, 0x1E, 0x00,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x01, 0xE1, 0xF0,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x02, 0x07, 0xE0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0x80, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x07, 0xFC, 0x00, 0x7E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x9F, 0xFF, 0x80, 0x00, 0x5F, 0xFF, 0xF8, 0x00, 0xFF,
  0x83, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF2,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0x00,
};

const GFXglyph NotoSans_Light72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 6, 52, 18, 6, -51 },
  { 40, 16, 18, 26, 5, -51 },
  { 76, 43, 51, 47, 2, -51 },
  { 351, 31, 59, 41, 5, -55 },
  { 580, 51, 53, 58, 4, -52 },
  { 918, 46, 53, 52, 4, -52 },
  { 1223, 4, 18, 14, 5, -51 },
  { 1232, 15, 62, 20, 3, -51 },
  { 1349, 15, 62, 20, 2, -51 },
  { 1466, 32, 31, 40, 4, -55 },
  { 1590, 33, 34, 41, 4, -42 },
  { 1731, 8, 17, 16, 3, -8 },
  { 1748, 17, 3, 23, 3, -21 },
  { 1755, 6, 7, 18, 6, -6 },
  { 1761, 23, 51, 25, 1, -51 },
  { 1908, 33, 53, 41, 4, -52 },
  { 2127, 17, 51, 41, 7, -51 },
  { 2236, 32, 52, 41, 4, -52 },
  { 2444, 33, 53, 41, 3, -52 },
  { 2663, 38, 52, 41, 2, -52 },
  { 2910, 32, 52, 41, 5, -51 },
  { 3118, 33, 53, 41, 4, -52 },
  { 3337, 33, 51, 41, 4, -51 },
  { 3548, 33, 53, 41, 4, -52 },
  { 3767, 33, 53, 41, 4, -52 },
  { 3986, 6, 40, 18, 6, -39 },
  { 4016, 9, 48, 18, 3, -39 },
  { 4070, 33, 34, 41, 4, -43 },
  { 4211, 33, 18, 41, 4, -34 },
  { 4286, 33, 34, 41, 4, -43 },
  { 4427, 26, 53, 31, 2, -52 },
  { 4600, 56, 58, 64, 4, -51 },
  { 5006, 44, 52, 44, 0, -52 },
  { 5292, 35, 51, 46, 7, -51 },
  { 5516, 39, 53, 45, 4, -52 },
  { 5775, 40, 51, 51, 7, -51 },
  { 6030, 28, 51, 40, 7, -51 },
  { 6209, 29, 51, 36, 7, -51 },
  { 6394, 43, 53, 52, 4, -52 },
  { 6679, 38, 51, 52, 7, -51 },
  { 6922, 15, 51, 22, 4, -51 },
  { 7018, 17, 64, 18, -6, -51 },
  { 7154, 35, 51, 42, 7, -51 },
  { 7378, 29, 51, 37, 7, -51 },
  { 7563, 49, 51, 63, 7, -51 },
  { 7876, 38, 51, 52, 7, -51 },
  { 8119, 47, 53, 55, 4, -52 },
  { 8431, 32, 51, 42, 7, -51 },
  { 8635, 47, 64, 55, 4, -52 },
  { 9011, 35, 51, 43, 7, -51 },
  { 9235, 32, 53, 39, 4, -52 },
  { 9447, 38, 51, 38, 0, -51 },
  { 9690, 38, 52, 52, 7, -51 },
  { 9937, 42, 51, 42, 0, -51 },
  { 10205, 61, 51, 65, 2, -51 },
  { 10594, 39, 51, 39, 0, -51 },
  { 10843, 39, 51, 39, 0, -51 },
  { 11092, 36, 51, 41, 3, -51 },
  { 11322, 15, 62, 23, 6, -51 },
  { 11439, 23, 51, 25, 1, -51 },
  { 11586, 15, 62, 23, 2, -51 },
  { 11703, 35, 32, 41, 3, -52 },
  { 11843, 30, 4, 30, 0, 6 },
  { 11858, 13, 11, 19, 3, -55 },
  { 11876, 30, 40, 39, 3, -39 },
  { 12026, 33, 56, 43, 6, -55 },
  { 12257, 28, 40, 34, 4, -39 },
  { 12397, 33, 56, 43, 4, -55 },
  { 12628, 32, 40, 40, 4, -39 },
  { 12788, 25, 55, 22, 1, -55 },
  { 12960, 33, 56, 43, 4, -39 },
  { 13191, 31, 55, 43, 6, -55 },
  { 13405, 5, 52, 17, 6, -52 },
  { 13438, 15, 69, 17, -4, -52 },
  { 13568, 29, 55, 36, 6, -55 },
  { 13768, 4, 55, 17, 6, -55 },
  { 13796, 52, 39, 64, 6, -39 },
  { 14050, 31, 39, 43, 6, -39 },
  { 14202, 34, 40, 42, 4, -39 },
  { 14372, 33, 56, 43, 6, -39 },
  { 14603, 33, 56, 43, 4, -39 },
  { 14834, 21, 39, 28, 6, -39 },
  { 14937, 27, 40, 34, 3, -39 },
  { 15072, 22, 48, 24, 1, -47 },
  { 15204, 31, 39, 43, 6, -38 },
  { 15356, 34, 38, 34, 0, -38 },
  { 15518, 51, 38, 53, 1, -38 },
  { 15761, 33, 38, 36, 2, -38 },
  { 15918, 34, 55, 34, 0, -38 },
  { 16152, 27, 38, 33, 3, -38 },
  { 16281, 21, 62, 26, 2, -51 },
  { 16444, 3, 73, 39, 18, -55 },
  { 16472, 22, 62, 26, 2, -51 },
  { 16643, 33, 8, 41, 4, -29 },
};

const GFXfont NotoSans_Light72pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light72pt7bBitmaps,
  (GFXglyph *)NotoSans_Light72pt7bGlyphs,
  0x20, 0x7E, 98
};

#endif // _NOTOSANS_LIGHT72PT7B_H_
