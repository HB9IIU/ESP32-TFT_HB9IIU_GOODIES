#ifndef _NOTOSANS_LIGHT56PT7B_H_
#define _NOTOSANS_LIGHT56PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light56pt7bBitmaps[] PROGMEM = {
  0x00, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xB9, 0xCE, 0x73,
  0x9C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x00, 0x00, 0x00, 0x00, 0xE7,
  0xFF, 0xEF, 0x30, 0xE0, 0x7F, 0x03, 0xB8, 0x1D, 0xC0, 0xEE, 0x07, 0x70,
  0x3B, 0x81, 0xDC, 0x0E, 0xE0, 0x37, 0x01, 0xB8, 0x0D, 0xC0, 0x6E, 0x03,
  0x70, 0x18, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x07, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00,
  0xE0, 0x06, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x30, 0x03, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x70, 0x03, 0x00,
  0x00, 0x38, 0x03, 0x80, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x60, 0x00, 0x07, 0x00, 0x30, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x38, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0xE0,
  0x0E, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x38,
  0x03, 0x80, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3C, 0x00, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x3F, 0xB9, 0xFC, 0x7C,
  0x38, 0x18, 0x70, 0x38, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x38, 0x00, 0xE0,
  0x38, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x38, 0x00, 0xE0,
  0x38, 0x00, 0xF0, 0x38, 0x00, 0x78, 0x38, 0x00, 0x3E, 0x38, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x39, 0xF8, 0x00, 0x38, 0x7C, 0x00, 0x38, 0x3E, 0x00,
  0x38, 0x1E, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x0F, 0x00, 0x38, 0x0F, 0x00,
  0x38, 0x0F, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x1E, 0x80,
  0x38, 0x3C, 0xE0, 0x38, 0x7C, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x0E, 0x00, 0x7F, 0xE0, 0x00, 0x1C, 0x01, 0xE1, 0xE0, 0x00, 0x70,
  0x03, 0x81, 0xC0, 0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x03, 0x80, 0x1C, 0x03,
  0x80, 0x0E, 0x00, 0x30, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70,
  0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x03, 0x80, 0x07, 0x00,
  0x38, 0x07, 0x00, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x00, 0xE0, 0x70,
  0x00, 0x38, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x03, 0x83, 0x80, 0x00, 0xE0,
  0x07, 0x07, 0x01, 0x01, 0xC0, 0x0E, 0x1C, 0x1F, 0xC1, 0x80, 0x18, 0x38,
  0xFF, 0xE3, 0x80, 0x70, 0xE1, 0xC1, 0xC7, 0x00, 0xE1, 0xC7, 0x01, 0xC7,
  0x03, 0x87, 0x0E, 0x03, 0x8F, 0x0F, 0x1C, 0x38, 0x03, 0x8F, 0xFC, 0x38,
  0x70, 0x07, 0x0F, 0xF0, 0xE0, 0xE0, 0x0E, 0x02, 0x01, 0xC1, 0x80, 0x1C,
  0x00, 0x07, 0x03, 0x00, 0x18, 0x00, 0x0E, 0x0E, 0x00, 0x30, 0x00, 0x38,
  0x1C, 0x00, 0x60, 0x00, 0x70, 0x38, 0x00, 0xC0, 0x01, 0xC0, 0x30, 0x01,
  0x80, 0x07, 0x00, 0x60, 0x03, 0x00, 0x0E, 0x00, 0xC0, 0x0E, 0x00, 0x38,
  0x01, 0xC0, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x07, 0x00,
  0x70, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x1C,
  0x00, 0x0E, 0x0E, 0x00, 0x70, 0x00, 0x1F, 0xF8, 0x01, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00,
  0x07, 0x80, 0x3C, 0x00, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x0F, 0x87, 0xC0,
  0x01, 0xC1, 0xE0, 0x3E, 0x00, 0x1C, 0x3C, 0x01, 0xF0, 0x03, 0xC7, 0x80,
  0x0F, 0x80, 0x38, 0x78, 0x00, 0x7C, 0x03, 0x87, 0x00, 0x03, 0xE0, 0x70,
  0xF0, 0x00, 0x1F, 0x07, 0x0F, 0x00, 0x00, 0xF8, 0xF0, 0xF0, 0x00, 0x07,
  0xDE, 0x0F, 0x00, 0x00, 0x3F, 0xC0, 0xF0, 0x00, 0x01, 0xFC, 0x07, 0x00,
  0x00, 0x0F, 0x80, 0x70, 0x00, 0x00, 0xFC, 0x07, 0x80, 0x00, 0x3F, 0xE0,
  0x3C, 0x00, 0x07, 0xDF, 0x03, 0xF0, 0x01, 0xF8, 0xF8, 0x1F, 0xE3, 0xFE,
  0x07, 0xC0, 0x7F, 0xFF, 0xC0, 0x3E, 0x01, 0xFF, 0xE0, 0x01, 0xF0, 0x00,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x1E,
  0x01, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0,
  0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x78, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1E, 0x00, 0xE0,
  0x0F, 0x00, 0x70, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0xE0,
  0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x00,
  0xF0, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xE0, 0x3C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x00,
  0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x38, 0x0F, 0x01,
  0xC0, 0x78, 0x0E, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0xC0, 0x1C, 0x01, 0x7C,
  0x0E, 0x07, 0xBF, 0xC6, 0x1F, 0xFF, 0xFF, 0x7F, 0xF0, 0x7F, 0xFF, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x0E,
  0x00, 0x38, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0C, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x1E,
  0x3C, 0x78, 0xE1, 0xC7, 0x8E, 0x1C, 0x38, 0xE1, 0xC3, 0x86, 0x1C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x73, 0xFF, 0xF7, 0x98, 0x00, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0x87, 0xE0, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x81,
  0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x3C, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x01,
  0xC7, 0x80, 0x00, 0x79, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x0E, 0x70,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x1E,
  0x38, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0xF0, 0x70, 0x00,
  0x38, 0x0E, 0x00, 0x1E, 0x03, 0xC0, 0x0F, 0x00, 0x7E, 0x1F, 0x80, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x01,
  0xF0, 0x0F, 0xC0, 0x7F, 0x07, 0xDC, 0x3C, 0x71, 0xE1, 0xDF, 0x07, 0xF8,
  0x1D, 0x80, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x08, 0x00, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x07, 0xF8, 0x7F, 0x07, 0xC0, 0x07, 0xC3, 0xC0,
  0x01, 0xE0, 0x80, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0xFC, 0x0F, 0xF8, 0x7F, 0x0F, 0xC0, 0x03, 0xC3, 0x80, 0x00, 0xF1, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE8, 0x00, 0x01, 0xE7,
  0x00, 0x03, 0xE3, 0xF8, 0x0F, 0xE1, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x80, 0x38, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0x00, 0x03, 0x80, 0x3C, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x1F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x77, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x04, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x90,
  0x00, 0x07, 0x8E, 0x00, 0x0F, 0x87, 0xF0, 0x3F, 0x83, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x07,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xF0, 0x08, 0x01, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x1F, 0xC0, 0x1C, 0x3F, 0xFC, 0x07, 0x1F, 0xFF, 0xC1, 0xCF, 0x00, 0xF8,
  0x77, 0x00, 0x0F, 0x3F, 0x80, 0x01, 0xCF, 0xC0, 0x00, 0x7B, 0xE0, 0x00,
  0x0E, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x07, 0x70, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1D,
  0xE0, 0x00, 0x07, 0x38, 0x00, 0x03, 0xCE, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x38, 0x78, 0x00, 0x1C, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x07, 0x80, 0x7E,
  0x0F, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0x03, 0xF0, 0x1E,
  0x00, 0x3E, 0x07, 0x00, 0x03, 0x83, 0xC0, 0x00, 0xF0, 0xE0, 0x00, 0x1C,
  0x38, 0x00, 0x07, 0x1E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00,
  0x1C, 0x38, 0x00, 0x07, 0x0F, 0x00, 0x03, 0xC1, 0xC0, 0x01, 0xE0, 0x78,
  0x00, 0xF0, 0x0F, 0x80, 0x78, 0x01, 0xF8, 0x7C, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFD, 0xFC, 0x00, 0x7C, 0x0F,
  0x80, 0x7C, 0x00, 0xF8, 0x3C, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0x79, 0xC0, 0x00, 0x0E, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x0F, 0x80,
  0x07, 0x81, 0xFC, 0x0F, 0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0x07, 0xE0, 0x1E, 0x00, 0x7C, 0x0F, 0x00, 0x0F, 0x03, 0x80,
  0x01, 0xE1, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x07, 0x3C, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x7B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x3F, 0x38, 0x00, 0x1F, 0xCF,
  0x00, 0x0E, 0xE1, 0xF0, 0x0F, 0x38, 0x3F, 0xFF, 0x8E, 0x03, 0xFF, 0xC3,
  0x80, 0x3F, 0x80, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x03, 0x00, 0xFC, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0xF7, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x9F, 0xFF, 0xBC, 0xC0, 0x1E, 0x7C, 0xF9, 0xF1, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x1E, 0x38, 0xF1, 0xE3, 0x87, 0x0E, 0x3C, 0x70, 0xE1, 0x87, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x7F, 0xF8, 0x3F, 0xFF, 0xE0, 0xFC, 0x3F, 0xC7,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x7C, 0x00, 0x1C, 0x3C, 0x00,
  0x3F, 0xFE, 0x00, 0xC3, 0x80, 0x0F, 0xFF, 0xE0, 0x0E, 0x38, 0x01, 0xE0,
  0x0E, 0x00, 0xE7, 0x00, 0x3C, 0x00, 0xE0, 0x0E, 0x70, 0x07, 0x80, 0x0E,
  0x00, 0x67, 0x00, 0x70, 0x00, 0xE0, 0x07, 0x60, 0x0F, 0x00, 0x0E, 0x00,
  0x7E, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0xE0, 0x0E, 0x00, 0x0E, 0x00, 0x7E,
  0x00, 0xE0, 0x00, 0xE0, 0x07, 0xE0, 0x1C, 0x00, 0x0E, 0x00, 0x7E, 0x01,
  0xC0, 0x00, 0xE0, 0x06, 0xE0, 0x1C, 0x00, 0x0E, 0x00, 0x6E, 0x00, 0xE0,
  0x01, 0xE0, 0x0E, 0xE0, 0x0E, 0x00, 0x1E, 0x00, 0xEE, 0x00, 0xE0, 0x01,
  0xE0, 0x0E, 0xE0, 0x0E, 0x00, 0x3E, 0x01, 0xC6, 0x00, 0x70, 0x03, 0x60,
  0x1C, 0x70, 0x07, 0x80, 0xE7, 0x03, 0x87, 0x00, 0x3F, 0xFC, 0x3F, 0xF0,
  0x70, 0x01, 0xFF, 0x83, 0xFE, 0x03, 0x80, 0x07, 0xE0, 0x0F, 0x80, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x70, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x0E,
  0x1C, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x0F, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x70, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x07,
  0x00, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x78, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x00, 0xE0, 0x0F,
  0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x78, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00,
  0x07, 0x9C, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x3B, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC3,
  0x80, 0x03, 0xF8, 0xE0, 0x00, 0x1F, 0x38, 0x00, 0x03, 0xCE, 0x00, 0x00,
  0x7B, 0x80, 0x00, 0x1E, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0xB8, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x3C, 0x38, 0x01, 0xFE,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xE0, 0x0F, 0xFC, 0x38, 0x00,
  0x0F, 0x8E, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x1E, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x7C, 0xE0,
  0x00, 0x7E, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xF0, 0xFF, 0x01, 0xF8, 0x00, 0x38, 0x0F, 0x80, 0x00, 0x20, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x60, 0x0F,
  0xF8, 0x7F, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x38, 0x00, 0x3F, 0x80, 0xE0, 0x00, 0x1F, 0x83, 0x80, 0x00, 0x1F,
  0x0E, 0x00, 0x00, 0x3E, 0x38, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0xF3,
  0x80, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0x7B, 0x80, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x0F, 0x38, 0x00,
  0x00, 0x3C, 0xE0, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x0F, 0x0E, 0x00, 0x00,
  0xF8, 0x38, 0x00, 0x0F, 0xC0, 0xE0, 0x01, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFC, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEE, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xC0, 0x00, 0xF0, 0x0F, 0x80, 0x00,
  0x08, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0xE0,
  0x00, 0x3F, 0xFF, 0x70, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x00, 0x77, 0x80, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x07,
  0x1E, 0x00, 0x00, 0x03, 0x8F, 0x80, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x00,
  0xE0, 0xF8, 0x00, 0x00, 0x70, 0x3E, 0x00, 0x00, 0x38, 0x0F, 0xC0, 0x00,
  0x3C, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x2D, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x1F, 0x80,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E,
  0x00, 0x38, 0x01, 0xE0, 0x0F, 0x3F, 0xF8, 0xFF, 0xC3, 0xFC, 0x00, 0xE0,
  0x00, 0x03, 0xDC, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x3C, 0x70, 0x00, 0x0F,
  0x0E, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x3C, 0x07, 0x00,
  0x0F, 0x00, 0xE0, 0x03, 0xC0, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x3C, 0x00,
  0x70, 0x07, 0x80, 0x0E, 0x01, 0xE0, 0x01, 0xC0, 0x78, 0x00, 0x38, 0x1E,
  0x00, 0x07, 0x07, 0x80, 0x00, 0xE1, 0xE0, 0x00, 0x1C, 0x7C, 0x00, 0x03,
  0x9F, 0x80, 0x00, 0x77, 0xF8, 0x00, 0x0F, 0xE7, 0x80, 0x01, 0xF8, 0xF0,
  0x00, 0x3C, 0x0F, 0x00, 0x07, 0x00, 0xF0, 0x00, 0xE0, 0x0F, 0x00, 0x1C,
  0x01, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xE0, 0x0E, 0x00, 0x1E,
  0x01, 0xC0, 0x03, 0xC0, 0x38, 0x00, 0x3C, 0x07, 0x00, 0x03, 0xC0, 0xE0,
  0x00, 0x3C, 0x1C, 0x00, 0x07, 0x83, 0x80, 0x00, 0x78, 0x70, 0x00, 0x07,
  0x8E, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x0F, 0x38, 0x00, 0x00, 0xF7, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xB8, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xDF, 0xB8, 0x00, 0x00, 0x0E,
  0xFD, 0xC0, 0x00, 0x00, 0xE7, 0xE7, 0x00, 0x00, 0x07, 0x3F, 0x38, 0x00,
  0x00, 0x39, 0xF9, 0xE0, 0x00, 0x03, 0x8F, 0xC7, 0x00, 0x00, 0x1C, 0x7E,
  0x38, 0x00, 0x01, 0xE3, 0xF0, 0xE0, 0x00, 0x0E, 0x1F, 0x87, 0x00, 0x00,
  0x70, 0xFC, 0x3C, 0x00, 0x07, 0x07, 0xE0, 0xE0, 0x00, 0x38, 0x3F, 0x07,
  0x00, 0x03, 0xC1, 0xF8, 0x1C, 0x00, 0x1C, 0x0F, 0xC0, 0xE0, 0x00, 0xE0,
  0x7E, 0x07, 0x80, 0x0E, 0x03, 0xF0, 0x1C, 0x00, 0x70, 0x1F, 0x80, 0xE0,
  0x07, 0x80, 0xFC, 0x07, 0x80, 0x38, 0x07, 0xE0, 0x1C, 0x01, 0xC0, 0x3F,
  0x00, 0xF0, 0x1C, 0x01, 0xF8, 0x03, 0x80, 0xE0, 0x0F, 0xC0, 0x1C, 0x0F,
  0x00, 0x7E, 0x00, 0xF0, 0x70, 0x03, 0xF0, 0x03, 0x83, 0x80, 0x1F, 0x80,
  0x1E, 0x38, 0x00, 0xFC, 0x00, 0x71, 0xC0, 0x07, 0xE0, 0x03, 0x9E, 0x00,
  0x3F, 0x00, 0x1E, 0xE0, 0x01, 0xF8, 0x00, 0x77, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x03, 0xC0, 0x00, 0xFC, 0x00, 0x0E, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x1F, 0x38, 0x00, 0x00, 0xFD, 0xE0,
  0x00, 0x07, 0xE7, 0x80, 0x00, 0x3F, 0x3C, 0x00, 0x01, 0xF8, 0xF0, 0x00,
  0x0F, 0xC3, 0xC0, 0x00, 0x7E, 0x0E, 0x00, 0x03, 0xF0, 0x78, 0x00, 0x1F,
  0x81, 0xE0, 0x00, 0xFC, 0x0F, 0x00, 0x07, 0xE0, 0x3C, 0x00, 0x3F, 0x00,
  0xF0, 0x01, 0xF8, 0x07, 0x80, 0x0F, 0xC0, 0x1E, 0x00, 0x7E, 0x00, 0x78,
  0x03, 0xF0, 0x03, 0xC0, 0x1F, 0x80, 0x0F, 0x00, 0xFC, 0x00, 0x3C, 0x07,
  0xE0, 0x01, 0xE0, 0x3F, 0x00, 0x07, 0x81, 0xF8, 0x00, 0x1E, 0x0F, 0xC0,
  0x00, 0xF0, 0x7E, 0x00, 0x03, 0xC3, 0xF0, 0x00, 0x0F, 0x1F, 0x80, 0x00,
  0x78, 0xFC, 0x00, 0x01, 0xE7, 0xE0, 0x00, 0x07, 0xBF, 0x00, 0x00, 0x3D,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x01,
  0xF0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x00, 0x77,
  0x80, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x00,
  0x0E, 0x3C, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x0A, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0xE0, 0x01, 0xF8, 0xE0, 0x00, 0x7C, 0xE0, 0x00,
  0x3E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1E, 0xE0, 0x00,
  0x1E, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0xF8, 0xE0, 0x07, 0xF0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00,
  0x1E, 0x38, 0x00, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x00, 0x77, 0x80, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x00, 0x0E, 0x3C, 0x00,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x0B, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0x80, 0x07, 0xE0, 0xE0, 0x00,
  0x7C, 0x38, 0x00, 0x07, 0x8E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x3C, 0xE0,
  0x00, 0x0F, 0x38, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1C,
  0xE0, 0x00, 0x0F, 0x38, 0x00, 0x03, 0xCE, 0x00, 0x00, 0xF3, 0x80, 0x00,
  0x38, 0xE0, 0x00, 0x1E, 0x38, 0x00, 0x0F, 0x0E, 0x00, 0x07, 0x83, 0x80,
  0x0F, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x38, 0x00, 0xF0, 0x0E, 0x00, 0x1C,
  0x03, 0x80, 0x07, 0x80, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x3C, 0x0E, 0x00,
  0x07, 0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0x07, 0x8E,
  0x00, 0x01, 0xE3, 0x80, 0x00, 0x3C, 0xE0, 0x00, 0x0F, 0x38, 0x00, 0x01,
  0xEE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0x00, 0x04, 0x00, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xC1, 0xFE, 0x3F, 0xC1, 0xF0, 0x00, 0xE1, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE7, 0x00, 0x03, 0xE3, 0xFC, 0x1F, 0xE1, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x00, 0x58, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x38,
  0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x0F,
  0x80, 0x07, 0xC0, 0x1F, 0xE1, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xB8, 0x00,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x01, 0xE1, 0xC0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x03, 0x80, 0x07, 0x00, 0x03, 0xC0,
  0x03, 0x80, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x07, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x70, 0x0F,
  0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x00, 0x78,
  0xE0, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x07,
  0xB8, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x07,
  0xE0, 0x00, 0x0E, 0x78, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x07,
  0xE0, 0x00, 0x1E, 0x38, 0x00, 0x07, 0x70, 0x00, 0x1C, 0x3C, 0x00, 0x0E,
  0x70, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x0E,
  0x70, 0x00, 0x3C, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x1E, 0x00, 0x1C,
  0x38, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x78, 0x0E, 0x00, 0x1C,
  0x1C, 0x00, 0x78, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x0F, 0x00, 0x38,
  0x1C, 0x00, 0x70, 0x07, 0x00, 0x38, 0x1C, 0x00, 0xF0, 0x07, 0x00, 0x78,
  0x0E, 0x00, 0xE0, 0x07, 0x80, 0x70, 0x0E, 0x00, 0xE0, 0x03, 0x80, 0x70,
  0x0E, 0x00, 0xE0, 0x03, 0x80, 0x70, 0x07, 0x01, 0xE0, 0x03, 0x80, 0xE0,
  0x07, 0x01, 0xC0, 0x03, 0xC0, 0xE0, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0xE0,
  0x07, 0x83, 0xC0, 0x01, 0xC1, 0xE0, 0x03, 0x83, 0xC0, 0x01, 0xC1, 0xC0,
  0x03, 0x83, 0x80, 0x01, 0xE1, 0xC0, 0x03, 0x83, 0x80, 0x00, 0xE1, 0xC0,
  0x01, 0xC7, 0x80, 0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00, 0x00, 0xE3, 0x80,
  0x01, 0xC7, 0x00, 0x00, 0xF3, 0x80, 0x01, 0xC7, 0x00, 0x00, 0x73, 0x80,
  0x00, 0xEF, 0x00, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x77, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0xF0, 0x70,
  0x00, 0x01, 0xC0, 0xF0, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xE0,
  0x00, 0x38, 0x01, 0xE0, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x01, 0xC0,
  0x07, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x03, 0x80, 0x38, 0x00, 0x07, 0x80,
  0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x0F, 0x1C,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0x38, 0x78, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x01, 0xC0, 0xF0, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x38, 0x01, 0xE0, 0x00,
  0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0x00, 0x03, 0xC0, 0x1E,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0xE7, 0x80, 0x00,
  0x07, 0x8E, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07,
  0x80, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x07, 0x00, 0x03, 0x80,
  0x1E, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x03, 0xC0, 0x01,
  0xC0, 0x0E, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x39, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0x70, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x0E, 0x07,
  0x00, 0x01, 0xC0, 0x30, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x80, 0x18, 0x00,
  0x38, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x70, 0x00, 0xE0, 0x0E, 0x00,
  0x06, 0x00, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x38,
  0x38, 0x00, 0x01, 0x83, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x0E, 0xF0, 0x00, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x01, 0xFF, 0x80, 0x3F, 0xFF, 0x81, 0xFE, 0x7F,
  0x07, 0x00, 0x1E, 0x10, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xF8, 0x07,
  0x3E, 0x00, 0x1D, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0xC0, 0x03, 0xB7, 0x80, 0x1C, 0xDF, 0x81, 0xE3, 0x3F, 0xFF, 0x0C,
  0x3F, 0xF0, 0x30, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x07,
  0xFE, 0x03, 0x8F, 0xFF, 0xC1, 0xCF, 0xE7, 0xF0, 0xEF, 0x00, 0x7C, 0x76,
  0x00, 0x0F, 0x3E, 0x00, 0x03, 0x9F, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x77,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xEF, 0x80,
  0x00, 0xF7, 0xC0, 0x00, 0x73, 0xF0, 0x00, 0x79, 0xDC, 0x00, 0xF8, 0xE7,
  0xC1, 0xF8, 0x61, 0xFF, 0xF8, 0x30, 0x7F, 0xF0, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xF0, 0x02, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x00, 0x41, 0xFC, 0x3F, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x3F, 0xF0, 0xF0,
  0x3F, 0xFE, 0x1C, 0x1F, 0xCF, 0xC7, 0x0F, 0x80, 0x39, 0xC7, 0x80, 0x07,
  0x73, 0xC0, 0x00, 0xFC, 0xF0, 0x00, 0x1F, 0x78, 0x00, 0x07, 0xDE, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xDC, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x1F, 0x38,
  0x00, 0x07, 0xCF, 0x00, 0x03, 0xF1, 0xE0, 0x00, 0xDC, 0x7C, 0x00, 0xE7,
  0x0F, 0xC0, 0xF9, 0xC1, 0xFF, 0xF8, 0x70, 0x1F, 0xFC, 0x1C, 0x00, 0x20,
  0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x01, 0xF8, 0xFE, 0x01, 0xF0,
  0x07, 0x81, 0xE0, 0x01, 0xE0, 0xE0, 0x00, 0x70, 0xF0, 0x00, 0x3C, 0x70,
  0x00, 0x0E, 0x78, 0x00, 0x07, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0xC0, 0xFC, 0x0F, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x00,
  0x08, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0xF0, 0x10,
  0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x3F, 0xFE, 0x3F,
  0xFF, 0xC7, 0xFF, 0xF8, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFF, 0xC1,
  0xC0, 0xFF, 0xF8, 0x70, 0x7F, 0x3F, 0x9C, 0x3C, 0x00, 0xF7, 0x1E, 0x00,
  0x1D, 0xCF, 0x00, 0x03, 0xF3, 0x80, 0x00, 0x7D, 0xE0, 0x00, 0x1F, 0x78,
  0x00, 0x03, 0xDC, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0x70, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x7C,
  0xE0, 0x00, 0x1F, 0x3C, 0x00, 0x0F, 0xC7, 0x80, 0x03, 0x71, 0xF0, 0x03,
  0xBC, 0x3F, 0x03, 0xEF, 0x07, 0xFF, 0xE3, 0xC0, 0x7F, 0xF0, 0xF0, 0x00,
  0x80, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xC2, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0xFF, 0xC0, 0xE1,
  0xFF, 0xF0, 0xE7, 0xF3, 0xF8, 0xEF, 0x00, 0x7C, 0xEC, 0x00, 0x1E, 0xF8,
  0x00, 0x1E, 0xF8, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0x73, 0xFF, 0xF7, 0x00, 0x00, 0x00, 0x00, 0xE7, 0x39, 0xCE,
  0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C,
  0xE7, 0x39, 0xCE, 0x70, 0x00, 0xE0, 0x0F, 0x01, 0xF0, 0x1F, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xCC, 0x7C, 0xFF, 0x8F,
  0xF0, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x0F, 0xB8, 0x00, 0x1C, 0x70, 0x00, 0x70, 0xE0,
  0x01, 0xE1, 0xC0, 0x07, 0x83, 0x80, 0x1E, 0x07, 0x00, 0x78, 0x0E, 0x01,
  0xE0, 0x1C, 0x07, 0x80, 0x38, 0x1E, 0x00, 0x70, 0x78, 0x00, 0xE1, 0xE0,
  0x01, 0xC7, 0x80, 0x03, 0x8F, 0x00, 0x07, 0x3F, 0x00, 0x0E, 0xEF, 0x00,
  0x1F, 0x8E, 0x00, 0x3E, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0xE0, 0x1E, 0x01,
  0xC0, 0x1C, 0x03, 0x80, 0x3C, 0x07, 0x00, 0x3C, 0x0E, 0x00, 0x3C, 0x1C,
  0x00, 0x38, 0x38, 0x00, 0x78, 0x70, 0x00, 0x78, 0xE0, 0x00, 0x79, 0xC0,
  0x00, 0x73, 0x80, 0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0xFF,
  0x80, 0x3F, 0xF0, 0xE3, 0xFF, 0xE0, 0xFF, 0xF8, 0xE7, 0xE7, 0xF1, 0xF9,
  0xFC, 0xEE, 0x00, 0xF3, 0xC0, 0x1E, 0xFC, 0x00, 0x7B, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00, 0x1C, 0x00, 0x07,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00,
  0x1C, 0x00, 0x07, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00, 0x1C, 0x00,
  0x07, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0xE0,
  0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00, 0x1C,
  0x00, 0x07, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00, 0x1C, 0x00, 0x07,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00,
  0x1C, 0x00, 0x07, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00, 0x1C, 0x00,
  0x07, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0xE0,
  0x00, 0x1C, 0x00, 0x07, 0xE0, 0xFF, 0xC0, 0xE1, 0xFF, 0xF0, 0xE7, 0xE3,
  0xF8, 0xEF, 0x00, 0x7C, 0xEC, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF8, 0x00,
  0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xCF, 0xF0, 0x07, 0xC0, 0x1F, 0x01,
  0xE0, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xE3, 0xC0, 0x00,
  0x1E, 0x78, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x78,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xB8, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x03,
  0x9E, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x1C, 0x3C, 0x00, 0x07, 0x83, 0xC0,
  0x01, 0xE0, 0x3C, 0x00, 0x78, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0x01, 0x00, 0x00, 0xE0, 0xFF, 0xC0, 0x70, 0xFF,
  0xF8, 0x39, 0xFC, 0xFE, 0x1C, 0xE0, 0x0F, 0x8E, 0xE0, 0x01, 0xE7, 0xE0,
  0x00, 0x7B, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x0E, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1D, 0xF0, 0x00, 0x1E, 0xF8, 0x00,
  0x0E, 0x7E, 0x00, 0x0F, 0x3B, 0x80, 0x1F, 0x1C, 0xF8, 0x3F, 0x0E, 0x3F,
  0xFF, 0x07, 0x07, 0xFE, 0x03, 0x80, 0x28, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC1, 0xC0, 0xFF, 0xF8, 0x70, 0x7F, 0x3F, 0x1C, 0x3C, 0x00, 0xE7, 0x1E,
  0x00, 0x1D, 0xCF, 0x00, 0x03, 0xF3, 0x80, 0x00, 0x7D, 0xE0, 0x00, 0x1F,
  0x70, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0x70, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x7D, 0xE0, 0x00, 0x1F, 0x3C, 0x00, 0x0F, 0xCF, 0x80, 0x07, 0x71, 0xF0,
  0x03, 0xBC, 0x3F, 0x07, 0xCF, 0x07, 0xFF, 0xE3, 0xC0, 0x7F, 0xF0, 0xF0,
  0x03, 0x80, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF,
  0xEF, 0x00, 0xEE, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0xFF, 0x8F,
  0xE1, 0xFC, 0xF0, 0x00, 0xC7, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x07, 0xB0, 0x00, 0x79, 0xF0, 0x0F, 0xCF, 0xFF, 0xFC, 0x1F, 0xFF,
  0x80, 0x03, 0x00, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x7F, 0xFE, 0xFF, 0xFF, 0x7F,
  0xFF, 0x83, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x01, 0xF8, 0x60, 0x7F, 0xF0, 0x1F, 0xF8, 0x01,
  0xC0, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x3E, 0xE0, 0x00, 0xFD, 0xF0, 0x03, 0xB9, 0xF8, 0x3E, 0x31, 0xFF, 0xF8,
  0x61, 0xFF, 0xC0, 0xC0, 0x18, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x8E,
  0x00, 0x01, 0xC3, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x1E, 0x00, 0x0E,
  0x03, 0x80, 0x07, 0x80, 0xE0, 0x01, 0xC0, 0x3C, 0x00, 0x70, 0x07, 0x00,
  0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x03,
  0xC0, 0x70, 0x00, 0x70, 0x3C, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x83, 0x80,
  0x00, 0xE1, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x3B,
  0x80, 0x03, 0xF0, 0x00, 0xF7, 0x00, 0x07, 0xE0, 0x01, 0xCF, 0x00, 0x0D,
  0xC0, 0x03, 0x8E, 0x00, 0x39, 0xC0, 0x0F, 0x1C, 0x00, 0x73, 0x80, 0x1C,
  0x38, 0x00, 0xE7, 0x00, 0x38, 0x78, 0x03, 0x8E, 0x00, 0x70, 0x70, 0x07,
  0x0E, 0x01, 0xE0, 0xE0, 0x0E, 0x1C, 0x03, 0x81, 0xC0, 0x38, 0x38, 0x07,
  0x01, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x3C, 0x07, 0x03,
  0x80, 0xE0, 0x70, 0x0F, 0x07, 0x00, 0xE0, 0xE0, 0x0E, 0x0E, 0x01, 0xC1,
  0xC0, 0x1C, 0x38, 0x03, 0x87, 0x00, 0x38, 0x70, 0x03, 0x8E, 0x00, 0x38,
  0xE0, 0x07, 0x1C, 0x00, 0x73, 0x80, 0x0E, 0x38, 0x00, 0xE7, 0x00, 0x1C,
  0xE0, 0x01, 0xCE, 0x00, 0x1D, 0xC0, 0x01, 0xD8, 0x00, 0x3B, 0x80, 0x03,
  0xF0, 0x00, 0x77, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x8E, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0xF0, 0x78, 0x00,
  0x78, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x0F,
  0x01, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x3C, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0x3C, 0x00, 0x03, 0x87, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0xF0, 0x3C, 0x00,
  0x38, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x07,
  0x81, 0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x39,
  0xE0, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x8E, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x70, 0x70, 0x00, 0x3C, 0x1E, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x80, 0xE0,
  0x01, 0xC0, 0x3C, 0x00, 0x70, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x0E, 0x00,
  0x38, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x03, 0xC0, 0x70, 0x00, 0x70, 0x3C,
  0x00, 0x1C, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE1, 0xE0, 0x00, 0x3C,
  0x70, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x0E, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x87, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0x00, 0x3F, 0x00, 0xFF, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x1F, 0x00, 0xFC, 0x00,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xFF, 0x00, 0x3F,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xF0, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x01, 0xF0, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03,
  0xE0, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x3E, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x7C, 0x03, 0xFC, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x4F, 0xFE, 0x00, 0x17, 0xFF, 0xE0, 0x1F, 0xC0, 0xFF, 0x9F, 0xC0, 0x0F,
  0xFF, 0xA0, 0x00, 0x7F, 0x80,
};

const GFXglyph NotoSans_Light56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 5, 41, 14, 4, -40 },
  { 27, 13, 14, 20, 4, -40 },
  { 50, 33, 40, 36, 2, -40 },
  { 215, 24, 46, 32, 4, -43 },
  { 353, 39, 42, 45, 3, -41 },
  { 558, 36, 42, 40, 3, -41 },
  { 747, 3, 14, 11, 4, -40 },
  { 753, 12, 49, 16, 2, -40 },
  { 827, 11, 49, 16, 2, -40 },
  { 895, 25, 24, 31, 3, -43 },
  { 970, 26, 26, 32, 3, -33 },
  { 1055, 7, 14, 13, 2, -7 },
  { 1068, 14, 3, 18, 2, -17 },
  { 1074, 5, 6, 14, 4, -5 },
  { 1078, 18, 40, 19, 1, -40 },
  { 1168, 26, 42, 32, 3, -41 },
  { 1305, 14, 40, 32, 5, -40 },
  { 1375, 25, 41, 32, 3, -41 },
  { 1504, 25, 42, 32, 3, -41 },
  { 1636, 30, 40, 32, 1, -40 },
  { 1786, 25, 41, 32, 4, -40 },
  { 1915, 26, 42, 32, 3, -41 },
  { 2052, 26, 40, 32, 3, -40 },
  { 2182, 26, 42, 32, 3, -41 },
  { 2319, 26, 42, 32, 3, -41 },
  { 2456, 5, 31, 14, 4, -30 },
  { 2476, 7, 37, 14, 2, -30 },
  { 2509, 26, 26, 32, 3, -33 },
  { 2594, 26, 14, 32, 3, -27 },
  { 2640, 26, 26, 32, 3, -33 },
  { 2725, 21, 42, 24, 1, -41 },
  { 2836, 44, 45, 50, 3, -40 },
  { 3084, 34, 40, 34, 0, -40 },
  { 3254, 26, 40, 35, 6, -40 },
  { 3384, 30, 42, 35, 3, -41 },
  { 3542, 30, 40, 40, 6, -40 },
  { 3692, 22, 40, 31, 6, -40 },
  { 3802, 22, 40, 28, 6, -40 },
  { 3912, 33, 42, 41, 3, -41 },
  { 4086, 29, 40, 41, 6, -40 },
  { 4231, 12, 40, 17, 3, -40 },
  { 4291, 14, 50, 14, -5, -40 },
  { 4379, 27, 40, 33, 6, -40 },
  { 4514, 22, 40, 29, 6, -40 },
  { 4624, 37, 40, 49, 6, -40 },
  { 4809, 29, 40, 41, 6, -40 },
  { 4954, 36, 42, 43, 3, -41 },
  { 5143, 24, 40, 33, 6, -40 },
  { 5263, 36, 51, 43, 3, -41 },
  { 5493, 26, 40, 34, 6, -40 },
  { 5623, 25, 42, 31, 3, -41 },
  { 5755, 29, 40, 30, 0, -40 },
  { 5900, 30, 41, 40, 5, -40 },
  { 6054, 33, 40, 33, 0, -40 },
  { 6219, 48, 40, 50, 1, -40 },
  { 6459, 31, 40, 31, 0, -40 },
  { 6614, 30, 40, 30, 0, -40 },
  { 6764, 28, 40, 32, 2, -40 },
  { 6904, 12, 49, 18, 5, -40 },
  { 6978, 18, 40, 19, 1, -40 },
  { 7068, 12, 49, 18, 1, -40 },
  { 7142, 28, 25, 32, 2, -40 },
  { 7230, 24, 3, 23, 0, 5 },
  { 7239, 11, 9, 15, 2, -43 },
  { 7252, 22, 31, 30, 3, -30 },
  { 7338, 25, 44, 34, 5, -43 },
  { 7476, 22, 31, 27, 3, -30 },
  { 7562, 26, 44, 34, 3, -43 },
  { 7705, 25, 31, 31, 3, -30 },
  { 7802, 19, 43, 17, 1, -43 },
  { 7905, 26, 43, 34, 3, -30 },
  { 8045, 24, 43, 33, 5, -43 },
  { 8174, 5, 41, 13, 4, -41 },
  { 8200, 12, 54, 13, -3, -41 },
  { 8281, 23, 43, 28, 5, -43 },
  { 8405, 3, 43, 13, 5, -43 },
  { 8422, 40, 30, 50, 5, -30 },
  { 8572, 24, 30, 33, 5, -30 },
  { 8662, 27, 31, 33, 3, -30 },
  { 8767, 25, 43, 34, 5, -30 },
  { 8902, 26, 43, 34, 3, -30 },
  { 9042, 16, 30, 22, 5, -30 },
  { 9102, 21, 31, 26, 3, -30 },
  { 9184, 17, 38, 19, 1, -37 },
  { 9265, 23, 31, 33, 5, -30 },
  { 9355, 26, 30, 26, 0, -30 },
  { 9453, 39, 30, 41, 1, -30 },
  { 9600, 26, 30, 28, 1, -30 },
  { 9698, 26, 44, 26, 0, -30 },
  { 9841, 22, 30, 26, 2, -30 },
  { 9924, 16, 49, 20, 2, -40 },
  { 10022, 3, 57, 30, 14, -43 },
  { 10044, 17, 49, 20, 2, -40 },
  { 10149, 26, 6, 32, 3, -23 },
};

const GFXfont NotoSans_Light56pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light56pt7bBitmaps,
  (GFXglyph *)NotoSans_Light56pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _NOTOSANS_LIGHT56PT7B_H_
