#ifndef _NOTOSANS_LIGHT46PT7B_H_
#define _NOTOSANS_LIGHT46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light46pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xE6, 0x66, 0x66, 0x66,
  0x66, 0x00, 0x00, 0x0E, 0xFF, 0xE4, 0xE0, 0xFC, 0x1F, 0x83, 0x70, 0x6E,
  0x0D, 0xC1, 0xB8, 0x33, 0x06, 0x60, 0xCC, 0x19, 0x83, 0x30, 0x60, 0x00,
  0x18, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x18, 0x06,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x03,
  0x80, 0x60, 0x00, 0x70, 0x1C, 0x00, 0x0C, 0x03, 0x00, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x30,
  0x0C, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x38, 0x06, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x06, 0x01, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xF0, 0x1C, 0x07, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x60, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x70, 0x1C,
  0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0F,
  0x00, 0x0F, 0xFF, 0x83, 0xFF, 0xFC, 0x78, 0x61, 0xC7, 0x06, 0x00, 0xE0,
  0x60, 0x0E, 0x06, 0x00, 0xE0, 0x60, 0x0E, 0x06, 0x00, 0xE0, 0x60, 0x0E,
  0x06, 0x00, 0x70, 0x60, 0x07, 0xC6, 0x00, 0x1F, 0x60, 0x00, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x6F, 0x80, 0x06, 0x3C, 0x00, 0x60,
  0xE0, 0x06, 0x06, 0x00, 0x60, 0x70, 0x06, 0x07, 0x00, 0x60, 0x70, 0x06,
  0x06, 0x00, 0x60, 0xE0, 0x06, 0x1E, 0xE0, 0x63, 0xCF, 0xFF, 0xF8, 0x7F,
  0xFE, 0x00, 0x1E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x0F, 0xC0, 0x00, 0xE0, 0x0F, 0xF0, 0x00, 0x60, 0x0E, 0x1C,
  0x00, 0x70, 0x06, 0x07, 0x00, 0x30, 0x07, 0x01, 0x80, 0x38, 0x03, 0x00,
  0xC0, 0x18, 0x01, 0x80, 0x60, 0x1C, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0xE0,
  0x1C, 0x0C, 0x00, 0x70, 0x0E, 0x0E, 0x00, 0x38, 0x07, 0x06, 0x00, 0x0C,
  0x03, 0x87, 0x00, 0x06, 0x01, 0x83, 0x00, 0x03, 0x00, 0xC3, 0x8F, 0xC1,
  0x80, 0x61, 0x8F, 0xF0, 0xE0, 0x71, 0xCE, 0x1C, 0x30, 0x30, 0xC6, 0x07,
  0x1C, 0x38, 0xC7, 0x01, 0x87, 0xF8, 0xE3, 0x80, 0xC1, 0xF8, 0x61, 0x80,
  0x70, 0x00, 0x70, 0xC0, 0x38, 0x00, 0x30, 0x60, 0x1C, 0x00, 0x38, 0x30,
  0x06, 0x00, 0x18, 0x18, 0x03, 0x00, 0x1C, 0x0C, 0x03, 0x80, 0x0C, 0x06,
  0x01, 0xC0, 0x0C, 0x03, 0x00, 0xE0, 0x0E, 0x01, 0x80, 0x60, 0x06, 0x00,
  0xE0, 0x30, 0x07, 0x00, 0x30, 0x38, 0x03, 0x00, 0x1C, 0x18, 0x03, 0x80,
  0x07, 0xFC, 0x03, 0x80, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0, 0x0C,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x70, 0x03, 0x80, 0x03, 0x80, 0x1C, 0x00,
  0x1C, 0x00, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E,
  0x0F, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xF1, 0xE0, 0x03,
  0x8F, 0x07, 0x80, 0x18, 0xE0, 0x1E, 0x01, 0xC7, 0x00, 0x78, 0x0E, 0x70,
  0x01, 0xE0, 0x63, 0x80, 0x07, 0x87, 0x18, 0x00, 0x1E, 0x30, 0xC0, 0x00,
  0x7B, 0x86, 0x00, 0x01, 0xF8, 0x38, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x3E,
  0x0F, 0x00, 0x03, 0xF8, 0x3C, 0x00, 0x79, 0xE0, 0xF8, 0x0F, 0x87, 0x83,
  0xFF, 0xF8, 0x1E, 0x07, 0xFF, 0x00, 0x78, 0xFF, 0xFF, 0xFB, 0x6D, 0xB0,
  0x03, 0x81, 0x81, 0xC1, 0xC0, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x18, 0x1C,
  0x0E, 0x06, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x0C, 0x07, 0x03, 0x81, 0xC0, 0x60,
  0x38, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x30, 0x1C, 0x07, 0xC0, 0x30, 0x1C,
  0x07, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x70,
  0x18, 0x0C, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x1C, 0x0E, 0x06, 0x07,
  0x03, 0x03, 0x81, 0x81, 0xC1, 0xC0, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x01, 0x00, 0xC0,
  0x2E, 0x06, 0x0F, 0xFE, 0x23, 0xF9, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x00,
  0xF0, 0x00, 0x0D, 0x80, 0x00, 0xE6, 0x00, 0x0E, 0x38, 0x00, 0x60, 0xE0,
  0x07, 0x07, 0x00, 0x70, 0x1C, 0x03, 0x80, 0xF0, 0x04, 0x02, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x39, 0xCE, 0x67, 0x39, 0x8C, 0xE6, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xEF, 0xFE, 0x40, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38,
  0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x30,
  0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0,
  0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0x81, 0xE0, 0x78, 0x03, 0x83,
  0x80, 0x0C, 0x38, 0x00, 0x71, 0xC0, 0x01, 0x8C, 0x00, 0x0E, 0xE0, 0x00,
  0x77, 0x00, 0x03, 0xB8, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1B, 0x80,
  0x00, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x73, 0x00, 0x03, 0x9C, 0x00, 0x18,
  0xE0, 0x01, 0xC3, 0x80, 0x0C, 0x1E, 0x00, 0xE0, 0x78, 0x1E, 0x01, 0xFF,
  0xE0, 0x03, 0xFE, 0x00, 0x00, 0x70, 0x0F, 0x03, 0xF0, 0x77, 0x0E, 0x73,
  0xC7, 0xF8, 0x76, 0x07, 0x40, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x0F,
  0x81, 0xF0, 0xF0, 0x03, 0xC2, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFE, 0x00,
  0xFF, 0xFC, 0x1F, 0x80, 0xF1, 0xE0, 0x01, 0xC4, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x40, 0x00, 0x73, 0xC0, 0x0F, 0x9F, 0xFF, 0xF0, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x76, 0x00, 0x00, 0x73, 0x00, 0x00, 0x31, 0x80, 0x00, 0x38,
  0xC0, 0x00, 0x38, 0x60, 0x00, 0x18, 0x30, 0x00, 0x18, 0x18, 0x00, 0x1C,
  0x0C, 0x00, 0x1C, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x0E, 0x01, 0x80, 0x0E,
  0x00, 0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x30, 0x07, 0x00, 0x18, 0x07,
  0x00, 0x0C, 0x03, 0x00, 0x06, 0x03, 0x80, 0x03, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x3F, 0xFF, 0xC3, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC3, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x3F, 0x80, 0x7F, 0xFF, 0x07, 0xE1, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE8, 0x00, 0x1C, 0xF0,
  0x07, 0x8F, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFF,
  0x01, 0xF0, 0x08, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0xFF, 0x83, 0x9F, 0xFE, 0x1D, 0xC0,
  0x38, 0xD8, 0x00, 0xE7, 0x80, 0x03, 0xBC, 0x00, 0x1D, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3B, 0x00, 0x01, 0xDC, 0x00, 0x0C, 0x60, 0x00, 0xE3, 0x80, 0x07, 0x0E,
  0x00, 0x70, 0x38, 0x0F, 0x00, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0x80,
  0xF0, 0x70, 0x03, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0x31, 0x80, 0x01, 0x8C,
  0x00, 0x0E, 0x60, 0x00, 0x63, 0x80, 0x03, 0x1C, 0x00, 0x38, 0x70, 0x03,
  0x81, 0xC0, 0x38, 0x07, 0x87, 0x80, 0x1F, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xFE, 0x00, 0x78, 0x78, 0x0F, 0x00, 0xF0, 0xF0, 0x03, 0xC7, 0x00, 0x0F,
  0x70, 0x00, 0x3B, 0x80, 0x00, 0xD8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0D, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0x38, 0x00, 0x70,
  0xF0, 0x0F, 0x03, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x7F,
  0xF8, 0x07, 0xC0, 0xF0, 0x78, 0x03, 0xC3, 0x80, 0x0E, 0x38, 0x00, 0x39,
  0xC0, 0x00, 0xCC, 0x00, 0x07, 0x60, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x1D, 0xC0, 0x00, 0xEE,
  0x00, 0x0F, 0x38, 0x00, 0xD8, 0xE0, 0x1C, 0xC3, 0xFF, 0xC6, 0x0F, 0xFC,
  0x30, 0x04, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x18,
  0x00, 0x00, 0xEF, 0xFF, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0xFF, 0xE4, 0x38, 0xF3, 0xCE, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0xE3, 0x9C, 0x71, 0xC6, 0x38,
  0xE3, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x7F, 0xFE, 0x1E,
  0x07, 0x88, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x1E, 0x03, 0x80,
  0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x01, 0xC7,
  0x00, 0x06, 0x00, 0x19, 0xC0, 0x0F, 0xFE, 0x03, 0x30, 0x07, 0xE7, 0xC0,
  0x76, 0x01, 0xE0, 0x18, 0x07, 0xC0, 0x38, 0x03, 0x00, 0xF0, 0x0E, 0x00,
  0x60, 0x1E, 0x01, 0x80, 0x0C, 0x03, 0xC0, 0x70, 0x03, 0x80, 0x78, 0x0E,
  0x00, 0x70, 0x0F, 0x01, 0x80, 0x0E, 0x01, 0xE0, 0x30, 0x01, 0xC0, 0x3C,
  0x06, 0x00, 0x38, 0x07, 0x80, 0xC0, 0x07, 0x01, 0xF0, 0x1C, 0x00, 0xE0,
  0x36, 0x03, 0x80, 0x3C, 0x06, 0xC0, 0x38, 0x0D, 0x81, 0xDC, 0x07, 0x83,
  0xB8, 0x73, 0x80, 0x7F, 0xE3, 0xFC, 0x30, 0x03, 0xF0, 0x3E, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x08,
  0x00, 0x0F, 0x80, 0x0F, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x0C, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x01, 0x80, 0x03, 0x80,
  0x1C, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x7F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x07, 0x00, 0xC0,
  0x00, 0x30, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x38, 0x18, 0x00, 0x01,
  0x83, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0xE6, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x70, 0xFF, 0xF8,
  0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x30, 0x00, 0x78, 0xC0, 0x00, 0xF3,
  0x00, 0x01, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x0E, 0xC0, 0x00, 0x3B, 0x00,
  0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x1C, 0xC0, 0x00, 0xE3, 0x00, 0x07,
  0x8C, 0x01, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0x00, 0x0F, 0x8C,
  0x00, 0x0F, 0x30, 0x00, 0x1E, 0xC0, 0x00, 0x3B, 0x00, 0x00, 0xEC, 0x00,
  0x01, 0xB0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xEC, 0x00, 0x03,
  0xB0, 0x00, 0x0E, 0xC0, 0x00, 0x73, 0x00, 0x07, 0xCC, 0x01, 0xFE, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0x03,
  0xF0, 0x1F, 0x07, 0x80, 0x02, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xE0, 0x0E, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x18, 0x00, 0x3E, 0x0C, 0x00, 0x07, 0x86,
  0x00, 0x01, 0xE3, 0x00, 0x00, 0x71, 0x80, 0x00, 0x1C, 0xC0, 0x00, 0x0E,
  0x60, 0x00, 0x03, 0xB0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x0E, 0xC0,
  0x00, 0x0E, 0x60, 0x00, 0x07, 0x30, 0x00, 0x07, 0x18, 0x00, 0x07, 0x8C,
  0x00, 0x07, 0x86, 0x00, 0x0F, 0x83, 0x00, 0xFF, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0xFF, 0xFE, 0xFF, 0xFF, 0xB0, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEC,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x07, 0xE0, 0x1F, 0x03, 0xE0, 0x00, 0x60,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xD8, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x0E,
  0x1F, 0x00, 0x01, 0xC0, 0xFC, 0x00, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE3, 0xFF, 0xFF, 0xC0, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80,
  0x70, 0x0E, 0x03, 0xA0, 0xF7, 0xFC, 0xFF, 0x00, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xCC, 0x00, 0x0E, 0x30, 0x00, 0x78, 0xC0, 0x03, 0xC3, 0x00, 0x1E,
  0x0C, 0x00, 0xF0, 0x30, 0x07, 0x80, 0xC0, 0x3C, 0x03, 0x01, 0xE0, 0x0C,
  0x07, 0x00, 0x30, 0x38, 0x00, 0xC1, 0xC0, 0x03, 0x0E, 0x00, 0x0C, 0x78,
  0x00, 0x33, 0xE0, 0x00, 0xDD, 0xC0, 0x03, 0xE7, 0x80, 0x0F, 0x0F, 0x00,
  0x38, 0x1C, 0x00, 0xC0, 0x38, 0x03, 0x00, 0xF0, 0x0C, 0x01, 0xC0, 0x30,
  0x03, 0x80, 0xC0, 0x07, 0x03, 0x00, 0x1E, 0x0C, 0x00, 0x38, 0x30, 0x00,
  0x70, 0xC0, 0x00, 0xE3, 0x00, 0x03, 0xCC, 0x00, 0x07, 0x30, 0x00, 0x0E,
  0xC0, 0x00, 0x3C, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFD, 0x80, 0x00,
  0x06, 0xFB, 0x80, 0x00, 0x1D, 0xF7, 0x00, 0x00, 0x3B, 0xE7, 0x00, 0x00,
  0x67, 0xCE, 0x00, 0x01, 0xCF, 0x8C, 0x00, 0x03, 0x1F, 0x1C, 0x00, 0x0E,
  0x3E, 0x38, 0x00, 0x1C, 0x7C, 0x38, 0x00, 0x30, 0xF8, 0x70, 0x00, 0xE1,
  0xF0, 0x60, 0x01, 0x83, 0xE0, 0xE0, 0x07, 0x07, 0xC1, 0xC0, 0x0E, 0x0F,
  0x81, 0x80, 0x18, 0x1F, 0x03, 0x80, 0x70, 0x3E, 0x03, 0x00, 0xC0, 0x7C,
  0x07, 0x03, 0x80, 0xF8, 0x0E, 0x07, 0x01, 0xF0, 0x0C, 0x0C, 0x03, 0xE0,
  0x1C, 0x38, 0x07, 0xC0, 0x18, 0x60, 0x0F, 0x80, 0x39, 0xC0, 0x1F, 0x00,
  0x73, 0x80, 0x3E, 0x00, 0x66, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x03,
  0x00, 0x0E, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xDC, 0x00, 0x07, 0xDE, 0x00, 0x07, 0xCE,
  0x00, 0x07, 0xC7, 0x00, 0x07, 0xC7, 0x80, 0x07, 0xC3, 0x80, 0x07, 0xC1,
  0xC0, 0x07, 0xC1, 0xE0, 0x07, 0xC0, 0xE0, 0x07, 0xC0, 0x70, 0x07, 0xC0,
  0x78, 0x07, 0xC0, 0x38, 0x07, 0xC0, 0x1C, 0x07, 0xC0, 0x1E, 0x07, 0xC0,
  0x0E, 0x07, 0xC0, 0x07, 0x07, 0xC0, 0x07, 0x87, 0xC0, 0x03, 0x87, 0xC0,
  0x01, 0xC7, 0xC0, 0x01, 0xE7, 0xC0, 0x00, 0xE7, 0xC0, 0x00, 0x77, 0xC0,
  0x00, 0x7B, 0xC0, 0x00, 0x3B, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0,
  0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x0E,
  0x00, 0x00, 0xF0, 0xE0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x01, 0x98, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1D, 0x80, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x3C, 0x07, 0x80, 0x03, 0xC0, 0x1F, 0x80, 0x7C, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x8C, 0x00, 0x7C, 0xC0, 0x01, 0xCC, 0x00, 0x0E, 0xC0, 0x00, 0xEC, 0x00,
  0x06, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x06, 0xC0,
  0x00, 0xEC, 0x00, 0x0E, 0xC0, 0x01, 0xCC, 0x00, 0x3C, 0xC0, 0x0F, 0x8F,
  0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xF0, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x01,
  0xF8, 0x0F, 0xC0, 0x1F, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x0E, 0x00,
  0x00, 0xF0, 0xE0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x01, 0x98, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1D,
  0x80, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x3C, 0x07, 0x80, 0x03, 0xC0, 0x1F, 0x80, 0x7C, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0xFF, 0xF0, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x30, 0x00, 0xF0, 0xC0, 0x01, 0xE3, 0x00,
  0x03, 0x8C, 0x00, 0x0E, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x73, 0x00, 0x01,
  0xCC, 0x00, 0x07, 0x30, 0x00, 0x18, 0xC0, 0x00, 0xE3, 0x00, 0x03, 0x8C,
  0x00, 0x1C, 0x30, 0x01, 0xE0, 0xC0, 0x7F, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0x30, 0x0E, 0x00, 0xC0, 0x1C, 0x03, 0x00, 0x38, 0x0C, 0x00, 0xE0,
  0x30, 0x01, 0xC0, 0xC0, 0x07, 0x83, 0x00, 0x0E, 0x0C, 0x00, 0x1C, 0x30,
  0x00, 0x70, 0xC0, 0x00, 0xE3, 0x00, 0x03, 0xCC, 0x00, 0x07, 0x30, 0x00,
  0x0E, 0xC0, 0x00, 0x3C, 0x03, 0xFF, 0x80, 0x7F, 0xFF, 0x87, 0xC0, 0x7C,
  0x78, 0x00, 0x43, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x40, 0x00, 0x73, 0xC0,
  0x0F, 0x1F, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0x60, 0x00, 0x03, 0xB8, 0x00, 0x01, 0x9C, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0xE0, 0xF0, 0x00, 0xE0, 0x3E, 0x01, 0xE0, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x38, 0x70,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x07,
  0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x38, 0x07, 0x00, 0x07, 0x00, 0x60,
  0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x01, 0xC0,
  0x03, 0x80, 0x38, 0x00, 0x70, 0x06, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0,
  0x38, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x38, 0x00,
  0x03, 0x0E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0x30, 0x00, 0x00, 0xCE,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x07, 0xC0, 0x00, 0x70, 0x00, 0x1D, 0x80, 0x00, 0xF0, 0x00,
  0x3B, 0x80, 0x03, 0xE0, 0x00, 0x67, 0x00, 0x06, 0xC0, 0x01, 0xCE, 0x00,
  0x0D, 0x80, 0x03, 0x8C, 0x00, 0x3B, 0x80, 0x07, 0x1C, 0x00, 0x73, 0x00,
  0x0C, 0x38, 0x00, 0xC6, 0x00, 0x38, 0x30, 0x01, 0x8E, 0x00, 0x70, 0x70,
  0x07, 0x1C, 0x00, 0xE0, 0xE0, 0x0E, 0x18, 0x01, 0x81, 0xC0, 0x18, 0x38,
  0x07, 0x01, 0x80, 0x70, 0x70, 0x0E, 0x03, 0x80, 0xE0, 0x60, 0x1C, 0x07,
  0x01, 0x80, 0xC0, 0x70, 0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x0C, 0x0E, 0x03,
  0x81, 0xC0, 0x1C, 0x1C, 0x03, 0x03, 0x00, 0x38, 0x30, 0x07, 0x0E, 0x00,
  0x30, 0xE0, 0x0E, 0x1C, 0x00, 0x61, 0xC0, 0x0C, 0x38, 0x00, 0xE3, 0x00,
  0x18, 0x60, 0x01, 0xC6, 0x00, 0x39, 0xC0, 0x01, 0x9C, 0x00, 0x73, 0x80,
  0x03, 0xB8, 0x00, 0x67, 0x00, 0x07, 0x60, 0x00, 0xCC, 0x00, 0x0E, 0xC0,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x03,
  0x83, 0x80, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x07, 0x00, 0xE0, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x60, 0x00, 0x30,
  0x70, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x30, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1D, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x0E, 0x00,
  0x07, 0x03, 0x00, 0x07, 0x01, 0xC0, 0x03, 0x00, 0x70, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x0E, 0x01, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xC1, 0xC0, 0x00,
  0x70, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x03, 0xB8, 0x00, 0x03, 0x9C, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3,
  0x80, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x70,
  0x06, 0x00, 0x70, 0x03, 0x80, 0x38, 0x00, 0xC0, 0x38, 0x00, 0x70, 0x1C,
  0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0C, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC6,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0x80, 0x0E,
  0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00,
  0x70, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0,
  0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x60, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0xFF, 0xFF, 0xF0, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xCC, 0x00, 0x07, 0x38,
  0x00, 0x18, 0x60, 0x00, 0xE1, 0xC0, 0x03, 0x03, 0x00, 0x1C, 0x0E, 0x00,
  0x60, 0x18, 0x03, 0x80, 0x70, 0x0C, 0x00, 0xC0, 0x70, 0x03, 0x81, 0x80,
  0x06, 0x0E, 0x00, 0x1C, 0x30, 0x00, 0x31, 0xC0, 0x00, 0xE6, 0x00, 0x01,
  0xB8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x70, 0x38, 0x1C,
  0x0C, 0x06, 0x03, 0x01, 0xFC, 0x01, 0xFF, 0xE0, 0x7E, 0x3E, 0x0C, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0xFF, 0xF0, 0xFF, 0xFE, 0x7E, 0x01,
  0xDE, 0x00, 0x3B, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0xFE, 0x00, 0x1E, 0xE0, 0x06, 0xDE, 0x03, 0x99, 0xFF, 0xE3,
  0x1F, 0xF0, 0x60, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x3F, 0x01, 0xC7, 0xFE, 0x0E, 0xF8,
  0xFC, 0x7E, 0x00, 0xE3, 0xE0, 0x03, 0x9E, 0x00, 0x0E, 0xF0, 0x00, 0x77,
  0x00, 0x01, 0xB8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x6E, 0x00, 0x07, 0x78, 0x00, 0x3B, 0xC0, 0x03,
  0x9B, 0x00, 0x3C, 0xCE, 0x03, 0xC6, 0x3F, 0xFC, 0x30, 0xFF, 0x80, 0x00,
  0xFE, 0x03, 0xFF, 0xC3, 0xFB, 0xE3, 0xC0, 0x13, 0x80, 0x03, 0x80, 0x01,
  0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x06,
  0x1F, 0xFF, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x7E, 0x0E, 0x0F, 0xFC,
  0x71, 0xF8, 0xF3, 0x9E, 0x00, 0xDC, 0xE0, 0x03, 0xEE, 0x00, 0x1F, 0x70,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xB8, 0x00, 0x3D,
  0xC0, 0x03, 0xE7, 0x00, 0x3F, 0x3E, 0x03, 0xB8, 0xFF, 0xF9, 0xC1, 0xFF,
  0x0E, 0x01, 0xF8, 0x00, 0x7F, 0xF0, 0x0F, 0x0F, 0x81, 0xC0, 0x3C, 0x38,
  0x01, 0xC7, 0x00, 0x0E, 0x70, 0x00, 0xEE, 0x00, 0x06, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x02, 0x1E, 0x00, 0xE0, 0xFF,
  0xFE, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0x03, 0xFE, 0x07, 0x82, 0x07, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xF1, 0xC7, 0xE3, 0xEE, 0x78, 0x03,
  0x73, 0x80, 0x0F, 0xB8, 0x00, 0x3D, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x1E, 0xE0, 0x00, 0xF7, 0x00, 0x0F, 0x9C, 0x00, 0xDC,
  0x78, 0x0E, 0xE1, 0xFF, 0xE7, 0x07, 0xFC, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x60, 0x01, 0xE3, 0xF0, 0x3E, 0x0F, 0xFF, 0xE0, 0x0F, 0xF8,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0xFC, 0x0E, 0x3F, 0xF8, 0xEF, 0x8F, 0xCF, 0xC0, 0x1C,
  0xF8, 0x00, 0xEF, 0x00, 0x0E, 0xF0, 0x00, 0x6E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x70, 0x5F, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0x01, 0xC0, 0xE0, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x83, 0xA3, 0xDF, 0xCF, 0xC0, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x01, 0x70,
  0x01, 0xCE, 0x00, 0x71, 0xC0, 0x1C, 0x38, 0x07, 0x07, 0x01, 0xC0, 0xE0,
  0x70, 0x1C, 0x1C, 0x03, 0x87, 0x00, 0x71, 0xE0, 0x0E, 0x38, 0x01, 0xCF,
  0x00, 0x3B, 0xE0, 0x07, 0xEE, 0x00, 0xF8, 0xE0, 0x1E, 0x1E, 0x03, 0x81,
  0xC0, 0x70, 0x1C, 0x0E, 0x01, 0xC1, 0xC0, 0x3C, 0x38, 0x03, 0x87, 0x00,
  0x38, 0xE0, 0x03, 0x9C, 0x00, 0x7B, 0x80, 0x07, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01,
  0xF8, 0x01, 0xF8, 0x63, 0xFF, 0x07, 0xFF, 0x33, 0xC7, 0xC7, 0x8F, 0xDB,
  0x80, 0xF7, 0x00, 0xEF, 0x80, 0x3B, 0x00, 0x3F, 0x80, 0x0F, 0x00, 0x1F,
  0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0x80, 0x03, 0xE0, 0x01, 0xC0, 0x01,
  0xF0, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x38, 0x00,
  0x3E, 0x00, 0x1C, 0x00, 0x1F, 0x00, 0x0E, 0x00, 0x0F, 0x80, 0x07, 0x00,
  0x07, 0xC0, 0x03, 0x80, 0x03, 0xE0, 0x01, 0xC0, 0x01, 0xF0, 0x00, 0xE0,
  0x00, 0xF8, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x3E, 0x00, 0x1C,
  0x00, 0x1F, 0x00, 0x0E, 0x00, 0x0F, 0x80, 0x07, 0x00, 0x07, 0xC0, 0x03,
  0x80, 0x03, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x00, 0xFC, 0x0C, 0x3F, 0xF8,
  0xCF, 0x8F, 0xCD, 0xC0, 0x1C, 0xF8, 0x00, 0xEF, 0x00, 0x0E, 0xF0, 0x00,
  0x6E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x70, 0x01, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0xF8, 0xFC, 0x07, 0x00, 0x78, 0x38, 0x00, 0xE1,
  0xC0, 0x01, 0xC7, 0x00, 0x03, 0x38, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80,
  0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xB8, 0x00, 0x06, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xE6,
  0x00, 0x03, 0x9C, 0x00, 0x1C, 0x70, 0x00, 0x70, 0xE0, 0x03, 0x81, 0xE0,
  0x3C, 0x03, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0xFC, 0x06, 0x1F, 0xF8,
  0x33, 0xE3, 0xF1, 0x98, 0x03, 0xCD, 0x80, 0x0E, 0x78, 0x00, 0x3B, 0xC0,
  0x01, 0xDC, 0x00, 0x06, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xBC, 0x00, 0x1D, 0xE0, 0x00, 0xEF,
  0x80, 0x0E, 0x7C, 0x00, 0xF3, 0xB8, 0x0F, 0x1C, 0xFF, 0xF0, 0xE3, 0xFE,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xF1, 0xC7,
  0xC3, 0xCE, 0x78, 0x03, 0x73, 0x80, 0x0F, 0xB8, 0x00, 0x7D, 0xC0, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1E, 0xE0, 0x00, 0xF7, 0x00,
  0x0F, 0x9C, 0x00, 0xDC, 0xF0, 0x0E, 0xE3, 0xFF, 0xE7, 0x07, 0xFC, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0xFE, 0x1F, 0xF3, 0xFF, 0x98, 0x0D,
  0x80, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x00, 0x03, 0xFC,
  0x0F, 0xFF, 0xCF, 0x87, 0xEE, 0x00, 0x26, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x3D, 0xFF,
  0xFC, 0x3F, 0xF8, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0,
  0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80,
  0x1C, 0x00, 0x7F, 0x81, 0xFC, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0xF7, 0x00, 0x36, 0xF0, 0x1E, 0xCF, 0xFF, 0x98,
  0x7F, 0xC3, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0xE7, 0x00, 0x03, 0x0C, 0x00,
  0x1C, 0x38, 0x00, 0x70, 0xE0, 0x01, 0x81, 0x80, 0x0E, 0x07, 0x00, 0x38,
  0x1C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x01, 0x80, 0xE0, 0x07,
  0x03, 0x80, 0x1C, 0x0C, 0x00, 0x30, 0x70, 0x00, 0xE1, 0x80, 0x01, 0x8E,
  0x00, 0x07, 0x38, 0x00, 0x1C, 0xC0, 0x00, 0x37, 0x00, 0x00, 0xDC, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x03, 0xC0, 0x06, 0x60, 0x03, 0xE0, 0x0E,
  0x70, 0x07, 0x60, 0x0E, 0x70, 0x06, 0x60, 0x0E, 0x30, 0x06, 0x70, 0x0C,
  0x38, 0x0E, 0x70, 0x1C, 0x38, 0x0C, 0x30, 0x1C, 0x38, 0x0C, 0x38, 0x1C,
  0x18, 0x1C, 0x38, 0x18, 0x1C, 0x18, 0x18, 0x38, 0x1C, 0x18, 0x1C, 0x38,
  0x0C, 0x38, 0x1C, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x0E, 0x30, 0x0E, 0x70,
  0x0E, 0x70, 0x0E, 0x70, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60,
  0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0xF0, 0x00, 0x79, 0xC0,
  0x07, 0x07, 0x00, 0x70, 0x38, 0x03, 0x80, 0xE0, 0x38, 0x03, 0x83, 0x80,
  0x1C, 0x1C, 0x00, 0x71, 0xC0, 0x01, 0xDC, 0x00, 0x06, 0xE0, 0x00, 0x3E,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xEE, 0x00, 0x07, 0x70, 0x00,
  0x71, 0xC0, 0x07, 0x07, 0x00, 0x38, 0x18, 0x03, 0x80, 0xE0, 0x38, 0x03,
  0x83, 0x80, 0x0E, 0x1C, 0x00, 0x71, 0xC0, 0x01, 0xDC, 0x00, 0x07, 0xE0,
  0x00, 0x3D, 0xC0, 0x00, 0xE7, 0x00, 0x03, 0x0C, 0x00, 0x1C, 0x38, 0x00,
  0x70, 0xE0, 0x01, 0x81, 0x80, 0x0E, 0x07, 0x00, 0x38, 0x0C, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x18, 0x01, 0x80, 0xE0, 0x07, 0x03, 0x80, 0x0C,
  0x0C, 0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0, 0x01, 0x8E, 0x00, 0x07, 0x38,
  0x00, 0x1C, 0xC0, 0x00, 0x37, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x87, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0xBF, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x03, 0xF0, 0x1F, 0x00, 0xF0, 0x03, 0x80,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x01, 0xE0,
  0x3F, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x07, 0xC0, 0x1F, 0x00,
  0x1C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x1C,
  0x00, 0xF0, 0x01, 0xF0, 0x07, 0x80, 0xF8, 0x0E, 0x00, 0x60, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0F, 0x03, 0xF0, 0x1E, 0x00,
  0x0F, 0x00, 0x04, 0xFF, 0x80, 0x17, 0xBF, 0xC1, 0xF0, 0x0F, 0xFE, 0x80,
  0x0F, 0xF0,
};

const GFXglyph NotoSans_Light46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 4, 34, 11, 4, -33 },
  { 18, 11, 12, 17, 3, -33 },
  { 35, 27, 33, 30, 1, -33 },
  { 147, 20, 38, 26, 3, -35 },
  { 242, 33, 33, 37, 2, -33 },
  { 379, 29, 33, 33, 3, -33 },
  { 499, 3, 12, 9, 3, -33 },
  { 504, 9, 40, 13, 2, -33 },
  { 549, 9, 40, 13, 2, -33 },
  { 594, 21, 20, 25, 2, -35 },
  { 647, 22, 22, 26, 2, -27 },
  { 708, 5, 11, 10, 2, -5 },
  { 715, 11, 3, 15, 2, -14 },
  { 720, 4, 5, 11, 4, -4 },
  { 723, 14, 33, 16, 1, -33 },
  { 781, 21, 33, 26, 3, -33 },
  { 868, 12, 33, 26, 4, -33 },
  { 918, 21, 33, 26, 2, -33 },
  { 1005, 21, 33, 26, 2, -33 },
  { 1092, 25, 33, 26, 1, -33 },
  { 1196, 20, 33, 26, 3, -33 },
  { 1279, 21, 33, 26, 3, -33 },
  { 1366, 22, 33, 26, 2, -33 },
  { 1457, 21, 33, 26, 3, -33 },
  { 1544, 21, 34, 26, 2, -33 },
  { 1634, 4, 26, 11, 4, -25 },
  { 1647, 6, 31, 11, 2, -25 },
  { 1671, 22, 21, 26, 2, -27 },
  { 1729, 21, 12, 26, 3, -22 },
  { 1761, 22, 21, 26, 2, -27 },
  { 1819, 17, 34, 20, 1, -33 },
  { 1892, 35, 37, 41, 3, -33 },
  { 2054, 28, 33, 28, 0, -33 },
  { 2170, 22, 33, 29, 5, -33 },
  { 2261, 24, 33, 29, 3, -33 },
  { 2360, 25, 33, 33, 5, -33 },
  { 2464, 18, 33, 25, 5, -33 },
  { 2539, 18, 33, 23, 5, -33 },
  { 2614, 27, 33, 33, 3, -33 },
  { 2726, 24, 33, 33, 5, -33 },
  { 2825, 10, 33, 14, 2, -33 },
  { 2867, 11, 41, 12, -4, -33 },
  { 2924, 22, 33, 27, 5, -33 },
  { 3015, 18, 33, 24, 5, -33 },
  { 3090, 31, 33, 40, 5, -33 },
  { 3218, 24, 33, 34, 5, -33 },
  { 3317, 29, 33, 35, 3, -33 },
  { 3437, 20, 33, 27, 5, -33 },
  { 3520, 29, 41, 35, 3, -33 },
  { 3669, 22, 33, 28, 5, -33 },
  { 3760, 21, 33, 25, 2, -33 },
  { 3847, 24, 33, 24, 0, -33 },
  { 3946, 25, 33, 33, 4, -33 },
  { 4050, 27, 33, 27, 0, -33 },
  { 4162, 39, 33, 41, 1, -33 },
  { 4323, 25, 33, 25, 0, -33 },
  { 4427, 25, 33, 25, 0, -33 },
  { 4531, 23, 33, 26, 2, -33 },
  { 4626, 10, 40, 15, 4, -33 },
  { 4676, 14, 33, 16, 1, -33 },
  { 4734, 10, 40, 15, 1, -33 },
  { 4784, 22, 20, 26, 2, -33 },
  { 4839, 19, 2, 19, 0, 4 },
  { 4844, 8, 7, 12, 2, -35 },
  { 4851, 19, 25, 25, 2, -25 },
  { 4911, 21, 35, 28, 4, -35 },
  { 5003, 17, 25, 22, 3, -25 },
  { 5057, 21, 35, 28, 3, -35 },
  { 5149, 20, 25, 25, 3, -25 },
  { 5212, 16, 35, 14, 1, -35 },
  { 5282, 21, 36, 28, 3, -25 },
  { 5377, 20, 35, 27, 4, -35 },
  { 5465, 3, 34, 11, 4, -34 },
  { 5478, 9, 45, 11, -2, -34 },
  { 5529, 19, 35, 23, 4, -35 },
  { 5613, 3, 35, 11, 4, -35 },
  { 5627, 33, 25, 41, 4, -25 },
  { 5731, 20, 25, 27, 4, -25 },
  { 5794, 22, 25, 27, 3, -25 },
  { 5863, 21, 36, 28, 4, -25 },
  { 5958, 21, 36, 28, 3, -25 },
  { 6053, 13, 25, 18, 4, -25 },
  { 6094, 17, 25, 22, 2, -25 },
  { 6148, 13, 30, 16, 1, -30 },
  { 6197, 19, 24, 27, 4, -24 },
  { 6254, 22, 24, 22, 0, -24 },
  { 6320, 32, 24, 34, 1, -24 },
  { 6416, 21, 24, 23, 1, -24 },
  { 6479, 22, 35, 22, 0, -24 },
  { 6576, 17, 24, 21, 2, -24 },
  { 6627, 14, 40, 17, 1, -33 },
  { 6697, 3, 46, 25, 11, -35 },
  { 6715, 13, 40, 17, 2, -33 },
  { 6780, 22, 5, 26, 2, -19 },
};

const GFXfont NotoSans_Light46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light46pt7bBitmaps,
  (GFXglyph *)NotoSans_Light46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_LIGHT46PT7B_H_
