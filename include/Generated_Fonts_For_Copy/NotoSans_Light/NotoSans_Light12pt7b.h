#ifndef _NOTOSANS_LIGHT12PT7B_H_
#define _NOTOSANS_LIGHT12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light12pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0x80, 0xB6, 0xD0, 0x14, 0x28, 0x93, 0xF2, 0x44, 0xBE, 0x94,
  0x48, 0x27, 0xE9, 0x46, 0x1C, 0xA5, 0xF1, 0x00, 0x42, 0xA4, 0xA4, 0xA8,
  0xB7, 0x55, 0x29, 0x25, 0x47, 0x30, 0x92, 0x22, 0x86, 0x12, 0x62, 0xC2,
  0xFA, 0xF0, 0x29, 0x29, 0x22, 0x48, 0x80, 0x89, 0x12, 0x49, 0x2B, 0x00,
  0x21, 0x7C, 0xC9, 0x00, 0x21, 0x3E, 0x42, 0x10, 0x58, 0xE0, 0x80, 0x11,
  0x22, 0x24, 0x44, 0x80, 0x74, 0x63, 0x18, 0xC6, 0x31, 0x70, 0x2E, 0x92,
  0x49, 0x20, 0x74, 0x42, 0x11, 0x11, 0x10, 0xF8, 0x74, 0x42, 0x17, 0x04,
  0x21, 0xF0, 0x08, 0x10, 0x61, 0x44, 0x89, 0x3F, 0x84, 0x08, 0xFC, 0x21,
  0x0F, 0x04, 0x21, 0xF0, 0x3A, 0x21, 0x4D, 0xC6, 0x31, 0x70, 0xF8, 0x42,
  0x21, 0x10, 0x88, 0x40, 0x74, 0x63, 0x17, 0x46, 0x31, 0xF0, 0x74, 0x63,
  0x18, 0xBC, 0x21, 0xF0, 0x84, 0x40, 0x16, 0x1B, 0x20, 0xC1, 0x80, 0xF8,
  0x3E, 0x83, 0x82, 0x6C, 0x00, 0xF0, 0x42, 0x11, 0x11, 0x00, 0x60, 0x1C,
  0x31, 0xA0, 0x33, 0x9A, 0x4D, 0x26, 0x93, 0x36, 0x80, 0x3F, 0x00, 0x10,
  0x20, 0xA1, 0x42, 0x4F, 0x91, 0x41, 0x82, 0xF2, 0x28, 0x61, 0xFA, 0x18,
  0x61, 0xF8, 0x3D, 0x08, 0x20, 0x82, 0x08, 0x20, 0x7C, 0xF1, 0x1A, 0x14,
  0x18, 0x30, 0x60, 0xC2, 0xF8, 0xFC, 0x21, 0x0F, 0xC2, 0x10, 0xF8, 0xFC,
  0x21, 0x0F, 0xC2, 0x10, 0x80, 0x3E, 0x82, 0x04, 0x08, 0xD0, 0x60, 0xC1,
  0x7E, 0x86, 0x18, 0x61, 0xFE, 0x18, 0x61, 0x84, 0xEA, 0xAA, 0xC0, 0x24,
  0x92, 0x49, 0x27, 0x00, 0x86, 0x29, 0x28, 0xE2, 0x49, 0x22, 0x84, 0x84,
  0x21, 0x08, 0x42, 0x10, 0xF8, 0x81, 0xC1, 0xC3, 0xA3, 0xA5, 0xA5, 0x95,
  0x99, 0x89, 0x83, 0x87, 0x0D, 0x19, 0x32, 0x62, 0xC3, 0x86, 0x38, 0x8E,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x7C, 0xF4, 0x63, 0x18, 0xFA, 0x10, 0x80,
  0x38, 0x8E, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x7C, 0x10, 0x18, 0xF2, 0x28,
  0x62, 0x8B, 0xC8, 0xA2, 0x84, 0x74, 0x61, 0x06, 0x0C, 0x21, 0xF0, 0xFC,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC2, 0x78, 0x83, 0x05, 0x12, 0x24, 0x45, 0x0A, 0x14, 0x10, 0x84, 0x30,
  0x89, 0x31, 0x25, 0x24, 0xA4, 0xA5, 0x0C, 0x61, 0x8C, 0x21, 0x00, 0x84,
  0x89, 0x21, 0x41, 0x06, 0x12, 0x22, 0x86, 0x86, 0x14, 0x8A, 0x30, 0x41,
  0x04, 0x10, 0x7C, 0x10, 0x82, 0x10, 0x82, 0x10, 0xFC, 0xF2, 0x49, 0x24,
  0x93, 0x80, 0x88, 0x44, 0x42, 0x21, 0x10, 0xE4, 0x92, 0x49, 0x27, 0x80,
  0x10, 0xC2, 0x92, 0x46, 0x10, 0xF8, 0xC4, 0xF1, 0x79, 0x9F, 0x82, 0x0B,
  0x32, 0x8A, 0x18, 0x62, 0xF8, 0x3C, 0x88, 0x88, 0x70, 0x08, 0x5B, 0x38,
  0xC6, 0x31, 0x78, 0x64, 0xE3, 0xF8, 0x41, 0xE0, 0x34, 0xF4, 0x44, 0x44,
  0x40, 0x64, 0xE3, 0x18, 0xC5, 0xE1, 0x0F, 0x80, 0x84, 0x2D, 0x98, 0xC6,
  0x31, 0x88, 0x9F, 0x80, 0x20, 0x12, 0x49, 0x24, 0xE0, 0x84, 0x23, 0x2A,
  0x62, 0x92, 0x88, 0xFF, 0x80, 0x33, 0x66, 0x62, 0x31, 0x18, 0x8C, 0x46,
  0x22, 0x36, 0x63, 0x18, 0xC6, 0x20, 0x36, 0x63, 0x18, 0xC5, 0xC0, 0x33,
  0x28, 0x61, 0x86, 0x2F, 0xA0, 0x82, 0x00, 0x64, 0xE3, 0x18, 0xC5, 0xE1,
  0x08, 0x40, 0xF8, 0x88, 0x88, 0x69, 0x8E, 0x11, 0xF0, 0x4F, 0x44, 0x44,
  0x47, 0x8C, 0x63, 0x18, 0xFC, 0x8D, 0x24, 0x94, 0x30, 0x80, 0x88, 0xAA,
  0x95, 0x4A, 0xA6, 0x21, 0x10, 0xCC, 0xC3, 0x0C, 0x4B, 0x10, 0x8D, 0x24,
  0x94, 0x30, 0x82, 0x08, 0xC0, 0x78, 0x88, 0x44, 0x7C, 0x12, 0x22, 0x2C,
  0x42, 0x22, 0x30, 0xFF, 0xF0, 0xC2, 0x22, 0x21, 0x22, 0x22, 0xC0, 0xF8,
};

const GFXglyph NotoSans_Light12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 9, 3, 1, -9 },
  { 3, 3, 4, 4, 1, -9 },
  { 5, 7, 9, 8, 0, -9 },
  { 13, 5, 10, 7, 1, -9 },
  { 20, 8, 9, 10, 1, -9 },
  { 29, 7, 9, 9, 1, -9 },
  { 37, 1, 4, 2, 1, -9 },
  { 38, 3, 11, 3, 0, -9 },
  { 43, 3, 11, 3, 0, -9 },
  { 48, 5, 5, 7, 1, -9 },
  { 52, 5, 6, 7, 1, -7 },
  { 56, 2, 3, 3, 0, -1 },
  { 57, 3, 1, 4, 0, -4 },
  { 58, 1, 1, 3, 1, -1 },
  { 59, 4, 9, 4, 0, -9 },
  { 64, 5, 9, 7, 1, -9 },
  { 70, 3, 9, 7, 1, -9 },
  { 74, 5, 9, 7, 1, -9 },
  { 80, 5, 9, 7, 1, -9 },
  { 86, 7, 9, 7, 0, -9 },
  { 94, 5, 9, 7, 1, -9 },
  { 100, 5, 9, 7, 1, -9 },
  { 106, 5, 9, 7, 1, -9 },
  { 112, 5, 9, 7, 1, -9 },
  { 118, 5, 9, 7, 1, -9 },
  { 124, 1, 6, 3, 1, -6 },
  { 125, 2, 8, 3, 0, -6 },
  { 127, 5, 5, 7, 1, -7 },
  { 131, 5, 3, 7, 1, -6 },
  { 133, 5, 5, 7, 1, -7 },
  { 137, 5, 9, 5, 0, -9 },
  { 143, 9, 10, 11, 1, -9 },
  { 155, 7, 9, 7, 0, -9 },
  { 163, 6, 9, 8, 1, -9 },
  { 170, 6, 9, 7, 1, -9 },
  { 177, 7, 9, 9, 1, -9 },
  { 185, 5, 9, 7, 1, -9 },
  { 191, 5, 9, 6, 1, -9 },
  { 197, 7, 9, 9, 1, -9 },
  { 205, 6, 9, 9, 1, -9 },
  { 212, 2, 9, 4, 1, -9 },
  { 215, 3, 11, 3, -1, -9 },
  { 220, 6, 9, 7, 1, -9 },
  { 227, 5, 9, 6, 1, -9 },
  { 233, 8, 9, 10, 1, -9 },
  { 242, 7, 9, 9, 1, -9 },
  { 250, 7, 9, 9, 1, -9 },
  { 258, 5, 9, 7, 1, -9 },
  { 264, 7, 11, 9, 1, -9 },
  { 274, 6, 9, 7, 1, -9 },
  { 281, 5, 9, 7, 1, -9 },
  { 287, 6, 9, 6, 0, -9 },
  { 294, 7, 9, 9, 1, -9 },
  { 302, 7, 9, 7, 0, -9 },
  { 310, 11, 9, 11, 0, -9 },
  { 323, 7, 9, 7, 0, -9 },
  { 331, 6, 9, 6, 0, -9 },
  { 338, 6, 9, 7, 0, -9 },
  { 345, 3, 11, 4, 1, -9 },
  { 350, 4, 9, 4, 0, -9 },
  { 355, 3, 11, 4, 0, -9 },
  { 360, 6, 6, 7, 0, -9 },
  { 365, 5, 1, 5, 0, 1 },
  { 366, 3, 2, 3, 0, -9 },
  { 367, 4, 6, 6, 1, -6 },
  { 370, 6, 9, 7, 1, -9 },
  { 377, 4, 7, 6, 1, -7 },
  { 381, 5, 9, 7, 1, -9 },
  { 387, 5, 7, 7, 1, -7 },
  { 392, 4, 9, 4, 0, -9 },
  { 397, 5, 10, 7, 1, -7 },
  { 404, 5, 9, 7, 1, -9 },
  { 410, 1, 9, 3, 1, -9 },
  { 412, 3, 12, 3, -1, -9 },
  { 417, 5, 9, 6, 1, -9 },
  { 423, 1, 9, 3, 1, -9 },
  { 425, 9, 7, 11, 1, -7 },
  { 433, 5, 7, 7, 1, -7 },
  { 438, 5, 7, 7, 1, -7 },
  { 443, 6, 10, 7, 1, -7 },
  { 451, 5, 10, 7, 1, -7 },
  { 458, 4, 6, 5, 1, -6 },
  { 461, 4, 7, 6, 1, -7 },
  { 465, 4, 8, 4, 0, -8 },
  { 469, 5, 6, 7, 1, -6 },
  { 473, 6, 6, 6, 0, -6 },
  { 478, 9, 6, 9, 0, -6 },
  { 485, 6, 6, 6, 0, -6 },
  { 490, 6, 9, 6, 0, -6 },
  { 497, 5, 6, 6, 0, -6 },
  { 501, 4, 11, 4, 0, -9 },
  { 507, 1, 12, 7, 3, -9 },
  { 509, 4, 11, 4, 0, -9 },
  { 515, 5, 1, 7, 1, -5 },
};

const GFXfont NotoSans_Light12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light12pt7bBitmaps,
  (GFXglyph *)NotoSans_Light12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_LIGHT12PT7B_H_
