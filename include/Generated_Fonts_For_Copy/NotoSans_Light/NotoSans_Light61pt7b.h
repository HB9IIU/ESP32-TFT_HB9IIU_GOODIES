#ifndef _NOTOSANS_LIGHT61PT7B_H_
#define _NOTOSANS_LIGHT61PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light61pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xDE, 0xF7, 0xBD, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x70, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xF6, 0x00, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x01, 0xDC, 0x07, 0x70, 0x1D, 0xC0, 0x77,
  0x01, 0xD8, 0x07, 0x60, 0x19, 0x80, 0x66, 0x01, 0x98, 0x06, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x03, 0x80, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x70, 0x03,
  0x80, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x30, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x06,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x1C, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x1C,
  0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x03, 0x80,
  0x1C, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00,
  0x70, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0xFE, 0x71, 0xFC, 0x3C, 0x1C, 0x07, 0x1E, 0x07, 0x00,
  0x0F, 0x01, 0xC0, 0x03, 0xC0, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x07,
  0x00, 0x0E, 0x01, 0xC0, 0x03, 0x80, 0x70, 0x00, 0xF0, 0x1C, 0x00, 0x3C,
  0x07, 0x00, 0x07, 0x81, 0xC0, 0x01, 0xF0, 0x70, 0x00, 0x3F, 0x1C, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xDF, 0xE0, 0x00, 0x70, 0xFC, 0x00,
  0x1C, 0x0F, 0x80, 0x07, 0x01, 0xE0, 0x01, 0xC0, 0x3C, 0x00, 0x70, 0x0F,
  0x00, 0x1C, 0x03, 0xC0, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x1C, 0x00, 0x70,
  0x0F, 0x00, 0x1C, 0x03, 0xC0, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0x7B, 0x00,
  0x70, 0x7C, 0xFC, 0x1C, 0x7E, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xE0, 0x03, 0x80, 0x70, 0x00,
  0x38, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x1C, 0x00, 0x78, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x1E,
  0x00, 0x70, 0x03, 0x80, 0x03, 0x80, 0x0F, 0x00, 0x70, 0x00, 0x70, 0x00,
  0xE0, 0x1C, 0x00, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x80,
  0xE0, 0x00, 0x38, 0x00, 0x70, 0x3C, 0x00, 0x07, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0xE0, 0x03, 0xC1, 0xE0, 0x00, 0x0E, 0x00, 0x70, 0x38, 0x1F, 0x01,
  0xC0, 0x0E, 0x0E, 0x0F, 0xF8, 0x38, 0x01, 0xC1, 0xC3, 0xFF, 0x87, 0x00,
  0x38, 0x70, 0xF0, 0x78, 0xF0, 0x0E, 0x0E, 0x1C, 0x07, 0x0E, 0x01, 0xC3,
  0x87, 0x00, 0x71, 0xE0, 0x78, 0xF0, 0xE0, 0x0E, 0x1F, 0xFE, 0x1C, 0x1C,
  0x01, 0xE1, 0xFF, 0x87, 0x87, 0x00, 0x1C, 0x0F, 0xC0, 0xE0, 0xE0, 0x03,
  0x80, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x00, 0x07, 0x03, 0x80, 0x0E, 0x00,
  0x01, 0xC0, 0x70, 0x01, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x00, 0x0E,
  0x01, 0xC0, 0x07, 0x00, 0x03, 0xC0, 0x38, 0x00, 0xE0, 0x00, 0x70, 0x07,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0xE0, 0x03, 0x80, 0x03, 0x80, 0x1C, 0x00,
  0x70, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x03, 0xC0,
  0x07, 0x00, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x38,
  0x00, 0x0E, 0x03, 0x80, 0x0F, 0x00, 0x01, 0xF1, 0xF0, 0x01, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x78, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x01, 0xF0,
  0x00, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x00,
  0x01, 0xE7, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x01, 0xFB, 0xE0, 0x00, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3C, 0x1F, 0x03,
  0xE0, 0x00, 0x70, 0x7C, 0x03, 0xE0, 0x00, 0xE1, 0xF0, 0x03, 0xE0, 0x03,
  0xC3, 0xC0, 0x03, 0xE0, 0x07, 0x0F, 0x00, 0x03, 0xE0, 0x1E, 0x1E, 0x00,
  0x03, 0xE0, 0x3C, 0x38, 0x00, 0x03, 0xE0, 0xF0, 0x70, 0x00, 0x03, 0xE1,
  0xE0, 0xE0, 0x00, 0x03, 0xE7, 0x81, 0xC0, 0x00, 0x03, 0xFE, 0x03, 0x80,
  0x00, 0x03, 0xFC, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x0F, 0x00, 0x00, 0x03,
  0xE0, 0x1E, 0x00, 0x00, 0x1F, 0xE0, 0x1E, 0x00, 0x00, 0x7D, 0xE0, 0x3E,
  0x00, 0x03, 0xF1, 0xE0, 0x3F, 0x00, 0x1F, 0xC1, 0xE0, 0x3F, 0xFF, 0xFE,
  0x03, 0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0xE0, 0x0F, 0xFF, 0x80, 0x03, 0xF0,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF7, 0x77, 0x76, 0x66,
  0x66, 0x00, 0x78, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1E,
  0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x3C,
  0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78,
  0x01, 0xC0, 0x0F, 0x00, 0x3C, 0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C,
  0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x78, 0x03, 0x80, 0x3C, 0x01,
  0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x07,
  0x80, 0x78, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x70,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x40, 0x0E, 0x00, 0x6F, 0x01, 0xC0, 0x7F,
  0xFC, 0x38, 0x7F, 0xFF, 0xFB, 0x7F, 0xF0, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x3B, 0xC0, 0x00,
  0x0E, 0x38, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x70, 0x78, 0x00, 0x1E, 0x07,
  0x80, 0x07, 0x80, 0xF0, 0x01, 0xF0, 0x0F, 0x00, 0x7C, 0x00, 0xF0, 0x03,
  0x00, 0x1C, 0x00, 0x20, 0x02, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C,
  0x38, 0x38, 0x38, 0x70, 0x70, 0x70, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xB0, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x0F,
  0x00, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x3C, 0x3C,
  0x00, 0x01, 0xC3, 0xC0, 0x00, 0x1E, 0x38, 0x00, 0x00, 0xE7, 0x80, 0x00,
  0x0E, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x07, 0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x1E, 0x1C, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x80,
  0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x3F, 0xDF, 0xE0, 0x01, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x7C, 0x01, 0xF8, 0x07, 0xF0, 0x3F, 0xE0, 0xFB, 0xC3, 0xE7, 0x9F, 0x0F,
  0x7C, 0x1F, 0xF0, 0x3D, 0x80, 0x7A, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x7E, 0x00,
  0x1F, 0x03, 0x80, 0x00, 0xF8, 0x10, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x80, 0x1F, 0xFF, 0xFE, 0x07, 0xF8, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0x87,
  0x00, 0x00, 0x78, 0x20, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xCC, 0x00,
  0x00, 0xF8, 0xF0, 0x00, 0x1F, 0x0F, 0xFE, 0x7F, 0xE0, 0x7F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3A, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0x00, 0x03, 0xC0, 0x07, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0xF0, 0x07,
  0x80, 0x00, 0x78, 0x03, 0x80, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x1E, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x1F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x30, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE6, 0x00, 0x00,
  0xF8, 0xF0, 0x00, 0x7E, 0x1F, 0xF9, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xC0, 0x08, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x01, 0xFE, 0x00, 0xF0, 0xFF, 0xFC,
  0x0E, 0x1F, 0xFF, 0xE0, 0xE7, 0xC0, 0x1F, 0x0E, 0xF0, 0x00, 0x78, 0xEE,
  0x00, 0x03, 0xCF, 0xC0, 0x00, 0x3C, 0xF8, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x70, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x1E,
  0x3C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x78, 0x0F, 0xC0, 0x1F, 0x00, 0x3F, 0xDF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xFC,
  0x01, 0xF0, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x01,
  0xC3, 0xC0, 0x00, 0x1E, 0x38, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x1E, 0x38,
  0x00, 0x01, 0xE3, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x1C, 0x1E, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x78, 0x0F, 0x80, 0x0F, 0x00,
  0x7C, 0x03, 0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3E, 0x07, 0xE0,
  0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x1E, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x0F, 0x70, 0x00, 0x00,
  0xF7, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x0E, 0x3C, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x80,
  0xFF, 0x07, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x78, 0x3C,
  0x00, 0x07, 0x87, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x1E, 0x70, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1F,
  0x78, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x37, 0x3E, 0x00, 0x0F, 0x71, 0xF0,
  0x01, 0xE7, 0x0F, 0xF3, 0xFC, 0xF0, 0x7F, 0xFF, 0x0F, 0x01, 0xFF, 0xC0,
  0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF8, 0x01, 0xE1, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x77, 0xFF, 0xFF, 0xB8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFB, 0x00, 0x0E, 0x1F, 0x1F, 0x1F, 0x1F, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x3C,
  0x38, 0x78, 0x70, 0x70, 0x70, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x3E, 0x00, 0xFC, 0xC0,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x9F, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x07, 0xFF, 0x80, 0x1C, 0x1C, 0x00,
  0x1F, 0xFF, 0xC0, 0x0E, 0x3C, 0x00, 0x7F, 0x9F, 0xC0, 0x0E, 0x38, 0x00,
  0xF8, 0x01, 0xC0, 0x0E, 0x38, 0x01, 0xF0, 0x01, 0xC0, 0x0E, 0x70, 0x01,
  0xE0, 0x01, 0xC0, 0x07, 0x70, 0x03, 0xC0, 0x01, 0xC0, 0x07, 0x70, 0x03,
  0x80, 0x01, 0xC0, 0x07, 0x70, 0x07, 0x80, 0x01, 0xC0, 0x07, 0x70, 0x07,
  0x00, 0x01, 0xC0, 0x07, 0xF0, 0x07, 0x00, 0x01, 0xC0, 0x07, 0xE0, 0x07,
  0x00, 0x01, 0xC0, 0x07, 0xE0, 0x07, 0x00, 0x01, 0xC0, 0x07, 0xE0, 0x07,
  0x00, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0x00, 0x03, 0xC0, 0x0E, 0xE0, 0x07,
  0x00, 0x03, 0xC0, 0x0E, 0xF0, 0x07, 0x00, 0x03, 0xC0, 0x0E, 0x70, 0x07,
  0x80, 0x07, 0xC0, 0x1E, 0x70, 0x03, 0x80, 0x07, 0xC0, 0x1C, 0x70, 0x03,
  0xC0, 0x0E, 0xC0, 0x3C, 0x70, 0x01, 0xE0, 0x1C, 0xE0, 0x78, 0x70, 0x01,
  0xF8, 0x78, 0xF9, 0xF0, 0x38, 0x00, 0xFF, 0xF0, 0x7F, 0xE0, 0x38, 0x00,
  0x3F, 0xE0, 0x3F, 0xC0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x00,
  0x03, 0x8F, 0x00, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x01, 0xE1, 0xC0,
  0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x38, 0x00,
  0x00, 0x1C, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0x00, 0xE0, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x3C, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00,
  0x3C, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x07, 0x87, 0x00,
  0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x07,
  0x9C, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0x0F, 0x00, 0x01, 0xFC, 0x78, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xC7,
  0x80, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xE1, 0xE0, 0x01, 0xFC, 0x0F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x1E, 0x00, 0x03,
  0xF8, 0xF0, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0xFC, 0xF0,
  0x00, 0x3F, 0xC7, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x06, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0E, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x38, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x00, 0x1F, 0xC0, 0x3C,
  0x00, 0x01, 0xFC, 0x0F, 0x00, 0x00, 0x1F, 0x83, 0xC0, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x01, 0xCF, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x00, 0x3B, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xBC, 0x00, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x00, 0x73, 0xC0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x7E, 0x0F, 0x00, 0x00, 0x3F, 0x03,
  0xC0, 0x00, 0x3F, 0x80, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xC0, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x1C, 0x07, 0xE0, 0x00, 0x00, 0x81,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x00,
  0x3B, 0xC0, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x00, 0xE7, 0x80, 0x00,
  0x00, 0x1C, 0xF8, 0x00, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x00, 0x71, 0xF0,
  0x00, 0x00, 0x0E, 0x1F, 0x00, 0x00, 0x01, 0xC1, 0xF0, 0x00, 0x00, 0x38,
  0x1F, 0x80, 0x00, 0x07, 0x01, 0xFE, 0x00, 0x03, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x01, 0xFF, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE4, 0x0F, 0x8F,
  0xFF, 0x1F, 0xF8, 0x3F, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07,
  0xC3, 0xC0, 0x00, 0x3E, 0x0F, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x0F, 0x80,
  0xF0, 0x00, 0x7C, 0x03, 0xC0, 0x03, 0xE0, 0x0F, 0x00, 0x1F, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0xF3, 0xF8, 0x00,
  0x03, 0xDF, 0xF0, 0x00, 0x0F, 0xF3, 0xC0, 0x00, 0x3F, 0x87, 0x80, 0x00,
  0xFC, 0x1F, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x7C, 0x03, 0xC0, 0x00,
  0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF8,
  0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x70, 0x00, 0x00, 0x01, 0xDF, 0xBC, 0x00,
  0x00, 0x01, 0xEF, 0xCE, 0x00, 0x00, 0x00, 0xE7, 0xE7, 0x80, 0x00, 0x00,
  0x73, 0xF3, 0xC0, 0x00, 0x00, 0x79, 0xF8, 0xE0, 0x00, 0x00, 0x38, 0xFC,
  0x78, 0x00, 0x00, 0x3C, 0x7E, 0x1C, 0x00, 0x00, 0x1C, 0x3F, 0x0F, 0x00,
  0x00, 0x0E, 0x1F, 0x87, 0x80, 0x00, 0x0F, 0x0F, 0xC1, 0xC0, 0x00, 0x07,
  0x07, 0xE0, 0xF0, 0x00, 0x07, 0x83, 0xF0, 0x38, 0x00, 0x03, 0x81, 0xF8,
  0x1E, 0x00, 0x01, 0xC0, 0xFC, 0x0F, 0x00, 0x01, 0xE0, 0x7E, 0x03, 0x80,
  0x00, 0xE0, 0x3F, 0x01, 0xE0, 0x00, 0xF0, 0x1F, 0x80, 0x70, 0x00, 0x70,
  0x0F, 0xC0, 0x3C, 0x00, 0x38, 0x07, 0xE0, 0x1E, 0x00, 0x3C, 0x03, 0xF0,
  0x07, 0x00, 0x1C, 0x01, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xFC, 0x00, 0xE0,
  0x0E, 0x00, 0x7E, 0x00, 0x78, 0x07, 0x00, 0x3F, 0x00, 0x3C, 0x07, 0x80,
  0x1F, 0x80, 0x0E, 0x03, 0x80, 0x0F, 0xC0, 0x07, 0x83, 0xC0, 0x07, 0xE0,
  0x03, 0xC1, 0xC0, 0x03, 0xF0, 0x00, 0xE0, 0xE0, 0x01, 0xF8, 0x00, 0x78,
  0xF0, 0x00, 0xFC, 0x00, 0x1C, 0x70, 0x00, 0x7E, 0x00, 0x0F, 0x78, 0x00,
  0x3F, 0x00, 0x07, 0xB8, 0x00, 0x1F, 0x80, 0x01, 0xDC, 0x00, 0x0F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0x80, 0x00,
  0x70, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xEF, 0x00, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x07, 0xE7, 0x80, 0x00,
  0x07, 0xE3, 0xC0, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x07, 0xE1, 0xE0, 0x00,
  0x07, 0xE0, 0xF0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x07, 0xE0, 0x78, 0x00,
  0x07, 0xE0, 0x3C, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x07, 0xE0, 0x1E, 0x00,
  0x07, 0xE0, 0x0F, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x07, 0xE0, 0x07, 0x80,
  0x07, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x01, 0xE0,
  0x07, 0xE0, 0x00, 0xF0, 0x07, 0xE0, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x78,
  0x07, 0xE0, 0x00, 0x3C, 0x07, 0xE0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x1E,
  0x07, 0xE0, 0x00, 0x0F, 0x07, 0xE0, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x07,
  0x87, 0xE0, 0x00, 0x03, 0xC7, 0xE0, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x01,
  0xE7, 0xE0, 0x00, 0x00, 0xF7, 0xE0, 0x00, 0x00, 0xF7, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x00, 0x01, 0xE1, 0xC0, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x00, 0x38, 0x78, 0x00, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x00, 0x1E, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x0F, 0x00, 0x07, 0xF1, 0xE0, 0x00, 0x3F, 0x3C, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x07, 0x78, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0E, 0xF0, 0x00, 0x01, 0xDE, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF9,
  0xE0, 0x00, 0x7E, 0x3C, 0x00, 0x3F, 0x87, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x07,
  0xF8, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x01, 0xE1,
  0xC0, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x00, 0x07, 0x9C, 0x00, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00, 0x0E,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00,
  0x0F, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x00, 0x38, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00,
  0x07, 0x81, 0xF0, 0x00, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0x00, 0x03, 0xF0,
  0x78, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E, 0x3C,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xF0, 0x78, 0x00,
  0x3F, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07,
  0xC1, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x07, 0xE0, 0x0F, 0xE1,
  0xF0, 0x00, 0x18, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF4, 0x00, 0x00,
  0x7C, 0xF8, 0x00, 0x3F, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3C, 0x3E, 0x00,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1E, 0x70,
  0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x07, 0x81, 0xC0, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0xF0, 0x0E,
  0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x00,
  0x38, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00,
  0x0F, 0x1E, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x07, 0x9C, 0x00,
  0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x7B, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0x9E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x70,
  0xF0, 0x00, 0x07, 0x70, 0x00, 0x07, 0x87, 0x80, 0x00, 0x7B, 0x80, 0x00,
  0x3C, 0x1C, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1C, 0xF0,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0xE3, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x0F,
  0x1C, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x70, 0xF0, 0x00, 0x38, 0x07, 0x80,
  0x03, 0x83, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x1C, 0x1C, 0x00, 0x1E, 0x01,
  0xE0, 0x01, 0xE0, 0xE0, 0x00, 0xE0, 0x07, 0x00, 0x0E, 0x07, 0x80, 0x07,
  0x00, 0x3C, 0x00, 0x70, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x38, 0x07, 0x80, 0x1C, 0x00, 0x38, 0x01, 0xC0,
  0x1C, 0x01, 0xE0, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x0F, 0x00,
  0xF0, 0x07, 0x00, 0x78, 0x00, 0x38, 0x07, 0x00, 0x3C, 0x03, 0x80, 0x01,
  0xC0, 0x38, 0x00, 0xE0, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x07, 0x01, 0xE0,
  0x00, 0x78, 0x1C, 0x00, 0x3C, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0xE0,
  0x70, 0x00, 0x0F, 0x07, 0x00, 0x07, 0x07, 0x80, 0x00, 0x78, 0x78, 0x00,
  0x3C, 0x3C, 0x00, 0x03, 0xC3, 0x80, 0x01, 0xE1, 0xC0, 0x00, 0x0E, 0x1C,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x38, 0xF0, 0x00, 0x03,
  0xCF, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x03, 0xBC, 0x00, 0x01, 0xDE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03,
  0xC0, 0x1E, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x01, 0xE0, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0xF0,
  0x38, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x07,
  0x9C, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x03, 0xC0, 0xE0, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x01, 0xE0, 0x0F, 0x00,
  0x01, 0xE0, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x07, 0x80, 0x78, 0x00, 0x03,
  0xC0, 0x38, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x1E, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x70, 0x0F, 0x00,
  0x00, 0x3C, 0x07, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x07, 0x83, 0x80,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38,
  0x0E, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0xE0, 0x0E,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x07, 0x00,
  0x78, 0x00, 0x38, 0x03, 0x80, 0x00, 0xE0, 0x3C, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x1C, 0x1E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0x8F, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x00, 0x77, 0x80, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x0E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xE0,
  0x07, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xF0,
  0x0F, 0xC0, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0xFE,
  0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x8F, 0xE0, 0x03, 0xCF, 0x80, 0x01,
  0xEF, 0x80, 0x00, 0xF7, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xF7, 0x80, 0x03, 0xBB, 0xE0, 0x07, 0x9C, 0xFE,
  0x1F, 0x8E, 0x3F, 0xFF, 0x87, 0x0F, 0xFF, 0x03, 0x80, 0x30, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x01, 0xFE,
  0x00, 0xF0, 0xFF, 0xF8, 0x0F, 0x1F, 0xFF, 0xE0, 0xF3, 0xC0, 0x3F, 0x0F,
  0x70, 0x00, 0xF8, 0xFE, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x3C, 0xFC, 0x00,
  0x01, 0xEF, 0x80, 0x00, 0x1E, 0xF8, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0E,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xEF, 0x80, 0x00,
  0x1E, 0xF8, 0x00, 0x01, 0xEF, 0xC0, 0x00, 0x3C, 0xFC, 0x00, 0x07, 0xCF,
  0xE0, 0x00, 0xF8, 0xE7, 0x80, 0x1F, 0x0E, 0x3F, 0x9F, 0xE0, 0xE1, 0xFF,
  0xFC, 0x0E, 0x07, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xF0, 0x0F, 0x07, 0xC0, 0x01,
  0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x03, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFC,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x03, 0xFC, 0x07, 0x00, 0xFF, 0xF8, 0x70, 0x3F, 0xFF, 0xC7, 0x07,
  0xE0, 0x3E, 0x70, 0xF8, 0x00, 0xF7, 0x1F, 0x00, 0x03, 0x71, 0xE0, 0x00,
  0x3F, 0x3C, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x1F, 0x78, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x07, 0x70, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x1F, 0x1E,
  0x00, 0x03, 0xF1, 0xF0, 0x00, 0x77, 0x0F, 0x80, 0x0E, 0x70, 0x7F, 0x8F,
  0xC7, 0x03, 0xFF, 0xF8, 0x70, 0x0F, 0xFF, 0x07, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xF0,
  0x1F, 0x80, 0xF8, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF1,
  0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x3D, 0xE0, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xDF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x04, 0x0F, 0x80, 0x03, 0x80, 0xFF, 0x9F, 0xF0, 0x0F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x01, 0xFF,
  0xC0, 0x1F, 0xFE, 0x01, 0xF8, 0x70, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x1F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x80, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0x87, 0x03, 0xFF, 0xFC, 0x70, 0x7E, 0x01,
  0xE7, 0x0F, 0x80, 0x07, 0x71, 0xF0, 0x00, 0x3F, 0x1E, 0x00, 0x01, 0xF3,
  0xC0, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1F, 0x3C, 0x00, 0x01, 0xF1, 0xE0, 0x00,
  0x3F, 0x1F, 0x00, 0x07, 0x70, 0xF8, 0x00, 0xE7, 0x07, 0xF8, 0xFC, 0x70,
  0x3F, 0xFF, 0x87, 0x00, 0xFF, 0xF0, 0x70, 0x00, 0x60, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3E, 0x10, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0xF8, 0x1F, 0xF0, 0x7F,
  0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x07, 0xF8, 0x0F, 0x0F, 0xFF, 0xC3,
  0xC7, 0xFF, 0xF8, 0xF3, 0xC0, 0x3F, 0x3D, 0xC0, 0x03, 0xEF, 0xE0, 0x00,
  0x7B, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x70, 0xF7, 0xBF, 0xE6, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B,
  0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xE0, 0x00, 0xF0, 0x07,
  0x80, 0x3E, 0x01, 0xE0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x70, 0x07, 0x98, 0xF8, 0xFF, 0xC7, 0xFC, 0x0E, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x0B, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x78, 0xF0,
  0x00, 0x78, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x0F,
  0x00, 0x7C, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x3C, 0x00,
  0xF0, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x3C, 0x00,
  0x0F, 0x3F, 0x00, 0x07, 0xBF, 0xC0, 0x03, 0xFD, 0xE0, 0x01, 0xFC, 0x78,
  0x00, 0xFC, 0x1E, 0x00, 0x7C, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0x81, 0xE0,
  0x01, 0xE0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3E, 0x3C, 0x00, 0x0F, 0x1E,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x7C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x07, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x38, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF1, 0xCF, 0x80, 0xF8, 0xF8, 0x0F, 0xCF, 0x70, 0x03, 0xEF, 0x00, 0x1E,
  0x7F, 0x00, 0x0F, 0x70, 0x00, 0x7B, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xDF,
  0x00, 0x01, 0xF0, 0x00, 0x0E, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x77, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xBC, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x38, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x70, 0x00, 0x07, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x38, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x70, 0x00, 0x07, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x1F, 0xE0, 0x38, 0x3F, 0xFF, 0x0E, 0x1F, 0xFF, 0xE3,
  0x8F, 0x00, 0xFC, 0xF7, 0x00, 0x0F, 0xBF, 0x80, 0x01, 0xEF, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x3C, 0x00, 0x0F,
  0x81, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0,
  0xE0, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1E, 0x70,
  0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x03, 0xBC, 0x00,
  0x00, 0x0E, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x70,
  0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x0F,
  0x00, 0x03, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x0E, 0x0F, 0xFF, 0xC0, 0xE1, 0xFF, 0xFE, 0x0E, 0x3E, 0x03, 0xF0,
  0xF7, 0x00, 0x0F, 0x8F, 0xE0, 0x00, 0x7C, 0xFC, 0x00, 0x03, 0xCF, 0xC0,
  0x00, 0x1E, 0xF8, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x0E, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1E, 0xF8, 0x00,
  0x01, 0xEF, 0x80, 0x00, 0x1E, 0xFC, 0x00, 0x03, 0xCF, 0xE0, 0x00, 0x7C,
  0xFF, 0x00, 0x0F, 0x8F, 0x78, 0x01, 0xF0, 0xF3, 0xF9, 0xFE, 0x0F, 0x1F,
  0xFF, 0xC0, 0xF0, 0x7F, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xFF, 0x87, 0x03, 0xFF, 0xFC, 0x70, 0x7E, 0x03, 0xE7, 0x0F, 0x80, 0x0F,
  0x71, 0xF0, 0x00, 0x37, 0x1E, 0x00, 0x03, 0xF3, 0xC0, 0x00, 0x1F, 0x3C,
  0x00, 0x01, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x0F, 0x70, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x1F, 0x3C, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x37, 0x1F, 0x00, 0x07,
  0x70, 0xF8, 0x01, 0xE7, 0x07, 0xF9, 0xFC, 0x70, 0x3F, 0xFF, 0x87, 0x00,
  0xFF, 0xE0, 0x70, 0x01, 0xD0, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x3F, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x8F,
  0x83, 0xF7, 0x80, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF1, 0xF0, 0x03, 0xC7, 0x80, 0x00, 0x8E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xE8, 0x00, 0x03, 0xDC, 0x00, 0x0F, 0x3F, 0x83, 0xFC,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xFE, 0x70, 0x1F,
  0xFC, 0x03, 0xFF, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xDC, 0x00, 0x03, 0xF7, 0x80, 0x00, 0xDD, 0xF0, 0x00,
  0x77, 0x3E, 0x00, 0x79, 0xC7, 0xF1, 0xFC, 0x70, 0xFF, 0xFE, 0x1C, 0x1F,
  0xFE, 0x07, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7B, 0x80, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0x38, 0x70, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x1E,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xC0, 0x0E, 0x00,
  0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x78,
  0x00, 0x78, 0x03, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x0E, 0x01, 0xE0, 0x00,
  0x78, 0x0E, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78,
  0x38, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x01, 0xCF, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xE0, 0x00,
  0x3D, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x3C, 0x00, 0x0F, 0xC0, 0x01, 0xE7,
  0x80, 0x03, 0xB8, 0x00, 0x3C, 0x70, 0x00, 0x77, 0x00, 0x07, 0x0E, 0x00,
  0x0E, 0xF0, 0x00, 0xE1, 0xE0, 0x03, 0xCE, 0x00, 0x3C, 0x3C, 0x00, 0x71,
  0xC0, 0x07, 0x83, 0x80, 0x0E, 0x3C, 0x00, 0xE0, 0x70, 0x03, 0xC3, 0x80,
  0x1C, 0x0F, 0x00, 0x70, 0x70, 0x07, 0x80, 0xE0, 0x0E, 0x0F, 0x00, 0xF0,
  0x1C, 0x03, 0xC0, 0xE0, 0x1C, 0x03, 0xC0, 0x70, 0x1C, 0x03, 0x80, 0x78,
  0x0E, 0x03, 0xC0, 0xF0, 0x07, 0x03, 0xC0, 0x38, 0x1C, 0x00, 0xE0, 0x70,
  0x07, 0x03, 0x80, 0x1E, 0x0E, 0x00, 0xE0, 0xF0, 0x03, 0xC3, 0xC0, 0x1E,
  0x1E, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x38, 0x70,
  0x00, 0xF1, 0xC0, 0x07, 0x9E, 0x00, 0x0E, 0x78, 0x00, 0x73, 0xC0, 0x01,
  0xCE, 0x00, 0x0E, 0x70, 0x00, 0x39, 0xC0, 0x01, 0xEE, 0x00, 0x07, 0xF8,
  0x00, 0x1D, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x01, 0xF3, 0xC0, 0x00,
  0x3C, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x00,
  0x78, 0x01, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0x1C, 0x03, 0xC0, 0x01, 0xE0,
  0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0x3D, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x07, 0x8E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x01,
  0xE0, 0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x00,
  0xF0, 0x0F, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x3E, 0x78, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7B, 0x80, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x78, 0x0E, 0x00, 0x03, 0x80, 0x78, 0x00, 0x3C, 0x03, 0xC0,
  0x01, 0xC0, 0x0E, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x78, 0x00, 0x78, 0x03, 0xC0, 0x01, 0xC0, 0x1C, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x78, 0x0E, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x0F, 0x1E,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x01, 0x07, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0xC0, 0x03, 0xF0, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x0F, 0x80, 0x3F, 0xC0, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F,
  0xC0, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xC0, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x1F, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0xFC,
  0x00, 0x38, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x09, 0xFF, 0xE0, 0x00, 0xDF,
  0xFF, 0xC0, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0xFF, 0x40, 0x00,
  0xFF, 0xE2, 0x00, 0x00, 0x7C, 0x00,
};

const GFXglyph NotoSans_Light61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 5, 45, 15, 5, -44 },
  { 30, 14, 16, 22, 4, -44 },
  { 58, 36, 44, 39, 2, -44 },
  { 256, 26, 50, 35, 4, -46 },
  { 419, 43, 45, 50, 3, -44 },
  { 661, 39, 45, 44, 4, -44 },
  { 881, 4, 16, 12, 4, -44 },
  { 889, 13, 54, 17, 2, -44 },
  { 977, 12, 54, 17, 2, -44 },
  { 1058, 27, 26, 34, 3, -46 },
  { 1146, 29, 29, 35, 3, -36 },
  { 1252, 8, 15, 14, 2, -7 },
  { 1267, 15, 3, 20, 2, -18 },
  { 1273, 5, 6, 15, 5, -5 },
  { 1277, 20, 44, 21, 1, -44 },
  { 1387, 28, 45, 35, 3, -44 },
  { 1545, 15, 44, 35, 6, -44 },
  { 1628, 28, 44, 35, 3, -44 },
  { 1782, 28, 45, 35, 3, -44 },
  { 1940, 33, 44, 35, 1, -44 },
  { 2122, 27, 45, 35, 4, -44 },
  { 2274, 28, 45, 35, 4, -44 },
  { 2432, 29, 44, 35, 3, -44 },
  { 2592, 28, 45, 35, 3, -44 },
  { 2750, 28, 45, 35, 3, -44 },
  { 2908, 5, 34, 15, 5, -33 },
  { 2930, 8, 41, 15, 2, -33 },
  { 2971, 29, 28, 35, 3, -36 },
  { 3073, 28, 15, 35, 3, -29 },
  { 3126, 29, 28, 35, 3, -36 },
  { 3228, 22, 45, 26, 2, -44 },
  { 3352, 48, 49, 54, 3, -43 },
  { 3646, 37, 44, 37, 0, -44 },
  { 3850, 29, 44, 39, 6, -44 },
  { 4010, 32, 45, 38, 4, -44 },
  { 4190, 34, 44, 43, 6, -44 },
  { 4377, 24, 44, 34, 6, -44 },
  { 4509, 24, 44, 31, 6, -44 },
  { 4641, 35, 45, 44, 4, -44 },
  { 4838, 32, 44, 44, 6, -44 },
  { 5014, 13, 44, 19, 3, -44 },
  { 5086, 15, 55, 15, -5, -44 },
  { 5190, 30, 44, 36, 6, -44 },
  { 5355, 24, 44, 31, 6, -44 },
  { 5487, 41, 44, 53, 6, -44 },
  { 5713, 32, 44, 44, 6, -44 },
  { 5889, 39, 45, 47, 4, -44 },
  { 6109, 27, 44, 36, 6, -44 },
  { 6258, 39, 54, 47, 4, -44 },
  { 6522, 29, 44, 37, 6, -44 },
  { 6682, 27, 45, 33, 3, -44 },
  { 6834, 32, 44, 32, 0, -44 },
  { 7010, 32, 45, 44, 6, -44 },
  { 7190, 36, 44, 36, 0, -44 },
  { 7388, 53, 44, 55, 1, -44 },
  { 7680, 33, 44, 33, 0, -44 },
  { 7862, 33, 44, 33, 0, -44 },
  { 8044, 31, 44, 35, 2, -44 },
  { 8215, 13, 54, 20, 5, -44 },
  { 8303, 20, 44, 21, 1, -44 },
  { 8413, 12, 54, 20, 2, -44 },
  { 8494, 29, 27, 35, 3, -44 },
  { 8592, 26, 3, 26, 0, 5 },
  { 8602, 12, 10, 16, 2, -47 },
  { 8617, 25, 34, 33, 3, -33 },
  { 8724, 28, 47, 37, 5, -46 },
  { 8889, 24, 34, 29, 3, -33 },
  { 8991, 28, 47, 37, 3, -46 },
  { 9156, 27, 34, 34, 3, -33 },
  { 9271, 21, 47, 19, 1, -47 },
  { 9395, 28, 48, 37, 3, -33 },
  { 9563, 26, 46, 36, 5, -46 },
  { 9713, 5, 44, 14, 5, -44 },
  { 9741, 13, 59, 14, -3, -44 },
  { 9837, 25, 46, 30, 5, -46 },
  { 9981, 4, 46, 14, 5, -46 },
  { 10004, 45, 33, 55, 5, -33 },
  { 10190, 26, 33, 36, 5, -33 },
  { 10298, 30, 34, 36, 3, -33 },
  { 10426, 28, 47, 37, 5, -33 },
  { 10591, 28, 47, 37, 3, -33 },
  { 10756, 18, 33, 24, 5, -33 },
  { 10831, 23, 34, 29, 3, -33 },
  { 10929, 18, 41, 21, 1, -40 },
  { 11022, 26, 33, 36, 5, -32 },
  { 11130, 29, 32, 29, 0, -32 },
  { 11246, 43, 32, 45, 1, -32 },
  { 11418, 28, 32, 31, 1, -32 },
  { 11530, 29, 47, 29, 0, -32 },
  { 11701, 24, 32, 28, 2, -32 },
  { 11797, 18, 54, 22, 2, -44 },
  { 11919, 3, 61, 33, 15, -46 },
  { 11942, 18, 54, 22, 2, -44 },
  { 12064, 29, 7, 35, 3, -25 },
};

const GFXfont NotoSans_Light61pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light61pt7bBitmaps,
  (GFXglyph *)NotoSans_Light61pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _NOTOSANS_LIGHT61PT7B_H_
