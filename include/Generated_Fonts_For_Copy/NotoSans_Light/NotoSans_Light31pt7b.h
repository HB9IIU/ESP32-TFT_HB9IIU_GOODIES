#ifndef _NOTOSANS_LIGHT31PT7B_H_
#define _NOTOSANS_LIGHT31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light31pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x00, 0x2E, 0xC0, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0x70, 0xE1, 0x01, 0x02, 0x00, 0x41, 0x80, 0x30, 0x60,
  0x0C, 0x18, 0x03, 0x04, 0x00, 0x81, 0x00, 0x20, 0x41, 0xFF, 0xFF, 0x06,
  0x0C, 0x01, 0x82, 0x00, 0x40, 0x80, 0x10, 0x20, 0x04, 0x18, 0x03, 0x06,
  0x0F, 0xFF, 0xF8, 0x20, 0x40, 0x08, 0x10, 0x02, 0x0C, 0x01, 0x83, 0x00,
  0x60, 0x80, 0x18, 0x20, 0x04, 0x08, 0x00, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x3F, 0xE7, 0xA7, 0x71, 0x03, 0x08, 0x18, 0x40, 0xC2, 0x06, 0x10, 0x18,
  0x80, 0x74, 0x01, 0xF0, 0x01, 0xF0, 0x09, 0xC0, 0x43, 0x02, 0x18, 0x10,
  0xC0, 0x86, 0x04, 0x38, 0x23, 0x7F, 0xF9, 0xFF, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x7E, 0x00, 0xC1, 0x88, 0x06, 0x0C, 0x30, 0x30, 0x20, 0x40,
  0xC0, 0x81, 0x06, 0x02, 0x04, 0x10, 0x08, 0x18, 0xC0, 0x20, 0x42, 0x00,
  0x81, 0x18, 0x43, 0x04, 0x4F, 0xCC, 0x33, 0x21, 0x98, 0x99, 0x86, 0x3E,
  0x64, 0x08, 0x03, 0x10, 0x20, 0x08, 0x40, 0x80, 0x61, 0x03, 0x01, 0x04,
  0x08, 0x0C, 0x10, 0x20, 0x20, 0x60, 0x81, 0x81, 0x86, 0x0C, 0x03, 0x30,
  0x30, 0x07, 0x80, 0x0F, 0xE0, 0x01, 0x87, 0x00, 0x30, 0x30, 0x03, 0x01,
  0x00, 0x30, 0x18, 0x03, 0x03, 0x00, 0x10, 0x30, 0x01, 0x86, 0x00, 0x0D,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0x98, 0x06, 0x70, 0xC0, 0x4E,
  0x06, 0x0C, 0xC0, 0x30, 0xCC, 0x01, 0x98, 0xC0, 0x0D, 0x8C, 0x00, 0x70,
  0xC0, 0x07, 0x06, 0x01, 0xD8, 0x78, 0x78, 0xC1, 0xFE, 0x07, 0xFF, 0xFF,
  0x0E, 0x10, 0x61, 0x83, 0x04, 0x18, 0x30, 0x60, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC0, 0x81, 0x83, 0x06, 0x06, 0x0C, 0x08, 0x18, 0x18, 0x38,
  0xC1, 0x83, 0x0C, 0x18, 0x60, 0x83, 0x0C, 0x30, 0xC3, 0x04, 0x10, 0x43,
  0x0C, 0x30, 0xC3, 0x18, 0x61, 0x8C, 0x31, 0x8C, 0x00, 0x06, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x61, 0x0F, 0xFF, 0xE1, 0xF0, 0x05, 0x00,
  0x6C, 0x06, 0x30, 0x31, 0x83, 0x06, 0x08, 0x20, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x33, 0x26, 0x66,
  0x4C, 0xFF, 0x5D, 0x80, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x40,
  0x30, 0x0C, 0x06, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60,
  0x30, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x30, 0x00, 0x1F, 0xC0, 0xE1, 0xC6,
  0x03, 0x18, 0x06, 0x40, 0x1B, 0x00, 0x2C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x09, 0x00, 0x66, 0x01, 0x8C, 0x0C, 0x38, 0x60, 0x3F, 0x00, 0x06,
  0x1C, 0xEB, 0x9C, 0x30, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x3F, 0xC1, 0xC3, 0x8C, 0x03,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xF0,
  0xF0, 0x71, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x0C, 0x00, 0x38, 0x01, 0xE0, 0x3F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x01,
  0x80, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x34, 0x00, 0xEF,
  0x07, 0x8F, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x78, 0x00, 0x58, 0x00, 0xD8,
  0x01, 0x98, 0x01, 0x18, 0x03, 0x18, 0x06, 0x18, 0x0C, 0x18, 0x08, 0x18,
  0x18, 0x18, 0x30, 0x18, 0x20, 0x18, 0x60, 0x18, 0xC0, 0x18, 0xFF, 0xFF,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x3F, 0xF1, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0xFF, 0x86, 0x07, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0xA0, 0x0C, 0xF0,
  0xF1, 0xFF, 0x00, 0x07, 0xF8, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01,
  0x80, 0x04, 0x00, 0x30, 0x00, 0xC3, 0xC3, 0x7F, 0xCF, 0x03, 0xB8, 0x06,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0D, 0x00, 0x36, 0x01,
  0x8C, 0x06, 0x1C, 0x70, 0x3F, 0x80, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x80,
  0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00,
  0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x1F, 0xE0, 0xC1,
  0xC6, 0x01, 0x90, 0x06, 0xC0, 0x19, 0x00, 0x66, 0x01, 0x98, 0x0C, 0x38,
  0x60, 0x7F, 0x00, 0xF8, 0x07, 0x38, 0x70, 0x31, 0x80, 0x6C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xD8, 0x06, 0x70, 0x70, 0x7F, 0x80,
  0x1F, 0xC0, 0xC3, 0x86, 0x03, 0x30, 0x06, 0xC0, 0x1B, 0x00, 0x28, 0x00,
  0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xDC, 0x1B, 0x3F, 0xCC, 0x18,
  0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x41,
  0xC1, 0xFC, 0x00, 0x7D, 0x80, 0x00, 0x00, 0x00, 0x17, 0x60, 0x27, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x36, 0x66, 0x4C, 0xC0, 0x00, 0x04, 0x00,
  0x30, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x40,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x03, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x38,
  0x03, 0x80, 0x08, 0x00, 0x00, 0x7F, 0x98, 0x38, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x03, 0x00, 0xC0, 0x10,
  0x06, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x04, 0x01, 0xC0, 0x38, 0x00,
  0x00, 0x7F, 0x80, 0x03, 0xE3, 0xE0, 0x0E, 0x00, 0x30, 0x1C, 0x00, 0x18,
  0x30, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x60, 0x3F, 0x06, 0x40, 0xF7, 0x82,
  0xC1, 0xC1, 0x83, 0xC1, 0x81, 0x83, 0x83, 0x01, 0x83, 0x83, 0x01, 0x83,
  0x83, 0x01, 0x83, 0x83, 0x01, 0x83, 0x83, 0x01, 0x82, 0x83, 0x03, 0x86,
  0xC1, 0x86, 0x84, 0xC0, 0xFC, 0xFC, 0x40, 0x30, 0x30, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x40, 0x07, 0xFF, 0xC0,
  0x01, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x02, 0x80, 0x00, 0xD8,
  0x00, 0x1B, 0x00, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x10, 0x40, 0x06, 0x0C,
  0x00, 0xC1, 0x80, 0x10, 0x10, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x3F, 0xFE,
  0x06, 0x00, 0xC0, 0x80, 0x18, 0x30, 0x01, 0x86, 0x00, 0x31, 0x80, 0x03,
  0x30, 0x00, 0x64, 0x00, 0x0D, 0x80, 0x00, 0xC0, 0xFF, 0xE1, 0x83, 0xF3,
  0x00, 0x76, 0x00, 0x6C, 0x00, 0xD8, 0x01, 0xB0, 0x03, 0x60, 0x06, 0xC0,
  0x19, 0x81, 0xE3, 0xFF, 0x06, 0x03, 0xCC, 0x00, 0xD8, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x36, 0x00, 0xEF, 0xFF, 0x9F,
  0xFC, 0x00, 0x03, 0xFF, 0x0F, 0x07, 0x1C, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0F, 0x87, 0x03, 0xFE, 0xFF, 0xE0,
  0x61, 0xFC, 0x30, 0x07, 0x18, 0x00, 0xCC, 0x00, 0x36, 0x00, 0x1B, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x03,
  0x30, 0x03, 0x98, 0x03, 0x8F, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xFC, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xFF, 0xFC, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xFF,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x03, 0xFF, 0x83, 0xC0, 0xF1, 0xC0, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0D, 0x80, 0x03, 0x60, 0x00, 0xDC, 0x00, 0x33, 0x00, 0x0C, 0x70, 0x03,
  0x0F, 0x83, 0xC0, 0xFF, 0xE0, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xFC, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x33, 0xF0, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x06, 0x06, 0xFC, 0x70, 0xC0, 0x0F,
  0x80, 0x33, 0x00, 0xC6, 0x03, 0x8C, 0x0E, 0x18, 0x38, 0x30, 0xE0, 0x63,
  0x80, 0xC6, 0x01, 0x98, 0x03, 0x78, 0x07, 0xB8, 0x0E, 0x30, 0x18, 0x30,
  0x30, 0x30, 0x60, 0x70, 0xC0, 0x61, 0x80, 0x63, 0x00, 0x66, 0x00, 0xCC,
  0x00, 0xD8, 0x00, 0xC0, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFD,
  0x80, 0x0D, 0xEC, 0x00, 0x6F, 0x20, 0x02, 0x79, 0x80, 0x33, 0xCC, 0x01,
  0x9E, 0x30, 0x18, 0xF1, 0x80, 0xC7, 0x84, 0x04, 0x3C, 0x30, 0x61, 0xE1,
  0x83, 0x0F, 0x06, 0x30, 0x78, 0x31, 0x83, 0xC0, 0x88, 0x1E, 0x06, 0xC0,
  0xF0, 0x36, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x30, 0x0C, 0xC0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3D, 0x80, 0x1E, 0x60, 0x0F,
  0x30, 0x07, 0x8C, 0x03, 0xC3, 0x01, 0xE1, 0x80, 0xF0, 0x60, 0x78, 0x18,
  0x3C, 0x0C, 0x1E, 0x03, 0x0F, 0x00, 0xC7, 0x80, 0x63, 0xC0, 0x19, 0xE0,
  0x06, 0xF0, 0x03, 0x78, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1C, 0x07, 0xFE,
  0x00, 0xE0, 0xF0, 0x18, 0x01, 0x83, 0x00, 0x0C, 0x60, 0x00, 0xE6, 0x00,
  0x06, 0xC0, 0x00, 0x6C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x34,
  0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x0C, 0x30, 0x00, 0xC1, 0x80, 0x38,
  0x0F, 0x0F, 0x00, 0x3F, 0xC0, 0xFF, 0xC3, 0x0F, 0xCC, 0x03, 0xB0, 0x06,
  0xC0, 0x1B, 0x00, 0x3C, 0x00, 0xF0, 0x02, 0xC0, 0x1B, 0x00, 0x6C, 0x03,
  0x3F, 0xF8, 0xFF, 0x83, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x07, 0xFE, 0x00, 0xE0,
  0xF0, 0x18, 0x01, 0x83, 0x00, 0x0C, 0x60, 0x00, 0xE6, 0x00, 0x06, 0xC0,
  0x00, 0x6C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x24, 0x00, 0x06,
  0x60, 0x00, 0x66, 0x00, 0x0C, 0x30, 0x00, 0xC1, 0x80, 0x38, 0x0F, 0x0F,
  0x00, 0x3F, 0xC0, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x03, 0xC0, 0xFF, 0xC1, 0x87, 0xE3, 0x00, 0xE6, 0x00, 0xCC,
  0x00, 0x98, 0x01, 0xB0, 0x03, 0x60, 0x04, 0xC0, 0x19, 0x80, 0x73, 0x01,
  0xC7, 0xFE, 0x0C, 0x18, 0x18, 0x18, 0x30, 0x30, 0x60, 0x30, 0xC0, 0x31,
  0x80, 0x63, 0x00, 0x66, 0x00, 0xCC, 0x00, 0xD8, 0x00, 0xC0, 0x1F, 0xF3,
  0xC1, 0xD8, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x70,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03,
  0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x6F, 0x1F, 0x7F, 0xE0, 0xFF, 0xFF,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x05, 0x80, 0x02, 0xC0, 0x03, 0x60, 0x01, 0x98, 0x01, 0xCE, 0x01,
  0xC3, 0xE3, 0xC0, 0x7F, 0x80, 0xC0, 0x00, 0xD0, 0x00, 0x26, 0x00, 0x19,
  0x80, 0x06, 0x30, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x30, 0x60, 0x18, 0x18,
  0x06, 0x02, 0x01, 0x80, 0xC0, 0xC0, 0x30, 0x30, 0x06, 0x18, 0x01, 0x86,
  0x00, 0x61, 0x80, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0xF0, 0x07,
  0x00, 0x3C, 0x01, 0xE0, 0x0D, 0x80, 0x78, 0x06, 0x60, 0x16, 0x01, 0x98,
  0x0C, 0x80, 0x66, 0x03, 0x30, 0x10, 0xC0, 0x8C, 0x0C, 0x30, 0x61, 0x03,
  0x0C, 0x18, 0x60, 0xC1, 0x06, 0x18, 0x60, 0x61, 0x06, 0x18, 0x18, 0xC0,
  0x86, 0x06, 0x30, 0x31, 0x80, 0x8C, 0x0C, 0xC0, 0x32, 0x01, 0x30, 0x0D,
  0x80, 0x6C, 0x03, 0x60, 0x1A, 0x00, 0x50, 0x07, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x18, 0x03, 0x0C,
  0x01, 0x83, 0x01, 0x80, 0xC0, 0x80, 0x60, 0xC0, 0x18, 0xC0, 0x04, 0x60,
  0x03, 0x60, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x36, 0x00, 0x31,
  0x80, 0x18, 0xC0, 0x18, 0x30, 0x0C, 0x18, 0x0C, 0x06, 0x0C, 0x01, 0x86,
  0x00, 0xC6, 0x00, 0x36, 0x00, 0x0C, 0xC0, 0x03, 0xB0, 0x01, 0x98, 0x01,
  0x86, 0x00, 0xC1, 0x00, 0xC0, 0xC0, 0x60, 0x30, 0x60, 0x18, 0x20, 0x06,
  0x30, 0x03, 0x30, 0x00, 0xD8, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x7F, 0xFE, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x83, 0xFF, 0xC0, 0xC0, 0x18,
  0x06, 0x00, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x08, 0x03, 0x00, 0xC0,
  0x18, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x00, 0x60, 0x18, 0x02, 0x00,
  0xC0, 0x30, 0xFC, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x07, 0xFF, 0xC0, 0x01,
  0x80, 0x07, 0x00, 0x0B, 0x00, 0x32, 0x00, 0x46, 0x01, 0x84, 0x02, 0x0C,
  0x0C, 0x08, 0x10, 0x18, 0x60, 0x10, 0x80, 0x33, 0x00, 0x24, 0x00, 0x78,
  0x00, 0x40, 0xFF, 0xF8, 0xC1, 0x83, 0x06, 0x0C, 0x03, 0xC1, 0xFF, 0x84,
  0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x1F, 0x1F, 0xF9, 0xC0,
  0xD8, 0x06, 0xC0, 0x3C, 0x01, 0xE0, 0x0D, 0x80, 0xEE, 0x19, 0x3F, 0x88,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x21, 0xE0, 0x9F, 0xE2, 0xC0, 0xCE, 0x01, 0xB0, 0x06, 0xC0, 0x0B, 0x00,
  0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x06, 0xC0,
  0x1A, 0x80, 0xCB, 0x8F, 0x27, 0xF0, 0x07, 0xC1, 0xFF, 0x38, 0x16, 0x00,
  0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x06, 0x00, 0x70, 0x03, 0x87, 0x0F, 0xE0, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC1, 0xE3, 0x1F, 0xEC,
  0xC0, 0xF6, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x60, 0x1D, 0x80, 0x73, 0x86,
  0xC7, 0xF3, 0x07, 0x80, 0xFF, 0x0C, 0x0C, 0xC0, 0x24, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x01, 0xFF, 0xFE, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x30,
  0x01, 0xC0, 0x07, 0x87, 0x0F, 0xF0, 0x01, 0xC0, 0xFC, 0x30, 0x06, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0xFF, 0x83, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x07, 0x80, 0x7F, 0xB3, 0x03, 0xD8, 0x07, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0D, 0x80, 0x76, 0x01, 0xCE, 0x3B, 0x1F, 0xCC, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x18, 0x00, 0x66, 0x07, 0x1F, 0xF8, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0xF0, 0x9F, 0xE5,
  0x81, 0xB8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0x5D, 0x80, 0x03, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xD8, 0x04, 0x1C, 0x18,
  0x00, 0x00, 0x00, 0x03, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x10, 0x60, 0xDF, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01,
  0x80, 0x68, 0x0C, 0x81, 0x88, 0x30, 0x86, 0x08, 0xC0, 0x98, 0x0B, 0xC0,
  0xE6, 0x0C, 0x60, 0x83, 0x08, 0x18, 0x80, 0xC8, 0x0C, 0x80, 0x68, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x81, 0xE2, 0x7F, 0x1F, 0xEB,
  0x06, 0xC1, 0xB8, 0x0E, 0x03, 0xC0, 0x30, 0x0F, 0x00, 0xC0, 0x3C, 0x03,
  0x00, 0xF0, 0x0C, 0x03, 0xC0, 0x30, 0x0F, 0x00, 0xC0, 0x3C, 0x03, 0x00,
  0xF0, 0x0C, 0x03, 0xC0, 0x30, 0x0F, 0x00, 0xC0, 0x3C, 0x03, 0x00, 0xF0,
  0x0C, 0x03, 0xC0, 0x30, 0x0C, 0x07, 0x84, 0xFF, 0x2C, 0x0D, 0xC0, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x18, 0x07, 0xC0, 0x3F,
  0xE0, 0xC0, 0xE3, 0x00, 0xCC, 0x00, 0xD8, 0x01, 0xB0, 0x03, 0x60, 0x02,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x16, 0x00, 0x6C, 0x00, 0xCC, 0x01, 0x9C,
  0x06, 0x1C, 0x38, 0x0F, 0xE0, 0x07, 0x82, 0x7F, 0x8B, 0x03, 0x28, 0x06,
  0xC0, 0x1B, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x1B, 0x00, 0x6A, 0x03, 0x2E, 0x1C, 0x8F, 0xC2, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x07,
  0x80, 0x7F, 0xB3, 0x03, 0xD8, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x76,
  0x03, 0xCE, 0x1B, 0x1F, 0xCC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x07, 0xCF, 0xEC, 0x14, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x00, 0x0F, 0x83, 0xFF, 0x60, 0x26, 0x00, 0x40, 0x06, 0x00, 0x70, 0x03,
  0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x70, 0x03, 0x00, 0x30, 0x03, 0x00, 0x3E,
  0x0E, 0x7F, 0xC0, 0x18, 0x06, 0x01, 0x80, 0xE0, 0xFF, 0xC6, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0xC4, 0x3F, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x7C,
  0x03, 0xE0, 0x3D, 0xC3, 0x67, 0xF3, 0xC0, 0x0E, 0xC0, 0x19, 0x80, 0x21,
  0x00, 0xC3, 0x01, 0x86, 0x06, 0x06, 0x0C, 0x0C, 0x10, 0x18, 0x60, 0x18,
  0xC0, 0x31, 0x00, 0x26, 0x00, 0x6C, 0x00, 0xD0, 0x00, 0xE0, 0x01, 0x80,
  0xE0, 0x38, 0x0D, 0x80, 0xE0, 0x36, 0x02, 0x80, 0xC8, 0x1B, 0x02, 0x30,
  0x6C, 0x18, 0xC1, 0x10, 0x63, 0x0C, 0x61, 0x04, 0x31, 0x8C, 0x18, 0x82,
  0x30, 0x66, 0x0C, 0xC0, 0x98, 0x32, 0x03, 0x40, 0x58, 0x0D, 0x01, 0x60,
  0x3C, 0x07, 0x80, 0x60, 0x1C, 0x01, 0x80, 0x30, 0xE0, 0x1D, 0x80, 0xC3,
  0x06, 0x06, 0x18, 0x0C, 0xC0, 0x36, 0x00, 0x78, 0x00, 0xC0, 0x07, 0x80,
  0x36, 0x00, 0xCC, 0x06, 0x18, 0x30, 0x61, 0x80, 0xC6, 0x01, 0xB0, 0x07,
  0xC0, 0x0E, 0xC0, 0x19, 0x80, 0x21, 0x00, 0xC3, 0x01, 0x86, 0x06, 0x06,
  0x0C, 0x0C, 0x18, 0x08, 0x60, 0x18, 0xC0, 0x31, 0x00, 0x26, 0x00, 0x6C,
  0x00, 0x50, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xC0, 0x01, 0x80, 0x3E, 0x00, 0x00, 0x7F, 0xF0, 0x02, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x18,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x0F, 0xFF, 0x03, 0x87, 0x83, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x07, 0x07, 0x00,
  0xC0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x10, 0x0C,
  0x03, 0xC0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3C, 0x06, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x78, 0x0C, 0x18,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x18, 0x78,
  0x38, 0x00, 0x10, 0x07, 0xFC, 0x18, 0x3F, 0xE0, 0x3C,
};

const GFXglyph NotoSans_Light31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 3, 22, 8, 2, -22 },
  { 10, 7, 8, 11, 2, -22 },
  { 17, 18, 22, 20, 1, -22 },
  { 67, 13, 26, 18, 2, -24 },
  { 110, 22, 22, 25, 2, -22 },
  { 171, 20, 22, 22, 2, -22 },
  { 226, 2, 8, 6, 2, -22 },
  { 228, 7, 27, 9, 1, -22 },
  { 252, 6, 27, 9, 1, -22 },
  { 273, 13, 14, 17, 2, -24 },
  { 296, 14, 14, 18, 2, -18 },
  { 321, 4, 8, 7, 1, -4 },
  { 325, 8, 1, 10, 1, -9 },
  { 326, 3, 3, 8, 2, -3 },
  { 328, 10, 22, 11, 0, -22 },
  { 356, 14, 22, 18, 2, -22 },
  { 395, 7, 22, 18, 3, -22 },
  { 415, 14, 22, 18, 2, -22 },
  { 454, 15, 22, 18, 1, -22 },
  { 496, 16, 22, 18, 1, -22 },
  { 540, 14, 22, 18, 2, -22 },
  { 579, 14, 22, 18, 2, -22 },
  { 618, 14, 22, 18, 2, -22 },
  { 657, 14, 22, 18, 2, -22 },
  { 696, 14, 22, 18, 2, -22 },
  { 735, 3, 17, 8, 2, -17 },
  { 742, 4, 21, 8, 1, -17 },
  { 753, 14, 15, 18, 2, -19 },
  { 780, 14, 8, 18, 2, -15 },
  { 794, 14, 15, 18, 2, -19 },
  { 821, 11, 22, 13, 1, -22 },
  { 852, 24, 25, 28, 2, -22 },
  { 927, 19, 22, 19, 0, -22 },
  { 980, 15, 22, 20, 3, -22 },
  { 1022, 16, 22, 19, 2, -22 },
  { 1066, 17, 22, 22, 3, -22 },
  { 1113, 12, 22, 17, 3, -22 },
  { 1146, 12, 22, 16, 3, -22 },
  { 1179, 18, 22, 22, 2, -22 },
  { 1229, 16, 22, 22, 3, -22 },
  { 1273, 6, 22, 10, 2, -22 },
  { 1290, 8, 28, 8, -3, -22 },
  { 1318, 15, 22, 18, 3, -22 },
  { 1360, 12, 22, 16, 3, -22 },
  { 1393, 21, 22, 27, 3, -22 },
  { 1451, 17, 22, 23, 3, -22 },
  { 1498, 20, 22, 24, 2, -22 },
  { 1553, 14, 22, 18, 3, -22 },
  { 1592, 20, 27, 24, 2, -22 },
  { 1660, 15, 22, 19, 3, -22 },
  { 1702, 13, 22, 17, 2, -22 },
  { 1738, 16, 22, 16, 0, -22 },
  { 1782, 17, 22, 22, 3, -22 },
  { 1829, 18, 22, 18, 0, -22 },
  { 1879, 26, 22, 28, 1, -22 },
  { 1951, 17, 22, 17, 0, -22 },
  { 1998, 17, 22, 17, 0, -22 },
  { 2045, 16, 22, 18, 1, -22 },
  { 2089, 6, 27, 10, 3, -22 },
  { 2110, 10, 22, 11, 0, -22 },
  { 2138, 6, 27, 10, 1, -22 },
  { 2159, 15, 14, 18, 1, -22 },
  { 2186, 13, 1, 13, 0, 3 },
  { 2188, 6, 5, 8, 1, -24 },
  { 2192, 13, 17, 17, 1, -17 },
  { 2220, 14, 24, 19, 3, -24 },
  { 2262, 12, 17, 15, 2, -17 },
  { 2288, 14, 24, 19, 2, -24 },
  { 2330, 13, 17, 17, 2, -17 },
  { 2358, 11, 24, 10, 0, -24 },
  { 2391, 14, 24, 19, 2, -17 },
  { 2433, 13, 24, 18, 3, -24 },
  { 2472, 3, 23, 7, 2, -23 },
  { 2481, 7, 30, 7, -2, -23 },
  { 2508, 12, 24, 15, 3, -24 },
  { 2544, 2, 24, 7, 3, -24 },
  { 2550, 22, 17, 28, 3, -17 },
  { 2597, 13, 17, 18, 3, -17 },
  { 2625, 15, 17, 18, 2, -17 },
  { 2657, 14, 24, 19, 3, -17 },
  { 2699, 14, 24, 19, 2, -17 },
  { 2741, 9, 17, 12, 3, -17 },
  { 2761, 12, 17, 15, 1, -17 },
  { 2787, 10, 20, 11, 0, -20 },
  { 2812, 13, 16, 18, 3, -16 },
  { 2838, 15, 16, 15, 0, -16 },
  { 2868, 22, 16, 23, 0, -16 },
  { 2912, 14, 16, 16, 1, -16 },
  { 2940, 15, 23, 15, 0, -16 },
  { 2984, 12, 16, 14, 1, -16 },
  { 3008, 9, 27, 11, 1, -22 },
  { 3039, 1, 32, 17, 8, -24 },
  { 3043, 9, 27, 11, 1, -22 },
  { 3074, 14, 4, 18, 2, -13 },
};

const GFXfont NotoSans_Light31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light31pt7bBitmaps,
  (GFXglyph *)NotoSans_Light31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_LIGHT31PT7B_H_
