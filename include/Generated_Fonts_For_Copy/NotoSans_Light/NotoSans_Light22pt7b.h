#ifndef _NOTOSANS_LIGHT22PT7B_H_
#define _NOTOSANS_LIGHT22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light22pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0x0F, 0x99, 0x99, 0x99, 0x04, 0x60, 0x62, 0x02,
  0x10, 0x10, 0x80, 0x84, 0x7F, 0xFC, 0x62, 0x02, 0x10, 0x10, 0x80, 0x84,
  0x3F, 0xFC, 0x22, 0x02, 0x10, 0x10, 0x80, 0x84, 0x04, 0x60, 0x04, 0x01,
  0x03, 0xF9, 0x92, 0x44, 0x31, 0x04, 0x41, 0x90, 0x3C, 0x01, 0xC0, 0x58,
  0x13, 0x04, 0x41, 0x38, 0x4B, 0xFC, 0x04, 0x01, 0x00, 0x38, 0x08, 0x44,
  0x10, 0xC4, 0x30, 0x84, 0x20, 0x84, 0x60, 0x84, 0x40, 0x84, 0x88, 0xC4,
  0xB6, 0x4D, 0x22, 0x39, 0x23, 0x02, 0x61, 0x06, 0x61, 0x04, 0x61, 0x0C,
  0x22, 0x08, 0x22, 0x10, 0x1C, 0x0F, 0x00, 0xC6, 0x02, 0x08, 0x08, 0x20,
  0x20, 0x80, 0xC6, 0x01, 0xE0, 0x03, 0x00, 0x36, 0x0D, 0x8C, 0x2C, 0x18,
  0xB0, 0x36, 0xC0, 0x71, 0x01, 0xC6, 0x0D, 0x8F, 0xC3, 0xFC, 0x13, 0x24,
  0x4C, 0xC8, 0x88, 0x88, 0x8C, 0x44, 0x62, 0x30, 0x84, 0x42, 0x23, 0x11,
  0x11, 0x11, 0x11, 0x32, 0x24, 0xC0, 0x0C, 0x03, 0x00, 0xC2, 0x11, 0xF7,
  0xC3, 0x00, 0xE0, 0x48, 0x31, 0x08, 0x40, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x3F, 0xF0, 0x40, 0x10, 0x04, 0x01, 0x00, 0x69, 0x69, 0x00, 0xFF,
  0xC0, 0xF0, 0x02, 0x04, 0x18, 0x20, 0x41, 0x02, 0x0C, 0x10, 0x20, 0xC1,
  0x02, 0x08, 0x10, 0x60, 0x1E, 0x0C, 0x66, 0x09, 0x03, 0x40, 0x70, 0x1C,
  0x06, 0x01, 0x80, 0x70, 0x1C, 0x05, 0x01, 0x40, 0x50, 0x22, 0x18, 0x7C,
  0x08, 0xDB, 0x90, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x1E, 0x38,
  0x64, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x03, 0x01, 0x80, 0xC0,
  0x20, 0x10, 0x08, 0x04, 0x03, 0xFF, 0x3E, 0x38, 0x68, 0x08, 0x03, 0x00,
  0xC0, 0x20, 0x18, 0xF8, 0x03, 0x00, 0x30, 0x04, 0x01, 0x00, 0x40, 0x38,
  0x1B, 0xFC, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x2C, 0x04, 0xC0, 0xCC, 0x08,
  0xC1, 0x0C, 0x30, 0xC2, 0x0C, 0x40, 0xCF, 0xFF, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x7F, 0x60, 0x30, 0x10, 0x08, 0x04, 0x02, 0x21, 0xFE, 0x01,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x0E, 0x0D, 0xFC, 0x07, 0x86, 0x03, 0x01,
  0x80, 0x40, 0x10, 0x04, 0xF3, 0xC6, 0xE0, 0xF0, 0x1C, 0x05, 0x01, 0x40,
  0x58, 0x12, 0x08, 0x7C, 0xFF, 0xC0, 0x10, 0x04, 0x02, 0x00, 0x80, 0x60,
  0x10, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x10, 0x08, 0x02, 0x01, 0x80, 0x40,
  0x1F, 0x08, 0x64, 0x0D, 0x03, 0x40, 0xD8, 0x23, 0x10, 0x38, 0x33, 0x18,
  0x24, 0x07, 0x01, 0xC0, 0x70, 0x16, 0x08, 0xFC, 0x1E, 0x18, 0x44, 0x0B,
  0x03, 0x80, 0x60, 0x1C, 0x05, 0x03, 0x61, 0x4F, 0x90, 0x04, 0x03, 0x00,
  0x80, 0x60, 0x31, 0xF8, 0xF0, 0x00, 0x0F, 0x6C, 0x00, 0x00, 0x09, 0x2D,
  0x20, 0x00, 0x40, 0x60, 0x60, 0x60, 0x60, 0x30, 0x03, 0x80, 0x38, 0x01,
  0x80, 0x10, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x80, 0x1C,
  0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x30, 0x30, 0x30, 0x70, 0x30, 0x00, 0x7C,
  0x86, 0x02, 0x03, 0x03, 0x02, 0x06, 0x0C, 0x18, 0x30, 0x20, 0x20, 0x00,
  0x00, 0x30, 0x30, 0x00, 0xE0, 0x03, 0x8E, 0x06, 0x00, 0x86, 0x00, 0x22,
  0x00, 0x1A, 0x0F, 0x85, 0x08, 0x43, 0x88, 0x21, 0x84, 0x10, 0xC2, 0x08,
  0x61, 0x04, 0x30, 0x86, 0x14, 0x26, 0x92, 0x0C, 0x31, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x08, 0x03, 0xF8, 0x00, 0x02, 0x00, 0x18, 0x01, 0x40, 0x0B,
  0x00, 0x48, 0x04, 0x40, 0x23, 0x03, 0x08, 0x10, 0x60, 0xFF, 0x0F, 0xF8,
  0x40, 0x66, 0x01, 0x20, 0x09, 0x00, 0x78, 0x01, 0xFE, 0x10, 0x72, 0x03,
  0x40, 0x28, 0x05, 0x00, 0xA0, 0x27, 0xF8, 0x81, 0x90, 0x0A, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xA0, 0x77, 0xF8, 0x07, 0xE1, 0xC3, 0x30, 0x02, 0x00,
  0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x04, 0x00,
  0x60, 0x02, 0x00, 0x18, 0x10, 0xFF, 0xFE, 0x08, 0x38, 0x80, 0x68, 0x02,
  0x80, 0x38, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03,
  0x80, 0x28, 0x06, 0x81, 0xCF, 0xF0, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0xFE, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0xFF,
  0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xFF, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x07, 0xF0, 0xE0, 0xCC, 0x00, 0x40,
  0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0xFE, 0x00, 0x50, 0x02,
  0x80, 0x16, 0x00, 0x98, 0x04, 0x60, 0x21, 0xFF, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x3F, 0xFF, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0xF9, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x9F, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x47, 0xE0, 0x80, 0x70, 0x1A, 0x06, 0x41,
  0x88, 0x61, 0x18, 0x26, 0x05, 0xC0, 0xE8, 0x18, 0x82, 0x18, 0x41, 0x88,
  0x11, 0x01, 0x20, 0x34, 0x03, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0xFF, 0xC0,
  0x07, 0xC0, 0x0E, 0x80, 0x2D, 0x00, 0x59, 0x01, 0xB2, 0x02, 0x66, 0x04,
  0xC4, 0x11, 0x88, 0x23, 0x18, 0xC6, 0x11, 0x0C, 0x32, 0x18, 0x28, 0x30,
  0x50, 0x60, 0xE0, 0xC0, 0x81, 0xC0, 0x1C, 0x01, 0xA0, 0x1B, 0x01, 0x90,
  0x18, 0x81, 0x8C, 0x18, 0x41, 0x86, 0x18, 0x31, 0x81, 0x18, 0x19, 0x80,
  0xD8, 0x05, 0x80, 0x78, 0x03, 0x07, 0xC0, 0x30, 0x60, 0xC0, 0x63, 0x00,
  0x64, 0x00, 0x48, 0x00, 0xB0, 0x01, 0x60, 0x03, 0xC0, 0x07, 0x80, 0x09,
  0x00, 0x12, 0x00, 0x26, 0x00, 0xC4, 0x01, 0x06, 0x0C, 0x07, 0xF0, 0xFC,
  0x21, 0xC8, 0x0A, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x06, 0xFF, 0x3E, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x07, 0xC0, 0x30, 0x60, 0xC0,
  0x63, 0x00, 0x64, 0x00, 0x48, 0x00, 0xB0, 0x01, 0x60, 0x03, 0xC0, 0x07,
  0x80, 0x09, 0x00, 0x12, 0x00, 0x26, 0x00, 0xC4, 0x01, 0x06, 0x0C, 0x07,
  0xF0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0xFC, 0x10, 0x72,
  0x02, 0x40, 0x68, 0x0D, 0x01, 0xA0, 0x24, 0x0C, 0xFE, 0x10, 0xC2, 0x08,
  0x40, 0x88, 0x19, 0x01, 0x20, 0x34, 0x03, 0x1F, 0x5C, 0x24, 0x03, 0x00,
  0xC0, 0x10, 0x06, 0x00, 0xE0, 0x07, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x40,
  0x38, 0x1B, 0xFC, 0xFF, 0xF0, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x34, 0x02,
  0x60, 0x41, 0xF8, 0x80, 0x1E, 0x00, 0x90, 0x04, 0xC0, 0x62, 0x02, 0x10,
  0x10, 0xC1, 0x82, 0x08, 0x10, 0xC0, 0xC4, 0x02, 0x20, 0x13, 0x00, 0xD0,
  0x02, 0x80, 0x1C, 0x00, 0x40, 0xC0, 0x60, 0x28, 0x0C, 0x05, 0x01, 0x81,
  0xB0, 0x50, 0x22, 0x09, 0x04, 0x41, 0x20, 0x88, 0x64, 0x31, 0x88, 0xC4,
  0x11, 0x08, 0x82, 0x21, 0x10, 0x6C, 0x26, 0x05, 0x02, 0x80, 0xA0, 0x50,
  0x14, 0x0A, 0x03, 0x01, 0x80, 0x20, 0x10, 0xC0, 0x36, 0x02, 0x20, 0x41,
  0x0C, 0x18, 0x80, 0x90, 0x0F, 0x00, 0x60, 0x06, 0x00, 0xD0, 0x09, 0x81,
  0x08, 0x30, 0xC2, 0x04, 0x40, 0x2C, 0x03, 0xC0, 0x34, 0x02, 0x60, 0x62,
  0x04, 0x30, 0xC1, 0x08, 0x19, 0x00, 0x90, 0x0E, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xFF, 0xE0, 0x08, 0x03, 0x00,
  0x40, 0x10, 0x06, 0x00, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x40, 0x18, 0x02,
  0x00, 0x80, 0x30, 0x07, 0xFF, 0xFC, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x3E, 0xC0, 0x81, 0x03, 0x02, 0x04, 0x04, 0x08,
  0x18, 0x10, 0x20, 0x60, 0x40, 0x80, 0x81, 0xF1, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x11, 0xF0, 0x04, 0x01, 0x80, 0x28, 0x09, 0x01, 0x10,
  0x42, 0x08, 0x22, 0x04, 0x40, 0x50, 0x0C, 0xFF, 0x80, 0xC4, 0x21, 0x1E,
  0x30, 0x80, 0x60, 0x10, 0x08, 0xFD, 0xC3, 0x81, 0x80, 0xC0, 0xF0, 0xAF,
  0x90, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x27, 0x8A, 0x1B, 0x02, 0xC0,
  0xE0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x3C, 0x0B, 0x86, 0xBF, 0x00, 0x0F,
  0x18, 0x58, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x40, 0x20, 0x08, 0x23,
  0xF0, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x47, 0x93, 0x15, 0x83, 0x40,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x14, 0x0D, 0x83, 0x3F, 0x40, 0x1E,
  0x0C, 0x66, 0x09, 0x03, 0xC0, 0x7F, 0xFC, 0x03, 0x00, 0x40, 0x10, 0x02,
  0x04, 0x7E, 0x0F, 0x19, 0x10, 0x30, 0x30, 0xFC, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x1E, 0x4C, 0x76, 0x0D, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x50, 0x36, 0x0C, 0xFD, 0x00, 0x40,
  0x10, 0x05, 0x02, 0x7F, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0xF2,
  0x87, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0x80, 0xCF, 0xFF, 0x11, 0x00, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0xE0, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x0A, 0x09, 0x08, 0x88,
  0x4C, 0x2C, 0x1F, 0x0C, 0x84, 0x22, 0x19, 0x06, 0x81, 0x80, 0xFF, 0xFF,
  0x80, 0x9E, 0x3C, 0xA3, 0x46, 0xC1, 0x83, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x9E, 0x50, 0xF0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x10, 0x1F, 0x06, 0x31, 0x83, 0x20, 0x2C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0x40, 0x48, 0x08, 0x82, 0x0F, 0x80, 0x9E, 0x28, 0x6C, 0x0B,
  0x03, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xF0, 0x2A, 0x1A, 0xFC, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x00, 0x1E, 0x4C, 0x54, 0x0D, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x50, 0x36, 0x1C, 0xFD, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x9E, 0x8C, 0x30, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x3E, 0x41, 0x80, 0x80, 0x40, 0x38, 0x0E, 0x03, 0x01, 0x01, 0x83,
  0xFE, 0x20, 0x40, 0x87, 0xF2, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x06, 0x07, 0x80, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0xF0, 0xEF, 0xD0, 0x80, 0x70, 0x14, 0x09, 0x82, 0x21, 0x88,
  0x43, 0x10, 0x4C, 0x12, 0x02, 0x80, 0xC0, 0x30, 0xC1, 0x81, 0x41, 0x83,
  0x41, 0xC2, 0x41, 0x42, 0x62, 0x46, 0x22, 0x44, 0x22, 0x24, 0x34, 0x24,
  0x14, 0x2C, 0x14, 0x18, 0x18, 0x18, 0x18, 0x18, 0x40, 0x44, 0x10, 0xC6,
  0x08, 0x80, 0xA0, 0x1C, 0x03, 0x80, 0x50, 0x11, 0x06, 0x30, 0x82, 0x60,
  0x30, 0x80, 0x70, 0x14, 0x09, 0x82, 0x21, 0x88, 0x43, 0x10, 0x4C, 0x12,
  0x02, 0x80, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x40, 0xF0, 0x00, 0xFF,
  0x01, 0x02, 0x06, 0x04, 0x08, 0x18, 0x30, 0x20, 0x40, 0xC0, 0xFF, 0x0C,
  0x63, 0x08, 0x20, 0x82, 0x08, 0x23, 0x06, 0x08, 0x20, 0x82, 0x08, 0x20,
  0xC1, 0xC0, 0xFF, 0xFF, 0xFC, 0x81, 0x83, 0x0C, 0x30, 0xC3, 0x0C, 0x10,
  0x31, 0x84, 0x30, 0xC3, 0x0C, 0x30, 0xCE, 0x00, 0x78, 0x61, 0xF0,
};

const GFXglyph NotoSans_Light22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 16, 5, 2, -16 },
  { 5, 4, 6, 8, 2, -16 },
  { 8, 13, 16, 14, 1, -16 },
  { 34, 10, 18, 13, 1, -17 },
  { 57, 16, 16, 18, 1, -16 },
  { 89, 14, 16, 16, 1, -16 },
  { 117, 1, 6, 4, 2, -16 },
  { 118, 4, 19, 6, 1, -16 },
  { 128, 4, 19, 6, 1, -16 },
  { 138, 10, 10, 12, 1, -17 },
  { 151, 10, 10, 13, 1, -13 },
  { 164, 3, 6, 5, 1, -3 },
  { 167, 5, 2, 7, 1, -7 },
  { 169, 2, 2, 5, 2, -2 },
  { 170, 7, 16, 8, 0, -16 },
  { 184, 10, 16, 13, 1, -16 },
  { 204, 5, 16, 13, 2, -16 },
  { 214, 10, 16, 13, 1, -16 },
  { 234, 10, 16, 13, 1, -16 },
  { 254, 12, 16, 13, 0, -16 },
  { 278, 9, 16, 13, 2, -16 },
  { 296, 10, 16, 13, 1, -16 },
  { 316, 10, 16, 13, 1, -16 },
  { 336, 10, 16, 13, 1, -16 },
  { 356, 10, 16, 13, 1, -16 },
  { 376, 2, 12, 5, 2, -12 },
  { 379, 3, 15, 5, 1, -12 },
  { 385, 10, 10, 13, 1, -13 },
  { 398, 10, 6, 13, 1, -11 },
  { 406, 10, 10, 13, 1, -13 },
  { 419, 8, 16, 9, 1, -16 },
  { 435, 17, 18, 20, 1, -16 },
  { 474, 13, 16, 13, 0, -16 },
  { 500, 11, 16, 14, 2, -16 },
  { 522, 12, 16, 14, 1, -16 },
  { 546, 12, 16, 16, 2, -16 },
  { 570, 9, 16, 12, 2, -16 },
  { 588, 9, 16, 11, 2, -16 },
  { 606, 13, 16, 16, 1, -16 },
  { 632, 12, 16, 16, 2, -16 },
  { 656, 5, 16, 7, 1, -16 },
  { 666, 5, 20, 6, -2, -16 },
  { 679, 11, 16, 13, 2, -16 },
  { 701, 9, 16, 11, 2, -16 },
  { 719, 15, 16, 19, 2, -16 },
  { 749, 12, 16, 16, 2, -16 },
  { 773, 15, 16, 17, 1, -16 },
  { 803, 10, 16, 13, 2, -16 },
  { 823, 15, 20, 17, 1, -16 },
  { 861, 11, 16, 13, 2, -16 },
  { 883, 10, 16, 12, 1, -16 },
  { 903, 12, 16, 12, 0, -16 },
  { 927, 12, 16, 16, 2, -16 },
  { 951, 13, 16, 13, 0, -16 },
  { 977, 19, 16, 20, 0, -16 },
  { 1015, 12, 16, 12, 0, -16 },
  { 1039, 12, 16, 12, 0, -16 },
  { 1063, 11, 16, 13, 1, -16 },
  { 1085, 5, 19, 7, 2, -16 },
  { 1097, 7, 16, 8, 0, -16 },
  { 1111, 4, 19, 7, 1, -16 },
  { 1121, 11, 10, 13, 1, -16 },
  { 1135, 9, 1, 9, 0, 2 },
  { 1137, 4, 4, 6, 1, -17 },
  { 1139, 9, 12, 12, 1, -12 },
  { 1153, 10, 17, 13, 2, -17 },
  { 1175, 9, 12, 10, 1, -12 },
  { 1189, 10, 17, 13, 1, -17 },
  { 1211, 10, 12, 12, 1, -12 },
  { 1226, 8, 17, 7, 0, -17 },
  { 1243, 10, 17, 13, 1, -12 },
  { 1265, 9, 17, 13, 2, -17 },
  { 1285, 1, 16, 5, 2, -16 },
  { 1287, 4, 21, 5, -1, -16 },
  { 1298, 9, 17, 11, 2, -17 },
  { 1318, 1, 17, 5, 2, -17 },
  { 1321, 16, 12, 20, 2, -12 },
  { 1345, 9, 12, 13, 2, -12 },
  { 1359, 11, 12, 13, 1, -12 },
  { 1376, 10, 17, 13, 2, -12 },
  { 1398, 10, 17, 13, 1, -12 },
  { 1420, 6, 12, 9, 2, -12 },
  { 1429, 8, 12, 10, 1, -12 },
  { 1441, 7, 15, 7, 0, -15 },
  { 1455, 9, 12, 13, 2, -12 },
  { 1469, 10, 12, 10, 0, -12 },
  { 1484, 16, 12, 16, 0, -12 },
  { 1508, 11, 12, 11, 0, -12 },
  { 1525, 10, 17, 10, 0, -12 },
  { 1547, 8, 12, 10, 1, -12 },
  { 1559, 6, 19, 8, 1, -16 },
  { 1574, 1, 22, 12, 5, -17 },
  { 1577, 6, 19, 8, 1, -16 },
  { 1592, 10, 2, 13, 1, -9 },
};

const GFXfont NotoSans_Light22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light22pt7bBitmaps,
  (GFXglyph *)NotoSans_Light22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_LIGHT22PT7B_H_
