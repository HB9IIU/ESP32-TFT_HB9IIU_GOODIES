#ifndef _NOTOSANS_LIGHT51PT7B_H_
#define _NOTOSANS_LIGHT51PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light51pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x31, 0x8C, 0x63, 0x00, 0x00, 0x00, 0x00, 0xF7, 0xBF, 0xE2,
  0x00, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x04, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x18, 0x03, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x03, 0x80, 0x70, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x38, 0x03, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xE0,
  0x1C, 0x01, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00,
  0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x38, 0x07, 0x00, 0x00, 0x60, 0x0E,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x80, 0x30, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x18, 0x03, 0x80, 0x00, 0x30, 0x06, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0x80, 0x70, 0x00,
  0x06, 0x00, 0xE0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00,
  0x70, 0x06, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x01, 0x80, 0x38, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x38,
  0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x8F, 0x0C,
  0x0C, 0x78, 0x30, 0x01, 0xC0, 0xC0, 0x0E, 0x03, 0x00, 0x38, 0x0C, 0x00,
  0xE0, 0x30, 0x03, 0x80, 0xC0, 0x0F, 0x03, 0x00, 0x1C, 0x0C, 0x00, 0x78,
  0x30, 0x00, 0xF8, 0xC0, 0x01, 0xFB, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x0C, 0x7C, 0x00, 0x30, 0x78,
  0x00, 0xC0, 0xF0, 0x03, 0x01, 0xC0, 0x0C, 0x07, 0x00, 0x30, 0x1C, 0x00,
  0xC0, 0x70, 0x03, 0x01, 0xC0, 0x0C, 0x07, 0x00, 0x30, 0x3B, 0x00, 0xC1,
  0xEF, 0xC3, 0x3F, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x03, 0x80, 0x3C, 0xF0, 0x00, 0x70,
  0x07, 0x03, 0x80, 0x07, 0x00, 0x70, 0x18, 0x00, 0xE0, 0x0E, 0x01, 0xC0,
  0x0C, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x18, 0x00, 0xC0,
  0x0C, 0x03, 0x80, 0x0C, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x0C, 0x07, 0x00,
  0x0C, 0x00, 0xC0, 0xE0, 0x00, 0xC0, 0x0C, 0x0E, 0x00, 0x0C, 0x00, 0xC1,
  0xC0, 0x00, 0xC0, 0x0C, 0x18, 0x00, 0x0E, 0x01, 0xC3, 0x87, 0xF0, 0xE0,
  0x1C, 0x30, 0xFF, 0x8E, 0x01, 0xC7, 0x1C, 0x3C, 0x70, 0x38, 0x63, 0x81,
  0xC7, 0x03, 0x8E, 0x38, 0x0E, 0x3C, 0xF1, 0xC3, 0x00, 0xE1, 0xFE, 0x1C,
  0x70, 0x06, 0x07, 0x83, 0x87, 0x00, 0x60, 0x00, 0x30, 0x70, 0x07, 0x00,
  0x07, 0x07, 0x00, 0x70, 0x00, 0x60, 0x70, 0x07, 0x00, 0x0E, 0x07, 0x00,
  0x70, 0x00, 0xC0, 0x70, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x70, 0x03, 0x80,
  0x70, 0x06, 0x00, 0x38, 0x07, 0x00, 0x60, 0x07, 0x00, 0x30, 0x0E, 0x00,
  0x60, 0x03, 0x80, 0xE0, 0x0E, 0x00, 0x38, 0x0C, 0x00, 0xC0, 0x01, 0xC1,
  0xC0, 0x1C, 0x00, 0x0F, 0xF8, 0x03, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFD,
  0xF8, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x70,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x01,
  0xE0, 0x0E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00,
  0x0F, 0x1E, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xF3, 0xC0, 0x01,
  0xC1, 0xE0, 0xF0, 0x00, 0xE1, 0xE0, 0x3C, 0x00, 0x71, 0xE0, 0x0F, 0x00,
  0x70, 0xE0, 0x03, 0xC0, 0x38, 0xF0, 0x00, 0xF0, 0x38, 0x70, 0x00, 0x3C,
  0x1C, 0x38, 0x00, 0x0F, 0x1C, 0x1C, 0x00, 0x03, 0xCE, 0x0E, 0x00, 0x00,
  0xFE, 0x07, 0x00, 0x00, 0x3F, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xE0, 0x00,
  0x0F, 0xC0, 0x78, 0x00, 0x1F, 0xF0, 0x1E, 0x00, 0x1F, 0x3C, 0x07, 0xE0,
  0x7E, 0x0F, 0x01, 0xFF, 0xFE, 0x03, 0xC0, 0x3F, 0xF8, 0x00, 0xF8, 0x00,
  0x80, 0x00, 0x00, 0xFF, 0xFD, 0xB6, 0xDB, 0x6C, 0x01, 0xE0, 0x70, 0x1C,
  0x03, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x38,
  0x03, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xF0, 0xE0, 0x1C, 0x03,
  0x80, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x70, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38,
  0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x38,
  0x0E, 0x07, 0x03, 0x80, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x20,
  0x0C, 0x01, 0xF0, 0x30, 0x3F, 0xF8, 0xC7, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xC0, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x0C, 0xC0, 0x00, 0x73, 0x80,
  0x03, 0x87, 0x00, 0x1E, 0x1E, 0x00, 0x70, 0x38, 0x03, 0x80, 0x70, 0x1E,
  0x01, 0xE0, 0x10, 0x02, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x1C, 0x73, 0xCE, 0x38, 0xE3, 0x1C, 0x71, 0x86, 0x38, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF7, 0xBF, 0xE2, 0x00, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x78, 0x0F, 0x01, 0xC0, 0x07, 0x07,
  0x80, 0x07, 0x0E, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0,
  0x00, 0x39, 0xC0, 0x00, 0x37, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1D,
  0x80, 0x00, 0x3B, 0x80, 0x00, 0xE7, 0x00, 0x01, 0xCE, 0x00, 0x03, 0x8E,
  0x00, 0x0F, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0x3E,
  0x0F, 0x80, 0x3F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x70, 0x1F, 0x03, 0xF0, 0x7F, 0x1E, 0x73, 0xC7, 0x78, 0x7F, 0x07, 0x40,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x7F,
  0xFF, 0x07, 0xE0, 0x0F, 0x07, 0x00, 0x0F, 0x04, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0x7E, 0x00, 0xF8, 0x70, 0x00, 0x38, 0x20, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0xC0, 0x00, 0x78, 0xFC, 0x01,
  0xF0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1D, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x1C, 0x1C, 0x00, 0x03, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x0E,
  0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x07, 0x00, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x38, 0x00, 0x70,
  0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x38, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x7F, 0xC0, 0x1F, 0xFF, 0xE0, 0x7F,
  0xBF, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x80, 0x01, 0xE3, 0xE0, 0x3F,
  0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0xF0, 0x07, 0xFD, 0xE0, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x03, 0x80, 0x30, 0xFF, 0xE0, 0xE3, 0xFF, 0xF1, 0xCE, 0x01,
  0xF3, 0xB8, 0x00, 0xF7, 0xC0, 0x00, 0xEF, 0x80, 0x01, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0D,
  0x80, 0x00, 0x1B, 0x80, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xCE,
  0x00, 0x03, 0x9C, 0x00, 0x0E, 0x1C, 0x00, 0x3C, 0x1C, 0x00, 0xF0, 0x3E,
  0x07, 0xC0, 0x1F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0xF0, 0x07, 0x83, 0xC0, 0x07, 0x87, 0x00, 0x07,
  0x1C, 0x00, 0x07, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x39,
  0xC0, 0x00, 0x71, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x83, 0x80, 0x0E, 0x07,
  0xC0, 0x78, 0x03, 0xC1, 0xE0, 0x03, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x3E, 0x7E, 0x01, 0xF0, 0x1F, 0x07, 0x80, 0x0F, 0x0E, 0x00,
  0x0F, 0x38, 0x00, 0x0E, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xB8, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0x78, 0x00, 0xF0, 0x7C, 0x07, 0xC0,
  0x7F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xF0, 0x0F, 0x03, 0x80, 0x0F, 0x0E,
  0x00, 0x0F, 0x1C, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0,
  0x00, 0x3B, 0x80, 0x00, 0x37, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1E, 0xE0, 0x00,
  0x7D, 0xE0, 0x01, 0xF9, 0xE0, 0x07, 0x71, 0xF0, 0x7C, 0xE1, 0xFF, 0xF1,
  0xC0, 0xFF, 0x83, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x80,
  0x7E, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x00, 0x27,
  0xBF, 0xEF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF7, 0xBF, 0xE2, 0x00, 0x18, 0xF3, 0xCF, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xCF,
  0x38, 0xE3, 0x9E, 0x71, 0xC7, 0x18, 0xE3, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0xC3, 0xFF, 0xFC, 0x38, 0x03, 0xC4,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x03, 0xC0,
  0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x7F, 0xE0, 0x0C, 0x30, 0x01, 0xFF, 0xF0, 0x0E, 0x70, 0x03, 0xC0,
  0x70, 0x0E, 0x70, 0x07, 0x00, 0x70, 0x06, 0x60, 0x0E, 0x00, 0x70, 0x06,
  0xE0, 0x1C, 0x00, 0x70, 0x06, 0xE0, 0x1C, 0x00, 0x70, 0x06, 0xE0, 0x18,
  0x00, 0x70, 0x07, 0xE0, 0x38, 0x00, 0x70, 0x07, 0xC0, 0x38, 0x00, 0x70,
  0x06, 0xC0, 0x38, 0x00, 0x70, 0x06, 0xC0, 0x38, 0x00, 0x70, 0x06, 0xC0,
  0x38, 0x00, 0x70, 0x06, 0xC0, 0x38, 0x00, 0xF0, 0x0E, 0xE0, 0x38, 0x00,
  0xF0, 0x0C, 0xE0, 0x1C, 0x00, 0xF0, 0x1C, 0xE0, 0x1C, 0x01, 0xB0, 0x1C,
  0xE0, 0x0E, 0x03, 0xB8, 0x38, 0x60, 0x07, 0xFF, 0x1F, 0xF0, 0x70, 0x03,
  0xFC, 0x0F, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x04, 0x00, 0x01, 0xF0, 0x00, 0x38, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x38, 0x70,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x70, 0x07, 0x00,
  0x00, 0xE0, 0x0E, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x07, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x01, 0xC0, 0x1E,
  0x00, 0x03, 0xC0, 0x38, 0x00, 0x03, 0x80, 0x70, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1E, 0x1C, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0xE0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0xE0, 0x03, 0xF8, 0xE0, 0x00, 0x7C, 0xE0, 0x00,
  0x1E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x78, 0xE0, 0x0F, 0xF0, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0xE0, 0x01, 0xF8, 0xE0, 0x00, 0x3C, 0xE0, 0x00,
  0x1E, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1E, 0xE0, 0x00,
  0x7C, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0xF0,
  0x3C, 0x00, 0x04, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x08, 0x07, 0xF0, 0x1F, 0x00, 0x7F, 0xFF, 0xE0,
  0x03, 0xFF, 0xF8, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x00, 0xE0, 0x07, 0xF8, 0x0E, 0x00, 0x07, 0xE0, 0xE0, 0x00, 0x1F,
  0x0E, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x3C, 0xE0,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x0F, 0x0E, 0x00, 0x03, 0xE0, 0xE0,
  0x00, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xC0, 0x7E, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x08, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x00, 0x77, 0x80, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x1C, 0xF0, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x01, 0xC3, 0xC0, 0x00,
  0x07, 0x07, 0x80, 0x00, 0x1C, 0x0F, 0x80, 0x00, 0x70, 0x1F, 0xE0, 0x1F,
  0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x70, 0xFF, 0xFF, 0xF1, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x0F, 0xFF, 0xFF, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00,
  0xE0, 0x1E, 0xCF, 0xCF, 0xF8, 0xFE, 0x00, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0x38, 0x00, 0x0F, 0x1C, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x07, 0x00,
  0x0F, 0x03, 0x80, 0x0F, 0x01, 0xC0, 0x0F, 0x00, 0xE0, 0x0F, 0x00, 0x70,
  0x0F, 0x00, 0x38, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x07,
  0x07, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC7, 0x80, 0x00, 0xE7, 0xE0, 0x00,
  0x77, 0x78, 0x00, 0x3F, 0x1C, 0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x03, 0xC0,
  0x07, 0x00, 0xE0, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07,
  0x80, 0x70, 0x01, 0xC0, 0x38, 0x00, 0xF0, 0x1C, 0x00, 0x3C, 0x0E, 0x00,
  0x0F, 0x07, 0x00, 0x03, 0x83, 0x80, 0x01, 0xE1, 0xC0, 0x00, 0x78, 0xE0,
  0x00, 0x1E, 0x70, 0x00, 0x07, 0x38, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xF0,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3B, 0xEE,
  0x00, 0x00, 0x0E, 0xFB, 0x80, 0x00, 0x03, 0x7E, 0xE0, 0x00, 0x01, 0xDF,
  0x9C, 0x00, 0x00, 0x77, 0xE7, 0x00, 0x00, 0x39, 0xF8, 0xE0, 0x00, 0x0E,
  0x7E, 0x38, 0x00, 0x03, 0x1F, 0x8E, 0x00, 0x01, 0xC7, 0xE1, 0xC0, 0x00,
  0x71, 0xF8, 0x70, 0x00, 0x38, 0x7E, 0x1C, 0x00, 0x0E, 0x1F, 0x83, 0x80,
  0x03, 0x07, 0xE0, 0xE0, 0x01, 0xC1, 0xF8, 0x1C, 0x00, 0x70, 0x7E, 0x07,
  0x00, 0x38, 0x1F, 0x81, 0xC0, 0x0E, 0x07, 0xE0, 0x38, 0x03, 0x01, 0xF8,
  0x0E, 0x01, 0xC0, 0x7E, 0x01, 0xC0, 0x70, 0x1F, 0x80, 0x70, 0x38, 0x07,
  0xE0, 0x1C, 0x0E, 0x01, 0xF8, 0x03, 0x83, 0x00, 0x7E, 0x00, 0xE1, 0xC0,
  0x1F, 0x80, 0x1C, 0x70, 0x07, 0xE0, 0x07, 0x38, 0x01, 0xF8, 0x01, 0xCE,
  0x00, 0x7E, 0x00, 0x3B, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01,
  0xF0, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x7E, 0x00, 0x1E, 0x00, 0x1F, 0x80,
  0x03, 0x80, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xDC, 0x00, 0x01, 0xFB,
  0xC0, 0x00, 0x3F, 0x3C, 0x00, 0x07, 0xE3, 0x80, 0x00, 0xFC, 0x78, 0x00,
  0x1F, 0x87, 0x80, 0x03, 0xF0, 0x70, 0x00, 0x7E, 0x0F, 0x00, 0x0F, 0xC0,
  0xF0, 0x01, 0xF8, 0x0E, 0x00, 0x3F, 0x01, 0xE0, 0x07, 0xE0, 0x1E, 0x00,
  0xFC, 0x01, 0xC0, 0x1F, 0x80, 0x3C, 0x03, 0xF0, 0x03, 0x80, 0x7E, 0x00,
  0x38, 0x0F, 0xC0, 0x07, 0x81, 0xF8, 0x00, 0x70, 0x3F, 0x00, 0x07, 0x07,
  0xE0, 0x00, 0xF0, 0xFC, 0x00, 0x0E, 0x1F, 0x80, 0x00, 0xE3, 0xF0, 0x00,
  0x1E, 0x7E, 0x00, 0x01, 0xCF, 0xC0, 0x00, 0x1D, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xF0, 0x38, 0x00,
  0x00, 0x38, 0x3C, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x07, 0x1E, 0x00,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x01,
  0xE3, 0x80, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x00, 0x70, 0x0F, 0x80, 0x00, 0x78, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0E,
  0x00, 0xFE, 0x38, 0x00, 0x3C, 0xE0, 0x00, 0x7B, 0x80, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xB8,
  0x00, 0x0E, 0xE0, 0x00, 0x73, 0x80, 0x07, 0xCF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFC, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x00, 0xF0, 0x38, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0x07, 0x1E, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0F,
  0x70, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x70, 0x0F, 0x80, 0x00,
  0x78, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0D, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xE0, 0x38, 0x01, 0xFC, 0x1C, 0x00, 0x1F, 0x0E, 0x00, 0x07, 0x87, 0x00,
  0x01, 0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x70,
  0x00, 0x0E, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC7,
  0x00, 0x01, 0xE3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0xF0, 0xE0, 0x00, 0xF0,
  0x70, 0x03, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0E, 0x00, 0xE0,
  0x07, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x03,
  0xC0, 0x70, 0x00, 0xE0, 0x38, 0x00, 0x78, 0x1C, 0x00, 0x1C, 0x0E, 0x00,
  0x07, 0x07, 0x00, 0x03, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x78, 0xE0,
  0x00, 0x1C, 0x70, 0x00, 0x07, 0x38, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xF0,
  0x00, 0xFF, 0x80, 0x1F, 0xFF, 0xC1, 0xFF, 0xFF, 0x8F, 0x80, 0x1E, 0x78,
  0x00, 0x09, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7A, 0x00, 0x03, 0xCF, 0xC0, 0x7E,
  0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x03, 0x9E, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x3C, 0x1E,
  0x00, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x40, 0x00, 0xE0, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x03, 0xC1, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0xE0, 0x07, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70,
  0x78, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xF7, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x70, 0x00, 0x1F, 0x00, 0x00, 0xE7,
  0x00, 0x01, 0xF0, 0x00, 0x0E, 0x78, 0x00, 0x1F, 0x80, 0x01, 0xC3, 0x80,
  0x01, 0xB8, 0x00, 0x1C, 0x38, 0x00, 0x39, 0x80, 0x01, 0xC3, 0x80, 0x03,
  0x9C, 0x00, 0x1C, 0x1C, 0x00, 0x39, 0xC0, 0x03, 0x81, 0xC0, 0x07, 0x1C,
  0x00, 0x38, 0x1C, 0x00, 0x70, 0xC0, 0x03, 0x81, 0xC0, 0x07, 0x0E, 0x00,
  0x78, 0x0E, 0x00, 0x60, 0xE0, 0x07, 0x00, 0xE0, 0x0E, 0x06, 0x00, 0x70,
  0x0E, 0x00, 0xE0, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x07, 0x00, 0xE0, 0x07,
  0x00, 0xC0, 0x70, 0x0E, 0x00, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x07, 0x01,
  0xC0, 0x38, 0x0E, 0x00, 0x38, 0x18, 0x03, 0x81, 0xC0, 0x03, 0x83, 0x80,
  0x18, 0x1C, 0x00, 0x38, 0x38, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x1C,
  0x1C, 0x00, 0x1C, 0x30, 0x01, 0xC3, 0x80, 0x01, 0xC7, 0x00, 0x0E, 0x38,
  0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00, 0x0E, 0x70, 0x00,
  0x0E, 0xE0, 0x00, 0x67, 0x00, 0x00, 0xEE, 0x00, 0x07, 0x70, 0x00, 0x0E,
  0xE0, 0x00, 0x77, 0x00, 0x00, 0xEC, 0x00, 0x07, 0x60, 0x00, 0x06, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x78, 0x0E, 0x00, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x38, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x1E, 0x03, 0x80,
  0x00, 0xE0, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x07,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x80, 0x1C, 0x00,
  0x38, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xF0, 0x0E, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x38, 0x3C, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x1C,
  0x70, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x0F, 0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x78,
  0x38, 0x00, 0x0E, 0x03, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x70, 0x07, 0x00,
  0x1E, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0xE0, 0x01, 0xE0, 0x1C, 0x00,
  0x1C, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x07, 0x78, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x03,
  0x8E, 0x00, 0x01, 0xC7, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00,
  0xE0, 0x38, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80,
  0x38, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x0E,
  0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x3B, 0x80, 0x00, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0x3C, 0x00, 0x1F, 0xFC,
  0x07, 0xFF, 0xF8, 0x1E, 0x03, 0xE0, 0x80, 0x07, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x01, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xF0, 0xE3, 0xE0,
  0x07, 0x3C, 0x00, 0x3B, 0xC0, 0x01, 0xDC, 0x00, 0x0F, 0xE0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x3D, 0xC0, 0x01, 0xEE, 0x00, 0x1F, 0x78, 0x01,
  0xD9, 0xE0, 0x3C, 0xC7, 0xFF, 0xC6, 0x1F, 0xF8, 0x30, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x1E, 0x00,
  0xE1, 0xFF, 0xC0, 0xE3, 0xFF, 0xE0, 0xE7, 0x80, 0xF0, 0xEE, 0x00, 0x78,
  0xFC, 0x00, 0x3C, 0xF8, 0x00, 0x1C, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0E,
  0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E,
  0xF0, 0x00, 0x1C, 0xF8, 0x00, 0x1C, 0xFC, 0x00, 0x38, 0xEE, 0x00, 0x78,
  0xE7, 0x81, 0xF0, 0xE3, 0xFF, 0xE0, 0xE1, 0xFF, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x0C, 0x00, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xF8, 0x06, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x10, 0xF8, 0x0E, 0x07, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x70,
  0x3F, 0xF0, 0xE0, 0xFF, 0xF9, 0xC7, 0xC0, 0x7B, 0x8F, 0x00, 0x3F, 0x3C,
  0x00, 0x3E, 0xF0, 0x00, 0x3D, 0xC0, 0x00, 0x7B, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x70, 0x00, 0x1E,
  0xF0, 0x00, 0x3C, 0xE0, 0x00, 0xF9, 0xE0, 0x03, 0x71, 0xF0, 0x1E, 0x61,
  0xFF, 0xF8, 0xC0, 0xFF, 0xC1, 0x80, 0x08, 0x00, 0x00, 0x18, 0x00, 0x07,
  0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xC0, 0x78, 0x1E, 0x00, 0x70, 0xF0, 0x01,
  0xE3, 0x80, 0x03, 0x9C, 0x00, 0x0F, 0x70, 0x00, 0x1D, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x08, 0x3E, 0x01, 0xE0, 0x7F, 0xFF, 0x80, 0x7F,
  0xF8, 0x00, 0x18, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0x78, 0x0E,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x07,
  0xFF, 0x0C, 0x1F, 0xFF, 0x18, 0xF8, 0x0F, 0x71, 0xE0, 0x07, 0xE7, 0x80,
  0x07, 0xDE, 0x00, 0x07, 0xB8, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x03, 0xDE,
  0x00, 0x07, 0x9C, 0x00, 0x1F, 0x1C, 0x00, 0x6E, 0x3E, 0x03, 0xDC, 0x3F,
  0xFF, 0x38, 0x1F, 0xF8, 0x70, 0x01, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xE3, 0x00, 0x07, 0x87, 0xE0, 0x7E, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0xC0, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x07, 0x00,
  0xE1, 0xFF, 0xC3, 0x8F, 0xFF, 0x8E, 0x70, 0x0F, 0x3B, 0x80, 0x1E, 0xFC,
  0x00, 0x3B, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xC0, 0xEF, 0xFF, 0x00, 0x00, 0x00, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xE0, 0x01, 0xC0,
  0x3C, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0xA1, 0xE7, 0xFC, 0xFE, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x0F, 0x70, 0x00, 0xF3, 0x80, 0x0F, 0x1C, 0x00, 0xF0,
  0xE0, 0x0F, 0x07, 0x00, 0x70, 0x38, 0x07, 0x01, 0xC0, 0x70, 0x0E, 0x07,
  0x00, 0x70, 0x70, 0x03, 0x87, 0x00, 0x1C, 0x70, 0x00, 0xE7, 0xC0, 0x07,
  0x77, 0x00, 0x3B, 0x3C, 0x01, 0xF0, 0xE0, 0x0F, 0x03, 0x80, 0x70, 0x0E,
  0x03, 0x80, 0x78, 0x1C, 0x01, 0xC0, 0xE0, 0x07, 0x07, 0x00, 0x1C, 0x38,
  0x00, 0xF1, 0xC0, 0x03, 0x8E, 0x00, 0x0E, 0x70, 0x00, 0x7B, 0x80, 0x01,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3C, 0x00, 0x0E, 0x07, 0x0F, 0xFC, 0x07,
  0xFE, 0x38, 0xFF, 0xF0, 0xFF, 0xF9, 0xCE, 0x07, 0xCF, 0x03, 0xEE, 0xC0,
  0x0E, 0xE0, 0x07, 0x7C, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x01, 0xF0, 0x00,
  0xFE, 0x00, 0x0F, 0x00, 0x07, 0xF0, 0x00, 0x78, 0x00, 0x3F, 0x80, 0x03,
  0xC0, 0x00, 0xFC, 0x00, 0x0C, 0x00, 0x07, 0xC0, 0x00, 0x60, 0x00, 0x3E,
  0x00, 0x03, 0x00, 0x01, 0xF0, 0x00, 0x18, 0x00, 0x0F, 0x80, 0x00, 0xC0,
  0x00, 0x7C, 0x00, 0x06, 0x00, 0x03, 0xE0, 0x00, 0x30, 0x00, 0x1F, 0x00,
  0x01, 0x80, 0x00, 0xF8, 0x00, 0x0C, 0x00, 0x07, 0xC0, 0x00, 0x60, 0x00,
  0x3E, 0x00, 0x03, 0x00, 0x01, 0xF0, 0x00, 0x18, 0x00, 0x0F, 0x80, 0x00,
  0xC0, 0x00, 0x7C, 0x00, 0x06, 0x00, 0x03, 0xE0, 0x00, 0x30, 0x00, 0x1F,
  0x00, 0x01, 0x80, 0x00, 0xF8, 0x00, 0x0C, 0x00, 0x07, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x1E, 0x03, 0x87, 0xFF, 0x0E, 0x3F, 0xFE, 0x39, 0xC0,
  0x3C, 0xEE, 0x00, 0x7B, 0xF0, 0x00, 0xEF, 0x80, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x00, 0x18, 0x00, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0x00, 0xF0, 0x1E, 0x00, 0x38, 0x3C, 0x00,
  0x1C, 0x38, 0x00, 0x1E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0E, 0x70, 0x00,
  0x0E, 0x38, 0x00, 0x1C, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x0F, 0x81,
  0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0x1C,
  0x00, 0xE0, 0xFF, 0xC0, 0xE3, 0xFF, 0xE0, 0xE7, 0x80, 0xF0, 0xEE, 0x00,
  0x78, 0xEC, 0x00, 0x3C, 0xF8, 0x00, 0x1C, 0xF8, 0x00, 0x0E, 0xF0, 0x00,
  0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00,
  0x0E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1C, 0xFC, 0x00, 0x3C, 0xEE, 0x00,
  0x78, 0xE7, 0x81, 0xF0, 0xE3, 0xFF, 0xE0, 0xE0, 0xFF, 0x80, 0xE0, 0x18,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x07, 0xFE, 0x0C, 0x1F, 0xFF, 0x18, 0xF8, 0x0F, 0x71, 0xC0, 0x07,
  0xE7, 0x00, 0x07, 0xDE, 0x00, 0x07, 0xB8, 0x00, 0x0F, 0x70, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x77, 0x00, 0x01, 0xEE, 0x00,
  0x03, 0xDE, 0x00, 0x0F, 0x9C, 0x00, 0x1F, 0x3C, 0x00, 0x6E, 0x3E, 0x03,
  0xDC, 0x3F, 0xFE, 0x38, 0x1F, 0xF8, 0x70, 0x03, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x1D, 0xC3, 0xFF, 0x8F, 0xFF, 0x3C,
  0x1E, 0xE0, 0x1D, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0xE3, 0xC0, 0x1C, 0x78, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0xC0, 0x01,
  0xEF, 0x80, 0x7C, 0xFF, 0xFF, 0x83, 0xFF, 0xE0, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x7F, 0xFF, 0xFF, 0xFE, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC1, 0x07,
  0xFE, 0x03, 0xFC, 0x00, 0xC0, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3D, 0xC0, 0x01, 0xF7, 0x00, 0x07, 0xDE, 0x00, 0x37, 0x3E,
  0x03, 0x9C, 0x7F, 0xFC, 0x70, 0x7F, 0xE1, 0xC0, 0x18, 0x00, 0xE0, 0x00,
  0x07, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x1E, 0x38, 0x00,
  0x1C, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x1C, 0x00,
  0x38, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x07, 0x00,
  0xE0, 0x07, 0x00, 0xE0, 0x03, 0x81, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0x81,
  0xC0, 0x01, 0xC3, 0x80, 0x01, 0xC3, 0x80, 0x00, 0xC3, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0x00, 0x0E, 0xE0, 0x00, 0xF0, 0x00, 0xE7, 0x00, 0x1F, 0x80,
  0x0E, 0x70, 0x01, 0xF8, 0x00, 0xE7, 0x00, 0x19, 0x80, 0x1C, 0x38, 0x03,
  0x9C, 0x01, 0xC3, 0x80, 0x39, 0xC0, 0x1C, 0x38, 0x03, 0x9C, 0x01, 0x83,
  0x80, 0x70, 0xE0, 0x38, 0x1C, 0x07, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0xE0,
  0x38, 0x1C, 0x0E, 0x06, 0x07, 0x00, 0xC0, 0xE0, 0x70, 0x70, 0x0E, 0x0E,
  0x07, 0x07, 0x00, 0xE1, 0xC0, 0x30, 0x70, 0x0E, 0x1C, 0x03, 0x8E, 0x00,
  0x71, 0xC0, 0x38, 0xE0, 0x07, 0x38, 0x01, 0x8E, 0x00, 0x73, 0x80, 0x1C,
  0xC0, 0x03, 0x38, 0x01, 0xDC, 0x00, 0x3B, 0x00, 0x0D, 0xC0, 0x03, 0xF0,
  0x00, 0xDC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x70, 0x00, 0x1E,
  0x70, 0x00, 0x78, 0xF0, 0x00, 0xE0, 0xE0, 0x03, 0x80, 0xE0, 0x0F, 0x00,
  0xE0, 0x1C, 0x01, 0xE0, 0x70, 0x01, 0xC1, 0xE0, 0x01, 0xC3, 0x80, 0x03,
  0xCE, 0x00, 0x03, 0xB8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x77, 0x00, 0x00, 0xE7, 0x00, 0x03, 0x8F,
  0x00, 0x0E, 0x0E, 0x00, 0x3C, 0x0E, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x1E,
  0x07, 0x80, 0x1C, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x3C, 0xE0, 0x00, 0x3B,
  0xC0, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E,
  0x70, 0x00, 0x1E, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x38,
  0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x70,
  0x07, 0x00, 0xF0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x03, 0x81, 0xC0,
  0x03, 0x81, 0xC0, 0x01, 0xC1, 0xC0, 0x01, 0xC3, 0x80, 0x01, 0xC3, 0x80,
  0x00, 0xE3, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x67, 0x00, 0x00, 0x76, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x87, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x7F,
  0x00, 0xF8, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00,
  0x7E, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x07,
  0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x1F, 0x80, 0x78, 0x01, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0x80, 0x00,
  0x0F, 0x80, 0x02, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x1E, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xD0, 0x00, 0x3E, 0x00,
};

const GFXglyph NotoSans_Light51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 5, 37, 13, 4, -36 },
  { 25, 11, 13, 19, 4, -36 },
  { 43, 31, 36, 33, 1, -36 },
  { 183, 22, 42, 29, 3, -39 },
  { 299, 36, 38, 41, 3, -37 },
  { 470, 33, 38, 37, 3, -37 },
  { 627, 3, 13, 10, 4, -36 },
  { 632, 11, 44, 14, 2, -36 },
  { 693, 10, 44, 14, 2, -36 },
  { 748, 22, 22, 28, 3, -39 },
  { 809, 23, 24, 29, 3, -30 },
  { 878, 6, 13, 12, 2, -6 },
  { 888, 12, 3, 16, 2, -15 },
  { 893, 5, 5, 12, 4, -4 },
  { 897, 16, 36, 18, 1, -36 },
  { 969, 23, 38, 29, 3, -37 },
  { 1079, 12, 36, 29, 5, -36 },
  { 1133, 23, 37, 29, 3, -37 },
  { 1240, 24, 38, 29, 2, -37 },
  { 1354, 27, 37, 29, 1, -37 },
  { 1479, 22, 37, 29, 4, -36 },
  { 1581, 23, 38, 29, 3, -37 },
  { 1691, 23, 36, 29, 3, -36 },
  { 1795, 23, 38, 29, 3, -37 },
  { 1905, 23, 38, 29, 3, -37 },
  { 2015, 5, 29, 12, 4, -28 },
  { 2034, 6, 35, 12, 2, -28 },
  { 2061, 23, 24, 29, 3, -30 },
  { 2130, 23, 12, 29, 3, -24 },
  { 2165, 23, 24, 29, 3, -30 },
  { 2234, 19, 38, 22, 1, -37 },
  { 2325, 40, 41, 45, 3, -36 },
  { 2530, 31, 37, 31, 0, -37 },
  { 2674, 24, 36, 32, 5, -36 },
  { 2782, 27, 38, 32, 3, -37 },
  { 2911, 28, 36, 36, 5, -36 },
  { 3037, 20, 36, 28, 5, -36 },
  { 3127, 20, 36, 26, 5, -36 },
  { 3217, 30, 38, 37, 3, -37 },
  { 3360, 27, 36, 37, 5, -36 },
  { 3482, 10, 36, 16, 3, -36 },
  { 3527, 12, 45, 13, -4, -36 },
  { 3595, 25, 36, 30, 5, -36 },
  { 3708, 20, 36, 26, 5, -36 },
  { 3798, 34, 36, 44, 5, -36 },
  { 3951, 27, 36, 37, 5, -36 },
  { 4073, 33, 38, 39, 3, -37 },
  { 4230, 22, 36, 30, 5, -36 },
  { 4329, 33, 46, 39, 3, -37 },
  { 4519, 25, 36, 31, 5, -36 },
  { 4632, 22, 38, 28, 3, -37 },
  { 4737, 27, 36, 27, 0, -36 },
  { 4859, 27, 37, 37, 5, -36 },
  { 4984, 30, 36, 30, 0, -36 },
  { 5119, 44, 36, 46, 1, -36 },
  { 5317, 28, 36, 28, 0, -36 },
  { 5443, 27, 36, 27, 0, -36 },
  { 5565, 25, 36, 29, 2, -36 },
  { 5678, 11, 44, 16, 4, -36 },
  { 5739, 16, 36, 18, 1, -36 },
  { 5811, 11, 44, 16, 1, -36 },
  { 5872, 25, 23, 29, 2, -37 },
  { 5944, 21, 2, 21, 0, 5 },
  { 5950, 9, 8, 14, 2, -39 },
  { 5959, 21, 29, 27, 2, -28 },
  { 6036, 24, 40, 31, 4, -39 },
  { 6156, 20, 29, 24, 3, -28 },
  { 6229, 23, 40, 31, 3, -39 },
  { 6344, 22, 29, 28, 3, -28 },
  { 6424, 18, 39, 16, 1, -39 },
  { 6512, 23, 40, 31, 3, -28 },
  { 6627, 22, 39, 30, 4, -39 },
  { 6735, 4, 37, 12, 4, -37 },
  { 6754, 11, 49, 12, -3, -37 },
  { 6822, 21, 39, 25, 4, -39 },
  { 6925, 3, 39, 12, 4, -39 },
  { 6940, 37, 28, 46, 4, -28 },
  { 7070, 22, 28, 30, 4, -28 },
  { 7147, 24, 29, 30, 3, -28 },
  { 7234, 24, 40, 31, 4, -28 },
  { 7354, 23, 40, 31, 3, -28 },
  { 7469, 15, 28, 20, 4, -28 },
  { 7522, 20, 29, 24, 2, -28 },
  { 7595, 15, 35, 17, 1, -34 },
  { 7661, 22, 28, 30, 4, -27 },
  { 7738, 24, 27, 24, 0, -27 },
  { 7819, 36, 27, 38, 1, -27 },
  { 7941, 23, 27, 26, 1, -27 },
  { 8019, 24, 39, 24, 0, -27 },
  { 8136, 20, 27, 24, 2, -27 },
  { 8204, 16, 44, 18, 1, -36 },
  { 8292, 2, 52, 28, 13, -39 },
  { 8305, 15, 44, 18, 2, -36 },
  { 8388, 23, 6, 29, 3, -21 },
};

const GFXfont NotoSans_Light51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light51pt7bBitmaps,
  (GFXglyph *)NotoSans_Light51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_LIGHT51PT7B_H_
