#ifndef _NOTOSANS_LIGHT33PT7B_H_
#define _NOTOSANS_LIGHT33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light33pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xD8, 0x01, 0xBE, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0x43, 0x42, 0x42, 0x42, 0x01, 0x81, 0x00, 0x30, 0x20,
  0x06, 0x0C, 0x00, 0xC1, 0x80, 0x10, 0x30, 0x06, 0x04, 0x00, 0xC0, 0x80,
  0x18, 0x30, 0x7F, 0xFF, 0xE0, 0x40, 0xC0, 0x08, 0x10, 0x03, 0x02, 0x00,
  0x60, 0xC0, 0x0C, 0x18, 0x01, 0x03, 0x07, 0xFF, 0xFE, 0xFF, 0xFF, 0xC1,
  0x83, 0x00, 0x30, 0x60, 0x04, 0x0C, 0x00, 0x81, 0x00, 0x30, 0x20, 0x06,
  0x0C, 0x00, 0xC1, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x7C, 0x0F, 0xFE, 0x73,
  0x19, 0x8C, 0x0C, 0x30, 0x30, 0xC0, 0xC3, 0x03, 0x0C, 0x06, 0x30, 0x0E,
  0xC0, 0x1F, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0xC6, 0x03, 0x0C, 0x0C, 0x30,
  0x30, 0xC0, 0xC3, 0x03, 0x0E, 0x0C, 0x6F, 0xFF, 0x0F, 0xF0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x60, 0xFE, 0x01, 0x81, 0x8C, 0x03,
  0x06, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x30, 0x60, 0x20, 0x20, 0x80,
  0x40, 0x43, 0x00, 0x81, 0x84, 0x01, 0x83, 0x18, 0x03, 0x06, 0x63, 0xE6,
  0x0C, 0xCC, 0x66, 0x33, 0x30, 0x4F, 0xE6, 0x60, 0xC7, 0x18, 0x81, 0x80,
  0x21, 0x03, 0x00, 0xC2, 0x06, 0x01, 0x04, 0x0C, 0x06, 0x08, 0x18, 0x18,
  0x10, 0x30, 0x30, 0x30, 0x60, 0xC0, 0x60, 0x81, 0x80, 0x63, 0x06, 0x00,
  0x7C, 0x07, 0xC0, 0x00, 0x7F, 0x80, 0x06, 0x06, 0x00, 0x30, 0x30, 0x03,
  0x00, 0x80, 0x18, 0x04, 0x00, 0xC0, 0x60, 0x03, 0x03, 0x00, 0x1C, 0x30,
  0x00, 0x67, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xDC, 0x00, 0x18,
  0x70, 0x19, 0x81, 0xC0, 0xD8, 0x07, 0x0C, 0xC0, 0x1C, 0x66, 0x00, 0x76,
  0x30, 0x01, 0xF1, 0x80, 0x07, 0x0E, 0x00, 0x7C, 0x38, 0x07, 0x70, 0xFB,
  0xF1, 0xC3, 0xFE, 0x07, 0xFF, 0xD5, 0x40, 0x06, 0x18, 0x30, 0xC1, 0x86,
  0x0C, 0x30, 0x60, 0xC1, 0x82, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x81, 0x83,
  0x06, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x60, 0x60, 0x60, 0xC0, 0xC0, 0xC1,
  0x81, 0x83, 0x06, 0x06, 0x0C, 0x18, 0x10, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x60, 0xC1, 0x83, 0x0C, 0x18, 0x60, 0xC3, 0x0E, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x83, 0x07, 0x8C, 0x7F, 0xFF, 0xC1,
  0xE0, 0x07, 0x80, 0x13, 0x00, 0xCC, 0x06, 0x18, 0x38, 0x70, 0x40, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x7F, 0xFF, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x33, 0x36, 0x66, 0x4C, 0xFF, 0xFF, 0xDF,
  0x00, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x08,
  0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x40, 0x18,
  0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x07, 0xC0,
  0x3F, 0xE0, 0xE0, 0xE3, 0x80, 0xC6, 0x00, 0xCC, 0x01, 0xB0, 0x01, 0x60,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0D, 0x00, 0x33, 0x00, 0x66,
  0x01, 0xC6, 0x03, 0x07, 0x1C, 0x07, 0xF0, 0x03, 0x07, 0x0F, 0x3B, 0x73,
  0xE3, 0x43, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x0F, 0xC0, 0x7F, 0xE3, 0xC0,
  0xE2, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xC0, 0xFF, 0xE3, 0x80, 0xE4, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x70, 0x01,
  0xC0, 0xFC, 0x01, 0xFF, 0x00, 0x07, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xD0, 0x03, 0x3C, 0x3C, 0x3F,
  0xF0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0D, 0x00, 0x0C, 0x80,
  0x06, 0x40, 0x06, 0x20, 0x06, 0x10, 0x02, 0x08, 0x03, 0x04, 0x03, 0x02,
  0x03, 0x01, 0x01, 0x80, 0x81, 0x80, 0x41, 0x80, 0x20, 0x80, 0x10, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x3F, 0xF8, 0x7F, 0xF0, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xFF,
  0x83, 0xC7, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xD0, 0x03, 0x3E, 0x3C, 0x3F,
  0xF0, 0x01, 0xF8, 0x0F, 0xF0, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x83, 0x03, 0x3F, 0xC6, 0xC0, 0xCF,
  0x00, 0xDC, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0D, 0x00,
  0x1B, 0x00, 0x37, 0x00, 0xC6, 0x03, 0x87, 0x1E, 0x07, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x60, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xC0,
  0x63, 0x00, 0x66, 0x00, 0xCC, 0x01, 0x98, 0x03, 0x30, 0x06, 0x70, 0x18,
  0x70, 0x60, 0x7B, 0x80, 0x3C, 0x01, 0xEE, 0x07, 0x07, 0x18, 0x07, 0x60,
  0x06, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xCC, 0x03,
  0x8F, 0x1E, 0x0F, 0xF0, 0x0F, 0xC0, 0x7F, 0xC1, 0xC0, 0xC3, 0x00, 0xCC,
  0x00, 0xD8, 0x01, 0xB0, 0x01, 0x60, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x3F, 0x00, 0x76, 0x03, 0x67, 0xFC, 0xC7, 0xF1, 0x80, 0x02, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x10, 0x78, 0x3F,
  0xC0, 0xDF, 0x00, 0x00, 0x00, 0x00, 0x06, 0xF8, 0x33, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x33, 0x76, 0x66, 0x4C, 0x00, 0x02, 0x00, 0x0C, 0x00,
  0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80,
  0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x78, 0x03,
  0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x00, 0x40, 0x00, 0x3F, 0x0F,
  0xFC, 0xC0, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60,
  0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x0C, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x60, 0x01, 0xC0, 0x70, 0x00, 0x18, 0x18,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0xC6, 0x01, 0xF8, 0x19, 0x81, 0xFF, 0x06,
  0x40, 0xC0, 0xC0, 0xB0, 0x60, 0x30, 0x2C, 0x18, 0x0C, 0x0B, 0x04, 0x03,
  0x03, 0xC1, 0x00, 0xC0, 0xA0, 0x40, 0x30, 0x28, 0x10, 0x0C, 0x0B, 0x06,
  0x03, 0x06, 0xC1, 0x81, 0x41, 0x30, 0x30, 0xD8, 0xCC, 0x07, 0xE3, 0xE1,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x80, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x98, 0x00,
  0x19, 0x80, 0x01, 0x88, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0x60,
  0x06, 0x06, 0x00, 0x60, 0x60, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0F, 0xFF,
  0x01, 0xFF, 0xF8, 0x18, 0x01, 0x81, 0x80, 0x0C, 0x30, 0x00, 0xC3, 0x00,
  0x0C, 0x60, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x6C, 0x00, 0x03, 0xFF,
  0x80, 0xFF, 0xF8, 0xC0, 0x3C, 0xC0, 0x0E, 0xC0, 0x06, 0xC0, 0x06, 0xC0,
  0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0C, 0xC0, 0x38, 0xFF, 0xE0, 0xC1,
  0xF8, 0xC0, 0x0E, 0xC0, 0x06, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x06, 0xC0, 0x0E, 0xFF, 0xFC, 0xFF, 0xF0, 0x00,
  0xFE, 0x00, 0xFF, 0xF0, 0xF0, 0x18, 0x70, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xFC, 0xF8, 0x0F, 0xFC, 0xFF, 0x00, 0x3F, 0xFE, 0x0C, 0x03, 0xC3,
  0x00, 0x3C, 0xC0, 0x03, 0x30, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1B,
  0x00, 0x0E, 0xC0, 0x07, 0x30, 0x07, 0x8F, 0xFF, 0x83, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0xFF, 0xFC, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xFC, 0x3C, 0x03,
  0x8E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x0D,
  0x80, 0x01, 0x98, 0x00, 0x33, 0x80, 0x06, 0x3C, 0x00, 0xC1, 0xF9, 0xF8,
  0x1F, 0xFE, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFC, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x7F, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x06, 0xFE, 0xF8, 0xC0,
  0x03, 0xC0, 0x06, 0xC0, 0x0C, 0xC0, 0x18, 0xC0, 0x30, 0xC0, 0x60, 0xC0,
  0xC0, 0xC1, 0x80, 0xC3, 0x00, 0xC7, 0x00, 0xCE, 0x00, 0xDE, 0x00, 0xF3,
  0x00, 0xE3, 0x80, 0xC1, 0x80, 0xC0, 0xC0, 0xC0, 0x60, 0xC0, 0x70, 0xC0,
  0x30, 0xC0, 0x18, 0xC0, 0x0C, 0xC0, 0x0E, 0xC0, 0x06, 0xC0, 0x03, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x0D, 0xD8, 0x00, 0x37, 0x60, 0x00, 0x9C, 0xC0, 0x06, 0x73, 0x00, 0x19,
  0xCC, 0x00, 0xC7, 0x18, 0x03, 0x1C, 0x60, 0x08, 0x70, 0xC0, 0x61, 0xC3,
  0x01, 0x87, 0x0C, 0x0C, 0x1C, 0x18, 0x30, 0x70, 0x60, 0x81, 0xC0, 0xC6,
  0x07, 0x03, 0x18, 0x1C, 0x0C, 0xC0, 0x70, 0x1B, 0x01, 0xC0, 0x68, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0xC0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xD8, 0x00, 0xF7, 0x00, 0x3C, 0xC0, 0x0F,
  0x18, 0x03, 0xC7, 0x00, 0xF0, 0xC0, 0x3C, 0x18, 0x0F, 0x07, 0x03, 0xC0,
  0xC0, 0xF0, 0x18, 0x3C, 0x07, 0x0F, 0x00, 0xC3, 0xC0, 0x18, 0xF0, 0x07,
  0x3C, 0x00, 0xCF, 0x00, 0x1B, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x07, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0x80, 0xF0, 0x30, 0x01,
  0xC3, 0x00, 0x06, 0x38, 0x00, 0x19, 0x80, 0x00, 0xCC, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00,
  0x01, 0x98, 0x00, 0x0C, 0x60, 0x00, 0xE3, 0x80, 0x06, 0x0E, 0x00, 0xE0,
  0x3F, 0x3E, 0x00, 0x7F, 0xC0, 0xFE, 0x01, 0xFF, 0xE3, 0x01, 0xE6, 0x00,
  0xEC, 0x00, 0xD8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1B,
  0x00, 0x36, 0x00, 0xCC, 0x0F, 0x1F, 0xFC, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0x80, 0xF0, 0x30, 0x01,
  0xC3, 0x00, 0x06, 0x38, 0x00, 0x19, 0x80, 0x00, 0xCC, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00,
  0x01, 0x98, 0x00, 0x0C, 0x60, 0x00, 0xE3, 0x80, 0x06, 0x0E, 0x00, 0xE0,
  0x3F, 0x3E, 0x00, 0x7F, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0xFE, 0x00, 0xFF,
  0xF0, 0xC0, 0x78, 0xC0, 0x1C, 0xC0, 0x0C, 0xC0, 0x06, 0xC0, 0x06, 0xC0,
  0x06, 0xC0, 0x0E, 0xC0, 0x0C, 0xC0, 0x1C, 0xC0, 0x38, 0xFF, 0xF0, 0xFF,
  0xC0, 0xC0, 0xC0, 0xC0, 0x60, 0xC0, 0x70, 0xC0, 0x30, 0xC0, 0x18, 0xC0,
  0x18, 0xC0, 0x0C, 0xC0, 0x0E, 0xC0, 0x06, 0xC0, 0x03, 0x07, 0xE0, 0xFF,
  0xF7, 0x00, 0x98, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0x80,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x6F,
  0x8F, 0x3F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x19, 0x80, 0x06, 0x60, 0x03, 0x8E, 0x01, 0xC1, 0xF3, 0xE0, 0x3F, 0xE0,
  0xC0, 0x00, 0x78, 0x00, 0x0D, 0x80, 0x03, 0x30, 0x00, 0x67, 0x00, 0x0C,
  0x60, 0x03, 0x0C, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x03, 0x03, 0x00, 0x60,
  0x30, 0x1C, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x0C, 0x18, 0x01, 0x83, 0x00,
  0x18, 0x60, 0x03, 0x18, 0x00, 0x63, 0x00, 0x06, 0x60, 0x00, 0xD8, 0x00,
  0x1B, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0xC0, 0x06, 0x00,
  0x3C, 0x00, 0xE0, 0x03, 0xC0, 0x0E, 0x00, 0x66, 0x00, 0xF0, 0x06, 0x60,
  0x0B, 0x00, 0x66, 0x01, 0xB0, 0x06, 0x60, 0x19, 0x00, 0xC3, 0x01, 0x98,
  0x0C, 0x30, 0x31, 0x80, 0xC3, 0x03, 0x08, 0x0C, 0x30, 0x30, 0xC1, 0x81,
  0x82, 0x0C, 0x18, 0x18, 0x60, 0xC1, 0x81, 0x86, 0x06, 0x30, 0x08, 0x60,
  0x63, 0x00, 0xC4, 0x06, 0x30, 0x0C, 0xC0, 0x23, 0x00, 0xCC, 0x03, 0x60,
  0x06, 0xC0, 0x36, 0x00, 0x78, 0x03, 0x60, 0x07, 0x80, 0x16, 0x00, 0x78,
  0x01, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x60, 0x01, 0x9C,
  0x00, 0x63, 0x00, 0x30, 0x60, 0x1C, 0x18, 0x06, 0x03, 0x03, 0x00, 0x60,
  0xC0, 0x18, 0x60, 0x03, 0x30, 0x00, 0xEC, 0x00, 0x1E, 0x00, 0x03, 0x00,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x33, 0x00, 0x1C, 0x60, 0x06, 0x18, 0x03,
  0x03, 0x00, 0xC0, 0xE0, 0x60, 0x18, 0x30, 0x03, 0x0C, 0x00, 0xC6, 0x00,
  0x1B, 0x00, 0x03, 0xC0, 0x00, 0xD8, 0x00, 0x66, 0x00, 0x38, 0xC0, 0x0C,
  0x30, 0x06, 0x06, 0x01, 0x81, 0x80, 0xC0, 0x30, 0x30, 0x0C, 0x18, 0x01,
  0x86, 0x00, 0x63, 0x00, 0x0C, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x7F, 0xFF, 0x3F,
  0xFF, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0F, 0xE0, 0xC0, 0x0C, 0x01, 0x80, 0x10, 0x03, 0x00, 0x60, 0x06, 0x00,
  0xC0, 0x18, 0x01, 0x80, 0x30, 0x02, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x30, 0x06, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x18, 0x03, 0xFF,
  0xFC, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x3F,
  0xE0, 0x00, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x60, 0x02, 0x60, 0x06,
  0x30, 0x04, 0x30, 0x0C, 0x18, 0x08, 0x18, 0x18, 0x0C, 0x10, 0x0C, 0x30,
  0x06, 0x20, 0x06, 0x60, 0x03, 0xC0, 0x03, 0xFF, 0xFC, 0xE0, 0xC3, 0x86,
  0x04, 0x0F, 0xC3, 0xFF, 0x08, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x0F, 0xF9, 0xE0, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0xF8, 0x0F, 0xF1, 0xD9, 0xFC, 0xC0, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x63, 0xE0, 0xDF, 0xF1,
  0xE0, 0x73, 0x80, 0x77, 0x00, 0x6C, 0x00, 0xD8, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xDC, 0x01,
  0xBC, 0x06, 0x4E, 0x78, 0x8F, 0xE0, 0x07, 0xE0, 0xFF, 0xCE, 0x02, 0xE0,
  0x06, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x1E, 0x70, 0x7F, 0x80,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x83, 0xE3, 0x1F, 0xF6, 0x70, 0x2D, 0xC0, 0x3B, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0xEC, 0x01, 0xDC, 0x07, 0x9E, 0x3B, 0x1F, 0xE6, 0x07,
  0xC0, 0x7F, 0xC3, 0x83, 0x98, 0x06, 0x60, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06,
  0x00, 0x0C, 0x01, 0x1E, 0x3C, 0x3F, 0xE0, 0x03, 0xF0, 0x73, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xFC, 0xFF, 0xC0, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x07, 0xC6, 0x3F,
  0xEC, 0xE0, 0x7B, 0x00, 0x76, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xD8,
  0x03, 0xB8, 0x0F, 0x3C, 0x76, 0x1F, 0xCC, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x01, 0x80, 0x03, 0x30, 0x0C, 0x7F, 0xF0, 0x3F, 0x80, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x31, 0xF0,
  0xDF, 0xF3, 0xC0, 0xEE, 0x01, 0xB8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0C, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x06, 0x0C, 0x18, 0x00, 0x00, 0x01, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x61, 0xBF, 0x7C, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x07, 0xC0, 0x76, 0x07, 0x30, 0x31, 0x83, 0x0C,
  0x30, 0x63, 0x03, 0x30, 0x1B, 0x80, 0xF6, 0x07, 0x38, 0x30, 0xC1, 0x83,
  0x0C, 0x0C, 0x60, 0x73, 0x01, 0x98, 0x06, 0xC0, 0x18, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x87, 0xC0, 0xF8, 0xDF, 0xE3, 0xFC, 0xF0, 0x76,
  0x0E, 0xE0, 0x3C, 0x06, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18,
  0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18,
  0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18,
  0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0x87, 0xC3,
  0x7F, 0xCF, 0x03, 0xB8, 0x06, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x30, 0x07, 0xC0, 0x1F, 0xF0, 0x38, 0x18,
  0x70, 0x0C, 0x60, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x02, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x06, 0xC0, 0x06, 0x60, 0x06, 0x60, 0x0C,
  0x30, 0x1C, 0x1C, 0x78, 0x0F, 0xE0, 0x87, 0xC1, 0xBF, 0xE3, 0x40, 0xE7,
  0x00, 0xEE, 0x00, 0xD8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xB8, 0x03, 0x78, 0x0C,
  0xDC, 0x71, 0x9F, 0xC3, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x07, 0xC6, 0x3F, 0xCC, 0xE0,
  0x5B, 0x00, 0x76, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xD8, 0x03, 0xB8,
  0x0F, 0x3C, 0x76, 0x3F, 0x8C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x87, 0xF7, 0xEF, 0x83,
  0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x1F, 0x87, 0xFF, 0xE0, 0x2C,
  0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x00, 0x30, 0x03, 0x00, 0x38, 0x06, 0xE0, 0xEF, 0xF8, 0x08, 0x06,
  0x01, 0x80, 0x60, 0x3F, 0xFF, 0xF1, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x0E,
  0x41, 0xF0, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x7C, 0x01, 0xF8, 0x0F, 0x78, 0xEC, 0xFE, 0x30, 0xC0, 0x07,
  0x80, 0x0D, 0x80, 0x1B, 0x00, 0x63, 0x00, 0xC6, 0x01, 0x8C, 0x06, 0x0C,
  0x0C, 0x18, 0x30, 0x30, 0x60, 0x30, 0xC0, 0x63, 0x00, 0x66, 0x00, 0xC8,
  0x01, 0xB0, 0x01, 0xE0, 0x03, 0x80, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x60,
  0x1C, 0x03, 0x60, 0x1C, 0x06, 0x60, 0x34, 0x06, 0x30, 0x36, 0x06, 0x30,
  0x26, 0x04, 0x30, 0x66, 0x0C, 0x30, 0x62, 0x0C, 0x18, 0x63, 0x0C, 0x18,
  0xC3, 0x18, 0x18, 0xC1, 0x18, 0x08, 0xC1, 0x98, 0x0D, 0x81, 0x98, 0x0D,
  0x80, 0xB0, 0x0D, 0x80, 0xF0, 0x05, 0x00, 0xF0, 0x07, 0x00, 0x60, 0x07,
  0x00, 0x60, 0xC0, 0x0C, 0xC0, 0x19, 0xC0, 0x61, 0x81, 0x81, 0x87, 0x01,
  0x8C, 0x03, 0x30, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1F, 0x00, 0x66,
  0x00, 0xC6, 0x03, 0x06, 0x0C, 0x0C, 0x38, 0x0C, 0x60, 0x0D, 0x80, 0x1C,
  0xC0, 0x07, 0xC0, 0x06, 0x60, 0x06, 0x60, 0x0C, 0x30, 0x0C, 0x30, 0x0C,
  0x30, 0x18, 0x18, 0x18, 0x18, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x60,
  0x06, 0x60, 0x06, 0x60, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0xFC, 0x00, 0xF0, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x0C, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x40,
  0xF0, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x18, 0x0E, 0x0E, 0x03, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x1E, 0x03, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x3C, 0x01, 0x80,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x01, 0xC0, 0x1C, 0x0F, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x01, 0xC1, 0xE0, 0xF0, 0x00, 0x7F, 0x03, 0x87,
  0xDE, 0x03, 0xF0,
};

const GFXglyph NotoSans_Light33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 24, 8, 3, -24 },
  { 10, 8, 9, 12, 2, -24 },
  { 19, 19, 24, 21, 1, -24 },
  { 76, 14, 27, 19, 2, -25 },
  { 124, 23, 24, 27, 2, -24 },
  { 193, 21, 24, 24, 2, -24 },
  { 256, 2, 9, 7, 2, -24 },
  { 259, 7, 29, 9, 1, -24 },
  { 285, 7, 29, 9, 1, -24 },
  { 311, 14, 14, 18, 2, -25 },
  { 336, 15, 15, 19, 2, -19 },
  { 365, 4, 8, 7, 1, -4 },
  { 369, 8, 2, 11, 1, -10 },
  { 371, 3, 3, 8, 3, -3 },
  { 373, 11, 24, 11, 0, -24 },
  { 406, 15, 24, 19, 2, -24 },
  { 451, 8, 24, 19, 3, -24 },
  { 475, 15, 24, 19, 2, -24 },
  { 520, 15, 24, 19, 2, -24 },
  { 565, 17, 24, 19, 1, -24 },
  { 616, 15, 24, 19, 2, -24 },
  { 661, 15, 24, 19, 2, -24 },
  { 706, 15, 24, 19, 2, -24 },
  { 751, 15, 24, 19, 2, -24 },
  { 796, 15, 24, 19, 2, -24 },
  { 841, 3, 18, 8, 3, -18 },
  { 848, 4, 22, 8, 1, -18 },
  { 859, 15, 16, 19, 2, -20 },
  { 889, 15, 8, 19, 2, -16 },
  { 904, 15, 16, 19, 2, -20 },
  { 934, 12, 24, 14, 1, -24 },
  { 970, 26, 26, 29, 2, -23 },
  { 1055, 20, 24, 20, 0, -24 },
  { 1115, 16, 24, 21, 3, -24 },
  { 1163, 18, 24, 21, 2, -24 },
  { 1217, 18, 24, 23, 3, -24 },
  { 1271, 13, 24, 18, 3, -24 },
  { 1310, 13, 24, 17, 3, -24 },
  { 1349, 19, 24, 24, 2, -24 },
  { 1406, 18, 24, 24, 3, -24 },
  { 1460, 7, 24, 10, 2, -24 },
  { 1481, 8, 30, 8, -3, -24 },
  { 1511, 16, 24, 19, 3, -24 },
  { 1559, 13, 24, 17, 3, -24 },
  { 1598, 22, 24, 29, 3, -24 },
  { 1664, 18, 24, 24, 3, -24 },
  { 1718, 21, 24, 25, 2, -24 },
  { 1781, 15, 24, 19, 3, -24 },
  { 1826, 21, 30, 25, 2, -24 },
  { 1905, 16, 24, 20, 3, -24 },
  { 1953, 14, 24, 18, 2, -24 },
  { 1995, 17, 24, 18, 0, -24 },
  { 2046, 18, 24, 24, 3, -24 },
  { 2100, 19, 24, 19, 0, -24 },
  { 2157, 28, 24, 30, 1, -24 },
  { 2241, 18, 24, 18, 0, -24 },
  { 2295, 18, 24, 18, 0, -24 },
  { 2349, 17, 24, 19, 1, -24 },
  { 2400, 7, 29, 11, 3, -24 },
  { 2426, 11, 24, 11, 0, -24 },
  { 2459, 7, 29, 11, 1, -24 },
  { 2485, 16, 15, 19, 1, -24 },
  { 2515, 14, 1, 14, 0, 3 },
  { 2517, 6, 5, 9, 1, -25 },
  { 2521, 13, 18, 18, 2, -18 },
  { 2551, 15, 25, 20, 3, -25 },
  { 2598, 13, 18, 16, 2, -18 },
  { 2628, 15, 25, 20, 2, -25 },
  { 2675, 14, 18, 18, 2, -18 },
  { 2707, 12, 25, 10, 0, -25 },
  { 2745, 15, 26, 20, 2, -18 },
  { 2794, 14, 25, 20, 3, -25 },
  { 2838, 2, 24, 8, 3, -24 },
  { 2844, 7, 32, 8, -2, -24 },
  { 2872, 13, 25, 16, 3, -25 },
  { 2913, 2, 25, 8, 3, -25 },
  { 2920, 24, 18, 30, 3, -18 },
  { 2974, 14, 18, 20, 3, -18 },
  { 3006, 16, 18, 19, 2, -18 },
  { 3042, 15, 26, 20, 3, -18 },
  { 3091, 15, 26, 20, 2, -18 },
  { 3140, 10, 18, 13, 3, -18 },
  { 3163, 12, 18, 15, 2, -18 },
  { 3190, 10, 22, 11, 0, -22 },
  { 3218, 14, 18, 20, 3, -18 },
  { 3250, 15, 18, 15, 0, -18 },
  { 3284, 24, 18, 24, 0, -18 },
  { 3338, 15, 18, 17, 1, -18 },
  { 3372, 16, 26, 15, 0, -18 },
  { 3424, 13, 18, 15, 1, -18 },
  { 3454, 10, 29, 12, 1, -24 },
  { 3491, 2, 33, 18, 8, -25 },
  { 3500, 10, 29, 12, 1, -24 },
  { 3537, 15, 3, 19, 2, -13 },
};

const GFXfont NotoSans_Light33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light33pt7bBitmaps,
  (GFXglyph *)NotoSans_Light33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_LIGHT33PT7B_H_
