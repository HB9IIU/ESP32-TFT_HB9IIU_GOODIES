#ifndef _NOTOSANS_LIGHT7PT7B_H_
#define _NOTOSANS_LIGHT7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light7pt7bBitmaps[] PROGMEM = {
  0x00, 0xF8, 0xF0, 0x5F, 0x5E, 0x60, 0x79, 0xBE, 0xF5, 0xBE, 0x75, 0x80,
  0x63, 0x1B, 0x2F, 0x80, 0xC0, 0x6A, 0x90, 0x95, 0x60, 0xCD, 0x80, 0x4F,
  0x40, 0xC0, 0xC0, 0x80, 0x56, 0x80, 0x69, 0x99, 0x60, 0xF8, 0xE1, 0x24,
  0xF0, 0xE1, 0x61, 0xE0, 0x26, 0x6F, 0x20, 0xE8, 0x61, 0xE0, 0x68, 0xF9,
  0x70, 0xF2, 0x24, 0x40, 0xF9, 0x69, 0xF0, 0xE9, 0xF1, 0x60, 0x90, 0x98,
  0x3C, 0x30, 0xF0, 0xC3, 0xC0, 0xE5, 0x24, 0x7A, 0x5A, 0xED, 0x89, 0xC0,
  0x26, 0x5B, 0x90, 0xF7, 0x5E, 0x78, 0x88, 0x70, 0xE9, 0x99, 0xE0, 0xEE,
  0xC0, 0xEE, 0x80, 0x7C, 0x27, 0x17, 0x80, 0xB7, 0xDA, 0xD5, 0xC0, 0x55,
  0x70, 0xBA, 0x6A, 0xAA, 0xC0, 0x99, 0xBF, 0xB0, 0xB7, 0xDA, 0x74, 0x63,
  0x17, 0x00, 0xF7, 0x48, 0x74, 0x63, 0x17, 0x08, 0xF7, 0x6A, 0xF1, 0x9E,
  0xF4, 0x44, 0x40, 0xB6, 0xDE, 0x99, 0x66, 0x40, 0xA6, 0xD7, 0x52, 0x48,
  0x96, 0x46, 0x90, 0x96, 0x44, 0x40, 0xF2, 0x44, 0xF0, 0xFC, 0xA5, 0x40,
  0xD5, 0x70, 0x46, 0x90, 0xE0, 0xC0, 0x67, 0xF0, 0x9A, 0xDE, 0x72, 0x30,
  0x17, 0x99, 0xF0, 0x77, 0x30, 0x7A, 0x48, 0x79, 0x97, 0x16, 0x9A, 0xDA,
  0xF8, 0xFE, 0xBA, 0xC0, 0xF8, 0xD5, 0x6B, 0x50, 0xD6, 0xD0, 0x69, 0x97,
  0xD6, 0xF9, 0x00, 0x79, 0x9F, 0x11, 0xEA, 0x71, 0xF0, 0xBA, 0xC0, 0xB6,
  0xF0, 0xB5, 0x20, 0xAD, 0x74, 0xA0, 0xA9, 0x50, 0xB5, 0x25, 0x00, 0xE5,
  0x70, 0x57, 0x50, 0xFE, 0xD5, 0x70, 0xF0,
};

const GFXglyph NotoSans_Light7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 5, 2, 0, -5 },
  { 2, 2, 2, 3, 0, -5 },
  { 3, 4, 5, 5, 0, -5 },
  { 6, 3, 5, 4, 0, -5 },
  { 8, 5, 5, 6, 0, -5 },
  { 12, 5, 5, 5, 0, -5 },
  { 16, 1, 2, 1, 0, -5 },
  { 17, 2, 6, 2, 0, -5 },
  { 19, 2, 6, 2, 0, -5 },
  { 21, 3, 3, 4, 0, -5 },
  { 23, 4, 3, 4, 0, -4 },
  { 25, 1, 2, 2, 0, -1 },
  { 26, 2, 1, 2, 0, -2 },
  { 27, 1, 1, 2, 0, -1 },
  { 28, 2, 5, 2, 0, -5 },
  { 30, 4, 5, 4, 0, -5 },
  { 33, 1, 5, 4, 1, -5 },
  { 34, 4, 5, 4, 0, -5 },
  { 37, 4, 5, 4, 0, -5 },
  { 40, 4, 5, 4, 0, -5 },
  { 43, 4, 5, 4, 0, -5 },
  { 46, 4, 5, 4, 0, -5 },
  { 49, 4, 5, 4, 0, -5 },
  { 52, 4, 5, 4, 0, -5 },
  { 55, 4, 5, 4, 0, -5 },
  { 58, 1, 4, 2, 0, -4 },
  { 59, 1, 5, 2, 0, -4 },
  { 60, 4, 3, 4, 0, -4 },
  { 62, 4, 1, 4, 0, -3 },
  { 63, 4, 3, 4, 0, -4 },
  { 65, 3, 5, 3, 0, -5 },
  { 67, 6, 6, 6, 0, -5 },
  { 72, 4, 5, 4, 0, -5 },
  { 75, 3, 5, 4, 1, -5 },
  { 77, 4, 5, 4, 0, -5 },
  { 80, 4, 5, 5, 1, -5 },
  { 83, 2, 5, 4, 1, -5 },
  { 85, 2, 5, 4, 1, -5 },
  { 87, 5, 5, 5, 0, -5 },
  { 91, 3, 5, 5, 1, -5 },
  { 93, 2, 5, 2, 0, -5 },
  { 95, 2, 6, 2, -1, -5 },
  { 97, 3, 5, 4, 1, -5 },
  { 99, 2, 5, 4, 1, -5 },
  { 101, 4, 5, 6, 1, -5 },
  { 104, 3, 5, 5, 1, -5 },
  { 106, 5, 5, 5, 0, -5 },
  { 110, 3, 5, 4, 1, -5 },
  { 112, 5, 6, 5, 0, -5 },
  { 116, 3, 5, 4, 1, -5 },
  { 118, 3, 5, 4, 0, -5 },
  { 120, 4, 5, 4, 0, -5 },
  { 123, 3, 5, 5, 1, -5 },
  { 125, 4, 5, 4, 0, -5 },
  { 128, 6, 5, 6, 0, -5 },
  { 132, 4, 5, 4, 0, -5 },
  { 135, 4, 5, 4, 0, -5 },
  { 138, 4, 5, 4, 0, -5 },
  { 141, 1, 6, 2, 1, -5 },
  { 142, 2, 5, 2, 0, -5 },
  { 144, 2, 6, 2, 0, -5 },
  { 146, 4, 3, 4, 0, -5 },
  { 148, 3, 1, 3, 0, 0 },
  { 149, 2, 1, 2, 0, -5 },
  { 150, 3, 4, 4, 0, -4 },
  { 152, 3, 5, 4, 1, -5 },
  { 154, 3, 4, 3, 0, -4 },
  { 156, 4, 5, 4, 0, -5 },
  { 159, 3, 4, 4, 0, -4 },
  { 161, 3, 5, 2, 0, -5 },
  { 163, 4, 6, 4, 0, -4 },
  { 166, 3, 5, 4, 1, -5 },
  { 168, 1, 5, 2, 0, -5 },
  { 169, 1, 7, 2, 0, -5 },
  { 170, 2, 5, 3, 1, -5 },
  { 172, 1, 5, 2, 0, -5 },
  { 173, 5, 4, 6, 1, -4 },
  { 176, 3, 4, 4, 1, -4 },
  { 178, 4, 4, 4, 0, -4 },
  { 180, 3, 6, 4, 1, -4 },
  { 183, 4, 6, 4, 0, -4 },
  { 186, 2, 4, 3, 1, -4 },
  { 187, 3, 4, 3, 0, -4 },
  { 189, 2, 5, 2, 0, -5 },
  { 191, 3, 4, 4, 1, -4 },
  { 193, 3, 4, 3, 0, -4 },
  { 195, 5, 4, 5, 0, -4 },
  { 198, 3, 4, 4, 0, -4 },
  { 200, 3, 6, 3, 0, -4 },
  { 203, 3, 4, 3, 0, -4 },
  { 205, 2, 6, 3, 0, -5 },
  { 207, 1, 7, 4, 1, -5 },
  { 208, 2, 6, 3, 0, -5 },
  { 210, 4, 1, 4, 0, -3 },
};

const GFXfont NotoSans_Light7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light7pt7bBitmaps,
  (GFXglyph *)NotoSans_Light7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_LIGHT7PT7B_H_
