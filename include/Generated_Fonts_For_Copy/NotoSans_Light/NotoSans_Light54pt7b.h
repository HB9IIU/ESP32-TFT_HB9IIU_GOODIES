#ifndef _NOTOSANS_LIGHT54PT7B_H_
#define _NOTOSANS_LIGHT54PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light54pt7bBitmaps[] PROGMEM = {
  0x00, 0x7B, 0xDC, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0x63, 0x00, 0x00, 0x00, 0x1C, 0xFF,
  0xFD, 0xE4, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x6E, 0x06, 0xE0, 0x6C, 0x06, 0x00,
  0x07, 0x00, 0x60, 0x00, 0x06, 0x00, 0x60, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x18, 0x01, 0x80, 0x1F,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0x38, 0x03, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00,
  0x70, 0x07, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00,
  0xE0, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xC0, 0x0C, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01,
  0x80, 0x38, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03,
  0x80, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x00, 0x70, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3E, 0x18, 0x3C, 0x78,
  0x18, 0x00, 0x70, 0x18, 0x00, 0x70, 0x18, 0x00, 0xF0, 0x18, 0x00, 0xE0,
  0x18, 0x00, 0xF0, 0x18, 0x00, 0x70, 0x18, 0x00, 0x70, 0x18, 0x00, 0x78,
  0x18, 0x00, 0x3C, 0x18, 0x00, 0x1F, 0x18, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x18, 0xF8, 0x00, 0x18, 0x3C, 0x00, 0x18, 0x1E, 0x00, 0x18, 0x0E, 0x00,
  0x18, 0x0E, 0x00, 0x18, 0x07, 0x00, 0x18, 0x07, 0x00, 0x18, 0x0F, 0x00,
  0x18, 0x0E, 0x00, 0x18, 0x0E, 0x00, 0x18, 0x1E, 0x60, 0x18, 0x7C, 0x7F,
  0x9F, 0xF8, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x07,
  0xE0, 0x00, 0x0E, 0x00, 0x7F, 0xC0, 0x00, 0x38, 0x03, 0xC7, 0x80, 0x01,
  0xC0, 0x0E, 0x07, 0x00, 0x06, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x01, 0x80,
  0x30, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x38,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x03, 0x80, 0x18, 0x07, 0x00, 0x0E, 0x00,
  0x60, 0x1C, 0x00, 0x38, 0x01, 0x80, 0xE0, 0x00, 0xE0, 0x06, 0x03, 0x00,
  0x03, 0x80, 0x18, 0x1C, 0x00, 0x0E, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x03,
  0x83, 0x81, 0xC0, 0xE0, 0x0E, 0x1C, 0x3F, 0xC3, 0x80, 0x38, 0x71, 0xFF,
  0x87, 0x00, 0xC3, 0x8F, 0x07, 0x1C, 0x07, 0x0E, 0x38, 0x0E, 0x38, 0x3C,
  0x71, 0xC0, 0x38, 0xF1, 0xE1, 0x87, 0x00, 0x61, 0xFF, 0x0E, 0x1C, 0x01,
  0x81, 0xF0, 0x70, 0x70, 0x07, 0x00, 0x01, 0xC1, 0x80, 0x1C, 0x00, 0x0E,
  0x06, 0x00, 0x70, 0x00, 0x38, 0x18, 0x01, 0xC0, 0x01, 0xC0, 0x60, 0x07,
  0x00, 0x07, 0x01, 0x80, 0x1C, 0x00, 0x38, 0x06, 0x00, 0x70, 0x00, 0xC0,
  0x18, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x18,
  0x00, 0xE0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0x0C, 0x03, 0x80, 0x1C, 0x00,
  0x38, 0x1C, 0x00, 0xE0, 0x00, 0x70, 0xF0, 0x03, 0x80, 0x01, 0xFF, 0x80,
  0x1C, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x07, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x03, 0x80, 0x00, 0x38, 0x00, 0x70, 0x00, 0x03, 0x80, 0x1E,
  0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7C, 0xF0, 0x00, 0x38, 0x3E, 0x0F, 0x00, 0x07, 0x0F, 0x80, 0xF0,
  0x01, 0xE1, 0xC0, 0x0F, 0x00, 0x38, 0x78, 0x00, 0xF0, 0x07, 0x0E, 0x00,
  0x0F, 0x01, 0xC3, 0xC0, 0x00, 0xF0, 0x38, 0x70, 0x00, 0x0F, 0x0F, 0x0E,
  0x00, 0x00, 0xF1, 0xC1, 0xC0, 0x00, 0x0F, 0x70, 0x38, 0x00, 0x00, 0xFE,
  0x07, 0x80, 0x00, 0x0F, 0x80, 0x70, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00,
  0x7F, 0x01, 0xF0, 0x00, 0x3E, 0xF0, 0x1F, 0x00, 0x0F, 0x8F, 0x01, 0xFC,
  0x1F, 0xC0, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0x00, 0xFF, 0xF8, 0x00, 0xF8,
  0x01, 0x40, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0,
  0x38, 0x07, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80,
  0xF0, 0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x78, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0F, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xE0, 0x1C, 0x03,
  0x80, 0x78, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x70, 0x07, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x38,
  0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x0E,
  0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x80, 0x18, 0x01, 0xF0, 0x18,
  0x0E, 0xFE, 0x18, 0x7F, 0xFF, 0xDB, 0xFF, 0x0F, 0xFF, 0xE0, 0x00, 0x3C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x6E, 0x00, 0x00, 0xE7, 0x00, 0x01, 0xC7,
  0x80, 0x03, 0xC3, 0x80, 0x03, 0x81, 0xC0, 0x07, 0x81, 0xE0, 0x0F, 0x00,
  0xF0, 0x0E, 0x00, 0xF0, 0x02, 0x00, 0x40, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x38, 0x71, 0xE3, 0xC7, 0x0E, 0x1C,
  0x70, 0xE1, 0x83, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x73, 0xFF,
  0xF7, 0x90, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xE0,
  0x1F, 0x01, 0xE0, 0x03, 0xC0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x78, 0x70,
  0x00, 0x1C, 0x78, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xBC, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x73, 0x80, 0x00, 0x39, 0xC0,
  0x00, 0x3C, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x07,
  0x80, 0x0F, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x03, 0xC0, 0x3E, 0x03,
  0xF0, 0x7B, 0x87, 0x9C, 0x78, 0xEF, 0x87, 0xF0, 0x3B, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x01, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x7E, 0x00, 0xF0, 0x78, 0x00,
  0x78, 0x20, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xFE, 0x0F, 0xC0, 0x0F, 0x87, 0x80, 0x01, 0xE1, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0xA0, 0x00, 0x07, 0x9C, 0x00, 0x07, 0xCF,
  0xE0, 0x1F, 0xC3, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x38, 0x70,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x1C, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0xE0,
  0x0E, 0x00, 0x0E, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0xE0, 0x07, 0x00, 0x07, 0x00, 0x70, 0x00, 0x38, 0x03,
  0x80, 0x01, 0xC0, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x70, 0x3C, 0x00,
  0x03, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x3F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0x07, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x80, 0x00, 0x78, 0xC0, 0x00, 0xF8, 0xFC, 0x07,
  0xE0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x01, 0x40, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xEF, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x7F, 0x00,
  0x70, 0xFF, 0xF0, 0x39, 0xFF, 0xFC, 0x39, 0xE0, 0x0F, 0x1D, 0xC0, 0x03,
  0xCF, 0xC0, 0x00, 0xF7, 0xC0, 0x00, 0x3B, 0xC0, 0x00, 0x1D, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1D, 0xE0, 0x00, 0x1E, 0x70,
  0x00, 0x0E, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x87, 0x80, 0x07, 0x81,
  0xE0, 0x07, 0x80, 0x7C, 0x0F, 0x80, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xFE, 0x03, 0xE0, 0x0F, 0x83, 0xC0, 0x01, 0xC1, 0xC0, 0x00, 0xF0,
  0xE0, 0x00, 0x38, 0xF0, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x07,
  0x1C, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x01, 0xE0, 0xE0, 0x00,
  0xE0, 0x78, 0x00, 0xE0, 0x1F, 0x01, 0xE0, 0x07, 0xE3, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x7C, 0x7E, 0x00, 0x78,
  0x07, 0xC0, 0x78, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x38,
  0x00, 0x03, 0xBC, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x07,
  0x38, 0x00, 0x07, 0x9E, 0x00, 0x03, 0x87, 0x80, 0x07, 0x81, 0xF8, 0x0F,
  0x80, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x10, 0x00, 0x00, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x03, 0xC0, 0x1E, 0x03, 0xC0,
  0x07, 0x83, 0xC0, 0x01, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0xE0,
  0x00, 0x0E, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xB8, 0x00, 0x07, 0xDC, 0x00, 0x07, 0xEF, 0x00, 0x07,
  0xE3, 0xC0, 0x07, 0x70, 0xFC, 0x1F, 0x38, 0x3F, 0xFF, 0x1C, 0x07, 0xFE,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x02, 0x01, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x77, 0xFF, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x73, 0xFF, 0xF7, 0x90, 0x1C, 0x7C,
  0xF9, 0xF1, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x3C, 0x78, 0xF1, 0xC3, 0x8F,
  0x1C, 0x38, 0x70, 0xC3, 0x86, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0xF0, 0xFF, 0xFF, 0xC7,
  0x00, 0x3C, 0x40, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x78, 0x00, 0x38, 0xE0, 0x01, 0xFF, 0xF0, 0x0E, 0x38,
  0x01, 0xFF, 0xFC, 0x03, 0x9C, 0x00, 0xF0, 0x07, 0x00, 0x67, 0x00, 0x78,
  0x01, 0xC0, 0x1D, 0xC0, 0x1C, 0x00, 0x70, 0x07, 0x60, 0x0E, 0x00, 0x1C,
  0x01, 0xF8, 0x03, 0x80, 0x07, 0x00, 0x7E, 0x01, 0xC0, 0x01, 0xC0, 0x1F,
  0x80, 0x70, 0x00, 0x70, 0x07, 0xE0, 0x1C, 0x00, 0x1C, 0x01, 0xF8, 0x07,
  0x00, 0x06, 0x00, 0x7E, 0x01, 0xC0, 0x01, 0x80, 0x1F, 0x80, 0x70, 0x00,
  0xE0, 0x07, 0xE0, 0x1C, 0x00, 0x38, 0x01, 0xB8, 0x07, 0x00, 0x0E, 0x00,
  0xEE, 0x01, 0xE0, 0x07, 0xC0, 0x3B, 0x80, 0x38, 0x01, 0xB0, 0x1C, 0x60,
  0x0F, 0x00, 0xEC, 0x07, 0x1C, 0x01, 0xF0, 0xF3, 0xC7, 0x87, 0x00, 0x3F,
  0xF8, 0x7F, 0xC1, 0xC0, 0x03, 0xF8, 0x0F, 0xC0, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x20, 0x00, 0x07, 0xE0, 0x00,
  0x38, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x37, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0x70, 0x07, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x00, 0x1C, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x70, 0x00, 0x01, 0xC0, 0x78, 0x00,
  0x00, 0xF0, 0x38, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0x0F, 0x0E, 0x00, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x1E, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xC0, 0x07, 0xF8,
  0xF0, 0x00, 0x1F, 0x3C, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x1E, 0xF0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x3B, 0xC0,
  0x00, 0x0E, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x73,
  0xC0, 0x00, 0x38, 0xF0, 0x00, 0x3C, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0xFE, 0x3C, 0x00, 0x07, 0xCF, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x0E, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xBC, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x03, 0xF8, 0x01, 0xE0, 0x3E, 0x00, 0x01,
  0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x20, 0x1F, 0xE0, 0x7F, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3C, 0x00, 0xFF, 0x80, 0xF0, 0x00,
  0x3F, 0x03, 0xC0, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x03,
  0xBC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x1E, 0x0F, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x3F, 0x80, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFC,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x04, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x78, 0x00,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0x07, 0x1E, 0x00, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x07, 0x0F, 0x80,
  0x00, 0x07, 0x07, 0xC0, 0x00, 0x07, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0xFF,
  0x81, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x30, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE1, 0xFF, 0xFF, 0xF8, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x40, 0xFB, 0xFF, 0x9F, 0xF8,
  0x7E, 0x00, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1C,
  0x78, 0x00, 0x07, 0x0F, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x70, 0x3C, 0x00,
  0x1E, 0x07, 0x80, 0x07, 0x80, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x01, 0xE0, 0x01, 0xE0, 0x78,
  0x00, 0x3C, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x1E,
  0x7C, 0x00, 0x03, 0xDF, 0xC0, 0x00, 0x7F, 0xBC, 0x00, 0x0F, 0xE7, 0x80,
  0x01, 0xF8, 0x78, 0x00, 0x3E, 0x07, 0x80, 0x07, 0x80, 0x78, 0x00, 0xF0,
  0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x00, 0xE0,
  0x0F, 0x00, 0x1E, 0x01, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x07, 0x80,
  0x01, 0xC0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C,
  0x78, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0xE0, 0x00, 0x00,
  0x3B, 0xF7, 0x00, 0x00, 0x01, 0xDF, 0xBC, 0x00, 0x00, 0x0E, 0xFC, 0xE0,
  0x00, 0x00, 0xE7, 0xE7, 0x00, 0x00, 0x07, 0x3F, 0x1C, 0x00, 0x00, 0x71,
  0xF8, 0xE0, 0x00, 0x03, 0x8F, 0xC7, 0x80, 0x00, 0x1C, 0x7E, 0x1C, 0x00,
  0x01, 0xC3, 0xF0, 0xE0, 0x00, 0x0E, 0x1F, 0x83, 0x80, 0x00, 0xE0, 0xFC,
  0x1C, 0x00, 0x07, 0x07, 0xE0, 0xE0, 0x00, 0x38, 0x3F, 0x03, 0x80, 0x03,
  0x81, 0xF8, 0x1C, 0x00, 0x1C, 0x0F, 0xC0, 0xF0, 0x01, 0xC0, 0x7E, 0x03,
  0x80, 0x0E, 0x03, 0xF0, 0x1C, 0x00, 0x70, 0x1F, 0x80, 0x70, 0x07, 0x00,
  0xFC, 0x03, 0x80, 0x38, 0x07, 0xE0, 0x1E, 0x03, 0x80, 0x3F, 0x00, 0x70,
  0x1C, 0x01, 0xF8, 0x03, 0x80, 0xE0, 0x0F, 0xC0, 0x0E, 0x0E, 0x00, 0x7E,
  0x00, 0x70, 0x70, 0x03, 0xF0, 0x03, 0xC7, 0x00, 0x1F, 0x80, 0x0E, 0x38,
  0x00, 0xFC, 0x00, 0x71, 0xC0, 0x07, 0xE0, 0x01, 0xDC, 0x00, 0x3F, 0x00,
  0x0E, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x38, 0x00, 0x1F, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xBC, 0x00, 0x00, 0xFC, 0xE0, 0x00, 0x07, 0xE7, 0x80, 0x00, 0x3F,
  0x1E, 0x00, 0x01, 0xF8, 0x70, 0x00, 0x0F, 0xC3, 0xC0, 0x00, 0x7E, 0x0F,
  0x00, 0x03, 0xF0, 0x38, 0x00, 0x1F, 0x81, 0xE0, 0x00, 0xFC, 0x07, 0x80,
  0x07, 0xE0, 0x1C, 0x00, 0x3F, 0x00, 0xF0, 0x01, 0xF8, 0x03, 0xC0, 0x0F,
  0xC0, 0x0E, 0x00, 0x7E, 0x00, 0x78, 0x03, 0xF0, 0x01, 0xE0, 0x1F, 0x80,
  0x07, 0x00, 0xFC, 0x00, 0x3C, 0x07, 0xE0, 0x00, 0xF0, 0x3F, 0x00, 0x03,
  0x81, 0xF8, 0x00, 0x1E, 0x0F, 0xC0, 0x00, 0x78, 0x7E, 0x00, 0x01, 0xC3,
  0xF0, 0x00, 0x0F, 0x1F, 0x80, 0x00, 0x3C, 0xFC, 0x00, 0x00, 0xE7, 0xE0,
  0x00, 0x07, 0xBF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x0F,
  0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00,
  0x0F, 0x3C, 0x00, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x01, 0xEE, 0x00, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0x07, 0x3C,
  0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x07,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0xF0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x02, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0xF0, 0x07, 0xF8, 0xF0, 0x00, 0x7C, 0xF0,
  0x00, 0x3E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x1C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x00, 0xE7, 0x80, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0x7B, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x00, 0x07, 0x70, 0x00, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x00, 0x3D, 0xC0,
  0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x1F, 0x00,
  0x00, 0xF0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xC0, 0x0F, 0xE0,
  0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x38, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x73, 0xC0,
  0x00, 0x1C, 0xF0, 0x00, 0x07, 0x3C, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xE3,
  0xC0, 0x00, 0x38, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x07,
  0x83, 0xC0, 0x1F, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0x00,
  0x70, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x3C, 0x00, 0x70, 0x0F,
  0x00, 0x1E, 0x03, 0xC0, 0x03, 0x80, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x1E,
  0x0F, 0x00, 0x03, 0x83, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x1C, 0x3C, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0xEF, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x1F, 0x00, 0x3C, 0x3C, 0x00, 0x04, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0xC0, 0x00, 0x78, 0xFE, 0x03, 0xF0, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0x00, 0xA0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3D,
  0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0xE1, 0xE0,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x3E, 0x00, 0x0F, 0x00, 0xFF, 0x07,
  0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x40, 0x00,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x7B,
  0x80, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x70, 0x3C,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x07, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x70, 0x01, 0xC0,
  0x00, 0xE0, 0x03, 0x80, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x1C, 0x01,
  0xE0, 0x00, 0x38, 0x03, 0x80, 0x00, 0x78, 0x07, 0x00, 0x00, 0x70, 0x1E,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xC1, 0xE0,
  0x00, 0x03, 0xC3, 0x80, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0x0F, 0x38, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x1D, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x77, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xDC, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0xC0, 0x00,
  0x38, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xE3, 0x80, 0x00, 0xEE, 0x00, 0x03,
  0x8E, 0x00, 0x03, 0x38, 0x00, 0x1E, 0x3C, 0x00, 0x1C, 0xE0, 0x00, 0x70,
  0x70, 0x00, 0x73, 0x80, 0x01, 0xC1, 0xC0, 0x01, 0xC7, 0x00, 0x0F, 0x07,
  0x00, 0x0E, 0x1C, 0x00, 0x38, 0x1E, 0x00, 0x38, 0x70, 0x00, 0xE0, 0x38,
  0x00, 0xE0, 0xE0, 0x03, 0x80, 0xE0, 0x03, 0x83, 0x80, 0x1E, 0x03, 0x80,
  0x1C, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x38, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x3C, 0x01, 0xE0, 0x38,
  0x07, 0x00, 0xE0, 0x03, 0x80, 0xE0, 0x0E, 0x03, 0x80, 0x0E, 0x03, 0x80,
  0x38, 0x1E, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x70, 0x00, 0xF0, 0x70, 0x03,
  0x81, 0xC0, 0x01, 0xC1, 0xC0, 0x07, 0x07, 0x00, 0x07, 0x0E, 0x00, 0x1C,
  0x3C, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0xE3,
  0x80, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x78,
  0x00, 0x0E, 0x70, 0x00, 0x39, 0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x77, 0x00,
  0x00, 0x77, 0x00, 0x01, 0xDC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x01,
  0xC3, 0xC0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x78, 0x0E, 0x00, 0x01, 0xC0,
  0x3C, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0xC0, 0x0E, 0x00, 0x07, 0x00, 0x78, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x3C,
  0x0E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00,
  0x78, 0x70, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x78,
  0x07, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x70, 0x01, 0xC0, 0x01, 0xE0, 0x0F, 0x00, 0x03, 0x80, 0x38, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0xF1,
  0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x00, 0x7B,
  0x80, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x01, 0xC3, 0xC0,
  0x00, 0x1E, 0x0E, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x0F, 0x01, 0xC0, 0x00,
  0x70, 0x0F, 0x00, 0x07, 0x80, 0x38, 0x00, 0x38, 0x01, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x1C, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0x67, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x03,
  0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x18, 0x1C, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0xC0, 0x38, 0x00, 0x38, 0x03, 0x80, 0x06, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x38, 0x00, 0xE0, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0,
  0x70, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38, 0x70, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0x77, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x01, 0xFF, 0x80, 0x3F, 0xFF, 0x03, 0xFC, 0x7E, 0x07, 0x00, 0x3C, 0x10,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x0F, 0xFC,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0xCF, 0xC0, 0x0F, 0x7C, 0x00, 0x3D, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xDF, 0xC0, 0x07, 0x77,
  0xC0, 0xF9, 0xCF, 0xFF, 0xC7, 0x1F, 0xFC, 0x1C, 0x02, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0xFF, 0x80, 0xE3, 0xFF, 0xE0, 0xE7, 0xE7, 0xF0, 0xEE, 0x00, 0x78, 0xFC,
  0x00, 0x3C, 0xF8, 0x00, 0x1C, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0E, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x1C, 0xF8,
  0x00, 0x3C, 0xCE, 0x00, 0x78, 0xCF, 0x81, 0xF0, 0xC7, 0xFF, 0xE0, 0xC1,
  0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x1F, 0x00, 0x21, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x43, 0xF8, 0x3E, 0x07, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x0F, 0xF8, 0x38, 0x1F, 0xFE, 0x1C, 0x3F, 0x8F, 0xCE, 0x3E,
  0x00, 0xF7, 0x1E, 0x00, 0x1B, 0x9E, 0x00, 0x07, 0xCE, 0x00, 0x03, 0xEF,
  0x00, 0x01, 0xF7, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x07, 0xB8, 0x00, 0x03, 0xDE, 0x00,
  0x03, 0xE7, 0x00, 0x01, 0xF3, 0xC0, 0x01, 0xB8, 0xF0, 0x01, 0xDC, 0x3E,
  0x03, 0xCE, 0x0F, 0xFF, 0xC7, 0x01, 0xFF, 0x83, 0x80, 0x0C, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x07, 0xE3, 0xF0, 0x0F, 0x00, 0x78,
  0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x1C, 0x38, 0x00, 0x1E, 0x78, 0x00, 0x0E,
  0x70, 0x00, 0x0E, 0x70, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0x00, 0x06, 0x0F, 0xE0, 0x7E, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xF8, 0x00, 0x04, 0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xC3, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x01, 0xFF,
  0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFF, 0x83, 0x81,
  0xFF, 0xF1, 0xC3, 0xFC, 0xFC, 0xE3, 0xE0, 0x0F, 0x71, 0xE0, 0x01, 0xB9,
  0xE0, 0x00, 0x7C, 0xE0, 0x00, 0x3E, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x07,
  0xB8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xF7, 0x00,
  0x00, 0x7B, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x3E, 0x70, 0x00, 0x1F, 0x3C,
  0x00, 0x1B, 0x8F, 0x00, 0x1D, 0xC3, 0xF0, 0x3C, 0xE0, 0xFF, 0xFC, 0x70,
  0x1F, 0xF8, 0x38, 0x01, 0x80, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xE1, 0x00, 0x00, 0xF0, 0xF0, 0x01, 0xF0, 0x7F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x0F, 0xF8, 0x1C, 0x7F, 0xFC,
  0x39, 0xF8, 0xFC, 0x77, 0x00, 0x3C, 0xFC, 0x00, 0x3D, 0xF0, 0x00, 0x3B,
  0xC0, 0x00, 0x77, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0x7F, 0xF7, 0x00, 0x00, 0x00, 0x77,
  0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77,
  0x77, 0x70, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0xDF, 0xF3, 0xFE,
  0x3F, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x7B, 0x80, 0x03, 0xCE, 0x00, 0x1E, 0x38, 0x00, 0xF0, 0xE0, 0x07,
  0x83, 0x80, 0x3C, 0x0E, 0x01, 0xE0, 0x38, 0x0F, 0x00, 0xE0, 0x78, 0x03,
  0x83, 0xC0, 0x0E, 0x0E, 0x00, 0x38, 0x70, 0x00, 0xE3, 0x80, 0x03, 0x9F,
  0x00, 0x0E, 0xFE, 0x00, 0x3F, 0x38, 0x00, 0xF8, 0x70, 0x03, 0xC1, 0xE0,
  0x0E, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x0E, 0x03, 0x80, 0x3C, 0x0E,
  0x00, 0x78, 0x38, 0x00, 0xE0, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x8E, 0x00,
  0x0F, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xC0,
  0xFF, 0x00, 0x7F, 0xC1, 0x87, 0xFF, 0x83, 0xFF, 0xE3, 0x1F, 0x3F, 0x8F,
  0xCF, 0xE7, 0x70, 0x0F, 0x3C, 0x03, 0xCF, 0x80, 0x0F, 0x60, 0x03, 0xDF,
  0x00, 0x0F, 0x80, 0x03, 0xBC, 0x00, 0x1F, 0x00, 0x07, 0xF8, 0x00, 0x1C,
  0x00, 0x07, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0xC0, 0x00, 0x70, 0x00, 0x1F,
  0x80, 0x00, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0x00, 0x01, 0xF8, 0x00, 0x0E, 0x00, 0x03,
  0xF0, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0xC0, 0x00,
  0x70, 0x00, 0x1F, 0x80, 0x00, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0x80, 0x00, 0xFC, 0x00, 0x07, 0x00, 0x01, 0xF8, 0x00,
  0x0E, 0x00, 0x03, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00, 0x38, 0x00,
  0x0F, 0xC0, 0x00, 0x70, 0x00, 0x1F, 0x80, 0x00, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0xC0, 0xFF, 0x81,
  0x87, 0xFF, 0xC3, 0x1F, 0x8F, 0xC7, 0x70, 0x03, 0xCF, 0xC0, 0x03, 0xDF,
  0x00, 0x03, 0xBC, 0x00, 0x07, 0x78, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x3C, 0x00, 0xF0, 0x1E, 0x00,
  0x1E, 0x0F, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x71, 0xE0, 0x00, 0x1E, 0x70,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x0E, 0x70, 0x00, 0x03, 0x9E, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x70,
  0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x0F, 0x00, 0xFC, 0x0F,
  0x80, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0xFF, 0x80, 0xC3, 0xFF, 0xE0, 0xC7, 0xE3, 0xF0, 0xEE, 0x00, 0x78, 0xFC,
  0x00, 0x3C, 0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x1C, 0xFC,
  0x00, 0x3C, 0xEE, 0x00, 0x78, 0xE7, 0x81, 0xF0, 0xE3, 0xFF, 0xE0, 0xE1,
  0xFF, 0xC0, 0xE0, 0x0C, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x83, 0x81, 0xFF, 0xE1, 0xC3,
  0xF8, 0xFC, 0xE3, 0xE0, 0x0F, 0x71, 0xE0, 0x01, 0xB9, 0xE0, 0x00, 0xFC,
  0xE0, 0x00, 0x3E, 0xF0, 0x00, 0x1F, 0x70, 0x00, 0x07, 0xB8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x7B, 0x80,
  0x00, 0x3D, 0xE0, 0x00, 0x3E, 0x70, 0x00, 0x1F, 0x3C, 0x00, 0x1B, 0x8F,
  0x00, 0x19, 0xC3, 0xE0, 0x7C, 0xE0, 0xFF, 0xF8, 0x70, 0x3F, 0xF8, 0x38,
  0x00, 0x80, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0xC0, 0xFF, 0x87, 0xFF, 0x1F, 0xFF, 0x78,
  0x0F, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x7F, 0xFF, 0x87, 0xE1, 0xFC, 0x78, 0x00, 0x47, 0x80,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x76, 0x00, 0x07, 0xBF, 0x00, 0xF9, 0xFF,
  0xFF, 0x83, 0xFF, 0xF0, 0x00, 0x20, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x07, 0xC1, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x18, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xEE, 0x00, 0x03,
  0xDC, 0x00, 0x07, 0xB8, 0x00, 0x1F, 0x78, 0x00, 0x3E, 0x78, 0x01, 0xCC,
  0x7C, 0x0F, 0x98, 0x7F, 0xFC, 0x30, 0x7F, 0xF0, 0x60, 0x04, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xDC, 0x00, 0x01, 0xCF, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0xF1, 0xC0, 0x00, 0x70, 0xF0, 0x00, 0x38, 0x38, 0x00,
  0x3C, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x0E, 0x01, 0xE0,
  0x07, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0x80, 0x1E, 0x01, 0xC0, 0x07,
  0x01, 0xC0, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x70, 0x00,
  0x38, 0x38, 0x00, 0x0E, 0x3C, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1F,
  0x80, 0x01, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0x80, 0x03, 0x9C, 0x00, 0x1F,
  0x00, 0x0E, 0x70, 0x00, 0xFC, 0x00, 0x39, 0xC0, 0x03, 0xB0, 0x01, 0xE3,
  0x80, 0x0C, 0xE0, 0x07, 0x0E, 0x00, 0x73, 0x80, 0x1C, 0x38, 0x01, 0xCE,
  0x00, 0x70, 0xE0, 0x07, 0x1C, 0x03, 0x81, 0xC0, 0x38, 0x70, 0x0E, 0x07,
  0x00, 0xE1, 0xC0, 0x38, 0x1C, 0x03, 0x83, 0x80, 0xE0, 0x78, 0x1C, 0x0E,
  0x07, 0x00, 0xE0, 0x70, 0x38, 0x1C, 0x03, 0x81, 0xC0, 0x70, 0x70, 0x0E,
  0x0E, 0x01, 0xC1, 0xC0, 0x1C, 0x38, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x1C,
  0x38, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x07, 0x1C, 0x00, 0xE3, 0x00, 0x0E,
  0x70, 0x03, 0x9C, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x00, 0xEE, 0x00, 0x1D,
  0xC0, 0x01, 0xB8, 0x00, 0x76, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x0F, 0x00, 0x07, 0x83, 0xC0,
  0x03, 0x80, 0xE0, 0x03, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x07,
  0x01, 0xC0, 0x01, 0xC1, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x38, 0xE0, 0x00,
  0x0E, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x77, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x38, 0xE0,
  0x00, 0x38, 0x38, 0x00, 0x3C, 0x1E, 0x00, 0x1C, 0x07, 0x80, 0x1C, 0x01,
  0xC0, 0x1E, 0x00, 0x70, 0x1E, 0x00, 0x3C, 0x0E, 0x00, 0x0E, 0x0E, 0x00,
  0x03, 0x8F, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x03, 0xB8,
  0x00, 0x01, 0xDC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xE3, 0x80, 0x00, 0xF1,
  0xC0, 0x00, 0x70, 0xF0, 0x00, 0x38, 0x38, 0x00, 0x3C, 0x1C, 0x00, 0x1C,
  0x07, 0x00, 0x0E, 0x03, 0x80, 0x0E, 0x01, 0xE0, 0x07, 0x00, 0x70, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x07, 0x01, 0xE0, 0x03, 0xC0,
  0xE0, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x0E,
  0x1C, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE6, 0x00, 0x00,
  0x37, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFB, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x80, 0x0F, 0xC0, 0x1F, 0xE0, 0x1F, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F,
  0xC0, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0xE0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x1F, 0x00, 0xFE, 0x00,
  0xF8, 0x00, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0xBF, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0xFC, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xE4, 0x00, 0x07, 0xC0,
};

const GFXglyph NotoSans_Light54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 5, 40, 13, 4, -39 },
  { 26, 12, 14, 20, 4, -39 },
  { 47, 32, 39, 35, 1, -39 },
  { 203, 24, 44, 31, 3, -41 },
  { 335, 38, 40, 44, 3, -39 },
  { 525, 35, 40, 39, 3, -39 },
  { 700, 3, 14, 11, 4, -39 },
  { 706, 11, 48, 15, 2, -39 },
  { 772, 11, 48, 15, 2, -39 },
  { 838, 24, 23, 30, 3, -41 },
  { 907, 25, 26, 31, 3, -32 },
  { 989, 7, 13, 12, 2, -6 },
  { 1001, 13, 3, 17, 2, -16 },
  { 1006, 5, 6, 13, 4, -5 },
  { 1010, 17, 39, 19, 1, -39 },
  { 1093, 25, 40, 31, 3, -39 },
  { 1218, 13, 39, 31, 5, -39 },
  { 1282, 24, 39, 31, 3, -39 },
  { 1399, 25, 40, 31, 2, -39 },
  { 1524, 29, 39, 31, 1, -39 },
  { 1666, 24, 40, 31, 4, -39 },
  { 1786, 25, 40, 31, 3, -39 },
  { 1911, 25, 39, 31, 3, -39 },
  { 2033, 25, 40, 31, 3, -39 },
  { 2158, 25, 40, 31, 3, -39 },
  { 2283, 5, 30, 13, 4, -29 },
  { 2302, 7, 36, 13, 2, -29 },
  { 2334, 25, 25, 31, 3, -32 },
  { 2413, 25, 14, 31, 3, -26 },
  { 2457, 25, 25, 31, 3, -32 },
  { 2536, 20, 40, 23, 1, -39 },
  { 2636, 42, 43, 48, 3, -38 },
  { 2862, 33, 39, 33, 0, -39 },
  { 3023, 26, 39, 34, 5, -39 },
  { 3150, 29, 40, 34, 3, -39 },
  { 3295, 30, 39, 38, 5, -39 },
  { 3442, 22, 39, 30, 5, -39 },
  { 3550, 22, 39, 27, 5, -39 },
  { 3658, 32, 40, 39, 3, -39 },
  { 3818, 29, 39, 39, 5, -39 },
  { 3960, 11, 39, 17, 3, -39 },
  { 4014, 13, 49, 14, -5, -39 },
  { 4094, 27, 39, 32, 5, -39 },
  { 4226, 22, 39, 28, 5, -39 },
  { 4334, 37, 39, 47, 5, -39 },
  { 4515, 29, 39, 39, 5, -39 },
  { 4657, 35, 40, 41, 3, -39 },
  { 4832, 24, 39, 32, 5, -39 },
  { 4949, 35, 48, 41, 3, -39 },
  { 5159, 26, 39, 32, 5, -39 },
  { 5286, 24, 40, 29, 3, -39 },
  { 5406, 28, 39, 29, 0, -39 },
  { 5543, 29, 40, 39, 5, -39 },
  { 5688, 31, 39, 31, 0, -39 },
  { 5840, 46, 39, 49, 1, -39 },
  { 6065, 30, 39, 30, 0, -39 },
  { 6212, 29, 39, 29, 0, -39 },
  { 6354, 27, 39, 31, 2, -39 },
  { 6486, 11, 48, 17, 5, -39 },
  { 6552, 17, 39, 19, 1, -39 },
  { 6635, 12, 48, 17, 1, -39 },
  { 6707, 27, 24, 31, 2, -39 },
  { 6788, 23, 2, 23, 0, 5 },
  { 6794, 10, 8, 14, 2, -41 },
  { 6804, 22, 30, 29, 3, -29 },
  { 6887, 24, 42, 32, 5, -41 },
  { 7013, 21, 30, 26, 3, -29 },
  { 7092, 25, 42, 32, 3, -41 },
  { 7224, 24, 30, 30, 3, -29 },
  { 7314, 19, 41, 17, 1, -41 },
  { 7412, 25, 42, 32, 3, -29 },
  { 7544, 23, 41, 32, 5, -41 },
  { 7662, 4, 39, 13, 4, -39 },
  { 7682, 11, 52, 13, -3, -39 },
  { 7754, 22, 41, 27, 5, -41 },
  { 7867, 3, 41, 13, 5, -41 },
  { 7883, 39, 29, 48, 5, -29 },
  { 8025, 23, 29, 32, 5, -29 },
  { 8109, 26, 30, 32, 3, -29 },
  { 8207, 24, 42, 32, 5, -29 },
  { 8333, 25, 42, 32, 3, -29 },
  { 8465, 15, 29, 21, 5, -29 },
  { 8520, 21, 30, 25, 2, -29 },
  { 8599, 16, 37, 18, 1, -36 },
  { 8673, 23, 30, 32, 4, -29 },
  { 8760, 25, 29, 25, 0, -29 },
  { 8851, 38, 29, 40, 1, -29 },
  { 8989, 25, 29, 27, 1, -29 },
  { 9080, 25, 42, 25, 0, -29 },
  { 9212, 21, 29, 25, 2, -29 },
  { 9289, 17, 48, 19, 1, -39 },
  { 9391, 3, 54, 29, 13, -41 },
  { 9412, 16, 48, 19, 2, -39 },
  { 9508, 25, 6, 31, 3, -22 },
};

const GFXfont NotoSans_Light54pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light54pt7bBitmaps,
  (GFXglyph *)NotoSans_Light54pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _NOTOSANS_LIGHT54PT7B_H_
