#ifndef _NOTOSANS_LIGHT14PT7B_H_
#define _NOTOSANS_LIGHT14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light14pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0x40, 0xB6, 0xD0, 0x12, 0x09, 0x04, 0x8F, 0xF1, 0x21, 0x23,
  0xFC, 0x48, 0x24, 0x12, 0x00, 0x21, 0xEA, 0x68, 0xA1, 0x81, 0x89, 0x26,
  0xA7, 0x08, 0xE1, 0x24, 0x89, 0x22, 0x50, 0x9B, 0xBA, 0x91, 0x44, 0x51,
  0x22, 0x48, 0xE0, 0x78, 0x22, 0x11, 0x09, 0x03, 0x02, 0x8A, 0x25, 0x0C,
  0x86, 0x3C, 0xC0, 0xF0, 0x5A, 0xAA, 0xA9, 0xC8, 0x92, 0x49, 0x25, 0x60,
  0x20, 0x8A, 0x5E, 0x31, 0x20, 0x20, 0x82, 0x3F, 0x20, 0x80, 0xF0, 0xE0,
  0x80, 0x08, 0x84, 0x42, 0x11, 0x08, 0x44, 0x00, 0x7A, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x85, 0xE0, 0x35, 0x91, 0x11, 0x11, 0x11, 0xF8, 0x10, 0x41,
  0x08, 0x42, 0x10, 0x43, 0xF0, 0xF8, 0x10, 0x41, 0x78, 0x20, 0x41, 0x07,
  0xE0, 0x04, 0x0C, 0x14, 0x14, 0x24, 0x44, 0x84, 0xFF, 0x04, 0x04, 0x7E,
  0x08, 0x20, 0xF8, 0x10, 0x41, 0x07, 0xE0, 0x3D, 0x08, 0x20, 0xFA, 0x18,
  0x61, 0x85, 0xE0, 0xFC, 0x10, 0x82, 0x08, 0x41, 0x08, 0x21, 0x00, 0x7A,
  0x18, 0x72, 0x31, 0x28, 0x61, 0x85, 0xE0, 0x7A, 0x18, 0x61, 0x85, 0xF0,
  0x41, 0x0B, 0xC0, 0xC1, 0x50, 0x05, 0x60, 0x0C, 0xCC, 0x30, 0x30, 0x30,
  0xFC, 0x00, 0x3F, 0xC0, 0xC0, 0xC3, 0x33, 0x00, 0xF8, 0x42, 0x11, 0x10,
  0x80, 0x01, 0x00, 0x1F, 0x04, 0x11, 0x01, 0x47, 0x99, 0x13, 0x22, 0x64,
  0x8C, 0x9A, 0x8C, 0x88, 0x00, 0xFC, 0x00, 0x08, 0x0C, 0x05, 0x04, 0x82,
  0x41, 0x11, 0xF8, 0x82, 0x41, 0x40, 0xC0, 0xFD, 0x06, 0x0C, 0x1F, 0xD0,
  0xE0, 0xC1, 0x83, 0xF8, 0x3E, 0x82, 0x04, 0x08, 0x10, 0x20, 0x40, 0x40,
  0x7C, 0xFC, 0x82, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0xFC, 0xFE,
  0x08, 0x20, 0xFE, 0x08, 0x20, 0x83, 0xF0, 0xFE, 0x08, 0x20, 0x83, 0xF8,
  0x20, 0x82, 0x00, 0x3F, 0x40, 0x80, 0x80, 0x80, 0x8F, 0x81, 0x81, 0x41,
  0x3F, 0x81, 0x81, 0x81, 0x81, 0xFF, 0x81, 0x81, 0x81, 0x81, 0x81, 0xE9,
  0x24, 0x92, 0x5C, 0x24, 0x92, 0x49, 0x24, 0x9C, 0x83, 0x0A, 0x24, 0x8A,
  0x1A, 0x22, 0x44, 0x85, 0x04, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x83,
  0xF0, 0xC0, 0xF0, 0x3A, 0x16, 0x85, 0xA1, 0x64, 0x99, 0x26, 0x31, 0x8C,
  0x61, 0x10, 0xC1, 0xC1, 0xA1, 0x91, 0x91, 0x89, 0x85, 0x85, 0x83, 0x81,
  0x3E, 0x20, 0xA0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x02, 0x41, 0x1F, 0x00,
  0xFA, 0x18, 0x61, 0x87, 0xE8, 0x20, 0x82, 0x00, 0x3E, 0x20, 0xA0, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x02, 0x41, 0x1F, 0x01, 0x00, 0x60, 0xF9, 0x0A,
  0x0C, 0x28, 0x5F, 0x22, 0x42, 0x85, 0x04, 0x7E, 0x08, 0x20, 0x60, 0x60,
  0x41, 0x07, 0xE0, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x42, 0x3C, 0x81, 0x81,
  0x42, 0x42, 0x22, 0x24, 0x24, 0x18, 0x18, 0x18, 0x82, 0x14, 0x61, 0x45,
  0x14, 0x52, 0x49, 0x22, 0x92, 0x28, 0xA2, 0x8C, 0x30, 0xC1, 0x04, 0xC2,
  0x42, 0x24, 0x28, 0x18, 0x18, 0x28, 0x24, 0x42, 0x83, 0x83, 0x42, 0x44,
  0x24, 0x28, 0x18, 0x10, 0x10, 0x10, 0x10, 0xFC, 0x08, 0x20, 0x81, 0x04,
  0x10, 0x20, 0x81, 0xFC, 0xF2, 0x49, 0x24, 0x92, 0x70, 0x82, 0x10, 0x82,
  0x10, 0x82, 0x10, 0x40, 0xE4, 0x92, 0x49, 0x24, 0xF0, 0x30, 0xC4, 0x92,
  0x86, 0x10, 0xFC, 0xA4, 0x74, 0x42, 0x3E, 0xC6, 0x3F, 0x81, 0x02, 0x05,
  0xCC, 0x50, 0xA0, 0xC1, 0x83, 0x0B, 0xE0, 0x3A, 0x21, 0x08, 0x42, 0x0F,
  0x04, 0x10, 0x4D, 0x4E, 0x18, 0x61, 0x86, 0x17, 0xC0, 0x31, 0x28, 0x61,
  0xFA, 0x08, 0x1F, 0x19, 0x11, 0xE4, 0x21, 0x08, 0x42, 0x10, 0x31, 0x38,
  0x61, 0x86, 0x18, 0x5F, 0x04, 0x1F, 0x80, 0x82, 0x08, 0x2E, 0xC6, 0x18,
  0x61, 0x86, 0x18, 0x40, 0x9F, 0xC0, 0x20, 0x12, 0x49, 0x24, 0x9E, 0x82,
  0x08, 0x21, 0x8A, 0x4A, 0x38, 0x92, 0x28, 0x40, 0xFF, 0xE0, 0x31, 0xB2,
  0x98, 0x46, 0x11, 0x84, 0x61, 0x18, 0x46, 0x11, 0x3B, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x31, 0x38, 0x61, 0x86, 0x18, 0x5E, 0x39, 0x8A, 0x14, 0x18,
  0x30, 0x71, 0x5C, 0x81, 0x02, 0x00, 0x31, 0x38, 0x61, 0x86, 0x18, 0x5F,
  0x04, 0x10, 0x40, 0x3C, 0x88, 0x88, 0x88, 0x74, 0x61, 0x83, 0x04, 0x3E,
  0x4F, 0x44, 0x44, 0x44, 0x30, 0x86, 0x18, 0x61, 0x86, 0x17, 0xC0, 0x86,
  0x89, 0x12, 0x42, 0x86, 0x04, 0x00, 0x84, 0x53, 0x14, 0xA9, 0x4A, 0x52,
  0x8C, 0x42, 0x10, 0xC6, 0x50, 0xA0, 0x82, 0x88, 0xB1, 0x80, 0x86, 0x89,
  0x12, 0x42, 0x86, 0x04, 0x08, 0x21, 0xC0, 0xF8, 0x88, 0x44, 0x43, 0xE0,
  0x19, 0x08, 0x42, 0x23, 0x04, 0x21, 0x08, 0x70, 0xFF, 0xFC, 0xC1, 0x08,
  0x42, 0x08, 0x64, 0x21, 0x09, 0xC0, 0xE6, 0x70,
};

const GFXglyph NotoSans_Light14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 10, 3, 1, -10 },
  { 3, 3, 4, 5, 1, -10 },
  { 5, 9, 10, 9, 0, -10 },
  { 17, 6, 12, 8, 1, -11 },
  { 26, 10, 10, 11, 1, -10 },
  { 39, 9, 10, 10, 1, -10 },
  { 51, 1, 4, 3, 1, -10 },
  { 52, 2, 12, 4, 1, -10 },
  { 55, 3, 12, 4, 0, -10 },
  { 60, 6, 6, 8, 1, -11 },
  { 65, 6, 6, 8, 1, -8 },
  { 70, 1, 4, 3, 1, -2 },
  { 71, 3, 1, 5, 1, -4 },
  { 72, 1, 1, 3, 1, -1 },
  { 73, 5, 10, 5, 0, -10 },
  { 80, 6, 10, 8, 1, -10 },
  { 88, 4, 10, 8, 1, -10 },
  { 93, 6, 10, 8, 1, -10 },
  { 101, 6, 10, 8, 1, -10 },
  { 109, 8, 10, 8, 0, -10 },
  { 119, 6, 10, 8, 1, -10 },
  { 127, 6, 10, 8, 1, -10 },
  { 135, 6, 10, 8, 1, -10 },
  { 143, 6, 10, 8, 1, -10 },
  { 151, 6, 10, 8, 1, -10 },
  { 159, 1, 8, 3, 1, -8 },
  { 160, 2, 10, 3, 0, -8 },
  { 163, 6, 6, 8, 1, -8 },
  { 168, 6, 4, 8, 1, -7 },
  { 171, 6, 6, 8, 1, -8 },
  { 176, 5, 10, 6, 0, -10 },
  { 183, 11, 11, 12, 1, -10 },
  { 199, 9, 10, 9, 0, -10 },
  { 211, 7, 10, 9, 1, -10 },
  { 220, 7, 10, 9, 1, -10 },
  { 229, 8, 10, 10, 1, -10 },
  { 239, 6, 10, 8, 1, -10 },
  { 247, 6, 10, 7, 1, -10 },
  { 255, 8, 10, 10, 1, -10 },
  { 265, 8, 10, 10, 1, -10 },
  { 275, 3, 10, 4, 1, -10 },
  { 279, 3, 13, 4, -1, -10 },
  { 284, 7, 10, 8, 1, -10 },
  { 293, 6, 10, 7, 1, -10 },
  { 301, 10, 10, 12, 1, -10 },
  { 314, 8, 10, 10, 1, -10 },
  { 324, 9, 10, 11, 1, -10 },
  { 336, 6, 10, 8, 1, -10 },
  { 344, 9, 12, 11, 1, -10 },
  { 358, 7, 10, 8, 1, -10 },
  { 367, 6, 10, 8, 1, -10 },
  { 375, 7, 10, 7, 0, -10 },
  { 384, 8, 10, 10, 1, -10 },
  { 394, 8, 10, 8, 0, -10 },
  { 404, 12, 10, 13, 0, -10 },
  { 419, 8, 10, 8, 0, -10 },
  { 429, 8, 10, 8, 0, -10 },
  { 439, 7, 10, 8, 1, -10 },
  { 448, 3, 12, 5, 1, -10 },
  { 453, 5, 10, 5, 0, -10 },
  { 460, 3, 12, 5, 0, -10 },
  { 465, 6, 6, 8, 1, -10 },
  { 470, 6, 1, 6, 0, 1 },
  { 471, 2, 3, 4, 1, -11 },
  { 472, 5, 8, 8, 1, -8 },
  { 477, 7, 11, 8, 1, -11 },
  { 487, 5, 8, 7, 1, -8 },
  { 492, 6, 11, 8, 1, -11 },
  { 501, 6, 8, 8, 1, -8 },
  { 507, 5, 11, 4, 0, -11 },
  { 514, 6, 11, 8, 1, -8 },
  { 523, 6, 11, 8, 1, -11 },
  { 532, 1, 10, 3, 1, -10 },
  { 534, 3, 13, 3, -1, -10 },
  { 539, 6, 11, 7, 1, -11 },
  { 548, 1, 11, 3, 1, -11 },
  { 550, 10, 8, 13, 1, -8 },
  { 560, 6, 8, 8, 1, -8 },
  { 566, 6, 8, 8, 1, -8 },
  { 572, 7, 11, 8, 1, -8 },
  { 582, 6, 11, 8, 1, -8 },
  { 591, 4, 8, 6, 1, -8 },
  { 595, 5, 8, 7, 1, -8 },
  { 600, 4, 9, 5, 0, -9 },
  { 605, 6, 7, 8, 1, -7 },
  { 611, 7, 7, 7, 0, -7 },
  { 618, 10, 7, 10, 0, -7 },
  { 627, 7, 7, 7, 0, -7 },
  { 634, 7, 10, 7, 0, -7 },
  { 643, 5, 7, 6, 1, -7 },
  { 648, 5, 12, 5, 0, -10 },
  { 656, 1, 14, 8, 3, -11 },
  { 658, 5, 12, 5, 0, -10 },
  { 666, 6, 2, 8, 1, -6 },
};

const GFXfont NotoSans_Light14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light14pt7bBitmaps,
  (GFXglyph *)NotoSans_Light14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_LIGHT14PT7B_H_
