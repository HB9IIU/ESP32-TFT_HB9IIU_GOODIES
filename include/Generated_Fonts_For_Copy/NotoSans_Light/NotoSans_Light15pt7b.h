#ifndef _NOTOSANS_LIGHT15PT7B_H_
#define _NOTOSANS_LIGHT15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light15pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0x0C, 0xB6, 0xD0, 0x09, 0x08, 0x84, 0x4F, 0xF1, 0x20,
  0x90, 0x49, 0xFF, 0x24, 0x12, 0x09, 0x00, 0x11, 0xF9, 0x24, 0xD0, 0xC1,
  0xC5, 0x16, 0x77, 0x04, 0x61, 0x24, 0x49, 0x22, 0x48, 0x95, 0xA5, 0x96,
  0xA4, 0x29, 0x12, 0x48, 0x92, 0x1C, 0x38, 0x22, 0x11, 0x08, 0x83, 0x81,
  0x83, 0x23, 0x09, 0x83, 0x41, 0x9F, 0x20, 0xF0, 0x2A, 0x49, 0x24, 0x92,
  0x26, 0xC4, 0x22, 0x21, 0x11, 0x22, 0x22, 0x40, 0x10, 0x4E, 0xCC, 0x29,
  0x20, 0x10, 0x20, 0x47, 0xF1, 0x02, 0x04, 0x00, 0xF0, 0xE0, 0xC0, 0x08,
  0x44, 0x21, 0x10, 0x88, 0x42, 0x20, 0x38, 0x8A, 0x14, 0x18, 0x30, 0x60,
  0xC1, 0x84, 0x89, 0xE0, 0x13, 0xD1, 0x11, 0x11, 0x11, 0x10, 0x79, 0x08,
  0x10, 0x20, 0x41, 0x04, 0x18, 0x20, 0x83, 0xF8, 0x79, 0x08, 0x10, 0x20,
  0x4F, 0x01, 0x01, 0x02, 0x0B, 0xE0, 0x06, 0x06, 0x0A, 0x12, 0x12, 0x22,
  0x42, 0xFF, 0x02, 0x02, 0x02, 0x7C, 0x82, 0x04, 0x0B, 0x19, 0x81, 0x01,
  0x02, 0x0B, 0xE0, 0x1C, 0xC1, 0x04, 0x0B, 0x98, 0xA0, 0xC1, 0x82, 0x89,
  0xF0, 0xFE, 0x04, 0x10, 0x20, 0x81, 0x04, 0x08, 0x20, 0x41, 0x80, 0x39,
  0x8A, 0x14, 0x24, 0x87, 0x11, 0x41, 0x83, 0x09, 0xF0, 0x79, 0x0A, 0x14,
  0x18, 0x30, 0xDE, 0x82, 0x04, 0x13, 0xC0, 0xC0, 0x03, 0x83, 0xC0, 0x02,
  0x19, 0xC4, 0x06, 0x03, 0x01, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x80, 0xC0,
  0x60, 0x30, 0xCE, 0x20, 0x00, 0xF8, 0x10, 0x41, 0x08, 0x42, 0x08, 0x00,
  0x02, 0x00, 0x0F, 0x03, 0x0C, 0x40, 0x28, 0x72, 0x89, 0x19, 0x11, 0x91,
  0x19, 0x12, 0x9A, 0xA8, 0x44, 0x40, 0x03, 0xF0, 0x08, 0x04, 0x05, 0x02,
  0x82, 0x21, 0x10, 0xF8, 0x82, 0x41, 0x20, 0x60, 0x20, 0xFC, 0x82, 0x82,
  0x82, 0x82, 0xFC, 0x82, 0x81, 0x81, 0x82, 0xFC, 0x1E, 0x61, 0x40, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x3F, 0xFC, 0x41, 0x20, 0x50, 0x28,
  0x0C, 0x06, 0x03, 0x01, 0x81, 0x41, 0x3F, 0x00, 0xFE, 0x08, 0x20, 0x83,
  0xF8, 0x20, 0x82, 0x0F, 0xC0, 0xFE, 0x08, 0x20, 0x83, 0xF8, 0x20, 0x82,
  0x08, 0x00, 0x1F, 0x10, 0x50, 0x10, 0x08, 0x04, 0x3A, 0x03, 0x01, 0x80,
  0xA0, 0x4F, 0xE0, 0x81, 0x81, 0x81, 0x81, 0x81, 0xFF, 0x81, 0x81, 0x81,
  0x81, 0x81, 0xE9, 0x24, 0x92, 0x4B, 0x80, 0x24, 0x92, 0x49, 0x24, 0x93,
  0x80, 0x83, 0x86, 0x84, 0x88, 0x90, 0xB0, 0xD8, 0x88, 0x84, 0x82, 0x83,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x0F, 0xC0, 0xC0, 0x78, 0x0E,
  0x82, 0xD0, 0x59, 0x0B, 0x22, 0x64, 0x4C, 0x51, 0x8A, 0x31, 0x46, 0x10,
  0x80, 0xC1, 0xC1, 0xA1, 0x91, 0x91, 0x89, 0x85, 0x85, 0x83, 0x81, 0x81,
  0x1E, 0x18, 0x44, 0x0A, 0x02, 0x80, 0x60, 0x18, 0x06, 0x02, 0x80, 0x90,
  0x43, 0xE0, 0xF9, 0x0E, 0x0C, 0x18, 0x30, 0xBE, 0x40, 0x81, 0x02, 0x00,
  0x1E, 0x18, 0x44, 0x0A, 0x02, 0x80, 0x60, 0x18, 0x06, 0x02, 0x80, 0x90,
  0x43, 0xE0, 0x08, 0x03, 0x00, 0x60, 0xF8, 0x86, 0x82, 0x82, 0x82, 0x8C,
  0xF8, 0x84, 0x84, 0x82, 0x83, 0x7E, 0x08, 0x20, 0xC0, 0xC0, 0xC1, 0x04,
  0x1F, 0x80, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x41, 0x3E,
  0x80, 0xC0, 0x90, 0x48, 0x24, 0x21, 0x10, 0x90, 0x28, 0x14, 0x0C, 0x02,
  0x00, 0x82, 0x0A, 0x18, 0x50, 0xC2, 0x8A, 0x24, 0x51, 0x12, 0x48, 0xA2,
  0x45, 0x14, 0x28, 0x60, 0x83, 0x04, 0x10, 0x81, 0x42, 0x22, 0x24, 0x18,
  0x08, 0x18, 0x24, 0x22, 0x42, 0x81, 0x81, 0x42, 0x42, 0x24, 0x24, 0x18,
  0x18, 0x08, 0x08, 0x08, 0x08, 0xFE, 0x08, 0x10, 0x41, 0x02, 0x08, 0x20,
  0x41, 0x03, 0xF8, 0xF2, 0x49, 0x24, 0x92, 0x4E, 0x82, 0x10, 0x82, 0x10,
  0x82, 0x10, 0x42, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0xF0, 0x10, 0x60,
  0xA2, 0x44, 0x50, 0xA0, 0x80, 0xFC, 0x90, 0x78, 0x10, 0x4F, 0xC6, 0x18,
  0xFD, 0x81, 0x02, 0x05, 0xEC, 0x30, 0x60, 0xC1, 0x83, 0x86, 0xF0, 0x7F,
  0x08, 0x20, 0x82, 0x08, 0x1F, 0x02, 0x04, 0x0B, 0xD8, 0x70, 0x60, 0xC1,
  0x83, 0x0D, 0xE8, 0x7A, 0x18, 0x7F, 0x82, 0x08, 0x1F, 0x39, 0x09, 0xE2,
  0x10, 0x84, 0x21, 0x08, 0x7B, 0x0E, 0x0C, 0x18, 0x30, 0x61, 0xBD, 0x02,
  0x06, 0x13, 0xC0, 0x81, 0x02, 0x05, 0xEC, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x08, 0x9F, 0xE0, 0x20, 0x12, 0x49, 0x24, 0x92, 0x70, 0x82, 0x08, 0x21,
  0x8A, 0x4A, 0x34, 0x9A, 0x28, 0x40, 0xFF, 0xE0, 0xB9, 0xD8, 0xC6, 0x10,
  0xC2, 0x18, 0x43, 0x08, 0x61, 0x0C, 0x21, 0xBD, 0x86, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x7D, 0x0A, 0x0C, 0x18, 0x30, 0x61, 0x3E, 0xBD, 0x86, 0x0C,
  0x18, 0x30, 0x70, 0xDE, 0x81, 0x02, 0x04, 0x00, 0x7B, 0x0E, 0x0C, 0x18,
  0x30, 0x61, 0xBD, 0x02, 0x04, 0x08, 0x10, 0xBE, 0x21, 0x08, 0x42, 0x10,
  0xFC, 0x20, 0xC1, 0x84, 0x3F, 0x42, 0x3E, 0x84, 0x21, 0x08, 0x41, 0xC0,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x61, 0xBD, 0x82, 0x85, 0x12, 0x22, 0x85,
  0x0A, 0x08, 0x84, 0x28, 0xC9, 0x29, 0x25, 0x24, 0x94, 0x63, 0x0C, 0x61,
  0x84, 0xC2, 0x48, 0xA0, 0xC1, 0x85, 0x11, 0x61, 0x82, 0x85, 0x12, 0x22,
  0x85, 0x0A, 0x08, 0x10, 0x40, 0x86, 0x00, 0xF8, 0x44, 0x42, 0x22, 0x1F,
  0x19, 0x08, 0x42, 0x13, 0x04, 0x21, 0x08, 0x41, 0x80, 0xFF, 0xFE, 0x84,
  0x44, 0x44, 0x32, 0x44, 0x44, 0xC0, 0xF2, 0x18,
};

const GFXglyph NotoSans_Light15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 11, 4, 1, -11 },
  { 4, 3, 4, 5, 1, -11 },
  { 6, 9, 11, 10, 0, -11 },
  { 19, 6, 12, 9, 1, -11 },
  { 28, 10, 11, 12, 1, -11 },
  { 42, 9, 11, 11, 1, -11 },
  { 55, 1, 4, 3, 1, -11 },
  { 56, 3, 13, 4, 1, -11 },
  { 61, 4, 13, 4, 0, -11 },
  { 68, 6, 6, 8, 1, -11 },
  { 73, 7, 7, 9, 1, -9 },
  { 80, 1, 4, 3, 1, -2 },
  { 81, 3, 1, 5, 1, -5 },
  { 82, 2, 1, 4, 1, -1 },
  { 83, 5, 11, 5, 0, -11 },
  { 90, 7, 11, 9, 1, -11 },
  { 100, 4, 11, 9, 1, -11 },
  { 106, 7, 11, 9, 1, -11 },
  { 116, 7, 11, 9, 1, -11 },
  { 126, 8, 11, 9, 0, -11 },
  { 137, 7, 11, 9, 1, -11 },
  { 147, 7, 11, 9, 1, -11 },
  { 157, 7, 11, 9, 1, -11 },
  { 167, 7, 11, 9, 1, -11 },
  { 177, 7, 11, 9, 1, -11 },
  { 187, 2, 8, 4, 1, -8 },
  { 189, 1, 10, 4, 1, -8 },
  { 191, 7, 7, 9, 1, -9 },
  { 198, 7, 4, 9, 1, -7 },
  { 202, 7, 7, 9, 1, -9 },
  { 209, 6, 11, 6, 0, -11 },
  { 218, 12, 12, 13, 1, -11 },
  { 236, 9, 11, 9, 0, -11 },
  { 249, 8, 11, 9, 1, -11 },
  { 260, 8, 11, 9, 1, -11 },
  { 271, 9, 11, 11, 1, -11 },
  { 284, 6, 11, 8, 1, -11 },
  { 293, 6, 11, 8, 1, -11 },
  { 302, 9, 11, 11, 1, -11 },
  { 315, 8, 11, 11, 1, -11 },
  { 326, 3, 11, 5, 1, -11 },
  { 331, 3, 14, 4, -1, -11 },
  { 337, 8, 11, 9, 1, -11 },
  { 348, 6, 11, 8, 1, -11 },
  { 357, 11, 11, 13, 1, -11 },
  { 373, 8, 11, 11, 1, -11 },
  { 384, 10, 11, 12, 1, -11 },
  { 398, 7, 11, 9, 1, -11 },
  { 408, 10, 14, 12, 1, -11 },
  { 426, 8, 11, 9, 1, -11 },
  { 437, 6, 11, 8, 1, -11 },
  { 446, 8, 11, 8, 0, -11 },
  { 457, 8, 11, 11, 1, -11 },
  { 468, 9, 11, 9, 0, -11 },
  { 481, 13, 11, 14, 0, -11 },
  { 499, 8, 11, 8, 0, -11 },
  { 510, 8, 11, 8, 0, -11 },
  { 521, 7, 11, 9, 1, -11 },
  { 531, 3, 13, 5, 1, -11 },
  { 536, 5, 11, 5, 0, -11 },
  { 543, 4, 13, 5, 0, -11 },
  { 550, 7, 7, 9, 1, -11 },
  { 557, 6, 1, 6, 0, 1 },
  { 558, 2, 2, 4, 1, -11 },
  { 559, 6, 8, 8, 1, -8 },
  { 565, 7, 11, 9, 1, -11 },
  { 575, 6, 8, 7, 1, -8 },
  { 581, 7, 11, 9, 1, -11 },
  { 591, 6, 8, 8, 1, -8 },
  { 597, 5, 11, 5, 0, -11 },
  { 604, 7, 12, 9, 1, -8 },
  { 615, 7, 11, 9, 1, -11 },
  { 625, 1, 11, 4, 1, -11 },
  { 627, 3, 15, 4, -1, -11 },
  { 633, 6, 11, 7, 1, -11 },
  { 642, 1, 11, 4, 1, -11 },
  { 644, 11, 8, 13, 1, -8 },
  { 655, 7, 8, 9, 1, -8 },
  { 662, 7, 8, 9, 1, -8 },
  { 669, 7, 12, 9, 1, -8 },
  { 680, 7, 12, 9, 1, -8 },
  { 691, 5, 8, 6, 1, -8 },
  { 696, 5, 8, 7, 1, -8 },
  { 701, 5, 10, 5, 0, -10 },
  { 708, 7, 8, 9, 1, -8 },
  { 715, 7, 8, 7, 0, -8 },
  { 722, 11, 8, 11, 0, -8 },
  { 733, 7, 8, 8, 0, -8 },
  { 740, 7, 12, 7, 0, -8 },
  { 751, 5, 8, 7, 1, -8 },
  { 756, 5, 13, 5, 0, -11 },
  { 765, 1, 15, 8, 4, -11 },
  { 767, 4, 13, 5, 1, -11 },
  { 774, 7, 2, 9, 1, -6 },
};

const GFXfont NotoSans_Light15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light15pt7bBitmaps,
  (GFXglyph *)NotoSans_Light15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_LIGHT15PT7B_H_
