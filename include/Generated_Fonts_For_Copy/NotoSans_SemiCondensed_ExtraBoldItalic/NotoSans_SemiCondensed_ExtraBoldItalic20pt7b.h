#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC20PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBoldItalic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBoldItalic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x73, 0xCE, 0x38, 0xE3, 0x8C, 0x70, 0x00, 0x1C, 0xF3, 0x80,
  0xF7, 0xEE, 0xEE, 0xCE, 0xCC, 0x06, 0x60, 0x66, 0x0E, 0xE0, 0xCC, 0x3F,
  0xF7, 0xFF, 0x19, 0x81, 0x98, 0xFF, 0xEF, 0xFE, 0x33, 0x03, 0x30, 0x77,
  0x06, 0x60, 0x01, 0x00, 0xF0, 0x7F, 0x9F, 0xE3, 0xA4, 0x74, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF0, 0x36, 0x35, 0xCF, 0xF8, 0xFE, 0x02, 0x00, 0xC0,
  0x3C, 0x1C, 0xFC, 0x61, 0xB9, 0xC7, 0x73, 0x0E, 0xEC, 0x1D, 0xBB, 0xBF,
  0x6F, 0xBD, 0xBB, 0x07, 0x66, 0x0C, 0xCC, 0x33, 0xB8, 0xE7, 0x71, 0x87,
  0xC6, 0x0F, 0x00, 0x0F, 0xC0, 0xFE, 0x07, 0x38, 0x3B, 0x81, 0xDC, 0x0F,
  0xC0, 0x7C, 0xE7, 0xEF, 0x77, 0xF7, 0x9F, 0xBC, 0xF9, 0xEF, 0x87, 0xFE,
  0x1F, 0x78, 0xFE, 0xEE, 0xC0, 0x1E, 0x38, 0xE1, 0x87, 0x0C, 0x38, 0x70,
  0xE1, 0x83, 0x06, 0x0C, 0x18, 0x38, 0x70, 0xE0, 0x1C, 0x18, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x30, 0xE1, 0xC3, 0x0E, 0x38, 0x71, 0xC0,
  0x1C, 0x4E, 0x36, 0x3F, 0xE3, 0xF1, 0xE3, 0xB0, 0xDC, 0x2C, 0x00, 0x1C,
  0x0E, 0x07, 0x03, 0x8F, 0xFF, 0xFC, 0x70, 0x38, 0x1C, 0x0E, 0x00, 0x7B,
  0x9D, 0xCE, 0x00, 0x7D, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0xE0, 0x38, 0x0E,
  0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x00, 0xE0, 0x18,
  0x07, 0x01, 0xC0, 0x00, 0x04, 0x0F, 0x8F, 0xEF, 0x77, 0x3F, 0x9F, 0x8F,
  0xC7, 0xE3, 0xF3, 0xF9, 0xDC, 0xEF, 0xE7, 0xF1, 0xF0, 0x0F, 0x1E, 0x7E,
  0xFE, 0xEE, 0x5C, 0x1C, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x38, 0x78, 0x0F,
  0xC3, 0xFC, 0x73, 0x84, 0x70, 0x0E, 0x03, 0x80, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3F, 0xE7, 0xFD, 0xFF, 0x00, 0x1F, 0x8F, 0xF1, 0x1C, 0x07,
  0x01, 0xC7, 0xE1, 0xE0, 0x7E, 0x03, 0x80, 0xE0, 0x3B, 0xBE, 0xFF, 0x3F,
  0x80, 0x01, 0xC0, 0xF0, 0x7C, 0x3F, 0x0F, 0x86, 0xE3, 0xB9, 0xCE, 0x67,
  0xBF, 0xFF, 0xFC, 0x1C, 0x07, 0x03, 0x80, 0x1F, 0xE3, 0xF8, 0x70, 0x1C,
  0x03, 0x80, 0x7E, 0x1F, 0xE1, 0x3C, 0x03, 0x80, 0x70, 0x0E, 0x77, 0xCF,
  0xF1, 0xFC, 0x00, 0x01, 0x03, 0xF1, 0xF8, 0xF0, 0x70, 0x1C, 0x0E, 0xF3,
  0xFE, 0xF7, 0xB8, 0xEE, 0x7B, 0x9C, 0xFF, 0x3F, 0x87, 0xC0, 0x7F, 0xDF,
  0xF0, 0x3C, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0x81,
  0xC0, 0xF0, 0x38, 0x00, 0x02, 0x03, 0xF1, 0xFC, 0xE7, 0x39, 0xCE, 0x71,
  0xF8, 0x3C, 0x3F, 0x9C, 0xE7, 0x3B, 0x8E, 0xF3, 0x9F, 0xE3, 0xE0, 0x04,
  0x1F, 0x9F, 0xEE, 0x7F, 0x3F, 0x1F, 0x8F, 0xEF, 0xFF, 0xBF, 0x81, 0xC1,
  0xE9, 0xE7, 0xE3, 0xE0, 0x39, 0xCE, 0x00, 0x00, 0x00, 0xF7, 0xB8, 0x1C,
  0x71, 0xC0, 0x00, 0x00, 0x00, 0x09, 0xC7, 0x1C, 0xE3, 0x00, 0x01, 0x83,
  0xC7, 0xEF, 0x8F, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0x80, 0x40, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x78, 0x7C,
  0xFD, 0xF0, 0xE0, 0x40, 0x00, 0x7F, 0x7F, 0x67, 0x07, 0x0F, 0x1E, 0x3C,
  0x38, 0x70, 0x00, 0x00, 0x70, 0xF0, 0xE0, 0x07, 0xF0, 0x3F, 0xF0, 0xE0,
  0x33, 0x8E, 0x76, 0x7E, 0x7D, 0xCC, 0xF3, 0x39, 0xE6, 0x67, 0xDC, 0xCD,
  0xBB, 0xBB, 0x3F, 0xE6, 0x73, 0x8E, 0x00, 0x0E, 0x18, 0x0F, 0xF0, 0x07,
  0x80, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7E, 0x0E, 0xE0, 0xEE, 0x1C, 0xE1,
  0xCE, 0x3F, 0xE3, 0xFE, 0x7F, 0xE7, 0x0E, 0x70, 0xFE, 0x0F, 0x1F, 0xC1,
  0xFE, 0x1C, 0xF3, 0xCE, 0x38, 0xE3, 0xFC, 0x3F, 0x83, 0xFC, 0x79, 0xC7,
  0x1C, 0x71, 0xC7, 0xFC, 0x7F, 0x8F, 0xF0, 0x01, 0x01, 0xFC, 0x7F, 0x9E,
  0x67, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x0F,
  0xF0, 0xFE, 0x0F, 0xC0, 0x1F, 0xC1, 0xFE, 0x1D, 0xF3, 0xCF, 0x38, 0x73,
  0x87, 0x38, 0x73, 0x8F, 0x78, 0xF7, 0x0E, 0x71, 0xE7, 0xFC, 0x7F, 0x8F,
  0xE0, 0x1F, 0xE3, 0xF8, 0x70, 0x1E, 0x03, 0x80, 0x7F, 0x0F, 0xE1, 0xFC,
  0x78, 0x0E, 0x01, 0xC0, 0x3F, 0x87, 0xF1, 0xFE, 0x00, 0x1F, 0xE3, 0xF8,
  0x70, 0x1E, 0x03, 0x80, 0x70, 0x0F, 0xE1, 0xFC, 0x78, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x01, 0xE0, 0x00, 0x01, 0x00, 0xFF, 0x1F, 0xE3, 0xC6, 0x78,
  0x07, 0x00, 0xF0, 0x0F, 0x3E, 0xE7, 0xEE, 0x1C, 0xE1, 0xCF, 0x1C, 0xFF,
  0xC7, 0xFC, 0x3F, 0x80, 0x1E, 0x38, 0xE1, 0xC7, 0x1E, 0x78, 0xE3, 0xC7,
  0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x78, 0xE3, 0x87, 0x1C, 0x38, 0xE1, 0xC7,
  0x1E, 0x78, 0xE0, 0x1F, 0xC7, 0xE0, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x78, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x7E, 0x3F, 0x80, 0x03, 0xC0, 0xE0,
  0x38, 0x0E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x38,
  0x0E, 0x03, 0x81, 0xE2, 0xF0, 0xFC, 0x3E, 0x00, 0x1C, 0x78, 0xE7, 0x87,
  0x38, 0x7B, 0x83, 0xBC, 0x1F, 0xC0, 0xFC, 0x07, 0xF0, 0x7F, 0x83, 0x9C,
  0x1C, 0xE0, 0xE7, 0x87, 0x1C, 0x78, 0xF0, 0x1C, 0x1C, 0x1C, 0x3C, 0x38,
  0x38, 0x38, 0x38, 0x78, 0x70, 0x70, 0x7F, 0x7F, 0xFF, 0x1F, 0x0F, 0x8F,
  0x87, 0xC7, 0xC7, 0xC7, 0xE3, 0xE3, 0xF3, 0xF1, 0xF9, 0xB8, 0xFD, 0xF8,
  0x7E, 0xDC, 0x77, 0xEE, 0x3B, 0xE7, 0x1D, 0xF3, 0x8E, 0xFB, 0x86, 0x79,
  0xC7, 0x3C, 0xE0, 0x1E, 0x1C, 0x78, 0x71, 0xF1, 0xCF, 0xC7, 0x3F, 0x38,
  0xEC, 0xE3, 0xBB, 0x8E, 0xEE, 0x73, 0xB9, 0xC7, 0xC7, 0x1F, 0x1C, 0x7C,
  0x61, 0xF3, 0x83, 0x80, 0x01, 0x00, 0xFC, 0x1F, 0xE3, 0xCF, 0x78, 0xF7,
  0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x0E, 0xE0, 0xEF, 0x1E, 0xFF, 0xC7,
  0xF8, 0x3F, 0x00, 0x1F, 0xC3, 0xFC, 0x77, 0x9E, 0x73, 0x8E, 0x71, 0xCF,
  0xF9, 0xFE, 0x7F, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x00, 0x01,
  0x00, 0xFC, 0x1F, 0xE3, 0xCF, 0x78, 0xF7, 0x07, 0xF0, 0x7F, 0x0F, 0xE0,
  0xFE, 0x0E, 0xE0, 0xEF, 0x1E, 0xFF, 0xC7, 0xF8, 0x3F, 0x00, 0x70, 0x07,
  0x80, 0x3C, 0x1F, 0xC3, 0xFC, 0x77, 0x9E, 0x73, 0x8E, 0x73, 0xCF, 0xF1,
  0xFC, 0x7F, 0x8E, 0x71, 0xCE, 0x39, 0xE7, 0x1D, 0xE3, 0xC0, 0x1F, 0xC7,
  0xF3, 0xC8, 0xE0, 0x38, 0x0F, 0x01, 0xF0, 0x3C, 0x07, 0x81, 0xE8, 0x7B,
  0xFC, 0xFF, 0x3F, 0x80, 0xFF, 0xFF, 0xCF, 0x07, 0x83, 0x81, 0xC0, 0xE0,
  0xF0, 0x70, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x00, 0x38, 0x73, 0x8F, 0x38,
  0xE7, 0x8E, 0x70, 0xE7, 0x0E, 0x71, 0xE7, 0x1C, 0xF1, 0xCE, 0x1C, 0xE3,
  0xCF, 0xF8, 0x7F, 0x83, 0xE0, 0xE1, 0xFC, 0x3B, 0x8F, 0x71, 0xCE, 0x79,
  0xCE, 0x39, 0xC7, 0x70, 0xEE, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xE0,
  0x00, 0xE3, 0xC7, 0xF1, 0xE3, 0xB8, 0xF3, 0x9C, 0xF9, 0xCE, 0x7C, 0xE7,
  0x7E, 0xE3, 0xBF, 0x71, 0xFB, 0xF0, 0xFD, 0xB8, 0x6C, 0xDC, 0x3E, 0x7C,
  0x1E, 0x3E, 0x0F, 0x1E, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x39, 0xE0, 0xE7,
  0x03, 0xB8, 0x0F, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0xC0, 0x77,
  0x03, 0xDC, 0x0E, 0x78, 0x71, 0xE3, 0xC3, 0x80, 0xE1, 0xF8, 0xEE, 0x79,
  0xDC, 0x7E, 0x1F, 0x87, 0xC1, 0xF0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x00, 0x1F, 0xF1, 0xFF, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x07,
  0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0xFC, 0x7F, 0xCF, 0xF8, 0x0F,
  0x87, 0x83, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x1C, 0x0E, 0x06,
  0x07, 0x03, 0x81, 0xC0, 0xF8, 0xF8, 0x00, 0xE7, 0x18, 0xC6, 0x39, 0xCE,
  0x71, 0x8C, 0x73, 0x9C, 0x1F, 0x1F, 0x06, 0x06, 0x0E, 0x0E, 0x0E, 0x0C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0xF8, 0xF0, 0x07, 0x01, 0xC0,
  0xF0, 0x7E, 0x1B, 0x8E, 0x63, 0x19, 0xC7, 0xE1, 0xC0, 0xFF, 0x80, 0xE7,
  0x30, 0x3D, 0xDF, 0xF7, 0xFB, 0xCE, 0xE3, 0xB8, 0xEE, 0x3B, 0x9C, 0xEF,
  0x3F, 0xC7, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3B, 0x8F, 0xF3, 0xDC,
  0xE7, 0x31, 0xDC, 0x77, 0x1D, 0xCF, 0x7F, 0xBF, 0xEE, 0xF0, 0x1F, 0x3F,
  0x7B, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xF6, 0xFE, 0x7C, 0x00, 0xE0, 0x38,
  0x07, 0x00, 0xE3, 0xDC, 0xFF, 0x9F, 0xE7, 0x9C, 0xE3, 0x9C, 0x73, 0x8E,
  0x73, 0x8E, 0xF1, 0xFE, 0x1D, 0xC0, 0x1F, 0x1F, 0xDC, 0xFE, 0x7E, 0xFF,
  0xFB, 0xE1, 0xC0, 0xE2, 0x7F, 0x1F, 0x80, 0x03, 0xE0, 0x7C, 0x1E, 0x03,
  0x80, 0xFC, 0x3F, 0x83, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x1F, 0x03, 0xC0, 0x70, 0x00, 0x1E,
  0xE7, 0xFC, 0xFF, 0x3C, 0xE7, 0x1C, 0xE3, 0x9C, 0x73, 0x9C, 0x77, 0x8F,
  0xF0, 0xEE, 0x03, 0xC8, 0x71, 0xFE, 0x3F, 0x83, 0xC0, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x3B, 0xCF, 0xF3, 0xDC, 0xE7, 0x39, 0xDC, 0x77, 0x1D, 0xCF,
  0x73, 0xBC, 0xEE, 0x38, 0x1C, 0x71, 0xC0, 0x3C, 0xE3, 0x8E, 0x79, 0xC7,
  0x1C, 0x73, 0xCE, 0x00, 0x03, 0x81, 0xC0, 0xE0, 0x00, 0x78, 0x38, 0x1C,
  0x0E, 0x07, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x7E,
  0x3E, 0x1E, 0x00, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0xF3, 0x9E,
  0x3B, 0xC3, 0xF8, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0x70, 0x77, 0x8F, 0x38,
  0xE3, 0xC0, 0x1E, 0x38, 0x70, 0xE3, 0xC7, 0x0E, 0x1C, 0x78, 0xE1, 0xC3,
  0x87, 0x1E, 0x38, 0x00, 0x3B, 0xDE, 0x3F, 0xFF, 0x3D, 0xFF, 0x39, 0xE7,
  0x79, 0xC7, 0x71, 0xCF, 0x71, 0xCE, 0x73, 0xCE, 0x73, 0x8E, 0xF3, 0x8E,
  0xE3, 0x9C, 0x3B, 0xCF, 0xF3, 0xDC, 0xE7, 0x39, 0xDC, 0x77, 0x1D, 0xCF,
  0x73, 0xBC, 0xEE, 0x38, 0x1F, 0x1F, 0xDE, 0xFE, 0x7E, 0x3F, 0x1F, 0x8F,
  0xCF, 0xEF, 0x7F, 0x1F, 0x00, 0x1D, 0xC3, 0xFC, 0x7B, 0x8E, 0x73, 0xCE,
  0x71, 0xCE, 0x39, 0xCF, 0x3F, 0xCF, 0xF9, 0xDE, 0x38, 0x07, 0x00, 0xE0,
  0x3C, 0x07, 0x00, 0x3D, 0xDF, 0xF7, 0xFB, 0xCE, 0xE3, 0xB8, 0xEE, 0x3B,
  0x9C, 0xEF, 0x3F, 0xC7, 0x70, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x3B,
  0x9F, 0x8F, 0xC7, 0x87, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x78, 0x38, 0x00,
  0x1F, 0x9F, 0x9E, 0x4F, 0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0xCF, 0x7F, 0x3F,
  0x00, 0x18, 0x71, 0xFF, 0xF7, 0x0E, 0x1C, 0x38, 0xE1, 0xC3, 0xA7, 0xC7,
  0x80, 0x71, 0xDC, 0x77, 0x3D, 0xCE, 0xF3, 0xB8, 0xEE, 0x3B, 0x9E, 0xEF,
  0x3F, 0xC7, 0x70, 0xE3, 0xF8, 0xEE, 0x7B, 0x9C, 0xE7, 0x1B, 0x86, 0xE1,
  0xF0, 0x7C, 0x1E, 0x07, 0x80, 0xE3, 0x8F, 0xCF, 0x3B, 0x9E, 0x77, 0x7D,
  0xCE, 0xDB, 0x9D, 0xB7, 0x3F, 0x7C, 0x7C, 0xF8, 0xF9, 0xE1, 0xE3, 0xC3,
  0xC7, 0x00, 0x3C, 0xF1, 0xCE, 0x1D, 0xC0, 0xFC, 0x0F, 0x80, 0xF0, 0x1F,
  0x01, 0xF8, 0x3B, 0x87, 0xB8, 0xF3, 0xC0, 0x38, 0xF3, 0x8E, 0x39, 0xE3,
  0x9C, 0x19, 0xC1, 0xB8, 0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01,
  0xC0, 0x3C, 0x0F, 0x80, 0xF0, 0x0E, 0x00, 0x1F, 0xC7, 0xF3, 0xF8, 0x1E,
  0x0F, 0x03, 0x81, 0xC0, 0xE0, 0x7F, 0x1F, 0xCF, 0xF0, 0x07, 0x0F, 0x0E,
  0x1C, 0x1C, 0x1C, 0x38, 0xF8, 0xE0, 0xF0, 0x38, 0x30, 0x70, 0x70, 0x70,
  0x78, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C, 0x1E, 0x0E, 0x0E, 0x0E,
  0x0C, 0x1C, 0x0F, 0x07, 0x1F, 0x3C, 0x38, 0x38, 0x38, 0x70, 0xF0, 0xE0,
  0x70, 0xFF, 0xFF, 0xF0, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBoldItalic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 14, 6, 0, -14 },
  { 12, 8, 5, 9, 2, -14 },
  { 17, 12, 14, 12, 0, -14 },
  { 38, 11, 16, 10, 0, -15 },
  { 60, 15, 14, 17, 1, -14 },
  { 87, 13, 14, 13, 0, -14 },
  { 110, 4, 5, 5, 2, -14 },
  { 113, 7, 17, 7, 1, -14 },
  { 128, 7, 18, 7, -1, -15 },
  { 144, 9, 9, 10, 2, -15 },
  { 155, 9, 10, 11, 1, -12 },
  { 167, 5, 5, 6, -1, -2 },
  { 171, 6, 3, 6, 0, -7 },
  { 174, 4, 3, 6, 0, -3 },
  { 176, 11, 14, 8, -1, -14 },
  { 196, 9, 15, 10, 1, -15 },
  { 213, 8, 14, 10, 2, -14 },
  { 227, 11, 14, 10, -1, -14 },
  { 247, 10, 14, 10, 0, -14 },
  { 265, 10, 14, 10, 0, -14 },
  { 283, 11, 14, 10, 0, -14 },
  { 303, 10, 15, 10, 1, -15 },
  { 322, 10, 14, 10, 1, -14 },
  { 340, 10, 15, 10, 0, -15 },
  { 359, 9, 15, 10, 1, -15 },
  { 376, 5, 11, 6, 0, -11 },
  { 383, 6, 14, 6, -1, -11 },
  { 394, 9, 10, 11, 1, -12 },
  { 406, 9, 6, 11, 1, -10 },
  { 413, 9, 10, 11, 1, -12 },
  { 425, 8, 14, 9, 1, -14 },
  { 439, 15, 16, 16, 1, -14 },
  { 469, 12, 14, 12, -1, -14 },
  { 490, 12, 14, 12, 0, -14 },
  { 511, 11, 15, 11, 1, -15 },
  { 532, 12, 14, 12, 0, -14 },
  { 553, 11, 14, 10, 0, -14 },
  { 573, 11, 14, 10, 0, -14 },
  { 593, 12, 15, 13, 1, -15 },
  { 616, 13, 14, 13, 0, -14 },
  { 639, 10, 14, 8, -1, -14 },
  { 657, 10, 18, 6, -3, -14 },
  { 680, 13, 14, 12, 0, -14 },
  { 703, 8, 14, 10, 0, -14 },
  { 717, 17, 14, 17, 0, -14 },
  { 747, 14, 14, 14, 0, -14 },
  { 772, 12, 15, 13, 1, -15 },
  { 795, 11, 14, 11, 0, -14 },
  { 815, 12, 18, 13, 1, -15 },
  { 842, 11, 14, 12, 0, -14 },
  { 862, 10, 14, 10, 0, -14 },
  { 880, 9, 14, 10, 2, -14 },
  { 896, 12, 14, 13, 1, -14 },
  { 917, 11, 14, 11, 2, -14 },
  { 937, 17, 14, 17, 2, -14 },
  { 967, 14, 14, 11, -1, -14 },
  { 992, 10, 14, 11, 2, -14 },
  { 1010, 12, 14, 10, -1, -14 },
  { 1031, 9, 17, 6, -1, -14 },
  { 1051, 5, 14, 8, 2, -14 },
  { 1060, 8, 17, 6, -1, -14 },
  { 1077, 10, 9, 10, 0, -14 },
  { 1089, 9, 1, 8, -2, 2 },
  { 1091, 4, 3, 7, 3, -15 },
  { 1093, 10, 11, 11, 1, -11 },
  { 1107, 10, 15, 11, 0, -15 },
  { 1126, 8, 11, 9, 1, -11 },
  { 1137, 11, 15, 11, 1, -15 },
  { 1158, 9, 11, 10, 1, -11 },
  { 1171, 11, 20, 7, -2, -15 },
  { 1199, 11, 16, 11, 0, -11 },
  { 1221, 10, 15, 11, 0, -15 },
  { 1240, 6, 15, 6, 0, -15 },
  { 1252, 9, 20, 6, -3, -15 },
  { 1275, 12, 15, 11, 0, -15 },
  { 1298, 7, 15, 6, 0, -15 },
  { 1312, 16, 11, 17, 0, -11 },
  { 1334, 10, 11, 11, 0, -11 },
  { 1348, 9, 11, 11, 1, -11 },
  { 1361, 11, 16, 11, -1, -11 },
  { 1383, 10, 16, 11, 1, -11 },
  { 1403, 9, 11, 8, 0, -11 },
  { 1416, 9, 11, 9, 0, -11 },
  { 1429, 7, 13, 8, 1, -13 },
  { 1441, 10, 11, 11, 1, -11 },
  { 1455, 10, 11, 10, 1, -11 },
  { 1469, 15, 11, 15, 1, -11 },
  { 1490, 12, 11, 10, -1, -11 },
  { 1507, 12, 16, 10, -1, -11 },
  { 1531, 10, 11, 9, -1, -11 },
  { 1545, 8, 17, 7, 0, -14 },
  { 1562, 2, 20, 10, 4, -15 },
  { 1567, 8, 17, 7, -1, -14 },
  { 1584, 9, 4, 11, 1, -9 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBoldItalic20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBoldItalic20pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBoldItalic20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC20PT7B_H_
