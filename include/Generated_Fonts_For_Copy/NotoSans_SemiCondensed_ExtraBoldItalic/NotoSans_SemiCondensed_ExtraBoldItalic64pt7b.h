#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC64PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC64PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBoldItalic.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBoldItalic64pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0,
  0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0x3F,
  0xF1, 0xFF, 0x9F, 0xF8, 0xFF, 0x8F, 0xF8, 0x7F, 0xC7, 0xFC, 0x3F, 0xE3,
  0xFE, 0x1F, 0xF1, 0xFE, 0x1F, 0xF1, 0xFF, 0x0F, 0xF8, 0xFF, 0x87, 0xFC,
  0x7F, 0xC3, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F,
  0x87, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F,
  0xE0, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x07,
  0xF8, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x3F,
  0x83, 0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x3F, 0x80,
  0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x03, 0xFC,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x01, 0xFE, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x7F, 0x80,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFD, 0xE7, 0xE0, 0x1F, 0xF9, 0xF0, 0x70, 0x0F, 0xFC,
  0xF0, 0x08, 0x07, 0xFC, 0x78, 0x00, 0x03, 0xFE, 0x3C, 0x00, 0x01, 0xFF,
  0x9E, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xBF, 0xF0, 0x00, 0x03, 0xDF, 0xF8,
  0x00, 0x03, 0xE7, 0xFC, 0x00, 0x01, 0xE3, 0xFE, 0x08, 0x00, 0xF1, 0xFF,
  0x07, 0x00, 0x79, 0xFF, 0x83, 0xF0, 0x3C, 0xFF, 0xC1, 0xFF, 0xBF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x07,
  0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0xEF, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC7, 0xF8, 0x03, 0xFC, 0x00, 0x7F,
  0x87, 0xF8, 0x03, 0xF8, 0x00, 0x7F, 0x87, 0xF8, 0x07, 0xF8, 0x00, 0x7F,
  0x87, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0xFF,
  0x07, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFF,
  0x07, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0xFE,
  0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0xFE,
  0x0F, 0xF1, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0xF8, 0xFE,
  0x1F, 0xE7, 0xF8, 0xFF, 0xFC, 0xFF, 0x7F, 0xC7, 0xF9, 0xFF, 0xFC, 0xFF,
  0xFF, 0xCF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0x9F, 0xE3, 0xFF, 0xFE, 0x7F,
  0xFF, 0x1F, 0xE7, 0xFF, 0xFE, 0x7F, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x3F,
  0xFC, 0x7F, 0x8F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7F, 0x8F, 0xF0, 0xFF, 0x00,
  0x00, 0xFF, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0xFF, 0x00,
  0x01, 0xFE, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0xFE, 0x00,
  0x07, 0xF8, 0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x00,
  0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC1, 0xFE, 0x00,
  0x1F, 0xE0, 0x3F, 0xC3, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x00,
  0x7F, 0x80, 0x3F, 0xC7, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xEF, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x01,
  0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x07,
  0xF8, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x00, 0x7F,
  0xC1, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00,
  0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0x9F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x0F, 0xFC, 0x07, 0xFF,
  0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFE, 0x07, 0xFF, 0xFF, 0x07,
  0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0x87,
  0xFF, 0x3F, 0xF9, 0xFF, 0x87, 0xFF, 0x1F, 0xFD, 0xFF, 0xC3, 0xFF, 0x07,
  0xFF, 0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F,
  0xF0, 0x07, 0xFF, 0xF0, 0x1F, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x81, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC7, 0xFF, 0x00, 0x1F, 0xFF, 0x83, 0xFF,
  0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF3, 0xFF, 0x3F, 0xE3, 0xFE,
  0x3F, 0xE3, 0xFC, 0x7F, 0xC7, 0xFC, 0x7F, 0xC7, 0xF8, 0x7F, 0x87, 0xF8,
  0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x10, 0x07, 0xF8, 0x00, 0xE0, 0x3F, 0xC0,
  0x07, 0xC1, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xFE, 0x7F, 0x00, 0x1F,
  0xFF, 0xF0, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFD, 0xFC, 0x00, 0xFF, 0xCF, 0xF0, 0x0F, 0xFC,
  0x7F, 0x80, 0x1F, 0xE1, 0xFE, 0x00, 0x7E, 0x0F, 0xF0, 0x01, 0xE0, 0x7F,
  0xC0, 0x03, 0x03, 0xFC, 0x00, 0x10, 0x0F, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x07, 0xFE, 0x0F, 0xF8,
  0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x81, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x3F,
  0xE0, 0x7F, 0x80, 0x3F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFE,
  0x7F, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x00,
  0x01, 0x01, 0xFC, 0x3F, 0xE7, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xE7, 0xFC, 0x7F, 0x81, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x9F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFC, 0x1F,
  0xF8, 0x1F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xE3, 0xFF,
  0x80, 0xFF, 0xC7, 0xFE, 0x01, 0xFF, 0x8F, 0xFC, 0x03, 0xFF, 0x3F, 0xF8,
  0x07, 0xFE, 0x7F, 0xE0, 0x0F, 0xFC, 0xFF, 0xC0, 0x1F, 0xFB, 0xFF, 0x80,
  0x3F, 0xF7, 0xFF, 0x00, 0xFF, 0xEF, 0xFC, 0x01, 0xFF, 0xDF, 0xF8, 0x03,
  0xFF, 0x3F, 0xF0, 0x07, 0xFE, 0xFF, 0xE0, 0x0F, 0xFD, 0xFF, 0xC0, 0x3F,
  0xFB, 0xFF, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0xFF, 0xCF, 0xFC, 0x01, 0xFF,
  0x9F, 0xF8, 0x07, 0xFF, 0x3F, 0xF0, 0x0F, 0xFE, 0x7F, 0xE0, 0x1F, 0xF8,
  0xFF, 0xC0, 0x7F, 0xF1, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0x87,
  0xFE, 0x07, 0xFF, 0x0F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x7F, 0xF0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x07, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x1F, 0xFD, 0xFF, 0x83, 0xFE, 0x7F, 0xE0,
  0xFF, 0x1F, 0xF8, 0x1F, 0x07, 0xFC, 0x03, 0x83, 0xFF, 0x00, 0xC0, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x3F,
  0xF8, 0x00, 0xFC, 0x03, 0xFF, 0x80, 0x0E, 0x00, 0x7F, 0xE0, 0x01, 0x80,
  0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0x0F, 0xFF, 0x80, 0x3C, 0x01, 0xFF, 0xC0, 0x08, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x10, 0x00, 0x07, 0xFF, 0x0E, 0x00, 0x07, 0xFF, 0x87,
  0xE0, 0x0F, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x1F, 0xEF,
  0xF8, 0x00, 0x0F, 0xF7, 0xFE, 0x00, 0x07, 0xF9, 0xFF, 0x80, 0x03, 0xFC,
  0x7F, 0xC0, 0x00, 0xFF, 0x3F, 0xF0, 0x00, 0x7F, 0x8F, 0xFC, 0x00, 0x3F,
  0xC3, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x03,
  0xFC, 0x1F, 0xF8, 0x01, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0x01, 0xFF, 0x80,
  0x7F, 0xC0, 0x7F, 0xC0, 0x1F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x10, 0x00, 0x0F,
  0xFE, 0x0E, 0x00, 0x1F, 0xFF, 0x07, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x05, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x02,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x7F, 0x00, 0x0F, 0xF8, 0xFF,
  0xE0, 0x0F, 0xFD, 0xFF, 0xF8, 0x07, 0xFE, 0xFF, 0xFC, 0x03, 0xFE, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFE, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC,
  0x07, 0xFE, 0x1F, 0xFE, 0x03, 0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0x87, 0xFF,
  0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0x80, 0x3F, 0xF0, 0xFF,
  0xC0, 0x3F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC, 0x0F,
  0xFC, 0x0F, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x87, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0x9F, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0xFF,
  0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F,
  0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x0F, 0xFC, 0x03,
  0xFF, 0x8F, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x8F, 0xFE,
  0x03, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0x80, 0x7F,
  0xE0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x0F, 0xF8, 0x7F, 0xE0, 0x07,
  0xFC, 0x3F, 0xF0, 0x07, 0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0x0F, 0xFC, 0x01,
  0xFF, 0x87, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xF8, 0x7F, 0xF0,
  0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xE3, 0xFF, 0x80, 0x7F, 0xE7, 0xFF, 0x00,
  0xFF, 0xCF, 0xFC, 0x03, 0xFF, 0x9F, 0xF8, 0x07, 0xFF, 0x3F, 0xF0, 0x0F,
  0xFE, 0x7F, 0xE0, 0x1F, 0xFC, 0xFF, 0xC0, 0x7F, 0xF1, 0xFF, 0x80, 0xFF,
  0xE3, 0xFF, 0x03, 0xFF, 0xC7, 0xFF, 0x0F, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFE, 0xFF, 0xC0, 0x7F, 0xF9, 0xFF, 0x00,
  0x3F, 0xC7, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x10, 0x03, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x1F, 0xC0, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xE0, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x01, 0xFC, 0x00, 0xFF,
  0x80, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xE0,
  0x3F, 0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0x1F, 0xC1, 0xFF, 0xC7, 0x80, 0x3F, 0xF0, 0x80,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x3F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xFF, 0x83,
  0xF8, 0x1F, 0xC0, 0x3F, 0xFF, 0xE1, 0xFC, 0x1F, 0xE0, 0x7F, 0xFF, 0xF0,
  0xFE, 0x0F, 0xE0, 0x7F, 0xFF, 0xF8, 0x7F, 0x0F, 0xE0, 0x7F, 0xFF, 0xF8,
  0x3F, 0x87, 0xF0, 0x3F, 0xE1, 0xFC, 0x0F, 0xE7, 0xF8, 0x3F, 0xC0, 0xFE,
  0x0F, 0xE3, 0xF8, 0x1F, 0xC0, 0xFF, 0x07, 0xF1, 0xFC, 0x1F, 0xE0, 0x7F,
  0x03, 0xF9, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0xFE, 0x0F, 0xF0, 0x1F,
  0xC0, 0xFE, 0x7F, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x3F, 0x83, 0xF8, 0x0F,
  0xE0, 0x3F, 0x9F, 0xC3, 0xFC, 0x07, 0xF0, 0x3F, 0x9F, 0xC1, 0xFE, 0x07,
  0xF8, 0x1F, 0xCF, 0xE0, 0xFE, 0x03, 0xFC, 0x0F, 0xE7, 0xF0, 0x7F, 0x01,
  0xFC, 0x0F, 0xE3, 0xF8, 0x3F, 0x81, 0xFE, 0x0F, 0xF1, 0xFC, 0x1F, 0xC0,
  0xFF, 0x07, 0xF0, 0xFE, 0x0F, 0xF0, 0xFF, 0x87, 0xF8, 0x7F, 0x07, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0xC1, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xE0, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xF0, 0x3F, 0xFC, 0xFF, 0xF8, 0x03, 0xF8, 0x1F,
  0xFC, 0x3F, 0xF8, 0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00,
  0x1F, 0xF7, 0xFC, 0x00, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0x03, 0xFE, 0x7F,
  0xC0, 0x00, 0x1F, 0xF9, 0xFF, 0x00, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x03,
  0xFF, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x7F, 0xE1, 0xFF,
  0x00, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x3F,
  0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x07, 0xFE, 0x07, 0xFE,
  0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x00,
  0x0F, 0xFC, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0xFF, 0xC7,
  0xFF, 0x00, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0xFF, 0xE0, 0x00,
  0x3F, 0xF3, 0xFF, 0x80, 0x00, 0xFF, 0xDF, 0xFC, 0x00, 0x03, 0xFF, 0x7F,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F,
  0xF8, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE,
  0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFC, 0x1F, 0xFE, 0x00, 0xFF,
  0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xF8, 0x03,
  0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF0, 0x07, 0xFF, 0x03, 0xFF,
  0x00, 0xFF, 0xF0, 0x3F, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xF8, 0x07, 0xFF, 0xC0,
  0x03, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x02, 0x00, 0x7F, 0xF8, 0x00, 0xE0, 0x07, 0xFF,
  0xE0, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF,
  0x80, 0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFE,
  0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xFF,
  0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x3F, 0xF0,
  0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x1F, 0xF8,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x03, 0xFF, 0x81, 0xFF, 0x80,
  0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0xE0,
  0xFF, 0xC0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x7F, 0xF0, 0x03, 0xFF, 0xC1, 0xFF, 0x80, 0x0F, 0xFE, 0x07,
  0xFE, 0x00, 0x7F, 0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F,
  0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F,
  0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x3F, 0xE0, 0x0F, 0xFF, 0xC0, 0x0F, 0x80, 0x7F, 0xFE, 0x00, 0x04, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0xE1, 0xFF,
  0xC0, 0xFF, 0xFF, 0x87, 0xFF, 0x03, 0xFF, 0xFE, 0x1F, 0xF8, 0x0F, 0xFF,
  0xF8, 0xFF, 0xE0, 0x3F, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xFF, 0x0F, 0xFE,
  0x07, 0xFF, 0xFC, 0x3F, 0xF8, 0x1F, 0xFF, 0xF0, 0xFF, 0xE0, 0x01, 0xFF,
  0xC3, 0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x3F, 0xF8,
  0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x0F, 0xFE,
  0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8,
  0x03, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x80, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFE, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xFE,
  0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x7F, 0xF0,
  0x7F, 0xF8, 0x00, 0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x00, 0x7F, 0xE3, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xDF, 0xFE, 0x00, 0x00, 0x3F, 0xF7, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFE, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0x87, 0xFF, 0x00, 0x00, 0x7F, 0xE1, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x00,
  0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x03,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x03, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFB, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xDF,
  0xC0, 0x1F, 0xEF, 0xF8, 0x03, 0xFE, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xF7, 0xF0, 0x0F, 0xF7, 0xFC, 0x00, 0xFF, 0xBF, 0xC0, 0x7F, 0xBF, 0xE0,
  0x0F, 0xF9, 0xFE, 0x07, 0xF9, 0xFF, 0x00, 0x7F, 0xCF, 0xF0, 0x3F, 0xDF,
  0xF8, 0x03, 0xFE, 0x7F, 0x83, 0xFC, 0xFF, 0xC0, 0x1F, 0xF3, 0xFC, 0x1F,
  0xE7, 0xFC, 0x00, 0xFF, 0x9F, 0xE1, 0xFE, 0x3F, 0xE0, 0x0F, 0xFC, 0xFF,
  0x0F, 0xF3, 0xFF, 0x00, 0x7F, 0xC7, 0xF8, 0xFF, 0x1F, 0xF8, 0x03, 0xFE,
  0x3F, 0xC7, 0xF8, 0xFF, 0xC0, 0x1F, 0xF1, 0xFE, 0x7F, 0x87, 0xFC, 0x01,
  0xFF, 0x8F, 0xF3, 0xFC, 0x3F, 0xE0, 0x0F, 0xFC, 0x7F, 0xBF, 0xE3, 0xFF,
  0x00, 0x7F, 0xC3, 0xFD, 0xFE, 0x1F, 0xF8, 0x03, 0xFE, 0x1F, 0xFF, 0xF0,
  0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x87, 0xFF,
  0xF8, 0x3F, 0xE0, 0x0F, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xC1,
  0xFF, 0xFC, 0x1F, 0xF8, 0x03, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0x80, 0x1F,
  0xF0, 0x7F, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xE0,
  0x0F, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0xF0, 0x1F,
  0xF8, 0x03, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF8,
  0x07, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xF8, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xE0, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xF8,
  0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFC,
  0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xFB, 0xFE, 0x01, 0xFF, 0x00,
  0x7F, 0xDF, 0xF0, 0x1F, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0xFF, 0xC0, 0x1F,
  0xF7, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x9F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF8,
  0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xC7, 0xFE, 0x1F, 0xF8, 0x03, 0xFE, 0x3F,
  0xF0, 0xFF, 0xC0, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x00, 0xFF, 0x87, 0xFC,
  0x3F, 0xE0, 0x0F, 0xFC, 0x3F, 0xF1, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x9F,
  0xF8, 0x03, 0xFE, 0x07, 0xFC, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xE7, 0xFC,
  0x01, 0xFF, 0x81, 0xFF, 0xBF, 0xE0, 0x0F, 0xFC, 0x0F, 0xFD, 0xFF, 0x00,
  0x7F, 0xC0, 0x3F, 0xEF, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFE, 0x00,
  0x7F, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x0F,
  0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0xF8, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x7F, 0xFC,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xF9, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xF8, 0x03, 0xFF, 0xC1, 0xFF,
  0xC0, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x3F,
  0xF1, 0xFF, 0xC0, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x03, 0xFF, 0x3F, 0xF8,
  0x00, 0x0F, 0xFC, 0xFF, 0xE0, 0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x00, 0xFF,
  0xDF, 0xFC, 0x00, 0x03, 0xFF, 0x7F, 0xF0, 0x00, 0x0F, 0xFD, 0xFF, 0xC0,
  0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x01, 0xFF, 0xDF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xEF, 0xFE, 0x00,
  0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x3F, 0xFB,
  0xFF, 0x80, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00,
  0x3F, 0xFC, 0xFF, 0xE0, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x07, 0xFF, 0x8F,
  0xFE, 0x00, 0x3F, 0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F,
  0xFF, 0x81, 0xFF, 0xF8, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFC, 0x1F, 0xFE, 0x01,
  0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7F,
  0xF0, 0x1F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xF8,
  0x07, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFE, 0x03,
  0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFE, 0x07, 0xFE, 0x03, 0xFF,
  0xC0, 0x7F, 0xE1, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFD, 0xFF, 0xF8,
  0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xFF, 0xC1, 0xFF, 0xE0,
  0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x3F, 0xF1,
  0xFF, 0xC0, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x03, 0xFF, 0x3F, 0xF8, 0x00,
  0x0F, 0xFC, 0xFF, 0xE0, 0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x00, 0xFF, 0xDF,
  0xFC, 0x00, 0x03, 0xFF, 0x7F, 0xF0, 0x00, 0x0F, 0xFD, 0xFF, 0xC0, 0x00,
  0x7F, 0xF7, 0xFF, 0x00, 0x01, 0xFF, 0xDF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x03,
  0xFF, 0xBF, 0xF8, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x3F, 0xFB, 0xFF,
  0x80, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x3F,
  0xFC, 0xFF, 0xE0, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x07, 0xFF, 0x8F, 0xFE,
  0x00, 0x3F, 0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFF,
  0x81, 0xFF, 0xF8, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F, 0xFC, 0x07, 0xFF, 0x03, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xF8, 0x07, 0xFF, 0x03, 0xFF,
  0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x03,
  0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xE1, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0xFF, 0xC0, 0x07,
  0xFE, 0x1F, 0xF8, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xF0,
  0x07, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF8, 0x1F,
  0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF8, 0x1F, 0xFC,
  0x07, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x0F, 0xFE, 0x0F,
  0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x3F, 0xF8, 0x7F, 0xF0, 0x03, 0xFF,
  0x8F, 0xFC, 0x00, 0x7F, 0xF1, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xE0, 0x1E, 0x00, 0xFF, 0xE0, 0x03, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x10, 0x00, 0x1F, 0xFC, 0x0E, 0x00,
  0x0F, 0xFE, 0x07, 0xC0, 0x0F, 0xFE, 0x03, 0xFE, 0x3F, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x00, 0xFF, 0xC0,
  0x7F, 0xE0, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFF, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x3F, 0xF0,
  0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xF8,
  0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xFF,
  0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xFE,
  0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x01, 0xFF,
  0xC0, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFE, 0x03, 0xFF,
  0x80, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0x7F,
  0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x1F,
  0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x8F, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x07, 0xFF, 0x7F, 0xE0,
  0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x0F, 0xFE, 0x7F, 0xE0, 0x00, 0xFF, 0xC7,
  0xFE, 0x00, 0x1F, 0xFC, 0x7F, 0xE0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x3F,
  0xF8, 0x7F, 0xE0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x7F, 0xE0,
  0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x0F, 0xFE, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xE0,
  0x7F, 0xF0, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x03,
  0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x03, 0xFE, 0x1F, 0xF8,
  0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x3F, 0xE3,
  0xFF, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x03,
  0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0x80,
  0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFE, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF9, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xF3, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0x8F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x1F, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xF8, 0x7F,
  0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF,
  0xC1, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFE, 0x07, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFC, 0x0F, 0xF8, 0x0F,
  0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xE0, 0x3F, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0xFF, 0x03, 0xFF,
  0x00, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x07, 0xFB, 0xFC,
  0x1F, 0xF8, 0x03, 0xFE, 0x0F, 0xF7, 0xF8, 0x3F, 0xF0, 0x07, 0xFC, 0x3F,
  0xEF, 0xF0, 0xFF, 0xC0, 0x0F, 0xF8, 0x7F, 0x9F, 0xE1, 0xFF, 0x80, 0x1F,
  0xF0, 0xFF, 0x3F, 0xC3, 0xFE, 0x00, 0x3F, 0xE3, 0xFE, 0x7F, 0x8F, 0xFC,
  0x00, 0x7F, 0xC7, 0xF8, 0xFF, 0x1F, 0xF8, 0x00, 0xFF, 0x9F, 0xF1, 0xFE,
  0x7F, 0xE0, 0x01, 0xFF, 0x3F, 0xC3, 0xFC, 0xFF, 0xC0, 0x03, 0xFE, 0x7F,
  0x87, 0xF9, 0xFF, 0x00, 0x07, 0xFD, 0xFF, 0x0F, 0xF7, 0xFE, 0x00, 0x0F,
  0xFB, 0xFC, 0x1F, 0xEF, 0xF8, 0x00, 0x1F, 0xEF, 0xF8, 0x3F, 0xDF, 0xF0,
  0x00, 0x3F, 0xDF, 0xE0, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xBF, 0xC0, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x1F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xDF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xFB,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x8F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0xC3, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xEF, 0xFC, 0x00, 0x7F, 0xFB, 0xFF, 0x80, 0x1F, 0xFC, 0x7F, 0xE0, 0x0F,
  0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0x87, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0x80,
  0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x1F, 0xFC, 0x03, 0xFF,
  0x07, 0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xC0, 0x0F,
  0xFC, 0x7F, 0xF0, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x7F, 0xCF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x03,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x3F, 0xEF, 0xF0,
  0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x7F, 0x87, 0xF0,
  0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xF8,
  0x03, 0xFC, 0x03, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x03, 0xFC,
  0x0F, 0xF0, 0x01, 0xFC, 0x1F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE,
  0x3F, 0xC0, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xE1, 0xFF, 0x87, 0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0x7F, 0xE0,
  0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x3F, 0xC0, 0x1F, 0xFE, 0x3F, 0xE0, 0x1F, 0xFF, 0x9F, 0xF0,
  0x1F, 0xFF, 0xDF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0x0F, 0xFF,
  0x07, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0x80, 0xFF,
  0xE1, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xE0, 0x1F,
  0xF8, 0x7F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x07, 0xFE, 0x1F, 0xF8, 0x03,
  0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0x87, 0xFF, 0x00,
  0xFF, 0xC3, 0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xE0,
  0x3F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFC,
  0x3F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xBF, 0xC0, 0x1F,
  0xFF, 0x9F, 0xE0, 0x07, 0xFF, 0x8F, 0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x1F, 0x00, 0x03, 0xFF, 0x3F, 0xE0, 0x03, 0xFF, 0x3F, 0xF8, 0x01, 0xFF,
  0xBF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x83,
  0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xC0, 0x3F, 0xF0,
  0x7F, 0xC0, 0x1F, 0xF8, 0x3F, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0x07, 0xFE,
  0x1F, 0xF8, 0x07, 0xFF, 0x0F, 0xF8, 0x03, 0xFF, 0x87, 0xFC, 0x01, 0xFF,
  0x87, 0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xE1, 0xFF, 0x80, 0x7F,
  0xE0, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xE0, 0x3F, 0xF8, 0x7F, 0xF0, 0x3F,
  0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0xFF,
  0xFE, 0x01, 0xFE, 0x7F, 0xFF, 0x00, 0xFF, 0x1F, 0xFE, 0x00, 0xFF, 0x87,
  0xFE, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x81, 0xFF, 0xF0, 0x18, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x04, 0x07, 0xFF, 0x03, 0xC0, 0x7F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7C, 0x1F, 0xF8, 0x00, 0x3F, 0xF1, 0xFF,
  0x80, 0x07, 0xFF, 0x9F, 0xF8, 0x00, 0xFF, 0xFD, 0xFF, 0x80, 0x1F, 0xFF,
  0xDF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0x1F, 0xFE,
  0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x7F,
  0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xFC,
  0x07, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x0F, 0xFE, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xF0,
  0x0F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFB, 0xFC, 0x00, 0x3F, 0xFF, 0x3F, 0xC0,
  0x01, 0xFF, 0xE3, 0xFC, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFE, 0x0F, 0xFC,
  0x3F, 0xF0, 0x1F, 0xF1, 0xFF, 0x80, 0x7F, 0xC7, 0xFE, 0x01, 0xFF, 0x3F,
  0xF0, 0x0F, 0xFC, 0xFF, 0xC0, 0x7F, 0xF7, 0xFF, 0x07, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x08, 0x1F, 0xF8, 0x00, 0xE0, 0x7F,
  0xF8, 0x1F, 0x81, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x40, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x40, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x10,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x83, 0xFC, 0x00, 0x7F, 0xF8, 0xFF, 0x80, 0x1F, 0xFF, 0x9F, 0xF0, 0x07,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF,
  0xF0, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0,
  0x3F, 0xF8, 0x1F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0xFF,
  0xE0, 0x1F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x7F, 0xE0, 0x0F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x7F,
  0xE0, 0x7F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0x80,
  0x7F, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0xFF, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xDF, 0xF0, 0x01, 0xFF, 0xF7, 0xFE, 0x00, 0x1F, 0xFC,
  0xFF, 0xC0, 0x00, 0xFF, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x18, 0x00, 0x3F, 0xF8, 0x03, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x0F, 0x80, 0x03,
  0xFE, 0x3F, 0xF0, 0x03, 0xFF, 0x3F, 0xFC, 0x01, 0xFF, 0xBF, 0xFF, 0x00,
  0xFF, 0xBF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x07, 0xFE,
  0x07, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x80, 0xFF,
  0xC1, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x1F,
  0xF8, 0x3F, 0xF0, 0x1F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF8, 0x07,
  0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x87, 0xFF, 0x01,
  0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xC0,
  0x3F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF0,
  0x0F, 0xFC, 0x1F, 0xF8, 0x07, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x07, 0xFE,
  0x01, 0xFF, 0x87, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xC1, 0xFF,
  0x80, 0x7F, 0xE0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xE0, 0x3F, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x08, 0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F,
  0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFE, 0x03, 0xFF,
  0x80, 0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x03, 0xFF,
  0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xF8, 0x00, 0x3F, 0xF1, 0xFF, 0xC0,
  0x00, 0xFF, 0xCF, 0xFE, 0x00, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x1F, 0xF9,
  0xFF, 0x80, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x01,
  0xFF, 0x87, 0xFE, 0x00, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x7F,
  0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x0F,
  0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x7F,
  0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFF,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0xE1, 0xFF, 0x80,
  0x7F, 0xE0, 0x07, 0xFC, 0x7F, 0xF8, 0x3F, 0xFE, 0x00, 0xFF, 0x9F, 0xFF,
  0x8F, 0xFF, 0xE0, 0x1F, 0xE7, 0xFF, 0xF3, 0xFF, 0xFC, 0x03, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xF8, 0x7F, 0xFE, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0x81,
  0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFE,
  0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xE0, 0x3F,
  0xF0, 0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x00,
  0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F,
  0xE0, 0x1F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF8,
  0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x83,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x01,
  0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xF0, 0x1F, 0xF8,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0x87, 0xFE, 0x00,
  0x3F, 0xC7, 0xFF, 0x80, 0x3F, 0xC7, 0xFF, 0xE0, 0x1F, 0xE7, 0xFF, 0xF0,
  0x0F, 0xF7, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0x7F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x0F,
  0xFC, 0x1F, 0xF8, 0x07, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x03,
  0xFF, 0x87, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x80,
  0x7F, 0xE0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xE0, 0x3F, 0xF8, 0x7F, 0xE0,
  0x1F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF8, 0x07, 0xFE, 0x0F, 0xFC,
  0x03, 0xFF, 0x0F, 0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x83, 0xFF,
  0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF,
  0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F,
  0xF8, 0x07, 0xFE, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xBF, 0xFC, 0x1F, 0xFC, 0x1F, 0xF8, 0x7F,
  0xF0, 0x3F, 0xF8, 0xFF, 0xC0, 0x7F, 0xF3, 0xFF, 0x80, 0x7F, 0xE7, 0xFE,
  0x00, 0xFF, 0xDF, 0xFC, 0x01, 0xFF, 0xBF, 0xF8, 0x07, 0xFF, 0x7F, 0xE0,
  0x0F, 0xFE, 0xFF, 0xC0, 0x1F, 0xFD, 0xFF, 0x80, 0x3F, 0xF7, 0xFF, 0x00,
  0x7F, 0xEF, 0xFE, 0x00, 0xFF, 0xDF, 0xF8, 0x03, 0xFF, 0xBF, 0xF0, 0x07,
  0xFF, 0x7F, 0xE0, 0x0F, 0xFC, 0xFF, 0xC0, 0x3F, 0xF9, 0xFF, 0x80, 0x7F,
  0xE3, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xE7, 0xFF, 0x80, 0x03, 0xFE,
  0xFF, 0xFC, 0x00, 0x3F, 0xDF, 0xFF, 0xE0, 0x03, 0xFD, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0x87, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x07, 0xFE,
  0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x1F, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xF0,
  0x07, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x07, 0xFE, 0x03,
  0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF,
  0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xF8,
  0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xDF, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0xE0, 0x01, 0xFF, 0x87,
  0xFC, 0x00, 0x1F, 0xF8, 0x1C, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x3F, 0xC0, 0x1F, 0xFE, 0x3F, 0xE0, 0x1F,
  0xFF, 0x9F, 0xF0, 0x1F, 0xFF, 0xEF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC3,
  0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0x3F, 0xF0,
  0xFF, 0xE0, 0x1F, 0xF8, 0x7F, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0x07, 0xFE,
  0x1F, 0xF8, 0x03, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x0F, 0xFE, 0x01, 0xFF,
  0x87, 0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x7F,
  0xE0, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F,
  0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xBF, 0xE0, 0x07, 0xFF, 0xBF, 0xF0, 0x00, 0xFF,
  0x1F, 0xF8, 0x00, 0x0C, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0xF0, 0xFF,
  0x01, 0xFF, 0x1F, 0xF0, 0x1F, 0xF3, 0xFE, 0x01, 0xFF, 0x7F, 0xE0, 0x1F,
  0xFF, 0xFE, 0x01, 0xFE, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0xC0, 0x3F, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFE, 0x07, 0x80, 0xFF, 0xE0, 0x18, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x80, 0x03, 0xFF, 0x0F, 0x00, 0x7F,
  0xF0, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC1, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x87, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x00,
  0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0,
  0x3F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF8,
  0x07, 0xFE, 0x1F, 0xFC, 0x07, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x07, 0xFE,
  0x01, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xE1, 0xFF,
  0x80, 0x7F, 0xE0, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F,
  0xF0, 0x0F, 0xFC, 0x1F, 0xF8, 0x0F, 0xFE, 0x1F, 0xF8, 0x07, 0xFE, 0x0F,
  0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0xC1,
  0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xE0, 0xFF, 0xF0,
  0x3F, 0xF0, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0xFF, 0x00, 0xFF, 0xFE, 0xFF,
  0x80, 0x7F, 0xFE, 0x7F, 0xC0, 0x1F, 0xFE, 0x3F, 0xC0, 0x07, 0xFE, 0x1F,
  0xE0, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0,
  0x07, 0xFE, 0x7F, 0xC0, 0x0F, 0xFE, 0x7F, 0xC0, 0x0F, 0xFC, 0x7F, 0xC0,
  0x1F, 0xFC, 0x7F, 0xC0, 0x1F, 0xF8, 0x7F, 0xC0, 0x3F, 0xF8, 0x7F, 0xE0,
  0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0,
  0xFF, 0xE0, 0x7F, 0xE0, 0xFF, 0xC0, 0x3F, 0xE0, 0xFF, 0xC0, 0x3F, 0xE1,
  0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x3F, 0xE3,
  0xFE, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x3F, 0xEF,
  0xFC, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xF0,
  0x1F, 0xFB, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xF7, 0xFC, 0x07, 0xFF, 0xC0,
  0x7F, 0xCF, 0xF8, 0x0F, 0xFF, 0x81, 0xFF, 0x9F, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0x3F, 0xE0, 0x7F, 0xFC, 0x0F, 0xFC, 0x7F, 0xC0, 0xFF, 0xF8, 0x1F,
  0xF8, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xE1, 0xFF, 0x07, 0xFF, 0xE0, 0xFF,
  0xC3, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0x07, 0xFC, 0x3F, 0xBF, 0x87, 0xFE,
  0x0F, 0xF8, 0x7F, 0x7F, 0x0F, 0xF8, 0x1F, 0xF1, 0xFE, 0xFE, 0x3F, 0xF0,
  0x3F, 0xE3, 0xF9, 0xFC, 0x7F, 0xE0, 0x7F, 0xC7, 0xF3, 0xF8, 0xFF, 0x80,
  0xFF, 0x9F, 0xE7, 0xF3, 0xFF, 0x01, 0xFF, 0x3F, 0x8F, 0xE7, 0xFC, 0x03,
  0xFE, 0xFF, 0x1F, 0xCF, 0xF8, 0x07, 0xFD, 0xFE, 0x3F, 0xBF, 0xE0, 0x0F,
  0xFB, 0xF8, 0x7F, 0x7F, 0xC0, 0x1F, 0xFF, 0xF0, 0xFE, 0xFF, 0x00, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xF8, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x00, 0x3F, 0xFE,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0,
  0x7F, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x7F, 0xF0, 0x00, 0x1F, 0xF9, 0xFF, 0xC0, 0x00, 0x3F, 0xFB, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x0F,
  0xFE, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0xFF, 0xC0, 0x00, 0x7F, 0xE1, 0xFF,
  0x80, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFE,
  0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0xFF,
  0xC0, 0xFF, 0xE0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x01, 0xFF, 0x03, 0xFF,
  0x00, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xF8, 0x00, 0x0F,
  0xF8, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x00, 0x3F, 0xE3, 0xFF,
  0x00, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x01,
  0xFF, 0x3F, 0xF0, 0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x03, 0xFD, 0xFF,
  0x80, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x04, 0xFF, 0xF8,
  0x00, 0x37, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFB, 0x00, 0x07, 0xFF, 0xC8, 0x00, 0x03, 0xF8, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBoldItalic64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 20, 47, 18, 0, -46 },
  { 119, 25, 17, 28, 6, -46 },
  { 173, 38, 46, 38, 1, -46 },
  { 392, 33, 53, 33, 1, -49 },
  { 611, 48, 47, 54, 4, -46 },
  { 893, 41, 47, 42, 1, -46 },
  { 1134, 12, 17, 16, 6, -46 },
  { 1160, 24, 56, 21, 2, -46 },
  { 1328, 24, 57, 21, -5, -47 },
  { 1499, 29, 30, 32, 5, -49 },
  { 1608, 30, 31, 35, 3, -38 },
  { 1725, 15, 16, 18, -3, -8 },
  { 1755, 18, 9, 20, 1, -22 },
  { 1776, 12, 12, 18, 0, -11 },
  { 1794, 35, 47, 27, -3, -46 },
  { 2000, 31, 47, 33, 2, -46 },
  { 2183, 26, 46, 33, 5, -46 },
  { 2333, 35, 46, 33, -2, -46 },
  { 2535, 33, 47, 33, 0, -46 },
  { 2729, 34, 46, 33, -1, -46 },
  { 2925, 33, 47, 33, 1, -46 },
  { 3119, 33, 47, 33, 2, -46 },
  { 3313, 34, 46, 33, 2, -46 },
  { 3509, 33, 47, 33, 1, -46 },
  { 3703, 31, 47, 33, 2, -46 },
  { 3886, 18, 37, 18, 0, -36 },
  { 3970, 22, 44, 18, -4, -36 },
  { 4091, 30, 33, 35, 3, -40 },
  { 4215, 30, 21, 35, 3, -33 },
  { 4294, 30, 33, 35, 3, -40 },
  { 4418, 26, 47, 27, 4, -46 },
  { 4571, 49, 52, 51, 2, -46 },
  { 4890, 38, 46, 38, -4, -46 },
  { 5109, 36, 46, 37, 1, -46 },
  { 5316, 36, 47, 36, 3, -46 },
  { 5528, 38, 46, 40, 1, -46 },
  { 5747, 33, 46, 32, 1, -46 },
  { 5937, 33, 46, 32, 1, -46 },
  { 6127, 38, 47, 41, 3, -46 },
  { 6351, 42, 46, 41, 1, -46 },
  { 6593, 30, 46, 24, -2, -46 },
  { 6766, 32, 60, 20, -10, -46 },
  { 7006, 42, 46, 37, 1, -46 },
  { 7248, 26, 46, 30, 1, -46 },
  { 7398, 53, 46, 53, 1, -46 },
  { 7703, 45, 46, 45, 1, -46 },
  { 7962, 38, 47, 43, 3, -46 },
  { 8186, 36, 46, 36, 1, -46 },
  { 8393, 38, 57, 43, 3, -46 },
  { 8664, 35, 46, 37, 1, -46 },
  { 8866, 33, 47, 32, 0, -46 },
  { 9060, 31, 46, 32, 5, -46 },
  { 9239, 39, 47, 41, 3, -46 },
  { 9469, 36, 46, 36, 5, -46 },
  { 9676, 55, 46, 54, 5, -46 },
  { 9993, 45, 46, 37, -4, -46 },
  { 10252, 34, 46, 34, 6, -46 },
  { 10448, 37, 46, 31, -2, -46 },
  { 10661, 27, 56, 21, -2, -46 },
  { 10850, 15, 47, 27, 7, -46 },
  { 10939, 27, 56, 21, -4, -46 },
  { 11128, 32, 30, 33, 0, -46 },
  { 11248, 27, 6, 25, -6, 5 },
  { 11269, 14, 10, 21, 9, -49 },
  { 11287, 33, 37, 35, 2, -36 },
  { 11440, 33, 50, 35, 0, -49 },
  { 11647, 28, 37, 29, 2, -36 },
  { 11777, 36, 50, 35, 2, -49 },
  { 12002, 30, 37, 33, 2, -36 },
  { 12141, 37, 64, 23, -7, -49 },
  { 12437, 35, 51, 35, 0, -36 },
  { 12661, 33, 49, 36, 0, -49 },
  { 12864, 20, 49, 18, 0, -49 },
  { 12987, 28, 64, 18, -8, -49 },
  { 13211, 38, 49, 35, 0, -49 },
  { 13444, 21, 49, 18, 0, -49 },
  { 13573, 51, 36, 53, 0, -36 },
  { 13803, 33, 36, 36, 0, -36 },
  { 13952, 31, 37, 35, 2, -36 },
  { 14096, 36, 51, 35, -3, -36 },
  { 14326, 33, 51, 35, 2, -36 },
  { 14537, 28, 36, 25, 0, -36 },
  { 14663, 28, 37, 28, 0, -36 },
  { 14793, 23, 43, 25, 3, -42 },
  { 14917, 33, 36, 36, 3, -35 },
  { 15066, 32, 35, 31, 3, -35 },
  { 15206, 47, 35, 48, 4, -35 },
  { 15412, 39, 35, 32, -3, -35 },
  { 15583, 39, 50, 32, -4, -35 },
  { 15827, 31, 35, 28, -2, -35 },
  { 15963, 27, 56, 22, 0, -46 },
  { 16152, 8, 64, 32, 12, -49 },
  { 16216, 26, 56, 22, -4, -46 },
  { 16398, 30, 11, 35, 3, -28 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBoldItalic64pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBoldItalic64pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBoldItalic64pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC64PT7B_H_
