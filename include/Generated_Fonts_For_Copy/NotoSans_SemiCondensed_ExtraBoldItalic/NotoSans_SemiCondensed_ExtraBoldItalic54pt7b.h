#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC54PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC54PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBoldItalic.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBoldItalic54pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x3F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x00,
  0x30, 0x00, 0x3F, 0xC7, 0xF9, 0xFE, 0x3F, 0xCF, 0xE1, 0xFC, 0x7F, 0x1F,
  0xE7, 0xF8, 0xFF, 0x3F, 0xC7, 0xF9, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x7F,
  0x0F, 0xE3, 0xF0, 0x7E, 0x1F, 0x87, 0xF1, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC,
  0x7E, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x0F, 0xE1, 0xF8, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x0F, 0xC3, 0xF8, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xE1, 0xF8, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFC, 0xE1, 0xC0, 0xFF, 0x3C, 0x08, 0x1F,
  0xE7, 0x80, 0x03, 0xFC, 0xE0, 0x00, 0x7F, 0x9C, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3B, 0xFE, 0x00, 0x0F,
  0x3F, 0xC0, 0x01, 0xE7, 0xF8, 0x80, 0x38, 0xFE, 0x1C, 0x07, 0x3F, 0xC7,
  0xE1, 0xEF, 0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x01, 0xFF, 0x80, 0x03, 0xF8, 0x01, 0xFF, 0xE0, 0x01, 0xF8, 0x01,
  0xFF, 0xF0, 0x01, 0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xFC, 0x01, 0xFF, 0xFE,
  0x00, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0xFE,
  0x00, 0x7F, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x87, 0xE0, 0x7E, 0x00, 0x1F,
  0x87, 0xF0, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x3F, 0x00, 0x0F, 0xE1, 0xFC,
  0x3F, 0x00, 0x07, 0xF0, 0xFE, 0x3F, 0x80, 0x03, 0xF8, 0x7E, 0x1F, 0x80,
  0x01, 0xF8, 0x7F, 0x1F, 0x81, 0xC0, 0xFC, 0x3F, 0x9F, 0xC7, 0xFC, 0x7F,
  0x3F, 0x9F, 0xC7, 0xFF, 0x3F, 0xFF, 0xCF, 0xC7, 0xFF, 0xDF, 0xFF, 0xCF,
  0xE7, 0xFF, 0xE7, 0xFF, 0xCF, 0xE7, 0xFF, 0xF3, 0xFF, 0xC7, 0xE3, 0xF9,
  0xFC, 0xFF, 0xC7, 0xF3, 0xF8, 0xFE, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x00,
  0x03, 0xF1, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x1F, 0xC0, 0x03, 0xF8,
  0x7F, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x07, 0xE0, 0x01, 0xFC, 0x1F, 0x83,
  0xF0, 0x01, 0xFC, 0x0F, 0xC3, 0xF8, 0x00, 0xFC, 0x07, 0xE1, 0xFC, 0x00,
  0xFE, 0x03, 0xF0, 0xFC, 0x00, 0xFE, 0x01, 0xF8, 0xFE, 0x00, 0x7E, 0x00,
  0xFE, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0xFF,
  0x00, 0x3F, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x07, 0xF8,
  0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x1F,
  0xE1, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x01, 0xFE, 0x3F, 0xC0, 0x00,
  0x7F, 0x9F, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x03,
  0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0x87, 0xFF, 0xFC,
  0x3F, 0xE3, 0xFF, 0xFF, 0x8F, 0xF1, 0xFF, 0xBF, 0xF7, 0xFC, 0x7F, 0xC7,
  0xFD, 0xFE, 0x3F, 0xE1, 0xFF, 0xFF, 0x8F, 0xF8, 0x3F, 0xFF, 0xC3, 0xFE,
  0x0F, 0xFF, 0xF0, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xC0, 0x3F, 0xFC, 0x0F,
  0xF8, 0x0F, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFB, 0xFF, 0x00, 0x7F, 0xF8,
  0x7F, 0xE0, 0x00, 0x80, 0x00, 0x00, 0x3F, 0xCF, 0xF3, 0xFC, 0xFE, 0x7F,
  0x9F, 0xE7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xE3, 0xF8, 0xFE, 0x3F, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x20, 0x1F, 0x80, 0x38, 0x3F, 0x80,
  0x3E, 0x3F, 0x00, 0x7F, 0xBF, 0x00, 0x7F, 0xFF, 0x07, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x1F, 0xEF, 0xC0,
  0x3F, 0xEF, 0xC0, 0x7F, 0xCF, 0xE0, 0x1F, 0x87, 0xE0, 0x0F, 0x87, 0xF0,
  0x07, 0x07, 0xF0, 0x02, 0x07, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF8, 0x3F, 0xC3, 0xFE,
  0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x3F, 0xC1, 0xFC, 0x0F,
  0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x00, 0x0F, 0x0F, 0xE7, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0x06, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F,
  0xF3, 0xFE, 0x0F, 0xF8, 0x7F, 0xC7, 0xFC, 0x1F, 0xF1, 0xFF, 0x07, 0xFC,
  0x7F, 0x81, 0xFF, 0x3F, 0xE0, 0x7F, 0xCF, 0xF8, 0x1F, 0xF7, 0xFC, 0x07,
  0xFD, 0xFF, 0x01, 0xFF, 0x7F, 0xC0, 0x7F, 0xDF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFB, 0xFE, 0x01, 0xFE, 0xFF, 0x80, 0xFF, 0xBF, 0xE0, 0x3F, 0xEF,
  0xF0, 0x0F, 0xFB, 0xFC, 0x03, 0xFC, 0xFF, 0x01, 0xFF, 0x3F, 0xC0, 0x7F,
  0xCF, 0xF0, 0x1F, 0xF3, 0xFC, 0x0F, 0xF8, 0xFF, 0x03, 0xFE, 0x3F, 0xC1,
  0xFF, 0x0F, 0xF0, 0x7F, 0xC3, 0xFE, 0x3F, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x00,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF9, 0xFF, 0xBF, 0xC7, 0xFB, 0xFE, 0x3F, 0x1F, 0xE0, 0xF0,
  0xFF, 0x02, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xF3, 0xFF, 0x00, 0x7C,
  0x0F, 0xF8, 0x03, 0xC0, 0x3F, 0xC0, 0x0C, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0x87, 0xFF, 0x00, 0xC0, 0x1F, 0xF0, 0x08,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x80, 0x01, 0xFF, 0x8F, 0x00, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xBF, 0xC0, 0x03, 0xF7, 0xF8,
  0x00, 0x7F, 0x7F, 0x80, 0x0F, 0xE7, 0xF8, 0x01, 0xFC, 0xFF, 0x80, 0x1F,
  0x8F, 0xF0, 0x03, 0xF8, 0xFF, 0x00, 0x7F, 0x0F, 0xF0, 0x0F, 0xE0, 0xFF,
  0x01, 0xFC, 0x1F, 0xF0, 0x1F, 0xC1, 0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x7F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFD, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x0E, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x20, 0x01, 0xFF,
  0x87, 0x00, 0x7F, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0x80, 0x00, 0x05, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFC, 0x02, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF1, 0xFE, 0x01, 0xFE, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFE, 0x0F, 0xF7, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF1, 0xFF, 0xC3, 0xFE, 0x3F, 0xF0, 0x3F,
  0xC7, 0xFC, 0x07, 0xF8, 0xFF, 0x80, 0xFF, 0x1F, 0xF0, 0x1F, 0xE3, 0xFC,
  0x07, 0xFC, 0x7F, 0x80, 0xFF, 0x8F, 0xF0, 0x1F, 0xF1, 0xFE, 0x03, 0xFC,
  0x3F, 0xE0, 0xFF, 0x87, 0xFC, 0x3F, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xDF,
  0xF8, 0x3F, 0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F,
  0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x0F, 0xF8, 0xFF,
  0x81, 0xFF, 0xBF, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0x9F, 0xF8, 0x7F, 0xC1,
  0xFF, 0x0F, 0xF0, 0x1F, 0xE3, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0xCF,
  0xF0, 0x0F, 0xF9, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xC7, 0xFC, 0x0F,
  0xF8, 0xFF, 0xC3, 0xFF, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF8, 0x7F, 0xE3, 0xFE, 0x1F, 0xF0, 0x7F, 0x8F, 0xF8, 0x1F,
  0xE3, 0xFE, 0x07, 0xF8, 0xFF, 0x01, 0xFF, 0x7F, 0xC0, 0x7F, 0xDF, 0xF0,
  0x1F, 0xF7, 0xFC, 0x07, 0xF9, 0xFF, 0x03, 0xFE, 0x7F, 0xC0, 0xFF, 0x9F,
  0xF0, 0x7F, 0xE7, 0xFE, 0x3F, 0xF9, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xC1, 0xFF, 0xEF, 0xF0, 0x7F, 0xFB, 0xFC, 0x0F, 0xF9,
  0xFE, 0x00, 0xF8, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x02, 0x00, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0xF8, 0x07, 0xF8, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x03, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0xE0, 0x3F, 0xE0, 0x7F,
  0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x0F, 0xE0, 0x06, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF8,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0x81, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xC7, 0xC1, 0xFF, 0x1C, 0x03, 0xFC, 0x40, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xC1,
  0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x03, 0xFC, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x81, 0xFC,
  0x01, 0xE0, 0x0F, 0xC1, 0xFC, 0x07, 0xFF, 0x87, 0xE1, 0xFC, 0x0F, 0xFF,
  0xE3, 0xF0, 0xFC, 0x0F, 0xFF, 0xF0, 0xF8, 0xFE, 0x0F, 0xFF, 0xF0, 0x7E,
  0x7E, 0x0F, 0xF1, 0xF8, 0x3F, 0x3F, 0x0F, 0xE0, 0xFC, 0x1F, 0xBF, 0x07,
  0xF0, 0x7E, 0x0F, 0xDF, 0x87, 0xF0, 0x7E, 0x07, 0xCF, 0xC3, 0xF0, 0x3F,
  0x07, 0xE7, 0xE1, 0xF8, 0x1F, 0x83, 0xF7, 0xE1, 0xFC, 0x0F, 0xC1, 0xFB,
  0xF0, 0xFC, 0x0F, 0xC0, 0xFD, 0xF8, 0x7E, 0x07, 0xE0, 0xFC, 0xFC, 0x3F,
  0x03, 0xF0, 0x7E, 0x7E, 0x1F, 0x83, 0xF8, 0x7E, 0x3F, 0x0F, 0xC1, 0xFC,
  0x3F, 0x1F, 0x87, 0xE1, 0xFE, 0x3F, 0x0F, 0xC3, 0xFF, 0xFF, 0xFF, 0x87,
  0xE1, 0xFF, 0xFF, 0xFF, 0x83, 0xF0, 0x7F, 0xF7, 0xFF, 0x81, 0xFC, 0x1F,
  0xF1, 0xFF, 0x80, 0x7E, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0x00, 0x00, 0xFF, 0x80, 0x07, 0x80, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFD,
  0xFC, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x03, 0xF9,
  0xFC, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xF1,
  0xFC, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x1F, 0xE1,
  0xFC, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0xFF, 0x01,
  0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xF0, 0x01,
  0xFE, 0x1F, 0xF0, 0x01, 0xFE, 0x3F, 0xE0, 0x01, 0xFE, 0x3F, 0xE0, 0x01,
  0xFE, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0x8F, 0xFF, 0x03,
  0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0xC1, 0xFF,
  0x01, 0xFF, 0x07, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0x81,
  0xFF, 0x81, 0xFE, 0x1F, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0x1F, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x1F,
  0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x0F, 0xF8,
  0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x07,
  0xFE, 0x1F, 0xF0, 0x7F, 0xF0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF,
  0xF1, 0xF8, 0x0F, 0xFE, 0x00, 0xE0, 0x3F, 0xF0, 0x00, 0x81, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x40, 0x3F, 0xF8, 0x0F, 0x00, 0x7F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0B,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFE,
  0x0F, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x03, 0xFC, 0x03, 0xFE, 0x07, 0xFC,
  0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x07, 0xFC,
  0x01, 0xFF, 0x07, 0xF8, 0x01, 0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0x0F, 0xF8,
  0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xF0,
  0x03, 0xFE, 0x1F, 0xF0, 0x03, 0xFE, 0x1F, 0xF0, 0x07, 0xFE, 0x1F, 0xF0,
  0x07, 0xFC, 0x1F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xFC, 0x3F, 0xE0,
  0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF8, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xC0,
  0x7F, 0xF0, 0x7F, 0xC0, 0xFF, 0xE0, 0x7F, 0xCF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xE1, 0xF8, 0x0F, 0xFF, 0x00, 0x38,
  0x0F, 0xFE, 0x00, 0x08, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC1, 0xFF, 0xF8,
  0xFF, 0x81, 0xFF, 0xF8, 0xFF, 0x81, 0xFF, 0xF8, 0xFF, 0x81, 0xFF, 0xF8,
  0xFF, 0x83, 0xFF, 0xF8, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0x83, 0xFF, 0xF0,
  0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0xE0,
  0xFF, 0x80, 0x1F, 0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xE0,
  0xFF, 0xC0, 0x3F, 0xE0, 0xFF, 0xE0, 0x3F, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xE0, 0x07,
  0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF0,
  0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x1F, 0xF0, 0x1F,
  0xF0, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0,
  0x0F, 0xF0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x0F,
  0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x1F, 0xE0, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x80,
  0x1F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F,
  0x80, 0x1F, 0xF0, 0x1F, 0xF0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0x80,
  0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x7F,
  0xC0, 0x7F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0xFF,
  0xC0, 0x1F, 0xF0, 0x3F, 0xF0, 0x03, 0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0x81,
  0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xE0, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x7F,
  0x87, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x03, 0xFE, 0x3F, 0xF0, 0x00,
  0x7F, 0xCF, 0xFC, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x01, 0xFE, 0x7F, 0xC0,
  0x00, 0x3F, 0xDF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x07, 0xFC, 0x7F, 0xC0,
  0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x03, 0xFE, 0x1F,
  0xF0, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x03, 0xFE,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x0F, 0xF0, 0x1F, 0xF8, 0x01,
  0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x01, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xDF, 0xC0, 0xFE, 0xFF, 0x00, 0xFE,
  0xFE, 0x07, 0xF7, 0xF0, 0x0F, 0xF7, 0xF0, 0x7F, 0x7F, 0x80, 0x7F, 0xBF,
  0x83, 0xFB, 0xFC, 0x03, 0xFD, 0xFC, 0x3F, 0x9F, 0xE0, 0x1F, 0xEF, 0xE1,
  0xFC, 0xFF, 0x00, 0xFE, 0x7F, 0x1F, 0xCF, 0xF0, 0x0F, 0xF3, 0xF8, 0xFE,
  0x7F, 0x80, 0x7F, 0x9F, 0xCF, 0xE3, 0xFC, 0x03, 0xFC, 0xFE, 0x7F, 0x1F,
  0xE0, 0x1F, 0xE7, 0xF3, 0xF1, 0xFF, 0x01, 0xFE, 0x3F, 0xBF, 0x8F, 0xF0,
  0x0F, 0xF1, 0xFD, 0xF8, 0x7F, 0x80, 0x7F, 0x8F, 0xFF, 0xC3, 0xFC, 0x03,
  0xFC, 0x7F, 0xFE, 0x1F, 0xE0, 0x1F, 0xE3, 0xFF, 0xE1, 0xFE, 0x01, 0xFE,
  0x1F, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0xF0, 0x7F, 0x80, 0x7F, 0x83,
  0xFF, 0x83, 0xFC, 0x03, 0xFC, 0x1F, 0xF8, 0x1F, 0xE0, 0x1F, 0xC0, 0xFF,
  0xC1, 0xFE, 0x01, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xE0,
  0x7F, 0x80, 0x7F, 0x81, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x03, 0xFF, 0x00, 0x0F, 0xF0,
  0x1F, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0xE0,
  0x07, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0x80,
  0xFF, 0xFC, 0x03, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xC0,
  0x3F, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFC, 0x07,
  0xFF, 0xF8, 0x1F, 0xE0, 0x1F, 0xDF, 0xE0, 0x7F, 0x80, 0x7F, 0x7F, 0x81,
  0xFE, 0x01, 0xFC, 0xFF, 0x07, 0xF8, 0x0F, 0xF3, 0xFC, 0x3F, 0xC0, 0x3F,
  0xCF, 0xF0, 0xFF, 0x00, 0xFF, 0x1F, 0xC3, 0xFC, 0x03, 0xFC, 0x7F, 0x8F,
  0xF0, 0x0F, 0xE1, 0xFE, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0xFE, 0x01, 0xFE,
  0x0F, 0xF7, 0xF8, 0x07, 0xF8, 0x3F, 0xDF, 0xE0, 0x1F, 0xE0, 0xFF, 0x7F,
  0x80, 0xFF, 0x03, 0xFD, 0xFE, 0x03, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xF0,
  0x1F, 0xFF, 0xC0, 0x3F, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0xFC,
  0x07, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0x80,
  0x3F, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xF8, 0x01, 0xFF, 0xE0,
  0x3F, 0xC0, 0x07, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xFC, 0x03, 0xFC, 0x00,
  0x7F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0x9F, 0xFE, 0x0F, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x03, 0xFF,
  0x1F, 0xF8, 0x01, 0xFF, 0x1F, 0xF0, 0x01, 0xFF, 0x3F, 0xF0, 0x01, 0xFF,
  0x3F, 0xE0, 0x01, 0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF,
  0x7F, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE,
  0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0x80, 0x07, 0xFC,
  0xFF, 0x80, 0x07, 0xFC, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0x80, 0x0F, 0xF8,
  0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xF0,
  0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x07,
  0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFE, 0x03, 0xFE,
  0x0F, 0xF8, 0x1F, 0xF8, 0x3F, 0xE0, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x9F, 0xFE, 0x0F,
  0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x1F, 0xF8, 0x01, 0xFF, 0x1F,
  0xF0, 0x01, 0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0x3F, 0xE0, 0x01, 0xFF, 0x7F,
  0xE0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF,
  0x80, 0x07, 0xFE, 0xFF, 0x80, 0x07, 0xFC, 0xFF, 0x80, 0x07, 0xFC, 0xFF,
  0x80, 0x0F, 0xFC, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xF8, 0xFF,
  0x80, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xC7, 0xFF, 0x03, 0xFE, 0x0F, 0xF8,
  0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F,
  0xC0, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x1F, 0xE0, 0x3F, 0xE0, 0xFF, 0x03,
  0xFF, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xCF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xE3, 0xFC, 0x01, 0xFF, 0x1F,
  0xF0, 0x0F, 0xF8, 0xFF, 0x80, 0x7F, 0xC3, 0xFC, 0x03, 0xFE, 0x1F, 0xF0,
  0x1F, 0xE0, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F,
  0xC0, 0xFF, 0x83, 0xFC, 0x07, 0xFC, 0x1F, 0xE0, 0x1F, 0xF1, 0xFF, 0x00,
  0xFF, 0x8F, 0xF8, 0x07, 0xFE, 0x7F, 0xC0, 0x3F, 0xF3, 0xFC, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xC0, 0x3F, 0xF9, 0xFC, 0x07, 0xFE, 0x01, 0x80, 0x7F, 0xC0, 0x08,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x04, 0x00, 0x3F, 0xE0, 0x70, 0x03,
  0xFE, 0x07, 0xC0, 0x7F, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x07, 0xFC, 0x01, 0xFF,
  0x07, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x07, 0xF8, 0x01, 0xFE,
  0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFE,
  0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xF0, 0x07, 0xFC,
  0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFC,
  0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8,
  0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0,
  0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0,
  0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xE0,
  0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xC0,
  0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0xFF, 0xBF, 0xC0, 0x07, 0xFC, 0xFF,
  0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0x03, 0xFE, 0x3F, 0xC0,
  0x0F, 0xF8, 0xFF, 0x00, 0x7F, 0xC3, 0xFC, 0x01, 0xFF, 0x0F, 0xF0, 0x0F,
  0xF8, 0x3F, 0xC0, 0x3F, 0xE0, 0xFF, 0x01, 0xFF, 0x03, 0xFC, 0x07, 0xFC,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0x83, 0xFC, 0x01,
  0xFE, 0x1F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xE3, 0xFE, 0x00, 0x7F,
  0x8F, 0xF0, 0x01, 0xFE, 0x7F, 0xC0, 0x07, 0xF9, 0xFE, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0x7F, 0xBF, 0xC0, 0x01, 0xFE, 0xFF, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x01, 0xFD, 0xFC, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xFF, 0xC0,
  0x0F, 0xF0, 0x03, 0xFD, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xEF, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF3, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0x9F, 0xE0, 0x1F, 0xF8, 0x07, 0xF8, 0xFF, 0x01, 0xFF, 0xC0,
  0x7F, 0xC7, 0xF8, 0x0F, 0xFE, 0x03, 0xFE, 0x3F, 0xC0, 0xFF, 0xF0, 0x1F,
  0xE1, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0x0F, 0xF0, 0x3F, 0xFC, 0x0F, 0xF0,
  0x7F, 0x83, 0xFF, 0xE0, 0xFF, 0x83, 0xFC, 0x1F, 0xFF, 0x07, 0xF8, 0x1F,
  0xE1, 0xFF, 0xF8, 0x3F, 0xC0, 0xFF, 0x0F, 0xFF, 0xC3, 0xFE, 0x07, 0xF8,
  0xFE, 0xFE, 0x1F, 0xE0, 0x3F, 0xC7, 0xF7, 0xF0, 0xFF, 0x01, 0xFE, 0x3F,
  0xBF, 0x8F, 0xF0, 0x0F, 0xF3, 0xF9, 0xFC, 0x7F, 0x80, 0x7F, 0x1F, 0xCF,
  0xE7, 0xFC, 0x03, 0xF9, 0xFE, 0x7F, 0x3F, 0xC0, 0x1F, 0xCF, 0xE3, 0xF9,
  0xFE, 0x00, 0xFE, 0x7F, 0x1F, 0xDF, 0xE0, 0x07, 0xF7, 0xF0, 0xFE, 0xFF,
  0x00, 0x3F, 0xBF, 0x87, 0xF7, 0xF0, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0x80,
  0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x3F, 0xF8,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x3F,
  0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xFC,
  0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x00, 0x7F,
  0xC7, 0xFC, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x03, 0xFD, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xEF, 0xF8, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x7F,
  0xC0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x0F,
  0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x1F,
  0xFF, 0xFC, 0x00, 0xFF, 0xBF, 0xE0, 0x0F, 0xF9, 0xFF, 0x00, 0xFF, 0xC7,
  0xF8, 0x07, 0xFC, 0x3F, 0xC0, 0x7F, 0xC1, 0xFF, 0x03, 0xFE, 0x0F, 0xF8,
  0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x01, 0xFE, 0x1F, 0xF0, 0x0F, 0xF1, 0xFF,
  0x00, 0x7F, 0x8F, 0xF8, 0x03, 0xFC, 0xFF, 0x80, 0x0F, 0xF7, 0xF8, 0x00,
  0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFD, 0xF8,
  0x00, 0x3F, 0xBF, 0x00, 0x0F, 0xE7, 0xF0, 0x01, 0xF8, 0xFE, 0x00, 0x7F,
  0x0F, 0xC0, 0x1F, 0xC1, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x07, 0xF0,
  0x3F, 0x80, 0x7E, 0x07, 0xF0, 0x0F, 0xC1, 0xFC, 0x01, 0xFC, 0x7F, 0x00,
  0x3F, 0x8F, 0xE0, 0x03, 0xF3, 0xF8, 0x00, 0x7E, 0xFF, 0x00, 0x0F, 0xE0,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xC0, 0xFF, 0x8F, 0xF1, 0xFF, 0x1F, 0xE1, 0xFC, 0x3F, 0xC3,
  0xF8, 0x3F, 0x00, 0x7F, 0x07, 0xF0, 0x1F, 0xF8, 0xFE, 0x03, 0xFF, 0xCF,
  0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xC1, 0xFF, 0x8F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFE, 0x07,
  0xFC, 0x7F, 0xE0, 0x7F, 0x87, 0xFC, 0x07, 0xF8, 0x7F, 0xC0, 0x7F, 0x87,
  0xF8, 0x07, 0xF8, 0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x0F, 0xF0, 0xFF, 0x80,
  0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0,
  0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x87, 0xFE, 0x0F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFD, 0xFC,
  0x07, 0xFF, 0xDF, 0xC0, 0x3F, 0xF9, 0xFC, 0x01, 0xFE, 0x3F, 0x80, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE7, 0xF0, 0x03, 0xFE, 0xFF,
  0x80, 0x3F, 0xDF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFE, 0x1F, 0xF0, 0x7F, 0xC1,
  0xFF, 0x07, 0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF0, 0x1F, 0xF0,
  0xFF, 0x01, 0xFF, 0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0x01, 0xFF, 0x1F, 0xE0,
  0x1F, 0xF1, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0xE1, 0xFE, 0x03, 0xFE,
  0x1F, 0xE0, 0x3F, 0xE3, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0xC3, 0xFF,
  0x0F, 0xF8, 0x3F, 0xFB, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0x7F, 0xFC, 0x07, 0xF3, 0xFF, 0x80, 0xFE,
  0x1F, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x87,
  0xFF, 0xFE, 0x0F, 0xFC, 0x0C, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x04, 0x3F, 0xF0, 0x38,
  0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xC7, 0xFC, 0x01, 0xFF, 0x9F,
  0xE0, 0x0F, 0xFF, 0x7F, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0x8F, 0xFC, 0x0F,
  0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFE, 0x07, 0xFC,
  0x07, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x83, 0xFE, 0x01,
  0xFE, 0x0F, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0xFF, 0x80, 0xFF,
  0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80,
  0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xDF, 0xC0, 0x0F, 0xFE, 0x7F, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0xE3, 0xFE,
  0x3F, 0xE0, 0xFF, 0x3F, 0xE0, 0x7F, 0x9F, 0xE0, 0x3F, 0xDF, 0xF0, 0x3F,
  0xEF, 0xF8, 0x3F, 0xE7, 0xF9, 0xFF, 0xF3, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x61, 0xFF, 0x80, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xEE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x21, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0xFF, 0x8F, 0xE0, 0x0F, 0xFF, 0x3F, 0x80, 0x7F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x01,
  0xFF, 0x8F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF,
  0x81, 0xFF, 0x07, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0,
  0x7F, 0x83, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x3F,
  0xC0, 0xFF, 0x80, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x1F, 0xF8, 0x0F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xBF, 0xC0, 0x0F, 0xFD, 0xFF, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x08, 0x00, 0x7F, 0xC0, 0x3C, 0x03, 0xFF, 0x00,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE3, 0xF8, 0x03, 0xFE, 0xFF,
  0xC0, 0x3F, 0xDF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0x1F, 0xF0, 0x7F, 0xE1,
  0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0,
  0xFF, 0x81, 0xFF, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x01, 0xFE, 0x1F, 0xF0,
  0x1F, 0xE1, 0xFF, 0x03, 0xFE, 0x1F, 0xE0, 0x3F, 0xE1, 0xFE, 0x03, 0xFC,
  0x1F, 0xE0, 0x3F, 0xC3, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xC3, 0xFC,
  0x07, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xFC, 0x07, 0xF8, 0x7F, 0xC0, 0xFF,
  0x87, 0xFC, 0x0F, 0xF8, 0x7F, 0x80, 0xFF, 0x87, 0xF8, 0x0F, 0xF0, 0xFF,
  0x81, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x8F, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x03,
  0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFC, 0x0F,
  0xF8, 0x03, 0xFC, 0x1F, 0xF0, 0x03, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x7F,
  0xC0, 0x07, 0xF8, 0xFF, 0xC0, 0x07, 0xF8, 0xFF, 0x80, 0x07, 0xF9, 0xFF,
  0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x3F, 0xE3, 0xFE,
  0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x7F, 0xC1, 0xFF,
  0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0xFF,
  0x80, 0x7F, 0x80, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x7F, 0x00,
  0x7F, 0x1F, 0xF8, 0x3F, 0xF0, 0x0F, 0xE7, 0xFF, 0x8F, 0xFF, 0x01, 0xFD,
  0xFF, 0xF3, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xF8, 0xFF, 0xE1,
  0xFF, 0x07, 0xFE, 0x1F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFF, 0x07, 0xFC,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x87, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF,
  0x81, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x83, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC3, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC3, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x7F,
  0xC0, 0xFF, 0x81, 0xFF, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC1, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE1, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE1, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x8F, 0xFC, 0x03, 0xF9, 0xFF, 0xE0, 0x3F,
  0xBF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xF0, 0x7F, 0xF1, 0xFF, 0x07, 0xFE, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x0F,
  0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x01,
  0xFE, 0x0F, 0xF0, 0x1F, 0xE1, 0xFF, 0x01, 0xFE, 0x1F, 0xF0, 0x3F, 0xE1,
  0xFE, 0x03, 0xFE, 0x1F, 0xE0, 0x3F, 0xC1, 0xFE, 0x03, 0xFC, 0x3F, 0xE0,
  0x3F, 0xC3, 0xFE, 0x07, 0xFC, 0x3F, 0xC0, 0x7F, 0xC3, 0xFC, 0x07, 0xF8,
  0x7F, 0xC0, 0x7F, 0x87, 0xFC, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0x87, 0xF8,
  0x0F, 0xF8, 0x7F, 0x80, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xC3, 0xFE, 0x3F,
  0xE0, 0x7F, 0x8F, 0xF8, 0x1F, 0xF7, 0xFC, 0x07, 0xFD, 0xFF, 0x01, 0xFF,
  0x7F, 0xC0, 0x7F, 0xDF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFB, 0xFE, 0x01,
  0xFE, 0xFF, 0x80, 0xFF, 0xBF, 0xE0, 0x3F, 0xEF, 0xF0, 0x0F, 0xFB, 0xFC,
  0x07, 0xFC, 0xFF, 0x01, 0xFF, 0x3F, 0xE0, 0xFF, 0xCF, 0xF8, 0x3F, 0xE3,
  0xFF, 0xBF, 0xF8, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x03, 0xF8, 0xFF, 0x80, 0x0F, 0xE7,
  0xFF, 0x00, 0x3F, 0xBF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xE1, 0xFF, 0x01, 0xFF, 0x07, 0xFC,
  0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03,
  0xFC, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0xC1, 0xFE,
  0x01, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0x80,
  0xFF, 0x81, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0xC3, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFB, 0xFF, 0xC0, 0x1F,
  0xE7, 0xFE, 0x00, 0xFF, 0x8F, 0xE0, 0x03, 0xFE, 0x04, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x07, 0xF0,
  0x0F, 0xF8, 0xFE, 0x03, 0xFF, 0xCF, 0xE0, 0x7F, 0xFE, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0x8F, 0xFC,
  0x3F, 0xF0, 0x7F, 0xC3, 0xFE, 0x07, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xFC,
  0x07, 0xF8, 0x7F, 0xC0, 0x7F, 0x87, 0xF8, 0x07, 0xF8, 0xFF, 0x80, 0x7F,
  0x8F, 0xF8, 0x0F, 0xF0, 0xFF, 0x80, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0xFF,
  0x00, 0xFF, 0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0x01, 0xFE, 0x0F, 0xF8, 0x3F,
  0xE0, 0xFF, 0x87, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xBF, 0xC0, 0x3F, 0xF7,
  0xFC, 0x01, 0xFE, 0x7F, 0x80, 0x02, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xF8, 0x3F, 0x03, 0xF8, 0xFE, 0x03, 0xF9, 0xFE,
  0x03, 0xFB, 0xFE, 0x03, 0xFB, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0x8C, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFC, 0x0F, 0xF8, 0x7C, 0x1F, 0xF0, 0x18, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0xC0, 0x0F, 0xF8, 0xFC, 0x3F, 0xF0, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xF0,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE,
  0xFF, 0xFF, 0xE0, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0,
  0x01, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF0,
  0x1F, 0xF0, 0xFF, 0x01, 0xFE, 0x1F, 0xF0, 0x1F, 0xE1, 0xFF, 0x03, 0xFE,
  0x1F, 0xF0, 0x3F, 0xE1, 0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xC3, 0xFE,
  0x03, 0xFC, 0x3F, 0xE0, 0x7F, 0xC3, 0xFC, 0x07, 0xFC, 0x3F, 0xC0, 0x7F,
  0x83, 0xFC, 0x07, 0xF8, 0x7F, 0xC0, 0xFF, 0x87, 0xFC, 0x0F, 0xF8, 0x7F,
  0x80, 0xFF, 0x87, 0xF8, 0x0F, 0xF0, 0x7F, 0x81, 0xFF, 0x0F, 0xF8, 0x1F,
  0xF0, 0xFF, 0x83, 0xFF, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x87, 0xFE, 0x0F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x07, 0xFF, 0xDF, 0xC0, 0x3F, 0xF9, 0xFC, 0x01, 0xFE, 0x1F, 0xC0,
  0x01, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x07, 0xFB, 0xFC, 0x03, 0xFE, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x7F, 0xCF,
  0xF0, 0x1F, 0xE3, 0xFC, 0x0F, 0xF8, 0x7F, 0x03, 0xFC, 0x1F, 0xC1, 0xFF,
  0x07, 0xF8, 0x7F, 0x81, 0xFE, 0x3F, 0xE0, 0x7F, 0x8F, 0xF0, 0x1F, 0xE7,
  0xFC, 0x07, 0xF9, 0xFE, 0x01, 0xFE, 0x7F, 0x80, 0x7F, 0xBF, 0xC0, 0x1F,
  0xEF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xFF,
  0x01, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0x01, 0xFE, 0xFF, 0x03, 0xFF,
  0x03, 0xFE, 0xFF, 0x03, 0xFF, 0x03, 0xFC, 0xFF, 0x07, 0xFF, 0x03, 0xFC,
  0xFF, 0x07, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xFF, 0x07, 0xF8, 0xFF, 0x0F,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xBF, 0x1F,
  0xF0, 0xFF, 0x1F, 0xBF, 0x1F, 0xE0, 0xFF, 0x1F, 0xBF, 0x1F, 0xE0, 0xFF,
  0x3F, 0x3F, 0x3F, 0xC0, 0x7F, 0x3F, 0x3F, 0x3F, 0xC0, 0x7F, 0x7F, 0x3F,
  0x7F, 0x80, 0x7F, 0x7E, 0x3F, 0x7F, 0x80, 0x7F, 0x7E, 0x3F, 0x7F, 0x00,
  0x7F, 0xFE, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x3F, 0xFF, 0x00, 0x7F, 0xFC,
  0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xE0, 0xFF,
  0xC0, 0x1F, 0xF0, 0xFF, 0xC0, 0x0F, 0xF8, 0x7F, 0xC0, 0x03, 0xFC, 0x7F,
  0xC0, 0x01, 0xFF, 0x7F, 0xE0, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x0F,
  0xF9, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xE0, 0x07,
  0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x0F, 0xF8, 0x07, 0xFE, 0x07, 0xFE, 0x07,
  0xFE, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0x80, 0x3F,
  0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC,
  0x1F, 0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x1F, 0xE0, 0x00,
  0x3F, 0xC7, 0xF8, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x01, 0xFC, 0xFF, 0x00,
  0x00, 0x7F, 0x7F, 0x80, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x07, 0xF7, 0xF0,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE,
  0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x28, 0x00, 0x00, 0x07, 0x80, 0x00, 0x4F, 0xFE,
  0x00, 0x37, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0xC0, 0x07, 0xFF,
  0x20, 0x00, 0x1E, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBoldItalic54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 17, 40, 15, 0, -39 },
  { 86, 21, 14, 24, 5, -39 },
  { 123, 32, 39, 32, 1, -39 },
  { 279, 27, 44, 28, 1, -41 },
  { 428, 41, 39, 45, 3, -39 },
  { 628, 34, 40, 36, 1, -39 },
  { 798, 10, 14, 13, 5, -39 },
  { 816, 21, 48, 18, 1, -39 },
  { 942, 20, 48, 18, -4, -39 },
  { 1062, 24, 25, 27, 4, -41 },
  { 1137, 25, 26, 29, 3, -32 },
  { 1219, 13, 14, 15, -3, -7 },
  { 1242, 15, 7, 17, 1, -18 },
  { 1256, 10, 10, 15, 0, -9 },
  { 1269, 30, 39, 23, -3, -39 },
  { 1416, 26, 40, 28, 2, -39 },
  { 1546, 21, 39, 28, 5, -39 },
  { 1649, 29, 39, 28, -2, -39 },
  { 1791, 28, 40, 28, 0, -39 },
  { 1931, 28, 39, 28, 0, -39 },
  { 2068, 27, 40, 28, 1, -39 },
  { 2203, 27, 40, 28, 2, -39 },
  { 2338, 30, 39, 28, 1, -39 },
  { 2485, 27, 40, 28, 1, -39 },
  { 2620, 26, 40, 28, 2, -39 },
  { 2750, 15, 31, 15, 0, -30 },
  { 2809, 18, 37, 15, -3, -30 },
  { 2893, 26, 27, 29, 2, -33 },
  { 2981, 26, 18, 29, 2, -28 },
  { 3040, 25, 27, 29, 3, -33 },
  { 3125, 22, 40, 23, 3, -39 },
  { 3235, 41, 44, 43, 2, -39 },
  { 3461, 32, 39, 32, -3, -39 },
  { 3617, 30, 39, 31, 1, -39 },
  { 3764, 30, 40, 30, 3, -39 },
  { 3914, 32, 39, 34, 1, -39 },
  { 4070, 28, 39, 27, 1, -39 },
  { 4207, 28, 39, 27, 1, -39 },
  { 4344, 32, 40, 34, 3, -39 },
  { 4504, 35, 39, 35, 1, -39 },
  { 4675, 26, 39, 21, -2, -39 },
  { 4802, 27, 51, 17, -9, -39 },
  { 4975, 35, 39, 31, 1, -39 },
  { 5146, 22, 39, 26, 1, -39 },
  { 5254, 45, 39, 45, 1, -39 },
  { 5474, 38, 39, 38, 1, -39 },
  { 5660, 32, 40, 36, 3, -39 },
  { 5820, 30, 39, 30, 1, -39 },
  { 5967, 32, 48, 36, 3, -39 },
  { 6159, 29, 39, 31, 1, -39 },
  { 6301, 28, 40, 27, 0, -39 },
  { 6441, 26, 39, 27, 4, -39 },
  { 6568, 32, 40, 34, 3, -39 },
  { 6728, 30, 39, 30, 5, -39 },
  { 6875, 45, 39, 45, 5, -39 },
  { 7095, 38, 39, 31, -3, -39 },
  { 7281, 29, 39, 29, 5, -39 },
  { 7423, 32, 39, 27, -2, -39 },
  { 7579, 23, 48, 17, -2, -39 },
  { 7717, 13, 39, 23, 6, -39 },
  { 7781, 23, 48, 17, -4, -39 },
  { 7919, 27, 25, 27, 0, -39 },
  { 8004, 23, 5, 21, -5, 4 },
  { 8019, 11, 8, 18, 8, -41 },
  { 8030, 28, 31, 30, 2, -30 },
  { 8139, 28, 42, 30, 0, -41 },
  { 8286, 23, 31, 24, 2, -30 },
  { 8376, 30, 42, 30, 2, -41 },
  { 8534, 25, 31, 28, 2, -30 },
  { 8631, 31, 54, 19, -6, -41 },
  { 8841, 30, 43, 30, 0, -30 },
  { 9003, 28, 41, 30, 0, -41 },
  { 9147, 17, 41, 15, 0, -41 },
  { 9235, 24, 54, 15, -7, -41 },
  { 9397, 32, 41, 29, 0, -41 },
  { 9561, 18, 41, 15, 0, -41 },
  { 9654, 43, 30, 45, 0, -30 },
  { 9816, 28, 30, 30, 0, -30 },
  { 9921, 26, 31, 29, 2, -30 },
  { 10022, 30, 43, 30, -2, -30 },
  { 10184, 28, 43, 30, 2, -30 },
  { 10335, 24, 30, 21, 0, -30 },
  { 10425, 24, 31, 24, 0, -30 },
  { 10518, 20, 37, 21, 2, -36 },
  { 10611, 28, 31, 30, 2, -30 },
  { 10720, 26, 30, 26, 3, -30 },
  { 10818, 40, 30, 40, 3, -30 },
  { 10968, 33, 30, 27, -3, -30 },
  { 11092, 34, 43, 27, -4, -30 },
  { 11275, 26, 30, 23, -1, -30 },
  { 11373, 23, 48, 19, 0, -39 },
  { 11511, 6, 53, 27, 10, -41 },
  { 11551, 22, 48, 19, -3, -39 },
  { 11683, 26, 10, 29, 2, -24 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBoldItalic54pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBoldItalic54pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBoldItalic54pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC54PT7B_H_
