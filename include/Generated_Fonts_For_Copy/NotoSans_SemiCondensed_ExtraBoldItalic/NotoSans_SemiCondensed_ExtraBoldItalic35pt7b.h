#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC35PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBoldItalic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBoldItalic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C,
  0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x3E,
  0x00, 0x00, 0x00, 0x1C, 0x07, 0xC1, 0xFC, 0x3F, 0x07, 0xE0, 0x78, 0x00,
  0x7E, 0x7D, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x78, 0xF9, 0xE3, 0xC7, 0x8F,
  0x3E, 0x3C, 0xF1, 0xE0, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x00, 0x3C, 0x78,
  0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x71, 0xE0, 0x07, 0x8F, 0x03, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x07, 0x8F, 0x00,
  0x78, 0xF0, 0x03, 0xC7, 0x81, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xE7, 0xFF, 0xFF, 0x03, 0xCF, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F,
  0x1E, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x3F, 0xC0, 0x7F, 0xF8, 0x7F, 0xFC, 0x7F,
  0xFE, 0x3F, 0xDE, 0x3F, 0x61, 0x1F, 0x30, 0x0F, 0xD8, 0x07, 0xFC, 0x01,
  0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xDF,
  0x80, 0x6F, 0xD0, 0x37, 0xEE, 0x3B, 0xE7, 0xFF, 0xF3, 0xFF, 0xF1, 0xFF,
  0xF0, 0xFF, 0xF0, 0x0F, 0xC0, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x0F, 0xC0, 0x1F, 0x07, 0xF8, 0x0F, 0x83, 0xFE, 0x03, 0xC1, 0xF7, 0xC1,
  0xE0, 0x78, 0xF0, 0xF8, 0x1E, 0x7C, 0x3C, 0x0F, 0x9F, 0x1E, 0x03, 0xC7,
  0xCF, 0x80, 0xF1, 0xE3, 0xC0, 0x3C, 0x79, 0xE0, 0x0F, 0x3E, 0xF9, 0xFB,
  0xFF, 0x3D, 0xFE, 0xFF, 0xDE, 0x7F, 0xDF, 0xEF, 0xBE, 0xF3, 0xF3, 0xCF,
  0x3C, 0x01, 0xE7, 0xCF, 0x00, 0xF9, 0xE3, 0xC0, 0x3C, 0x78, 0xF0, 0x1E,
  0x1E, 0x3C, 0x0F, 0x87, 0x9F, 0x03, 0xC1, 0xE7, 0x81, 0xE0, 0x7B, 0xE0,
  0xF8, 0x1F, 0xF0, 0x3C, 0x07, 0xF8, 0x1E, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7E, 0x7C,
  0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE7, 0xE0, 0x07, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE3, 0xF0, 0xFF, 0x87, 0xC3,
  0xFF, 0x8F, 0x8F, 0xFF, 0x3F, 0x3F, 0x3F, 0xFC, 0x7E, 0x7F, 0xF8, 0xF8,
  0x7F, 0xE3, 0xF0, 0x7F, 0x87, 0xE0, 0xFE, 0x07, 0xE3, 0xFC, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xF3, 0xF8, 0x7E, 0xF9,
  0xF3, 0xE7, 0xCF, 0x1E, 0x7C, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x0F, 0x82, 0x1F,
  0x07, 0x3C, 0x1F, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFE, 0x1F, 0xFC,
  0x7F, 0x01, 0xFF, 0x0F, 0xDF, 0x0F, 0x9E, 0x0E, 0x3E, 0x04, 0x70, 0x00,
  0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x1F,
  0x8F, 0x8F, 0xC7, 0xC3, 0xE3, 0xE1, 0xF0, 0xF0, 0xF8, 0x00, 0x7F, 0xDF,
  0xF7, 0xFD, 0xFF, 0xFF, 0xC0, 0x19, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE1, 0xFD, 0xF8, 0xFC, 0xFC, 0xFC,
  0x3E, 0x7E, 0x1F, 0x7E, 0x0F, 0xBF, 0x0F, 0xDF, 0x87, 0xEF, 0x83, 0xFF,
  0xC1, 0xFF, 0xE0, 0xFB, 0xF0, 0x7D, 0xF8, 0x7E, 0xFC, 0x3F, 0x7C, 0x1F,
  0x3E, 0x1F, 0x9F, 0x8F, 0x8F, 0xDF, 0xC3, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F,
  0xC0, 0x1F, 0xC0, 0x00, 0x00, 0x7C, 0x07, 0xF0, 0x3F, 0x83, 0xFE, 0x1F,
  0xF8, 0xFF, 0xEF, 0xFF, 0x9F, 0x7C, 0x79, 0xF0, 0x8F, 0xC0, 0x3F, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x0F, 0x0F, 0xC0, 0x81, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07,
  0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x00,
  0x03, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0x9F, 0xC1,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF2, 0x00, 0xFC, 0xF0, 0xFF, 0x3F,
  0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F,
  0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xF7, 0xC0, 0x79, 0xF0, 0x3C, 0xFC,
  0x1F, 0x3F, 0x0F, 0x8F, 0x83, 0xC3, 0xE1, 0xE1, 0xF8, 0xFF, 0xFF, 0xBF,
  0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F,
  0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFF, 0x03,
  0xBF, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xF2, 0x01, 0xFC, 0xF9, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFE,
  0x0F, 0xF0, 0x87, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F,
  0xBF, 0x07, 0xDF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xCF, 0xCF, 0xE3,
  0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0xCF, 0xC3, 0xF3, 0xF1, 0xF8,
  0x7E, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xE0, 0x00,
  0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xF1, 0xF8, 0xF8, 0xF8,
  0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x9F, 0x0F, 0xFF, 0x83, 0xFF, 0x80,
  0xFF, 0x00, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xF8, 0xF8, 0xFC, 0xFC, 0x3E,
  0x7C, 0x1F, 0xBE, 0x0F, 0xDF, 0x07, 0xCF, 0xC7, 0xE7, 0xFF, 0xF3, 0xFF,
  0xF0, 0xFF, 0xF0, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0x03, 0xFF,
  0xC3, 0xFF, 0xE3, 0xFB, 0xF1, 0xF8, 0xFD, 0xF8, 0x7E, 0xFC, 0x3F, 0x7E,
  0x1F, 0xBF, 0x0F, 0xDF, 0x8F, 0xEF, 0xC7, 0xF7, 0xFF, 0xF1, 0xFF, 0xF8,
  0xFF, 0x7C, 0x3F, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F,
  0x88, 0x3F, 0x87, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x00, 0x00,
  0x02, 0x03, 0xE0, 0xFC, 0x7F, 0x1F, 0x87, 0xE0, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x81, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xE0, 0x00, 0x80, 0x3E, 0x03, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F,
  0x80, 0xF0, 0x00, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x7F, 0x01,
  0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x00, 0xFC, 0x00, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x00,
  0x0F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0xFF, 0x07,
  0xFE, 0x1F, 0xF8, 0x7F, 0xC0, 0xFF, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0xC0,
  0x00, 0x0F, 0xF0, 0xFF, 0xE7, 0xFF, 0xDF, 0xFF, 0x3C, 0xFC, 0x81, 0xF0,
  0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0x80,
  0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x7C,
  0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0xC0, 0xF0, 0xF0, 0xFF, 0x9E,
  0x3C, 0x3F, 0xF1, 0xE7, 0x8F, 0xFE, 0x3D, 0xE3, 0xE3, 0xC7, 0xBC, 0x78,
  0xF0, 0xF7, 0x9E, 0x1E, 0x1C, 0xE3, 0xC3, 0xC7, 0xBC, 0x78, 0x78, 0xF7,
  0x8F, 0x1E, 0x1E, 0xF1, 0xE3, 0xC7, 0x9E, 0x3C, 0xF9, 0xF3, 0xC7, 0xFF,
  0xFC, 0x78, 0xFE, 0xFF, 0x07, 0x8F, 0x8F, 0xC0, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x01, 0x00, 0x1F, 0xC7, 0xE0, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3E, 0xF0,
  0x01, 0xF7, 0x80, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x0F, 0xCF, 0x80, 0x7C,
  0x7C, 0x07, 0xE3, 0xE0, 0x3E, 0x1F, 0x03, 0xF0, 0xF8, 0x1F, 0x07, 0xC1,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF,
  0xE3, 0xF0, 0x1F, 0x1F, 0x00, 0xF9, 0xF8, 0x07, 0xCF, 0x80, 0x3F, 0xFC,
  0x01, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF,
  0x07, 0xFF, 0xF0, 0x7C, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xE0, 0xF8, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF,
  0xF8, 0x1F, 0x1F, 0xC3, 0xF0, 0xFC, 0x3F, 0x07, 0xC3, 0xF0, 0xFC, 0x3E,
  0x0F, 0xC3, 0xE1, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x07,
  0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF,
  0x87, 0xFF, 0xE1, 0xFF, 0x7C, 0x7F, 0x01, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7F, 0x01, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x01,
  0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xE1, 0xFC, 0x3F, 0x07, 0xE1,
  0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x7C, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03,
  0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0xFC, 0x7C, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F,
  0x03, 0xF1, 0xF8, 0x3F, 0x0F, 0x83, 0xF8, 0x7C, 0x3F, 0x87, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7F,
  0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xFF,
  0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x81, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x1F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1,
  0xFC, 0x04, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0xC3, 0xFE, 0xFC, 0x3F, 0xEF, 0xC7, 0xFC, 0xFC, 0x7F,
  0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0x8F, 0xE0,
  0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x0F,
  0xFC, 0x00, 0x03, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F,
  0x03, 0xF0, 0x7C, 0x07, 0xC0, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0,
  0x7E, 0x0F, 0xC0, 0xF8, 0x1F, 0x01, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xC0, 0x7C, 0x1F, 0x81, 0xF8,
  0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0xF8, 0x0F, 0x81, 0xF0, 0x3F, 0x07,
  0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF0, 0x3E, 0x03, 0xE0, 0xFC,
  0x0F, 0xC0, 0x07, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F,
  0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x03, 0xFF,
  0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x01, 0x1F, 0xC0, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x38, 0x00, 0x00, 0x03,
  0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0x87, 0xF0, 0x3F, 0x1F, 0xC0, 0x7C,
  0x3F, 0x00, 0xF8, 0xFC, 0x03, 0xF3, 0xF0, 0x07, 0xEF, 0xE0, 0x0F, 0x9F,
  0x80, 0x1F, 0x7E, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xDF, 0x80, 0x3F, 0x3F, 0x00,
  0x7E, 0x7E, 0x00, 0xF8, 0xFC, 0x01, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F,
  0xC3, 0xF0, 0x1F, 0x83, 0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0x03,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0,
  0x07, 0xFF, 0xEF, 0xFF, 0x9F, 0xFF, 0x3F, 0xFE, 0xFF, 0xFC, 0x03, 0xF8,
  0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x81, 0xFE, 0x03,
  0xFE, 0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF,
  0x03, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x3D, 0xF0, 0x3F, 0xE1, 0xFF, 0xC1,
  0xF7, 0x87, 0xBE, 0x07, 0xDE, 0x1E, 0xF8, 0x1F, 0x78, 0xFB, 0xE0, 0x7D,
  0xF3, 0xDF, 0x81, 0xF7, 0xDF, 0x7C, 0x0F, 0xDF, 0x79, 0xF0, 0x3E, 0x7F,
  0xE7, 0xC0, 0xF9, 0xFF, 0x1F, 0x03, 0xE7, 0xFC, 0xFC, 0x0F, 0x9F, 0xE3,
  0xE0, 0x7C, 0x7F, 0x8F, 0x81, 0xF1, 0xFC, 0x3E, 0x07, 0xC7, 0xF0, 0xF8,
  0x1F, 0x0F, 0x87, 0xE0, 0xFC, 0x3E, 0x1F, 0x00, 0x03, 0xF0, 0x0F, 0x83,
  0xF8, 0x07, 0xC1, 0xFE, 0x03, 0xE0, 0xFF, 0x03, 0xE0, 0x7F, 0x81, 0xF0,
  0x3F, 0xE0, 0xF8, 0x3F, 0xF0, 0x7C, 0x1F, 0xF8, 0x7E, 0x0F, 0xFC, 0x3E,
  0x07, 0xFF, 0x1F, 0x07, 0xCF, 0x8F, 0x83, 0xE7, 0xC7, 0xC1, 0xF3, 0xE7,
  0xE0, 0xF8, 0xFB, 0xE0, 0x7C, 0x7D, 0xF0, 0x7E, 0x3E, 0xF8, 0x3E, 0x1F,
  0x7C, 0x1F, 0x07, 0xFC, 0x0F, 0x83, 0xFE, 0x07, 0xC1, 0xFF, 0x07, 0xE0,
  0xFF, 0x83, 0xE0, 0x3F, 0xC1, 0xF0, 0x1F, 0xC0, 0xF8, 0x0F, 0xE0, 0xFC,
  0x07, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE1, 0xFE, 0xFF, 0x1F, 0xC1, 0xF8, 0xFC, 0x07, 0xEF, 0xE0, 0x3F,
  0x7E, 0x01, 0xFB, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x3F, 0x7E, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x7E, 0xF8, 0x07, 0xE7,
  0xE0, 0x3F, 0x3F, 0x03, 0xF1, 0xF8, 0x3F, 0x8F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x7C, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xF8, 0x3F, 0x1F, 0x87,
  0xE1, 0xF9, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF,
  0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x0F, 0xC1, 0xF8, 0xFC, 0x07, 0xEF, 0xE0, 0x3F, 0x7E, 0x01, 0xFB,
  0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0x7E, 0x01,
  0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x7E, 0xF8, 0x07, 0xE7, 0xE0, 0x3F, 0x3F,
  0x03, 0xF1, 0xF8, 0x3F, 0x8F, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xFC,
  0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xDF, 0xE0, 0x7C,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0, 0xF8, 0x7E, 0x1F,
  0x8F, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xE0, 0x3F, 0x3E, 0x03, 0xF3, 0xF0, 0x3E, 0x3F, 0x03, 0xE1, 0xF0,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x0F, 0xC7, 0xC0, 0xFC, 0xFC, 0x0F,
  0xC0, 0x00, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF,
  0x87, 0xF0, 0x41, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x88, 0x07, 0xE3, 0x01, 0xF8, 0xFF, 0xFE,
  0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF0, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7C,
  0x3F, 0x07, 0xE1, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0,
  0x7C, 0x3E, 0x07, 0xE1, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0x87,
  0xE0, 0x7C, 0x3E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F,
  0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x7E, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFC, 0x03,
  0xFF, 0xC0, 0x7E, 0xFC, 0x07, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0x8F, 0xC1,
  0xF8, 0xFC, 0x1F, 0x8F, 0xC3, 0xF0, 0xFC, 0x3F, 0x07, 0xC3, 0xE0, 0x7C,
  0x7E, 0x07, 0xC7, 0xC0, 0x7C, 0xFC, 0x07, 0xCF, 0x80, 0x7D, 0xF8, 0x07,
  0xDF, 0x00, 0x7D, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x00, 0xF8, 0x0F, 0x80, 0xFF, 0xE0, 0x3E, 0x07, 0xEF, 0x81, 0xF8, 0x1F,
  0xBE, 0x07, 0xE0, 0x7C, 0xF8, 0x3F, 0x83, 0xF3, 0xE0, 0xFE, 0x0F, 0x8F,
  0x83, 0xF8, 0x7E, 0x3E, 0x1F, 0xE1, 0xF8, 0xF8, 0x7F, 0x87, 0xC3, 0xE3,
  0xFE, 0x3F, 0x0F, 0x8F, 0x78, 0xF8, 0x3E, 0x7D, 0xE7, 0xE0, 0xF9, 0xF7,
  0x9F, 0x03, 0xE7, 0x9E, 0x7C, 0x0F, 0xBE, 0x7B, 0xF0, 0x3E, 0xF1, 0xEF,
  0x80, 0xFF, 0xC7, 0xBE, 0x03, 0xFF, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0,
  0x3F, 0xE1, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x0F,
  0xE0, 0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x3F, 0x81, 0xF8, 0x3F, 0x80, 0xFC, 0x1F, 0x80, 0x3E, 0x1F, 0x80,
  0x1F, 0x8F, 0xC0, 0x0F, 0xCF, 0xC0, 0x07, 0xEF, 0xC0, 0x01, 0xF7, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x03, 0xF7, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xF9,
  0xF8, 0x01, 0xF8, 0x7E, 0x01, 0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0xFC,
  0x0F, 0xE0, 0xFE, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xFF, 0x81, 0xF9, 0xF0,
  0x7E, 0x3E, 0x0F, 0xC7, 0xE3, 0xF0, 0xFC, 0x7C, 0x1F, 0x9F, 0x81, 0xF7,
  0xE0, 0x3E, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07,
  0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x03, 0xFE, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0xF0, 0xF8, 0xF8, 0xF8,
  0xF8, 0x78, 0x78, 0x78, 0x7C, 0x7C, 0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3E,
  0x3E, 0x3E, 0x3E, 0x1E, 0x1E, 0x1F, 0x1F, 0x1F, 0x1F, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC1, 0xFF, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F,
  0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xBC, 0x07, 0x9E, 0x07,
  0xC7, 0x83, 0xC3, 0xC3, 0xC1, 0xE3, 0xE0, 0xF9, 0xE0, 0x3D, 0xF0, 0x1F,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x7C, 0x7E, 0x3E,
  0x1E, 0x0F, 0x00, 0x80, 0x01, 0xF9, 0xF0, 0xFF, 0x7C, 0x7F, 0xFF, 0x1F,
  0xFF, 0x8F, 0xE7, 0xE3, 0xF1, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x9F, 0x07,
  0xCF, 0xC1, 0xF3, 0xF0, 0x7C, 0xFC, 0x3F, 0x3F, 0x0F, 0xCF, 0xC7, 0xE3,
  0xFB, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x87, 0xFB, 0xC0, 0xFC, 0xF0, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x3F, 0x10, 0x0F, 0xBF, 0x03, 0xFF, 0xE0, 0xFF, 0xFC,
  0x7F, 0xFF, 0x1F, 0xCF, 0xC7, 0xE1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x3F,
  0x0F, 0xCF, 0x83, 0xF3, 0xE0, 0xFC, 0xF8, 0x3E, 0x3E, 0x1F, 0x9F, 0x87,
  0xE7, 0xF3, 0xF1, 0xFF, 0xFC, 0x7F, 0xFE, 0x1E, 0xFF, 0x0F, 0x9F, 0x80,
  0x00, 0x70, 0x07, 0xFC, 0x3F, 0xF8, 0xFF, 0xF1, 0xFF, 0xC7, 0xF0, 0x8F,
  0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x02, 0x7F, 0x38, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0,
  0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x08, 0x7C, 0x07, 0xE7,
  0xC0, 0xFF, 0x7C, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0x1F, 0x83, 0xF1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7C, 0x1F, 0x0F, 0xC1, 0xF0, 0xFC,
  0x1F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3E, 0x0F, 0xC7, 0xE0, 0xFE, 0xFE, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFB, 0xC0, 0x3F, 0x3C, 0x00, 0x00, 0x20,
  0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE1, 0xFB, 0xF9, 0xF8, 0xFC, 0xF8,
  0x7E, 0xFC, 0x3E, 0x7C, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFE, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x18, 0x7F, 0xFC, 0x3F, 0xFE,
  0x0F, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0x00, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x9F, 0xC0, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x7F, 0x7C, 0x1F, 0xEF, 0x87, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0x1F, 0x87,
  0xE3, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC7, 0xC1, 0xF1, 0xF8, 0x3E, 0x3F,
  0x07, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F, 0x1F, 0x8F, 0xC3, 0xFB, 0xF8, 0x7F,
  0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xDF, 0x00, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x86, 0x07, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF,
  0xC0, 0x7F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x10, 0x0F, 0xBF,
  0x83, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xCF, 0xC7, 0xE1, 0xF1,
  0xF8, 0x7C, 0x7C, 0x3F, 0x3F, 0x0F, 0xCF, 0xC3, 0xF3, 0xF0, 0xF8, 0xF8,
  0x3E, 0x3E, 0x1F, 0x9F, 0x87, 0xE7, 0xE1, 0xF9, 0xF0, 0x7C, 0x7C, 0x1F,
  0x1F, 0x0F, 0xCF, 0xC3, 0xF0, 0x01, 0xC0, 0x7C, 0x1F, 0x83, 0xF0, 0x7C,
  0x03, 0x00, 0x00, 0x00, 0x0F, 0xC1, 0xF0, 0x3E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xC0, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0xFC, 0x1F,
  0x83, 0xE0, 0x7C, 0x0F, 0x83, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x7C, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xF8, 0x01, 0xF0, 0x27, 0xE0, 0x7F, 0xC0, 0xFF, 0x01, 0xFC, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x01, 0x0F, 0xC3,
  0xF0, 0x7C, 0x3F, 0x03, 0xE3, 0xF0, 0x3F, 0x3F, 0x01, 0xF9, 0xF0, 0x0F,
  0x9F, 0x80, 0x7D, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xF7, 0xE0, 0x3F, 0x3F, 0x01, 0xF9,
  0xF8, 0x0F, 0x87, 0xE0, 0x7C, 0x3F, 0x03, 0xE1, 0xF8, 0x3F, 0x07, 0xE0,
  0x03, 0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF0, 0x3E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x1F, 0x83,
  0xF0, 0x00, 0x00, 0x04, 0x01, 0x00, 0xFB, 0xF8, 0xFC, 0x0F, 0x7F, 0x9F,
  0xE0, 0xF7, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF1, 0xFC, 0xFF, 0x3F, 0x1F,
  0x87, 0xE3, 0xF1, 0xF8, 0xFC, 0x3F, 0x1F, 0x0F, 0xC3, 0xF3, 0xF0, 0xFC,
  0x3E, 0x3F, 0x0F, 0x83, 0xE3, 0xE0, 0xF8, 0x7E, 0x3E, 0x0F, 0x87, 0xE3,
  0xE1, 0xF8, 0x7E, 0x7E, 0x1F, 0x87, 0xC7, 0xE1, 0xF0, 0x7C, 0x7C, 0x1F,
  0x0F, 0xC7, 0xC3, 0xF0, 0xFC, 0x7C, 0x3F, 0x0F, 0x8F, 0xC3, 0xF0, 0xF8,
  0x00, 0x06, 0x03, 0xEF, 0xE0, 0xF7, 0xFC, 0x3D, 0xFF, 0x0F, 0xFF, 0xC7,
  0xF3, 0xF1, 0xF8, 0x7C, 0x7E, 0x1F, 0x1F, 0x0F, 0xCF, 0xC3, 0xF3, 0xF0,
  0xFC, 0xFC, 0x3E, 0x3E, 0x0F, 0x8F, 0x87, 0xE7, 0xE1, 0xF9, 0xF8, 0x7E,
  0x7C, 0x1F, 0x1F, 0x07, 0xC7, 0xC3, 0xF3, 0xF0, 0xFC, 0x00, 0x20, 0x01,
  0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xF1, 0xF8, 0xFC, 0xF8, 0x7E,
  0xFC, 0x3F, 0x7E, 0x1F, 0xBE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1,
  0xF7, 0xE1, 0xFB, 0xF0, 0xFD, 0xF8, 0xFC, 0x7F, 0xFC, 0x3F, 0xFE, 0x0F,
  0xFE, 0x03, 0xFC, 0x00, 0x00, 0x01, 0x00, 0x3E, 0xFC, 0x03, 0xDF, 0xE0,
  0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0x3F, 0x07, 0xE1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xF0, 0xF8, 0x3F, 0x0F, 0x83,
  0xE0, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xFC, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x1F, 0xFF, 0x03, 0xF7, 0xE0, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xC0, 0x01, 0xFD, 0xF0, 0xFF, 0x7C, 0x7F, 0xFF, 0x1F,
  0xFF, 0x8F, 0xC7, 0xE3, 0xF1, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x9F, 0x07,
  0xCF, 0xC1, 0xF3, 0xF0, 0x7C, 0xFC, 0x3F, 0x3F, 0x0F, 0xCF, 0xC7, 0xE3,
  0xFB, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xC0, 0xFD, 0xF0, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x06, 0x1F, 0x3C, 0x3E, 0xF8, 0x7B,
  0xF1, 0xFF, 0xC3, 0xFF, 0x87, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x60, 0x0F, 0xF8, 0x3F,
  0xF8, 0xFF, 0xF3, 0xFF, 0xC7, 0xE0, 0x8F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x1F, 0x80, 0x1F, 0x20, 0x3E, 0x60,
  0xFC, 0xFF, 0xF9, 0xFF, 0xE3, 0xFF, 0x83, 0xFE, 0x00, 0x03, 0xC0, 0x3E,
  0x01, 0xE0, 0x1F, 0x01, 0xFF, 0xBF, 0xFD, 0xFF, 0xFF, 0xFF, 0x1F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C,
  0x03, 0xE0, 0x1F, 0x90, 0xFF, 0x87, 0xFC, 0x3F, 0xE0, 0xFF, 0x00, 0x1F,
  0x87, 0xC7, 0xC1, 0xF1, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0x8F, 0x83,
  0xE3, 0xE1, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x9F, 0x87, 0xC7, 0xC1, 0xF1,
  0xF0, 0xFC, 0x7C, 0x3F, 0x3F, 0x1F, 0xCF, 0xEF, 0xE3, 0xFF, 0xF8, 0x7F,
  0xFE, 0x1F, 0xEF, 0x83, 0xF3, 0xC0, 0xF8, 0x1F, 0xFC, 0x1F, 0xBE, 0x0F,
  0xDF, 0x07, 0xCF, 0x87, 0xE7, 0xC3, 0xE3, 0xE3, 0xF0, 0xF9, 0xF0, 0x7D,
  0xF8, 0x3E, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x0F, 0xC0, 0x00, 0xF8,
  0x3F, 0x0F, 0xFE, 0x1F, 0xC3, 0xEF, 0x87, 0xF1, 0xFB, 0xE3, 0xFC, 0x7C,
  0xF8, 0xFF, 0x1F, 0x3E, 0x3F, 0xCF, 0x8F, 0x9E, 0xF3, 0xE3, 0xE7, 0xBD,
  0xF0, 0xFB, 0xEF, 0x7C, 0x3E, 0xF7, 0xFF, 0x0F, 0xBD, 0xEF, 0x83, 0xFE,
  0x7B, 0xE0, 0xFF, 0x9E, 0xF0, 0x3F, 0xE7, 0xFC, 0x0F, 0xF1, 0xFE, 0x03,
  0xFC, 0x7F, 0x80, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC,
  0x00, 0x07, 0xE1, 0xFC, 0x1F, 0x8F, 0xC0, 0x7E, 0x7E, 0x00, 0xF9, 0xF8,
  0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0xF9, 0xF0, 0x07, 0xE7, 0xC0, 0x3F, 0x1F, 0x81,
  0xF8, 0x7E, 0x0F, 0xE1, 0xFC, 0x00, 0x0F, 0x81, 0xF8, 0x7C, 0x0F, 0x83,
  0xE0, 0xFC, 0x1F, 0x87, 0xC0, 0xFC, 0x7E, 0x07, 0xE3, 0xE0, 0x1F, 0x3F,
  0x00, 0xF9, 0xF0, 0x07, 0xDF, 0x80, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xC1,
  0xFF, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0xFF, 0xF8, 0x7F, 0xFC, 0x7F, 0xFC, 0x3F, 0xFE, 0x00, 0x00, 0x3E,
  0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x0F, 0xF0,
  0x1F, 0x80, 0x7C, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFE,
  0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x20, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xC0, 0x1F, 0x80, 0x7F,
  0x01, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x03,
  0xFC, 0x1F, 0xE0, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xE0, 0x08,
  0x00, 0x00, 0x7F, 0x01, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFE,
  0x80, 0x38,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBoldItalic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 11, 25, 10, 0, -25 },
  { 36, 14, 9, 15, 3, -25 },
  { 52, 21, 25, 21, 0, -25 },
  { 118, 17, 29, 18, 1, -27 },
  { 180, 26, 25, 29, 2, -25 },
  { 262, 23, 25, 23, 0, -25 },
  { 334, 7, 9, 9, 3, -25 },
  { 342, 13, 31, 11, 1, -25 },
  { 393, 14, 32, 11, -3, -26 },
  { 449, 15, 17, 18, 3, -27 },
  { 481, 16, 17, 19, 2, -21 },
  { 515, 9, 9, 10, -2, -4 },
  { 526, 10, 5, 11, 0, -12 },
  { 533, 6, 6, 10, 0, -6 },
  { 538, 19, 25, 15, -2, -25 },
  { 598, 17, 25, 18, 1, -25 },
  { 652, 14, 25, 18, 3, -25 },
  { 696, 19, 25, 18, -1, -25 },
  { 756, 18, 25, 18, 0, -25 },
  { 813, 18, 25, 18, 0, -25 },
  { 870, 18, 25, 18, 0, -25 },
  { 927, 18, 25, 18, 1, -25 },
  { 984, 19, 25, 18, 1, -25 },
  { 1044, 17, 25, 18, 1, -25 },
  { 1098, 17, 25, 18, 1, -25 },
  { 1152, 10, 20, 10, 0, -20 },
  { 1177, 12, 25, 10, -2, -20 },
  { 1215, 16, 18, 19, 2, -22 },
  { 1251, 16, 11, 19, 2, -18 },
  { 1273, 16, 18, 19, 2, -22 },
  { 1309, 14, 25, 15, 2, -25 },
  { 1353, 27, 28, 28, 1, -25 },
  { 1448, 21, 25, 21, -2, -25 },
  { 1514, 20, 25, 20, 0, -25 },
  { 1577, 19, 25, 20, 2, -25 },
  { 1637, 21, 25, 22, 0, -25 },
  { 1703, 19, 25, 17, 0, -25 },
  { 1763, 19, 25, 17, 0, -25 },
  { 1823, 20, 25, 22, 2, -25 },
  { 1886, 23, 25, 23, 0, -25 },
  { 1958, 17, 25, 13, -1, -25 },
  { 2012, 18, 33, 11, -6, -25 },
  { 2087, 23, 25, 20, 0, -25 },
  { 2159, 15, 25, 17, 0, -25 },
  { 2206, 30, 25, 29, 0, -25 },
  { 2300, 25, 25, 25, 0, -25 },
  { 2379, 21, 25, 23, 2, -25 },
  { 2445, 20, 25, 20, 0, -25 },
  { 2508, 21, 31, 23, 2, -25 },
  { 2590, 20, 25, 20, 0, -25 },
  { 2653, 18, 25, 17, 0, -25 },
  { 2710, 17, 25, 17, 3, -25 },
  { 2764, 21, 25, 22, 2, -25 },
  { 2830, 20, 25, 20, 3, -25 },
  { 2893, 30, 25, 29, 3, -25 },
  { 2987, 25, 25, 20, -2, -25 },
  { 3066, 19, 25, 19, 3, -25 },
  { 3126, 20, 25, 17, -1, -25 },
  { 3189, 15, 31, 11, -1, -25 },
  { 3248, 8, 25, 15, 4, -25 },
  { 3273, 14, 31, 11, -2, -25 },
  { 3328, 17, 16, 18, 0, -25 },
  { 3362, 14, 3, 14, -3, 3 },
  { 3368, 8, 6, 11, 5, -27 },
  { 3374, 18, 20, 19, 1, -20 },
  { 3419, 18, 27, 19, 0, -27 },
  { 3480, 15, 20, 16, 1, -20 },
  { 3518, 20, 27, 19, 1, -27 },
  { 3586, 17, 20, 18, 1, -20 },
  { 3629, 20, 35, 12, -4, -27 },
  { 3717, 19, 28, 19, 0, -20 },
  { 3784, 18, 27, 20, 0, -27 },
  { 3845, 11, 27, 10, 0, -27 },
  { 3883, 15, 35, 10, -4, -27 },
  { 3949, 21, 27, 19, 0, -27 },
  { 4020, 11, 27, 10, 0, -27 },
  { 4058, 28, 20, 29, 0, -20 },
  { 4128, 18, 20, 20, 0, -20 },
  { 4173, 17, 20, 19, 1, -20 },
  { 4216, 20, 28, 19, -2, -20 },
  { 4286, 18, 28, 19, 1, -20 },
  { 4349, 15, 20, 14, 0, -20 },
  { 4387, 15, 20, 16, 0, -20 },
  { 4425, 13, 23, 14, 1, -23 },
  { 4463, 18, 19, 20, 1, -19 },
  { 4506, 17, 19, 17, 2, -19 },
  { 4547, 26, 19, 26, 2, -19 },
  { 4609, 22, 19, 18, -2, -19 },
  { 4662, 21, 27, 17, -2, -19 },
  { 4733, 17, 19, 15, -1, -19 },
  { 4774, 15, 31, 12, 0, -25 },
  { 4833, 5, 35, 17, 6, -27 },
  { 4855, 14, 31, 12, -2, -25 },
  { 4910, 16, 6, 19, 2, -15 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBoldItalic35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBoldItalic35pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBoldItalic35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC35PT7B_H_
