#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC21PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBoldItalic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBoldItalic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x38, 0x71, 0xE3, 0xC7, 0x0E, 0x1C, 0x30, 0xE0, 0x00, 0x0F,
  0x1E, 0x38, 0x00, 0x77, 0x67, 0xE6, 0xEE, 0xEE, 0x07, 0x70, 0x33, 0x81,
  0x98, 0x1C, 0xC3, 0xFF, 0x9F, 0xFD, 0x33, 0x03, 0xB8, 0x19, 0x87, 0xFF,
  0xBF, 0xF8, 0x67, 0x03, 0x30, 0x19, 0x81, 0xDC, 0x00, 0x01, 0x00, 0x20,
  0x3F, 0x8F, 0xF3, 0xA4, 0x74, 0x0F, 0x81, 0xF8, 0x1F, 0x80, 0xF8, 0x17,
  0x42, 0xE7, 0xFD, 0xFF, 0x1F, 0xC0, 0x40, 0x18, 0x00, 0x3C, 0x1C, 0x7E,
  0x18, 0x76, 0x38, 0x66, 0x70, 0xE6, 0x60, 0xEE, 0xE0, 0xEF, 0xDE, 0xFD,
  0xBF, 0x7B, 0xB7, 0x07, 0x77, 0x06, 0x77, 0x0E, 0x67, 0x1C, 0x66, 0x18,
  0x7E, 0x38, 0x3C, 0x07, 0xC0, 0x3F, 0x81, 0xEE, 0x07, 0x38, 0x1C, 0xE0,
  0x7F, 0x00, 0xF8, 0x0F, 0xCF, 0x7F, 0x39, 0xDF, 0xEF, 0x3F, 0x3C, 0x78,
  0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x80, 0x76, 0xEE, 0xE0, 0x0E, 0x38, 0xE1,
  0xC7, 0x0E, 0x1C, 0x70, 0xE1, 0xC3, 0x87, 0x0C, 0x18, 0x38, 0x70, 0xE1,
  0xC0, 0x0E, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x0E, 0x0E, 0x0E, 0x1C, 0x18, 0x38, 0xF0, 0x0E, 0x06, 0x33, 0x1F, 0xBF,
  0xF9, 0xFD, 0xF1, 0xDC, 0x67, 0x02, 0x00, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0xFF, 0xFF, 0xFF, 0xFC, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x3B, 0xDC, 0xEE,
  0x70, 0x7D, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xE0, 0x1C, 0x07, 0x01, 0xC0,
  0x38, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x00,
  0xE0, 0x38, 0x00, 0x0F, 0x0F, 0xE3, 0xFD, 0xE7, 0x71, 0xFC, 0x7E, 0x3F,
  0x8F, 0xE3, 0xB8, 0xEE, 0x7B, 0x9C, 0xFF, 0x3F, 0x87, 0xC0, 0x07, 0x1F,
  0x3F, 0xFE, 0xFE, 0x4E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x3C, 0x38, 0x38,
  0x38, 0x07, 0xC1, 0xFE, 0x1F, 0xF0, 0x8F, 0x00, 0xF0, 0x0E, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7F, 0xC7, 0xFC, 0xFF, 0xC0,
  0x1F, 0x87, 0xF8, 0x7F, 0x88, 0xF0, 0x1E, 0x07, 0x87, 0xE0, 0xF8, 0x1F,
  0x80, 0x78, 0x0F, 0x41, 0xEF, 0xF9, 0xFE, 0x3F, 0x80, 0x01, 0xE0, 0x3C,
  0x0F, 0x03, 0xE0, 0xFC, 0x3B, 0x86, 0xF1, 0xDC, 0x73, 0x9F, 0xFB, 0xFF,
  0x7F, 0xE0, 0x70, 0x0E, 0x01, 0xC0, 0x0F, 0xE3, 0xFC, 0x7F, 0x8E, 0x03,
  0x80, 0x7C, 0x0F, 0xE1, 0xFE, 0x03, 0xC0, 0x78, 0x0F, 0x41, 0xEF, 0xF9,
  0xFE, 0x3F, 0x80, 0x07, 0xC7, 0xF3, 0xFC, 0xE0, 0x70, 0x1D, 0xCE, 0xFB,
  0xFE, 0xF3, 0xB8, 0xEE, 0x3B, 0x9E, 0xFF, 0x3F, 0xC7, 0xE0, 0x7F, 0xEF,
  0xFD, 0xFF, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x78, 0x1E, 0x03, 0x80,
  0xF0, 0x1C, 0x07, 0x81, 0xE0, 0x3C, 0x00, 0x0F, 0xC3, 0xFC, 0x77, 0x9C,
  0x73, 0x8E, 0x3B, 0x87, 0xE0, 0xF8, 0x3F, 0x8E, 0x7B, 0xC7, 0x78, 0xEF,
  0x3C, 0xFF, 0x0F, 0xC0, 0x1F, 0x0F, 0xE7, 0xF9, 0xCF, 0xF3, 0xFC, 0xFF,
  0x3F, 0xFE, 0x7F, 0x8E, 0xE0, 0x70, 0x3C, 0xFE, 0x3F, 0x0F, 0x80, 0x18,
  0xF3, 0xCE, 0x00, 0x00, 0x00, 0x03, 0xCF, 0x38, 0x0C, 0x3C, 0x78, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x71, 0xE3, 0x87, 0x1C, 0x38, 0x00, 0x00, 0x40,
  0x70, 0x7C, 0x7C, 0x7C, 0x3C, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x70, 0x04,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x80, 0x38, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF0, 0xFC, 0xF8, 0xF8, 0x38, 0x08, 0x00, 0x3F,
  0x3F, 0x9F, 0xE8, 0x70, 0x78, 0x78, 0x78, 0x78, 0x38, 0x38, 0x00, 0x00,
  0x07, 0x07, 0x83, 0xC0, 0x03, 0xF0, 0x0F, 0xFC, 0x1C, 0x0E, 0x38, 0x06,
  0x73, 0xF6, 0x67, 0xF7, 0xEE, 0x67, 0xCC, 0x66, 0xCC, 0xE6, 0xCC, 0xE6,
  0xCC, 0xEC, 0xCF, 0x7C, 0xC6, 0x70, 0xE0, 0x00, 0x78, 0x60, 0x3F, 0xE0,
  0x0F, 0x80, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x76, 0x07, 0x70, 0xE7, 0x0E,
  0x71, 0xE7, 0x1C, 0x73, 0xFF, 0x3F, 0xF7, 0xFF, 0x70, 0x7F, 0x07, 0xF0,
  0x70, 0x1F, 0xC1, 0xFF, 0x1F, 0xF1, 0xC7, 0x3C, 0x73, 0xCE, 0x3F, 0xE3,
  0xFC, 0x3F, 0xE7, 0x8E, 0x78, 0xE7, 0x1E, 0x7F, 0xC7, 0xFC, 0xFF, 0x00,
  0x07, 0xE1, 0xFF, 0x3F, 0xE3, 0xC2, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0x87, 0xF8, 0x3F, 0x80, 0x1F,
  0xC0, 0xFF, 0x07, 0xFC, 0x38, 0xE3, 0xC7, 0x9E, 0x3C, 0xE1, 0xE7, 0x0F,
  0x38, 0x73, 0xC7, 0x9E, 0x3C, 0xE3, 0xC7, 0xFC, 0x3F, 0xC3, 0xF8, 0x00,
  0x1F, 0xE3, 0xFC, 0x7F, 0x8E, 0x03, 0xC0, 0x78, 0x0F, 0xF1, 0xFC, 0x3F,
  0x8F, 0x01, 0xE0, 0x38, 0x07, 0xF8, 0xFE, 0x3F, 0xC0, 0x1F, 0xE3, 0xFC,
  0x7F, 0x8E, 0x03, 0xC0, 0x78, 0x0F, 0xF1, 0xFC, 0x3F, 0x8F, 0x01, 0xE0,
  0x38, 0x07, 0x00, 0xE0, 0x3C, 0x00, 0x07, 0xF1, 0xFF, 0x3F, 0xF3, 0xC1,
  0x78, 0x07, 0x00, 0xF3, 0xFF, 0x3E, 0xF3, 0xEF, 0x0E, 0xF1, 0xEF, 0x1E,
  0x7F, 0xC7, 0xFC, 0x3F, 0xC0, 0x1E, 0x3C, 0x78, 0xF1, 0xC3, 0x87, 0x0E,
  0x3C, 0x38, 0xF1, 0xE3, 0xFF, 0x8F, 0xFC, 0x3F, 0xF1, 0xE1, 0xC7, 0x8F,
  0x1C, 0x3C, 0x70, 0xE1, 0xC3, 0x8F, 0x1E, 0x00, 0x1F, 0xC7, 0xF0, 0xF0,
  0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x3C,
  0x1F, 0xCF, 0xE0, 0x01, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x81, 0xE0, 0x78,
  0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0xBC,
  0x3F, 0x0F, 0x81, 0x80, 0x1E, 0x3C, 0x71, 0xE1, 0xCF, 0x07, 0x38, 0x3D,
  0xE0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x81, 0xEE, 0x07, 0xBC, 0x1C,
  0xF0, 0x71, 0xC1, 0xC7, 0x8F, 0x1E, 0x00, 0x1E, 0x0E, 0x07, 0x03, 0x83,
  0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x3C, 0x1E, 0x0E, 0x07, 0xFB, 0xFB, 0xFC,
  0x1F, 0x07, 0xC7, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC6, 0xE3, 0xF3, 0xF0, 0xEC, 0xDC, 0x3B, 0x77, 0x1C, 0xD9, 0xC7, 0x3E,
  0xF1, 0xCF, 0x38, 0x73, 0xCE, 0x1C, 0xE3, 0x8E, 0x39, 0xE0, 0x1E, 0x0E,
  0x3E, 0x1C, 0x7C, 0x78, 0xF8, 0xE3, 0xF1, 0xC7, 0x73, 0x8E, 0xE7, 0x1D,
  0xDE, 0x3B, 0xF8, 0xE3, 0xF1, 0xC7, 0xE3, 0x8F, 0xC7, 0x1F, 0x0E, 0x1E,
  0x38, 0x3C, 0x00, 0x07, 0xE0, 0xFF, 0x8F, 0xFC, 0x78, 0xE7, 0x87, 0xB8,
  0x3F, 0xC1, 0xFE, 0x0E, 0xF0, 0x77, 0x87, 0xBC, 0x3D, 0xE3, 0xCF, 0xFC,
  0x3F, 0xE0, 0xFC, 0x00, 0x1F, 0xC1, 0xFE, 0x1F, 0xF1, 0xCF, 0x3C, 0x73,
  0xCF, 0x38, 0xF3, 0xFE, 0x3F, 0xC7, 0xF0, 0x78, 0x07, 0x00, 0x70, 0x07,
  0x00, 0xF0, 0x00, 0x07, 0xE0, 0xFF, 0x8F, 0xFC, 0x78, 0xE7, 0x87, 0xB8,
  0x3F, 0xC1, 0xFE, 0x0E, 0xF0, 0x77, 0x87, 0xBC, 0x3D, 0xE3, 0xCF, 0xFC,
  0x3F, 0xE0, 0xFC, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x1F, 0xC1,
  0xFE, 0x1F, 0xF1, 0xCF, 0x3C, 0xF3, 0xCF, 0x39, 0xE3, 0xFE, 0x3F, 0x87,
  0xB8, 0x7B, 0x87, 0x3C, 0x71, 0xC7, 0x1E, 0xF1, 0xE0, 0x0F, 0xC3, 0xFC,
  0xFF, 0x1E, 0x23, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0E,
  0x41, 0xCF, 0xF9, 0xFE, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x70, 0x3C,
  0x0F, 0x03, 0x80, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x0F,
  0x00, 0x3C, 0x79, 0xC3, 0x8E, 0x1C, 0x70, 0xE7, 0x8F, 0x3C, 0x79, 0xC3,
  0x8E, 0x1C, 0x70, 0xE7, 0x8F, 0x3C, 0x71, 0xE3, 0x8F, 0xFC, 0x3F, 0xC0,
  0xFC, 0x00, 0xE0, 0xFE, 0x1E, 0xE1, 0xCE, 0x3C, 0xE3, 0x8E, 0x38, 0xE7,
  0x0E, 0x70, 0xEF, 0x0E, 0xE0, 0xEE, 0x0F, 0xC0, 0x7C, 0x07, 0x80, 0x78,
  0x00, 0xE1, 0xC3, 0xF8, 0x70, 0xEE, 0x3C, 0x7B, 0x8F, 0x1C, 0xE7, 0xCF,
  0x39, 0xF3, 0x8E, 0xFC, 0xE3, 0xBF, 0x70, 0xED, 0xDC, 0x3F, 0x7F, 0x0F,
  0xDF, 0x83, 0xE7, 0xE0, 0xF9, 0xF0, 0x3C, 0x7C, 0x0F, 0x1F, 0x00, 0x1E,
  0x1E, 0x1C, 0x78, 0x39, 0xE0, 0x7B, 0x80, 0xFE, 0x00, 0xFC, 0x01, 0xF0,
  0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x77, 0x01, 0xEF, 0x03, 0x9E, 0x0E,
  0x1C, 0x3C, 0x3C, 0x00, 0xE1, 0xFE, 0x3B, 0xCF, 0x3B, 0xC7, 0x70, 0xFE,
  0x1F, 0x83, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C,
  0x00, 0x1F, 0xF8, 0xFF, 0x87, 0xFC, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0xFC, 0x3F, 0xE3,
  0xFF, 0x00, 0x0F, 0x87, 0xC3, 0x81, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x03, 0x81, 0xC0, 0xE0, 0x7C, 0x7C, 0x00, 0xE7,
  0x18, 0xE7, 0x39, 0xCE, 0x71, 0x8E, 0x73, 0x9C, 0xE0, 0x1F, 0x1F, 0x07,
  0x07, 0x06, 0x0E, 0x0E, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C, 0x1C, 0x18, 0x38,
  0x38, 0xF8, 0xF8, 0x03, 0x01, 0xC0, 0x78, 0x3E, 0x1D, 0x86, 0x63, 0x9D,
  0xC7, 0x60, 0xF8, 0x30, 0xFF, 0xFF, 0x80, 0xF3, 0x8E, 0x1C, 0xE7, 0xF9,
  0xFF, 0x39, 0xEF, 0x3D, 0xC7, 0x38, 0xE7, 0x1C, 0xE7, 0x9F, 0xF3, 0xFC,
  0x3F, 0x80, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xD8, 0x77, 0x8F, 0xF9,
  0xEF, 0x38, 0xEF, 0x1D, 0xC7, 0xB8, 0xE7, 0x1C, 0xFF, 0xBF, 0xE7, 0x78,
  0x0F, 0x1F, 0xDF, 0xCF, 0x2F, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x7F, 0x3F,
  0x8F, 0xC0, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xF1, 0xDE, 0x7F, 0x9F, 0xF3,
  0x9E, 0xF3, 0xDC, 0x73, 0x8E, 0x71, 0xCE, 0x79, 0xFF, 0x3F, 0xC3, 0xF8,
  0x0F, 0x0F, 0xE7, 0xF9, 0xCF, 0xF3, 0xBF, 0xEF, 0xF3, 0x80, 0xE0, 0x3C,
  0xCF, 0xF1, 0xF8, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x78, 0x07, 0xC1, 0xFC,
  0x1F, 0xC0, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0xF8, 0x0F, 0x80, 0xF0, 0x00, 0x0E,
  0x71, 0xFE, 0x3F, 0xE3, 0x9E, 0x79, 0xE7, 0x1C, 0x71, 0xC7, 0x1C, 0x73,
  0xC7, 0xFC, 0x7F, 0x83, 0xB8, 0x03, 0x80, 0x78, 0xFF, 0x0F, 0xF0, 0xFC,
  0x00, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xD8, 0x77, 0xCF, 0xF9, 0xE7,
  0x38, 0xEF, 0x3D, 0xE7, 0x38, 0xE7, 0x1C, 0xE3, 0xBC, 0xF7, 0x9C, 0x0E,
  0x3C, 0x70, 0x01, 0xC7, 0x8E, 0x1C, 0x38, 0xF1, 0xE3, 0x87, 0x0E, 0x3C,
  0x78, 0x01, 0xC0, 0xF0, 0x38, 0x00, 0x03, 0x81, 0xE0, 0x78, 0x1C, 0x07,
  0x01, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x0F,
  0xC3, 0xE0, 0xF0, 0x00, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x73,
  0xCF, 0x39, 0xE3, 0xBC, 0x3F, 0x87, 0xF0, 0x7F, 0x07, 0xF8, 0x77, 0x87,
  0x38, 0xF3, 0xCF, 0x3C, 0x1E, 0x3C, 0x70, 0xE1, 0xC7, 0x8E, 0x1C, 0x38,
  0xF1, 0xE3, 0x87, 0x0E, 0x3C, 0x78, 0x19, 0x86, 0x1D, 0xEF, 0x8F, 0xFF,
  0xE7, 0xBE, 0xF3, 0x8E, 0x7B, 0xCF, 0x39, 0xE7, 0x1C, 0xE3, 0x8E, 0x71,
  0xC7, 0x39, 0xE7, 0xBC, 0xF3, 0x9E, 0x71, 0xC0, 0x19, 0x87, 0x7C, 0xFF,
  0x9E, 0x73, 0x8E, 0x73, 0xDE, 0x73, 0x8E, 0x71, 0xCE, 0x3B, 0xCF, 0x79,
  0xC0, 0x0E, 0x0F, 0xE7, 0xF9, 0xCF, 0xF3, 0xF8, 0xFE, 0x3F, 0x8E, 0xE7,
  0xBF, 0xEF, 0xF1, 0xF8, 0x0C, 0xC1, 0xDE, 0x1F, 0xF1, 0xEF, 0x1C, 0x73,
  0xC7, 0x38, 0xF3, 0x8E, 0x38, 0xE3, 0xFE, 0x7F, 0xC7, 0x78, 0x70, 0x07,
  0x00, 0x70, 0x0F, 0x00, 0xE0, 0x00, 0x1C, 0xE7, 0xF9, 0xFF, 0x39, 0xEF,
  0x3D, 0xC7, 0x38, 0xE7, 0x1C, 0xE7, 0x9F, 0xF3, 0xFC, 0x3B, 0x80, 0x70,
  0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x00, 0x19, 0x9D, 0xCF, 0xE7, 0xE3, 0x83,
  0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x3C, 0x1E, 0x00, 0x0E, 0x1F, 0xCF, 0xEF,
  0x17, 0x81, 0xF0, 0x7C, 0x1E, 0x07, 0x67, 0xBF, 0x9F, 0x80, 0x1C, 0x18,
  0x3F, 0xFE, 0xFE, 0x70, 0x70, 0x70, 0x70, 0xF0, 0xE0, 0xFC, 0xFC, 0x7C,
  0x79, 0xEF, 0x39, 0xC7, 0x38, 0xE7, 0x1D, 0xE7, 0xB8, 0xE7, 0x1C, 0xE7,
  0x9F, 0xF3, 0xFE, 0x3D, 0x80, 0xE1, 0xF8, 0x7E, 0x3B, 0x8E, 0xE7, 0x1D,
  0xC7, 0xE1, 0xF8, 0x7C, 0x1F, 0x07, 0x81, 0xE0, 0xE3, 0xCF, 0xE3, 0xCE,
  0xE7, 0xCE, 0xE7, 0xDC, 0xE7, 0xDC, 0xEF, 0xFC, 0xED, 0xF8, 0xFD, 0xB8,
  0xF9, 0xF0, 0xF9, 0xF0, 0xF9, 0xE0, 0x71, 0xE0, 0x1C, 0x78, 0xE7, 0x87,
  0xB8, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3C, 0x03, 0xF0, 0x1F, 0x81, 0xDE,
  0x1E, 0xF1, 0xE3, 0x80, 0x38, 0x73, 0x87, 0x38, 0xE3, 0xCE, 0x1D, 0xC1,
  0xDC, 0x1F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1C, 0x03,
  0xC0, 0xF8, 0x0F, 0x80, 0xE0, 0x00, 0x1F, 0xE3, 0xF8, 0x7F, 0x01, 0xC0,
  0x78, 0x1E, 0x03, 0x80, 0xE0, 0x3C, 0x0F, 0xF1, 0xFE, 0x7F, 0x80, 0x07,
  0x87, 0xC3, 0xC1, 0xC1, 0xC0, 0xE0, 0x70, 0x78, 0xF8, 0x78, 0x1E, 0x07,
  0x03, 0x83, 0x81, 0xC0, 0xE0, 0x78, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1C, 0x1E, 0x1E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0F, 0x0F,
  0x1F, 0x3C, 0x38, 0x38, 0x38, 0x78, 0xF0, 0xE0, 0xF8, 0x7F, 0xF8, 0xFC,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBoldItalic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 7, 15, 6, 0, -15 },
  { 15, 8, 5, 9, 2, -15 },
  { 20, 13, 15, 12, 0, -15 },
  { 45, 11, 17, 11, 0, -16 },
  { 69, 16, 15, 18, 1, -15 },
  { 99, 14, 15, 14, 0, -15 },
  { 126, 4, 5, 5, 2, -15 },
  { 129, 7, 18, 7, 1, -15 },
  { 145, 8, 18, 7, -2, -15 },
  { 163, 9, 10, 11, 2, -16 },
  { 175, 10, 11, 11, 1, -13 },
  { 189, 5, 6, 6, -1, -3 },
  { 193, 6, 3, 7, 0, -7 },
  { 196, 4, 3, 6, 0, -3 },
  { 198, 11, 15, 9, -1, -15 },
  { 219, 10, 15, 11, 1, -15 },
  { 238, 8, 15, 11, 2, -15 },
  { 253, 12, 15, 11, -1, -15 },
  { 276, 11, 15, 11, 0, -15 },
  { 297, 11, 15, 11, 0, -15 },
  { 318, 11, 15, 11, 0, -15 },
  { 339, 10, 15, 11, 1, -15 },
  { 358, 11, 15, 11, 1, -15 },
  { 379, 11, 15, 11, 0, -15 },
  { 400, 10, 15, 11, 1, -15 },
  { 419, 6, 12, 6, 0, -12 },
  { 428, 7, 15, 6, -1, -12 },
  { 442, 10, 11, 11, 1, -13 },
  { 456, 10, 7, 11, 1, -11 },
  { 465, 10, 11, 11, 1, -13 },
  { 479, 9, 15, 9, 1, -15 },
  { 496, 16, 17, 17, 1, -15 },
  { 530, 12, 15, 13, -1, -15 },
  { 553, 12, 15, 12, 0, -15 },
  { 576, 12, 15, 12, 1, -15 },
  { 599, 13, 15, 13, 0, -15 },
  { 624, 11, 15, 10, 0, -15 },
  { 645, 11, 15, 10, 0, -15 },
  { 666, 12, 15, 13, 1, -15 },
  { 689, 14, 15, 14, 0, -15 },
  { 716, 10, 15, 8, -1, -15 },
  { 735, 10, 20, 7, -3, -15 },
  { 760, 14, 15, 12, 0, -15 },
  { 787, 9, 15, 10, 0, -15 },
  { 804, 18, 15, 17, 0, -15 },
  { 838, 15, 15, 15, 0, -15 },
  { 867, 13, 15, 14, 1, -15 },
  { 892, 12, 15, 12, 0, -15 },
  { 915, 13, 19, 14, 1, -15 },
  { 946, 12, 15, 12, 0, -15 },
  { 969, 11, 15, 10, 0, -15 },
  { 990, 10, 15, 10, 2, -15 },
  { 1009, 13, 15, 13, 1, -15 },
  { 1034, 12, 15, 12, 2, -15 },
  { 1057, 18, 15, 18, 2, -15 },
  { 1091, 15, 15, 12, -1, -15 },
  { 1120, 11, 15, 11, 2, -15 },
  { 1141, 13, 15, 10, -1, -15 },
  { 1166, 9, 18, 7, -1, -15 },
  { 1187, 5, 15, 9, 2, -15 },
  { 1197, 8, 18, 7, -1, -15 },
  { 1215, 10, 10, 11, 0, -15 },
  { 1228, 9, 2, 8, -2, 2 },
  { 1231, 5, 3, 7, 3, -16 },
  { 1233, 11, 12, 12, 1, -12 },
  { 1250, 11, 16, 12, 0, -16 },
  { 1272, 9, 12, 9, 1, -12 },
  { 1286, 11, 16, 12, 1, -16 },
  { 1308, 10, 12, 11, 1, -12 },
  { 1323, 12, 21, 7, -2, -16 },
  { 1355, 12, 17, 12, 0, -12 },
  { 1381, 11, 16, 12, 0, -16 },
  { 1403, 7, 16, 6, 0, -16 },
  { 1417, 10, 21, 6, -3, -16 },
  { 1444, 12, 16, 11, 0, -16 },
  { 1468, 7, 16, 6, 0, -16 },
  { 1482, 17, 12, 18, 0, -12 },
  { 1508, 11, 12, 12, 0, -12 },
  { 1525, 10, 12, 11, 1, -12 },
  { 1540, 12, 17, 12, -1, -12 },
  { 1566, 11, 17, 12, 1, -12 },
  { 1590, 9, 12, 8, 0, -12 },
  { 1604, 9, 12, 9, 0, -12 },
  { 1618, 8, 14, 8, 1, -14 },
  { 1632, 11, 12, 12, 1, -12 },
  { 1649, 10, 12, 10, 1, -12 },
  { 1664, 16, 12, 16, 1, -12 },
  { 1688, 13, 12, 11, -1, -12 },
  { 1708, 12, 17, 10, -1, -12 },
  { 1734, 11, 12, 9, -1, -12 },
  { 1751, 9, 18, 7, 0, -15 },
  { 1772, 2, 21, 10, 4, -16 },
  { 1778, 8, 18, 7, -1, -15 },
  { 1796, 10, 3, 11, 1, -9 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBoldItalic21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBoldItalic21pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBoldItalic21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC21PT7B_H_
