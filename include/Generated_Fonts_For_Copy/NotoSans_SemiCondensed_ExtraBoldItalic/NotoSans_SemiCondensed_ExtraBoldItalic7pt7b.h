#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC7PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBoldItalic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBoldItalic7pt7bBitmaps[] PROGMEM = {
  0x00, 0x56, 0x80, 0xF0, 0x3F, 0x6F, 0xA0, 0x74, 0x6A, 0xE0, 0x6A, 0xCD,
  0xCD, 0x58, 0x72, 0x9F, 0x6F, 0x00, 0xC0, 0x6A, 0x49, 0x00, 0x24, 0x93,
  0x80, 0xDF, 0x00, 0x4F, 0x40, 0xC0, 0xC0, 0x80, 0x32, 0x44, 0x80, 0x65,
  0xBA, 0xE0, 0x75, 0x80, 0x63, 0x24, 0xE0, 0x63, 0x62, 0xE0, 0x36, 0x6E,
  0x60, 0x74, 0x62, 0xE0, 0x74, 0xEA, 0xE0, 0x72, 0x24, 0xC0, 0x75, 0x6A,
  0xE0, 0x6F, 0xE2, 0xC0, 0x42, 0x42, 0x80, 0x3C, 0x30, 0xF0, 0xF0, 0xC3,
  0xC0, 0x65, 0x0C, 0x39, 0xDB, 0x7E, 0x81, 0xC0, 0x25, 0x5F, 0x90, 0x75,
  0x6D, 0xE0, 0x74, 0xCC, 0x60, 0x75, 0x5D, 0xE0, 0x74, 0x6C, 0xE0, 0x74,
  0x6C, 0x80, 0x74, 0xFD, 0x70, 0x5A, 0x9D, 0xAB, 0x00, 0x69, 0x2C, 0x24,
  0xB5, 0xA0, 0x5B, 0x99, 0xCB, 0x00, 0x49, 0x6E, 0x6D, 0xB7, 0xAE, 0xA8,
  0x6B, 0x5F, 0x69, 0x00, 0x72, 0xF5, 0xA7, 0x00, 0x75, 0x7C, 0x80, 0x72,
  0xF5, 0xA6, 0x18, 0x75, 0x7E, 0xB0, 0x74, 0x62, 0xE0, 0xFA, 0x48, 0x5A,
  0x95, 0xA6, 0x00, 0xBA, 0xCC, 0x80, 0xAF, 0xAF, 0x3C, 0xB0, 0x5B, 0x18,
  0xCB, 0x00, 0xBB, 0x48, 0x72, 0x4C, 0xE0, 0x69, 0x49, 0x80, 0xF8, 0x55,
  0x60, 0x26, 0xB0, 0xE0, 0xC0, 0x7F, 0xAE, 0x46, 0x5A, 0xE0, 0x7A, 0x70,
  0x17, 0xFA, 0xE0, 0x6F, 0x8E, 0x37, 0x22, 0x44, 0xC0, 0x7F, 0xAE, 0x2C,
  0x47, 0x5A, 0xA0, 0x56, 0x80, 0x24, 0xA4, 0xA0, 0x45, 0x6E, 0xA0, 0x56,
  0x80, 0x69, 0x7A, 0xAA, 0x75, 0xAA, 0x6F, 0xAE, 0x65, 0xAE, 0x88, 0x7F,
  0xAE, 0x22, 0x6A, 0x40, 0x79, 0xE0, 0x5D, 0x6C, 0x55, 0xAE, 0xBA, 0x64,
  0xBE, 0xED, 0xB4, 0xF6, 0x6A, 0x96, 0x64, 0xC8, 0x6D, 0x70, 0x69, 0x69,
  0x80, 0xFE, 0x55, 0xA0, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBoldItalic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 5, 2, 0, -5 },
  { 3, 2, 2, 3, 1, -5 },
  { 4, 4, 5, 4, 0, -5 },
  { 7, 4, 5, 4, 0, -5 },
  { 10, 6, 5, 6, 0, -5 },
  { 14, 5, 5, 5, 0, -5 },
  { 18, 1, 2, 2, 1, -5 },
  { 19, 3, 6, 2, 0, -5 },
  { 22, 3, 6, 2, -1, -5 },
  { 25, 3, 3, 4, 1, -5 },
  { 27, 4, 3, 4, 0, -4 },
  { 29, 1, 2, 2, 0, -1 },
  { 30, 2, 1, 2, 0, -2 },
  { 31, 1, 1, 2, 0, -1 },
  { 32, 4, 5, 3, 0, -5 },
  { 35, 4, 5, 4, 0, -5 },
  { 38, 2, 5, 4, 1, -5 },
  { 40, 4, 5, 4, 0, -5 },
  { 43, 4, 5, 4, 0, -5 },
  { 46, 4, 5, 4, 0, -5 },
  { 49, 4, 5, 4, 0, -5 },
  { 52, 4, 5, 4, 0, -5 },
  { 55, 4, 5, 4, 0, -5 },
  { 58, 4, 5, 4, 0, -5 },
  { 61, 4, 5, 4, 0, -5 },
  { 64, 2, 4, 2, 0, -4 },
  { 65, 2, 5, 2, 0, -4 },
  { 67, 4, 3, 4, 0, -4 },
  { 69, 4, 3, 4, 0, -4 },
  { 71, 4, 3, 4, 0, -4 },
  { 73, 3, 5, 3, 0, -5 },
  { 75, 6, 6, 6, 0, -5 },
  { 80, 4, 5, 4, 0, -5 },
  { 83, 4, 5, 4, 0, -5 },
  { 86, 4, 5, 4, 0, -5 },
  { 89, 4, 5, 4, 0, -5 },
  { 92, 4, 5, 4, 0, -5 },
  { 95, 4, 5, 3, 0, -5 },
  { 98, 4, 5, 4, 0, -5 },
  { 101, 5, 5, 5, 0, -5 },
  { 105, 3, 5, 3, 0, -5 },
  { 107, 3, 7, 2, -1, -5 },
  { 110, 5, 5, 4, 0, -5 },
  { 114, 3, 5, 3, 0, -5 },
  { 116, 6, 5, 6, 0, -5 },
  { 120, 5, 5, 5, 0, -5 },
  { 124, 5, 5, 5, 0, -5 },
  { 128, 4, 5, 4, 0, -5 },
  { 131, 5, 6, 5, 0, -5 },
  { 135, 4, 5, 4, 0, -5 },
  { 138, 4, 5, 3, 0, -5 },
  { 141, 3, 5, 3, 1, -5 },
  { 143, 5, 5, 4, 0, -5 },
  { 147, 4, 5, 4, 1, -5 },
  { 150, 6, 5, 6, 1, -5 },
  { 154, 5, 5, 4, 0, -5 },
  { 158, 3, 5, 4, 1, -5 },
  { 160, 4, 5, 3, 0, -5 },
  { 163, 3, 6, 2, 0, -5 },
  { 166, 1, 5, 3, 1, -5 },
  { 167, 2, 6, 2, 0, -5 },
  { 169, 4, 3, 4, 0, -5 },
  { 171, 3, 1, 3, -1, 0 },
  { 172, 2, 1, 2, 1, -5 },
  { 173, 4, 4, 4, 0, -4 },
  { 175, 4, 5, 4, 0, -5 },
  { 178, 3, 4, 3, 0, -4 },
  { 180, 4, 5, 4, 0, -5 },
  { 183, 4, 4, 4, 0, -4 },
  { 185, 4, 7, 2, -1, -5 },
  { 189, 4, 6, 4, 0, -4 },
  { 192, 4, 5, 4, 0, -5 },
  { 195, 2, 5, 2, 0, -5 },
  { 197, 3, 7, 2, -1, -5 },
  { 200, 4, 5, 4, 0, -5 },
  { 203, 2, 5, 2, 0, -5 },
  { 205, 6, 4, 6, 0, -4 },
  { 208, 4, 4, 4, 0, -4 },
  { 210, 4, 4, 4, 0, -4 },
  { 212, 4, 6, 4, 0, -4 },
  { 215, 4, 6, 4, 0, -4 },
  { 218, 3, 4, 3, 0, -4 },
  { 220, 3, 4, 3, 0, -4 },
  { 222, 3, 5, 3, 0, -5 },
  { 224, 4, 4, 4, 0, -4 },
  { 226, 4, 4, 3, 0, -4 },
  { 228, 6, 4, 5, 0, -4 },
  { 231, 4, 4, 4, 0, -4 },
  { 233, 4, 6, 3, 0, -4 },
  { 236, 3, 4, 3, 0, -4 },
  { 238, 3, 6, 2, 0, -5 },
  { 241, 1, 7, 3, 1, -5 },
  { 242, 2, 6, 2, 0, -5 },
  { 244, 4, 1, 4, 0, -3 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBoldItalic7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBoldItalic7pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBoldItalic7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC7PT7B_H_
