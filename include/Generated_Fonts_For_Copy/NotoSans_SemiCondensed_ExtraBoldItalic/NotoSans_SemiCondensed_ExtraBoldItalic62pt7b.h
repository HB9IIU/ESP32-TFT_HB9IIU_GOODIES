#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC62PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC62PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBoldItalic.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBoldItalic62pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xC0,
  0x07, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xE3, 0xFF, 0x3F, 0xE3, 0xFE,
  0x3F, 0xE3, 0xFE, 0x3F, 0xC3, 0xFE, 0x7F, 0xC3, 0xFC, 0x7F, 0xC3, 0xFC,
  0x7F, 0x83, 0xFC, 0x7F, 0x87, 0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF8,
  0x7F, 0x07, 0xF8, 0xFF, 0x07, 0xF0, 0xFF, 0x07, 0xF0, 0xFE, 0x07, 0xF0,
  0xFE, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0xFE, 0x0F,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF0,
  0x3F, 0x80, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x79, 0xF8, 0x07, 0xFE,
  0x78, 0x38, 0x07, 0xFC, 0x78, 0x08, 0x07, 0xFC, 0x70, 0x00, 0x07, 0xFC,
  0xF0, 0x00, 0x07, 0xFC, 0xF0, 0x00, 0x07, 0xFE, 0xF0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xBF, 0xF0, 0x00, 0x07,
  0x9F, 0xF0, 0x00, 0x07, 0x9F, 0xF0, 0x40, 0x07, 0x9F, 0xF0, 0x60, 0x0F,
  0x1F, 0xF0, 0x7C, 0x0F, 0x3F, 0xF0, 0x7F, 0x8F, 0x7F, 0xF0, 0x7F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xF0, 0x01,
  0xFF, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0x00, 0x0F,
  0xF1, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xC3, 0xF8, 0x03, 0xF8, 0x00, 0x7F,
  0x87, 0xF0, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC,
  0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xE0,
  0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x83,
  0xFC, 0x3F, 0x80, 0x00, 0xFF, 0x07, 0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x1F,
  0xE1, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xC7, 0xF0, 0x7F, 0x87, 0xF8, 0x7F,
  0x1F, 0xE3, 0xFF, 0x87, 0xF1, 0xFE, 0x3F, 0x8F, 0xFF, 0x8F, 0xFF, 0xF8,
  0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xF3, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7,
  0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0x1F, 0xC7, 0xFD, 0xFE, 0x3F, 0xFC, 0x7F,
  0x9F, 0xE1, 0xFC, 0x3F, 0xF0, 0xFE, 0x3F, 0xC3, 0xF8, 0x1F, 0x83, 0xF8,
  0x7F, 0x07, 0xF0, 0x00, 0x0F, 0xF1, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0xC3,
  0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF8, 0x7F, 0x80, 0x01, 0xFE, 0x0F,
  0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xC1, 0xFE, 0x00, 0x0F, 0xE0, 0x7F,
  0x83, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x07, 0xF0, 0x00, 0xFF, 0x01, 0xFE,
  0x1F, 0xE0, 0x01, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x07, 0xF8,
  0xFF, 0x00, 0x1F, 0xE0, 0x0F, 0xF3, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xFF,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xFF,
  0xC0, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x00, 0xFF,
  0x81, 0xFF, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0xFF, 0x81, 0xFE,
  0x00, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x00,
  0xFF, 0x87, 0xFC, 0x00, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0x00, 0xFF,
  0xFE, 0x03, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFE, 0x07, 0xFF, 0xFE, 0x07,
  0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFC, 0x3F,
  0xFF, 0xFF, 0x1F, 0xF8, 0x3F, 0xF3, 0xFF, 0x9F, 0xF8, 0x7F, 0xF1, 0xFF,
  0xFF, 0xF0, 0x7F, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xE7, 0xFC, 0xFF, 0x9F,
  0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFC, 0x7F, 0x8F, 0xF1, 0xFC, 0x3F, 0x87,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x30, 0x0F, 0xE0, 0x03, 0xC0, 0xFE, 0x00, 0x3F,
  0x0F, 0xC0, 0x07, 0xF9, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x77, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0x7F, 0x00,
  0x7F, 0xE7, 0xF8, 0x03, 0xFE, 0x3F, 0x80, 0x1F, 0xC3, 0xFC, 0x00, 0xF8,
  0x3F, 0xE0, 0x03, 0x81, 0xFE, 0x00, 0x10, 0x1F, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0,
  0xFF, 0x81, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F,
  0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x00, 0x0F, 0xC7, 0xFD, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xF0, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xBF,
  0xF8, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0x03, 0xFF,
  0x0F, 0xFC, 0x0F, 0xFC, 0x7F, 0xE0, 0x3F, 0xF1, 0xFF, 0x80, 0xFF, 0xCF,
  0xFE, 0x03, 0xFF, 0x3F, 0xF0, 0x0F, 0xFC, 0xFF, 0xC0, 0x3F, 0xF7, 0xFF,
  0x00, 0xFF, 0xDF, 0xF8, 0x03, 0xFF, 0x7F, 0xE0, 0x0F, 0xFD, 0xFF, 0x80,
  0x7F, 0xE7, 0xFE, 0x01, 0xFF, 0xBF, 0xF0, 0x07, 0xFE, 0xFF, 0xC0, 0x1F,
  0xFB, 0xFF, 0x00, 0x7F, 0xEF, 0xFC, 0x03, 0xFF, 0xBF, 0xF0, 0x0F, 0xFC,
  0xFF, 0xC0, 0x3F, 0xF3, 0xFF, 0x00, 0xFF, 0xCF, 0xFC, 0x07, 0xFE, 0x3F,
  0xE0, 0x1F, 0xF8, 0xFF, 0x80, 0xFF, 0xE3, 0xFF, 0x03, 0xFF, 0x0F, 0xFC,
  0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x87, 0xFF, 0x7F,
  0xC1, 0xFF, 0x3F, 0xE0, 0xFE, 0x3F, 0xF0, 0x3E, 0x1F, 0xF8, 0x0E, 0x0F,
  0xF8, 0x04, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xE0, 0xFF, 0xE0, 0x03, 0xE0, 0x1F,
  0xFC, 0x00, 0x70, 0x07, 0xFE, 0x00, 0x18, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0x1F, 0xFF, 0x00, 0x78, 0x07, 0xFF, 0x00, 0x20, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x80, 0x00, 0x3F, 0xF0, 0xC0, 0x00,
  0x7F, 0xF0, 0xF8, 0x01, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x3F, 0xCF, 0xF8,
  0x00, 0x1F, 0xEF, 0xFC, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x1F, 0xE3, 0xFE,
  0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x0F, 0xF1, 0xFF, 0x80, 0x0F, 0xF0, 0xFF,
  0xC0, 0x0F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF0, 0x3F, 0xE0, 0x07, 0xF8, 0x3F,
  0xF0, 0x07, 0xF8, 0x1F, 0xF8, 0x07, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x02, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x80, 0x00, 0xFF, 0xE0,
  0xC0, 0x01, 0xFF, 0xE0, 0xF0, 0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFD,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x0C, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0xFE, 0x00, 0x1F, 0xF3, 0xFF, 0x80, 0x3F, 0xF7, 0xFF, 0xC0,
  0x3F, 0xEF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xF8, 0x7F, 0xF0,
  0x7F, 0xF0, 0x3F, 0xF0, 0xFF, 0xE0, 0x3F, 0xF0, 0xFF, 0xE0, 0x3F, 0xF0,
  0xFF, 0xE0, 0x3F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0,
  0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xE0,
  0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xC0, 0xFF, 0xE0, 0x7F, 0xE1, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x07,
  0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F,
  0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF,
  0x81, 0xFF, 0x87, 0xFE, 0x03, 0xFF, 0x9F, 0xF8, 0x03, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFB, 0xFF, 0x81, 0xFF,
  0xC3, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x0F, 0xFC, 0x07, 0xFE, 0x1F, 0xF0,
  0x07, 0xFC, 0x7F, 0xE0, 0x0F, 0xF8, 0xFF, 0xC0, 0x1F, 0xF1, 0xFF, 0x80,
  0x3F, 0xE3, 0xFF, 0x00, 0x7F, 0xC7, 0xFE, 0x01, 0xFF, 0x8F, 0xFC, 0x03,
  0xFF, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x3F, 0xF8, 0x7F,
  0xF0, 0x7F, 0xE1, 0xFF, 0x80, 0xFF, 0x87, 0xFE, 0x03, 0xFE, 0x3F, 0xF0,
  0x0F, 0xFC, 0xFF, 0xC0, 0x3F, 0xF3, 0xFF, 0x00, 0xFF, 0xCF, 0xFC, 0x03,
  0xFF, 0x3F, 0xF0, 0x1F, 0xFD, 0xFF, 0x80, 0x7F, 0xF7, 0xFE, 0x01, 0xFF,
  0x9F, 0xFC, 0x0F, 0xFE, 0x3F, 0xF0, 0x7F, 0xF8, 0xFF, 0xE3, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0x7F, 0xC0, 0xFF, 0xFD, 0xFF, 0x03, 0xFF, 0xEF, 0xF8, 0x03, 0xFE,
  0x3F, 0xE0, 0x03, 0xE1, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x80, 0x1F, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x7F, 0x80, 0x7F,
  0xC0, 0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03,
  0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x03, 0x80, 0x00, 0x00,
  0x01, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFC,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x1F, 0xC3, 0xFF, 0x8F, 0x00, 0xFF, 0xC6,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x1F, 0xF0, 0x1F, 0xC0, 0xFF, 0x00, 0xFF,
  0xFC, 0x3F, 0x83, 0xFC, 0x07, 0xFF, 0xFC, 0x3F, 0x87, 0xF0, 0x1F, 0xFF,
  0xF8, 0x7F, 0x1F, 0xE0, 0x7F, 0xFF, 0xE0, 0xFE, 0x3F, 0x81, 0xFF, 0xFF,
  0xC1, 0xFC, 0xFF, 0x07, 0xF8, 0x3F, 0x83, 0xF9, 0xFC, 0x1F, 0xE0, 0x7F,
  0x07, 0xF3, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xEF, 0xE0, 0xFF, 0x03, 0xF8,
  0x1F, 0xDF, 0xC1, 0xFC, 0x07, 0xF0, 0x3F, 0xBF, 0x83, 0xF8, 0x0F, 0xE0,
  0x7E, 0x7F, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0xFC, 0x1F, 0xC0, 0x7F, 0x03,
  0xFB, 0xF8, 0x3F, 0x80, 0xFE, 0x07, 0xF7, 0xF0, 0x7F, 0x03, 0xFC, 0x1F,
  0xCF, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x9F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE,
  0x3F, 0x83, 0xF8, 0x3F, 0xC1, 0xFC, 0x7F, 0x07, 0xF0, 0xFF, 0x87, 0xF0,
  0xFE, 0x0F, 0xF3, 0xFF, 0xBF, 0xE1, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x83,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xF8, 0x3F, 0xFC, 0xFF, 0xF8, 0x07,
  0xF0, 0x3F, 0xF1, 0xFF, 0xE0, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xEF,
  0xF8, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00,
  0xFF, 0x9F, 0xF0, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x00, 0x7F, 0xC3, 0xFC,
  0x00, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x01, 0xFF,
  0x07, 0xF8, 0x00, 0x1F, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x81, 0xFF, 0x00,
  0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x07, 0xFE, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x01,
  0xFF, 0x8F, 0xFE, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x7F, 0xE7, 0xFF,
  0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x1F, 0xFB, 0xFF, 0x80, 0x00, 0xFF,
  0xDF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x81,
  0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x07, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x01,
  0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF0, 0x07, 0xFE, 0x07, 0xFE,
  0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xF0, 0x3F, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xC0, 0x1F, 0xFE, 0x00, 0x18, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x60,
  0x07, 0xFF, 0xC0, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x83,
  0xFF, 0xE0, 0x1F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x1F,
  0xF8, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x03, 0xFF,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0x00,
  0x3F, 0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x7F,
  0xE0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x03, 0xFF,
  0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x07, 0xFF, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0xFF, 0xE1, 0xFF,
  0x80, 0x0F, 0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0xFC,
  0x1F, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xF8, 0x3F, 0xF0, 0x0F,
  0xFF, 0x03, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xF0, 0x3F, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x3E, 0x01, 0xFF, 0xF0, 0x00, 0x60, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0xFC, 0x3F, 0xF0, 0x1F, 0xFF,
  0xE1, 0xFF, 0x80, 0xFF, 0xFF, 0x1F, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xE0,
  0x7F, 0xFF, 0x87, 0xFF, 0x03, 0xFF, 0xFC, 0x3F, 0xF0, 0x1F, 0xFF, 0xE1,
  0xFF, 0x81, 0xFF, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x01,
  0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF,
  0xE0, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xFC, 0x01, 0xFF,
  0x80, 0xFF, 0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x40, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xFF,
  0x00, 0x1F, 0xF8, 0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x07,
  0xFE, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0xFF, 0xC1, 0xFF, 0xC0,
  0x00, 0x7F, 0xE1, 0xFF, 0xC0, 0x00, 0x3F, 0xE1, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0xFF,
  0xE0, 0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x01, 0xFF, 0x8F, 0xFE,
  0x00, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x00, 0x1F, 0xF8,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x07, 0xFC, 0x07, 0xFF,
  0x00, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0x80, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFC, 0x03, 0xFD, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xC0, 0x1F, 0xEF, 0xF0, 0x1F, 0xEF, 0xF8, 0x03, 0xFD, 0xFE, 0x03, 0xFD,
  0xFF, 0x00, 0xFF, 0xBF, 0xC0, 0xFF, 0x3F, 0xE0, 0x1F, 0xF7, 0xF8, 0x1F,
  0xEF, 0xF8, 0x03, 0xFE, 0xFF, 0x03, 0xF9, 0xFF, 0x00, 0x7F, 0xDF, 0xE0,
  0xFF, 0x3F, 0xE0, 0x1F, 0xF3, 0xFC, 0x1F, 0xE7, 0xFC, 0x03, 0xFE, 0x7F,
  0x87, 0xF9, 0xFF, 0x80, 0x7F, 0xCF, 0xF0, 0xFF, 0x3F, 0xE0, 0x0F, 0xF9,
  0xFE, 0x3F, 0xC7, 0xFC, 0x01, 0xFF, 0x3F, 0xC7, 0xF8, 0xFF, 0x80, 0x7F,
  0xC7, 0xF9, 0xFE, 0x3F, 0xF0, 0x0F, 0xF8, 0xFF, 0x3F, 0xC7, 0xFE, 0x01,
  0xFF, 0x1F, 0xEF, 0xF0, 0xFF, 0x80, 0x3F, 0xE1, 0xFD, 0xFE, 0x1F, 0xF0,
  0x07, 0xFC, 0x3F, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x07, 0xFF, 0xF0, 0xFF,
  0xC0, 0x3F, 0xE0, 0xFF, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xFF, 0x83,
  0xFE, 0x00, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xFC,
  0x0F, 0xF8, 0x07, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x81, 0xFF,
  0xE0, 0x7F, 0xC0, 0x1F, 0xF0, 0x3F, 0xFC, 0x0F, 0xF8, 0x03, 0xFE, 0x07,
  0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF0,
  0x07, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xE0, 0x0F,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFF,
  0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0xE0,
  0x07, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xF8,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xF8, 0x03,
  0xFD, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xCF, 0xF8, 0x1F, 0xF0, 0x03, 0xFC,
  0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xCF, 0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0xFF,
  0x83, 0xFF, 0x00, 0x7F, 0xC7, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x7F, 0xC3,
  0xFE, 0x00, 0xFF, 0x87, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE,
  0x00, 0xFF, 0x83, 0xFE, 0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xE7, 0xFC, 0x00,
  0xFF, 0x83, 0xFE, 0x7F, 0xC0, 0x1F, 0xF8, 0x3F, 0xF7, 0xFC, 0x01, 0xFF,
  0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0x01,
  0xFF, 0x7F, 0x80, 0x1F, 0xF0, 0x1F, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xC0, 0x07, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xFE, 0x1F,
  0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0x0F,
  0xFC, 0x7F, 0xF0, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x03, 0xFF, 0x3F, 0xF8,
  0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0xFF, 0xDF, 0xFC, 0x00, 0x07, 0xFE,
  0xFF, 0xE0, 0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x01, 0xFF, 0xBF, 0xF0, 0x00,
  0x1F, 0xFD, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x1F,
  0xFD, 0xFF, 0x80, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x07, 0xFE, 0x7F, 0xE0,
  0x00, 0x7F, 0xF3, 0xFF, 0x00, 0x03, 0xFF, 0x9F, 0xF8, 0x00, 0x3F, 0xF8,
  0xFF, 0xE0, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x01,
  0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x05, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF0,
  0x0F, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF8,
  0x1F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xFE, 0x1F, 0xFE, 0x00,
  0x7F, 0xF0, 0xFF, 0xE0, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0x0F, 0xFC, 0x7F,
  0xF0, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x03, 0xFF, 0x3F, 0xF8, 0x00, 0x1F,
  0xF9, 0xFF, 0xC0, 0x00, 0xFF, 0xDF, 0xFC, 0x00, 0x07, 0xFE, 0xFF, 0xE0,
  0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x1F, 0xFD,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xF7, 0xFF, 0x00, 0x01, 0xFF, 0xBF, 0xF8, 0x00, 0x1F, 0xFD, 0xFF,
  0x80, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x7F,
  0xF3, 0xFF, 0x00, 0x03, 0xFF, 0x9F, 0xF8, 0x00, 0x3F, 0xF8, 0xFF, 0xE0,
  0x03, 0xFF, 0xC7, 0xFF, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x01, 0xFF, 0xE0,
  0xFF, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F,
  0xF0, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x03,
  0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xE0, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xE3, 0xFF, 0x00,
  0x1F, 0xF8, 0xFF, 0xC0, 0x07, 0xFE, 0x3F, 0xF0, 0x01, 0xFF, 0x87, 0xFE,
  0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xF0, 0x0F, 0xFC, 0x0F,
  0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xE0,
  0x3F, 0xF8, 0x1F, 0xF8, 0x07, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0xC1, 0xFF,
  0x80, 0x7F, 0xF0, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xF0, 0x03, 0xFF, 0x8F,
  0xFC, 0x00, 0xFF, 0xE3, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x78,
  0x03, 0xFF, 0x80, 0x18, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x40, 0x00, 0x7F, 0xE0,
  0x60, 0x00, 0xFF, 0xE0, 0x78, 0x00, 0xFF, 0xE0, 0x7F, 0x03, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x7F, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x07,
  0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x3F,
  0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xFC,
  0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xE0,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0xE0,
  0x3F, 0xF0, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x1F, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x07, 0xFF, 0x3F, 0xE0, 0x00, 0xFF,
  0xC7, 0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x07, 0xFE, 0x1F, 0xF0, 0x00,
  0xFF, 0xC3, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x07, 0xFE, 0x0F, 0xF8,
  0x01, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x0F, 0xFC, 0x07,
  0xFC, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xE0, 0x0F, 0xFC, 0x0F,
  0xFC, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x07, 0xFE,
  0x1F, 0xF8, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x01,
  0xFF, 0x1F, 0xF8, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x07, 0xFC, 0xFF, 0xC0,
  0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x03, 0xFE, 0xFF,
  0x80, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xBF, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFD, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xCF, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xE3,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xF8, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0x87, 0xFE, 0x01, 0xFF, 0xF0,
  0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x80, 0xFF,
  0xFC, 0x07, 0xFE, 0x0F, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xE0, 0x7F, 0xE0,
  0x7F, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFC,
  0x07, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0x7F, 0x87,
  0xFE, 0x01, 0xFF, 0x07, 0xFB, 0xFC, 0x3F, 0xF0, 0x0F, 0xF8, 0x7F, 0x9F,
  0xE1, 0xFF, 0x00, 0x7F, 0xC3, 0xFC, 0xFF, 0x1F, 0xF8, 0x03, 0xFE, 0x3F,
  0xE7, 0xF8, 0xFF, 0x80, 0x1F, 0xF1, 0xFE, 0x3F, 0xCF, 0xFC, 0x00, 0x7F,
  0x8F, 0xF1, 0xFE, 0x7F, 0xC0, 0x03, 0xFC, 0xFF, 0x8F, 0xF3, 0xFE, 0x00,
  0x1F, 0xE7, 0xF8, 0x7F, 0xBF, 0xF0, 0x00, 0xFF, 0x7F, 0xC3, 0xFD, 0xFF,
  0x00, 0x07, 0xFB, 0xFC, 0x1F, 0xEF, 0xF8, 0x00, 0x3F, 0xDF, 0xE0, 0xFE,
  0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x07, 0xF7, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x3F, 0xBF, 0xC0, 0x00, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x00,
  0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x0F,
  0xFC, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x0F, 0xFE,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF3,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE3, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC1, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xDF, 0xF8, 0x00, 0xFF, 0xE7, 0xFE,
  0x00, 0x7F, 0xF1, 0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xE0, 0x0F, 0xFE, 0x0F,
  0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE0,
  0x3F, 0xF0, 0x3F, 0xF0, 0x07, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x07, 0xFE,
  0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x1F, 0xF9, 0xFF, 0xC0, 0x07, 0xFE, 0x7F,
  0xE0, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F,
  0xC1, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF8, 0x3F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81,
  0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF8,
  0x3F, 0xE0, 0xFF, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFF,
  0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x00,
  0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFD, 0xFE,
  0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x7F, 0x87, 0xF8,
  0x00, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xC0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x81, 0xFE, 0x00, 0x7F, 0x03,
  0xFC, 0x00, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0x7F,
  0x80, 0x03, 0xF9, 0xFE, 0x00, 0x07, 0xF7, 0xFC, 0x00, 0x0F, 0xF0, 0x7F,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xE3, 0xFF, 0x1F, 0xF8, 0x7F, 0xC1, 0xFF,
  0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0xFF, 0x00, 0x7F, 0xF1, 0xFF, 0x01, 0xFF, 0xF9, 0xFF, 0x03,
  0xFF, 0xFD, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFE, 0x1F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFC, 0x3F,
  0xF0, 0x0F, 0xF8, 0x7F, 0xF0, 0x0F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF8, 0x7F,
  0xE0, 0x1F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF0, 0xFF,
  0xC0, 0x1F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF,
  0xC0, 0x3F, 0xE0, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF,
  0xC0, 0xFF, 0xE0, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0x7F, 0xC0, 0x3F, 0xFE, 0x7F, 0x80, 0x1F, 0xFC, 0x7F, 0x80, 0x0F,
  0xF8, 0x7F, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x83, 0x80, 0x01,
  0xFF, 0x9F, 0xF0, 0x01, 0xFF, 0xBF, 0xF8, 0x01, 0xFF, 0x7F, 0xFC, 0x01,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xEF, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x07,
  0xFC, 0x03, 0xFF, 0x07, 0xFC, 0x03, 0xFF, 0x0F, 0xFC, 0x03, 0xFF, 0x0F,
  0xF8, 0x03, 0xFF, 0x0F, 0xF8, 0x03, 0xFF, 0x0F, 0xF8, 0x03, 0xFF, 0x0F,
  0xF8, 0x07, 0xFE, 0x1F, 0xF8, 0x07, 0xFE, 0x1F, 0xF8, 0x07, 0xFE, 0x1F,
  0xF8, 0x0F, 0xFE, 0x1F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F,
  0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFE, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xC0, 0x7F, 0x9F, 0xFF, 0x80, 0x7F, 0x8F, 0xFF, 0x00, 0xFF,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF,
  0x9F, 0x83, 0xFF, 0xC0, 0x60, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x83, 0xFF,
  0x80, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x30, 0x3F, 0xF0, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x1F,
  0xFC, 0xFF, 0xC0, 0x0F, 0xFF, 0xDF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xF7, 0xFF, 0xC0, 0x3F, 0xF8, 0x3F, 0xF8, 0x07, 0xFF, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE,
  0x01, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x07, 0xFC, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC,
  0x07, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xF0, 0x1F, 0xF8, 0x07,
  0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x07, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xF8, 0x7F, 0xF8, 0x07,
  0xFF, 0x9F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF7,
  0xF8, 0x00, 0x3F, 0xFC, 0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xF7, 0xFF, 0x0F, 0xFE, 0x0F, 0xF8,
  0xFF, 0xE0, 0x7F, 0xC7, 0xFE, 0x03, 0xFE, 0x7F, 0xE0, 0x1F, 0xF3, 0xFF,
  0x01, 0xFF, 0x9F, 0xF0, 0x1F, 0xF9, 0xFF, 0x83, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0xC0, 0xFF, 0xE0, 0x1E, 0x07, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x18, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0C, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x0F, 0xF0, 0x01, 0xFF, 0xC7, 0xFC, 0x01, 0xFF, 0xF9, 0xFF, 0x00, 0xFF,
  0xFF, 0x7F, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xE1, 0xFF, 0xC0,
  0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF,
  0x03, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xE0, 0x7F, 0xE0, 0x1F,
  0xF8, 0x1F, 0xF8, 0x07, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0x80,
  0x7F, 0xC0, 0xFF, 0xC0, 0x1F, 0xF0, 0x3F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFC,
  0x03, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x87, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xBF,
  0xE0, 0x01, 0xFF, 0xCF, 0xF8, 0x00, 0x3F, 0xC7, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0xC0, 0x01, 0xFF, 0x80, 0x3E,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0x83, 0xC0, 0x01, 0xFF, 0x8F, 0xF8, 0x01, 0xFF,
  0xBF, 0xFC, 0x01, 0xFF, 0x7F, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x07, 0xFF,
  0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFE,
  0x03, 0xFF, 0x0F, 0xFC, 0x03, 0xFF, 0x0F, 0xFC, 0x03, 0xFE, 0x0F, 0xFC,
  0x07, 0xFE, 0x0F, 0xFC, 0x07, 0xFE, 0x0F, 0xF8, 0x07, 0xFE, 0x1F, 0xF8,
  0x07, 0xFE, 0x1F, 0xF8, 0x07, 0xFC, 0x1F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF8,
  0x0F, 0xFC, 0x1F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0,
  0x0F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF8, 0x3F, 0xE0,
  0x1F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x7F, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x03,
  0x00, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x8F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x80, 0x3F, 0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xF8,
  0x1F, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x07, 0xFE, 0x1F, 0xFC, 0x00,
  0x3F, 0xF1, 0xFF, 0xC0, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0xFF,
  0xC0, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x3F,
  0xEF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xF9, 0xFF,
  0x80, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x1F, 0xF8, 0x7F, 0xF0, 0x00, 0xFF,
  0xC1, 0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xF0,
  0x01, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x7F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFE, 0x03,
  0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0xFF, 0x07,
  0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x8F, 0xFF, 0x07, 0xFF, 0x80, 0x3F, 0xCF,
  0xFF, 0xC7, 0xFF, 0xE0, 0x1F, 0xEF, 0xFF, 0xE7, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0x81, 0xFF,
  0xE1, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xE0, 0xFF,
  0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0x3F, 0xF8, 0x1F, 0xF8, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x1F,
  0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC1,
  0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE1, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0,
  0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE,
  0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x80, 0xFF,
  0xC1, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xFE, 0x0F, 0xF8, 0x01, 0xFE,
  0x3F, 0xFC, 0x01, 0xFE, 0x7F, 0xFE, 0x01, 0xFE, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x07, 0xFF,
  0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFE,
  0x03, 0xFF, 0x07, 0xFC, 0x03, 0xFF, 0x0F, 0xFC, 0x03, 0xFE, 0x0F, 0xFC,
  0x07, 0xFE, 0x0F, 0xFC, 0x07, 0xFE, 0x0F, 0xF8, 0x07, 0xFE, 0x1F, 0xF8,
  0x07, 0xFE, 0x1F, 0xF8, 0x07, 0xFC, 0x1F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF8,
  0x0F, 0xFC, 0x1F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0,
  0x0F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF8, 0x3F, 0xE0,
  0x1F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x7F, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x3F, 0xF8, 0x7F, 0xF0, 0x7F, 0xE1,
  0xFF, 0x80, 0xFF, 0xCF, 0xFE, 0x03, 0xFF, 0x3F, 0xF0, 0x0F, 0xFC, 0xFF,
  0xC0, 0x3F, 0xF7, 0xFE, 0x00, 0xFF, 0xDF, 0xF8, 0x03, 0xFF, 0x7F, 0xE0,
  0x0F, 0xFD, 0xFF, 0x80, 0x7F, 0xEF, 0xFC, 0x01, 0xFF, 0xBF, 0xF0, 0x07,
  0xFE, 0xFF, 0xC0, 0x1F, 0xFB, 0xFF, 0x00, 0x7F, 0xEF, 0xFC, 0x03, 0xFF,
  0x3F, 0xF0, 0x0F, 0xFC, 0xFF, 0xC0, 0x7F, 0xF3, 0xFF, 0x01, 0xFF, 0x8F,
  0xFE, 0x0F, 0xFE, 0x1F, 0xFC, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x00, 0xFF,
  0x1F, 0xFC, 0x00, 0x1F, 0xE7, 0xFF, 0xC0, 0x03, 0xFD, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xF9, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x81,
  0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xE0, 0x0F, 0xFC, 0x07, 0xFC, 0x01, 0xFF,
  0x80, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF,
  0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xFE, 0x1F, 0xFC, 0x03,
  0xFF, 0xEF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xDF, 0xFF, 0xC0, 0x0F, 0xF9, 0xFF,
  0xF0, 0x01, 0xFF, 0x3F, 0xFC, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x0F, 0xFC,
  0x0C, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0xFF,
  0x00, 0x7F, 0xF8, 0xFF, 0x00, 0xFF, 0xF9, 0xFE, 0x01, 0xFF, 0xFD, 0xFE,
  0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0x7F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC,
  0x3F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xF8,
  0x7F, 0xF0, 0x0F, 0xF8, 0x7F, 0xE0, 0x0F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF8,
  0x7F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0xFF, 0xC0, 0x1F, 0xF0,
  0xFF, 0xC0, 0x1F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x3F, 0xE0,
  0xFF, 0xC0, 0x3F, 0xE0, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xE0,
  0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFE, 0xFF, 0x80, 0x1F, 0xFC, 0xFF, 0x80, 0x0F, 0xF9, 0xFF, 0x80,
  0x01, 0xC1, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x3F, 0xC1, 0xFC, 0x07, 0xF8, 0xFF, 0x80, 0xFF,
  0x3F, 0xF0, 0x1F, 0xEF, 0xFC, 0x03, 0xFD, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF,
  0x82, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFC, 0x0F, 0xFC, 0x07, 0x81, 0xFF, 0x80, 0x20, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80,
  0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x10,
  0x00, 0x7F, 0xE3, 0x80, 0x1F, 0xFC, 0x7E, 0x07, 0xFF, 0x0F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x87, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x83, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x06, 0x80, 0x00, 0x07, 0xFE, 0x01,
  0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFC, 0x03, 0xFF, 0x07, 0xFC, 0x03,
  0xFF, 0x0F, 0xFC, 0x03, 0xFE, 0x0F, 0xFC, 0x03, 0xFE, 0x0F, 0xFC, 0x07,
  0xFE, 0x0F, 0xF8, 0x07, 0xFE, 0x1F, 0xF8, 0x07, 0xFE, 0x1F, 0xF8, 0x07,
  0xFC, 0x1F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF0, 0x0F,
  0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0x1F,
  0xF8, 0x3F, 0xF0, 0x1F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF8, 0x7F, 0xE0, 0x1F,
  0xF0, 0x7F, 0xE0, 0x3F, 0xF0, 0x7F, 0xE0, 0x3F, 0xF0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x7F, 0xC0, 0x7F, 0xF0, 0x7F, 0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF,
  0xE0, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xF7, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xBF, 0xC0, 0x7F, 0xFF, 0xBF,
  0xC0, 0x3F, 0xFF, 0x3F, 0xC0, 0x1F, 0xFE, 0x3F, 0x80, 0x0F, 0xF8, 0x3F,
  0x80, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFB, 0xFF, 0x00, 0x7F, 0xF3, 0xFE, 0x00, 0xFF, 0xC7, 0xFC, 0x03, 0xFF,
  0x8F, 0xF8, 0x07, 0xFE, 0x1F, 0xF0, 0x0F, 0xFC, 0x3F, 0xE0, 0x3F, 0xF0,
  0x7F, 0xC0, 0x7F, 0xE0, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x03, 0xFF, 0x03,
  0xFE, 0x0F, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0xE0, 0x0F,
  0xF0, 0xFF, 0x80, 0x1F, 0xE3, 0xFF, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x7F,
  0x8F, 0xF8, 0x00, 0xFF, 0x3F, 0xE0, 0x01, 0xFE, 0x7F, 0xC0, 0x03, 0xFD,
  0xFF, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFD, 0xFF, 0x01,
  0xFF, 0xE0, 0x7F, 0xEF, 0xF8, 0x1F, 0xFE, 0x03, 0xFE, 0x7F, 0xC0, 0xFF,
  0xF0, 0x1F, 0xF3, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0x9F, 0xF0, 0x7F, 0xFC,
  0x0F, 0xF8, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xC7, 0xFC, 0x3F, 0xFF, 0x07,
  0xFC, 0x3F, 0xE1, 0xFF, 0xF8, 0x7F, 0xE1, 0xFF, 0x1F, 0xFF, 0xC3, 0xFE,
  0x0F, 0xF8, 0xFE, 0xFE, 0x1F, 0xF0, 0x7F, 0xC7, 0xF7, 0xF1, 0xFF, 0x03,
  0xFE, 0x7F, 0xBF, 0x8F, 0xF8, 0x1F, 0xF3, 0xF9, 0xFC, 0xFF, 0xC0, 0xFF,
  0x9F, 0xCF, 0xE7, 0xFC, 0x07, 0xFD, 0xFC, 0x7F, 0x3F, 0xE0, 0x3F, 0xEF,
  0xE3, 0xFB, 0xFE, 0x01, 0xFE, 0xFF, 0x1F, 0xDF, 0xF0, 0x0F, 0xF7, 0xF0,
  0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0x87, 0xFF, 0xF8, 0x03, 0xFD, 0xF8, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x00,
  0x7F, 0xFC, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x1F,
  0xFE, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xF8,
  0x00, 0x7F, 0xE1, 0xFF, 0xC0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x03, 0xFF,
  0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x3F, 0xF7, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xBF, 0xE0, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x7F, 0xF3, 0xFF,
  0x00, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x7F,
  0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x03,
  0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x3F,
  0xF0, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x00, 0x7F, 0xC3, 0xFF,
  0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x7F, 0xE0, 0x00, 0x1F,
  0xF1, 0xFF, 0x00, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x01, 0xFF, 0x3F, 0xE0,
  0x00, 0x07, 0xFD, 0xFF, 0x80, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00, 0x3F,
  0xDF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x87, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x0B, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xE4, 0x00, 0x0F, 0xFE, 0x20, 0x00,
  0x01, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBoldItalic62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 20, 45, 17, 0, -44 },
  { 114, 24, 16, 27, 6, -44 },
  { 162, 37, 44, 37, 1, -44 },
  { 366, 32, 51, 32, 1, -47 },
  { 570, 47, 46, 52, 3, -45 },
  { 841, 40, 46, 41, 1, -45 },
  { 1071, 11, 16, 15, 6, -44 },
  { 1093, 23, 55, 20, 2, -45 },
  { 1252, 23, 55, 20, -4, -45 },
  { 1411, 28, 30, 31, 5, -48 },
  { 1516, 29, 30, 34, 3, -37 },
  { 1625, 15, 16, 17, -3, -8 },
  { 1655, 17, 9, 20, 1, -21 },
  { 1675, 11, 11, 17, 0, -10 },
  { 1691, 34, 46, 26, -3, -45 },
  { 1887, 30, 46, 32, 2, -45 },
  { 2060, 25, 44, 32, 5, -44 },
  { 2198, 34, 45, 32, -2, -45 },
  { 2390, 32, 46, 32, 0, -45 },
  { 2574, 33, 44, 32, -1, -44 },
  { 2756, 32, 45, 32, 1, -44 },
  { 2936, 32, 46, 32, 2, -45 },
  { 3120, 33, 44, 32, 2, -44 },
  { 3302, 31, 46, 32, 1, -45 },
  { 3481, 30, 46, 32, 2, -45 },
  { 3654, 17, 36, 17, 0, -35 },
  { 3731, 20, 43, 17, -3, -35 },
  { 3839, 29, 32, 34, 3, -38 },
  { 3955, 29, 20, 34, 3, -32 },
  { 4028, 29, 32, 34, 3, -38 },
  { 4144, 25, 46, 27, 4, -45 },
  { 4288, 47, 50, 50, 2, -45 },
  { 4582, 37, 44, 37, -4, -44 },
  { 4786, 35, 44, 36, 1, -44 },
  { 4979, 35, 46, 35, 3, -45 },
  { 5181, 36, 44, 39, 1, -44 },
  { 5379, 32, 44, 31, 1, -44 },
  { 5555, 32, 44, 31, 1, -44 },
  { 5731, 37, 46, 39, 3, -45 },
  { 5944, 40, 44, 40, 1, -44 },
  { 6164, 29, 44, 24, -2, -44 },
  { 6324, 31, 58, 20, -10, -44 },
  { 6549, 41, 44, 36, 1, -44 },
  { 6775, 25, 44, 29, 1, -44 },
  { 6913, 51, 44, 51, 1, -44 },
  { 7194, 44, 44, 44, 1, -44 },
  { 7436, 37, 46, 41, 3, -45 },
  { 7649, 35, 44, 35, 1, -44 },
  { 7842, 37, 56, 41, 3, -45 },
  { 8101, 34, 44, 36, 1, -44 },
  { 8288, 32, 46, 31, 0, -45 },
  { 8472, 30, 44, 31, 5, -44 },
  { 8637, 38, 45, 39, 3, -44 },
  { 8851, 35, 44, 35, 5, -44 },
  { 9044, 53, 44, 52, 5, -44 },
  { 9336, 44, 44, 36, -4, -44 },
  { 9578, 34, 44, 33, 5, -44 },
  { 9765, 36, 44, 30, -2, -44 },
  { 9963, 26, 55, 20, -2, -45 },
  { 10142, 14, 46, 26, 7, -45 },
  { 10223, 26, 55, 20, -4, -45 },
  { 10402, 31, 28, 32, 0, -44 },
  { 10511, 26, 5, 25, -6, 5 },
  { 10528, 13, 9, 20, 9, -47 },
  { 10543, 32, 36, 34, 2, -35 },
  { 10687, 32, 48, 34, 0, -47 },
  { 10879, 27, 36, 28, 2, -35 },
  { 11001, 35, 48, 34, 2, -47 },
  { 11211, 29, 36, 32, 2, -35 },
  { 11342, 36, 62, 22, -7, -47 },
  { 11621, 34, 50, 34, 0, -35 },
  { 11834, 32, 47, 35, 0, -47 },
  { 12022, 20, 48, 18, 0, -48 },
  { 12142, 28, 63, 18, -8, -48 },
  { 12363, 37, 47, 33, 0, -47 },
  { 12581, 20, 47, 18, 0, -47 },
  { 12699, 49, 35, 52, 0, -35 },
  { 12914, 32, 35, 35, 0, -35 },
  { 13054, 30, 36, 34, 2, -35 },
  { 13189, 35, 50, 34, -3, -35 },
  { 13408, 32, 50, 34, 2, -35 },
  { 13608, 27, 35, 24, 0, -35 },
  { 13727, 27, 36, 28, 0, -35 },
  { 13849, 22, 42, 24, 3, -41 },
  { 13965, 32, 35, 35, 2, -34 },
  { 14105, 31, 34, 30, 3, -34 },
  { 14237, 45, 34, 46, 4, -34 },
  { 14429, 38, 34, 31, -3, -34 },
  { 14591, 38, 49, 31, -4, -34 },
  { 14824, 30, 34, 27, -2, -34 },
  { 14952, 26, 54, 22, 0, -44 },
  { 15128, 8, 61, 31, 11, -47 },
  { 15189, 25, 54, 22, -3, -44 },
  { 15358, 29, 11, 34, 3, -27 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBoldItalic62pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBoldItalic62pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBoldItalic62pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC62PT7B_H_
