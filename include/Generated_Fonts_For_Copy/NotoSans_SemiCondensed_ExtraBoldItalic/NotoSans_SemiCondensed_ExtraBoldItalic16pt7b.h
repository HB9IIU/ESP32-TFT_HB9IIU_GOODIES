#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC16PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBoldItalic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBoldItalic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0xCC, 0x67, 0x39, 0x80, 0x47, 0x38, 0x6E, 0xD9, 0xB6, 0x60,
  0x0D, 0x82, 0x61, 0xB1, 0xFF, 0x1B, 0x0C, 0x8F, 0xFB, 0xFE, 0x24, 0x1B,
  0x06, 0xC0, 0x04, 0x1F, 0x3F, 0x35, 0x38, 0x3C, 0x1E, 0x0F, 0x8F, 0xFE,
  0xFE, 0x10, 0x10, 0x30, 0x27, 0x8C, 0xD9, 0x8D, 0x98, 0xDB, 0x0D, 0xEE,
  0xF7, 0xF6, 0xDB, 0x19, 0xB1, 0x93, 0x31, 0xE6, 0x1C, 0x06, 0x07, 0xC3,
  0xB0, 0xEC, 0x3F, 0x07, 0x83, 0xCD, 0xBF, 0xE7, 0xB9, 0xCF, 0xF9, 0xFF,
  0x6D, 0xE0, 0x0C, 0x71, 0x8C, 0x31, 0x86, 0x18, 0x63, 0x8E, 0x18, 0x61,
  0x86, 0x00, 0x18, 0x61, 0xC3, 0x0C, 0x31, 0xC7, 0x18, 0x63, 0x8C, 0x71,
  0x8C, 0x00, 0x1C, 0xB3, 0xE9, 0xF3, 0x8D, 0x8B, 0x00, 0x30, 0x60, 0xC7,
  0xFF, 0xE6, 0x0C, 0x18, 0x77, 0x6C, 0xFF, 0x80, 0x5F, 0x80, 0x01, 0x81,
  0x80, 0xC0, 0xC0, 0xE0, 0x60, 0x70, 0x30, 0x38, 0x18, 0x18, 0x1C, 0x00,
  0x04, 0x1F, 0x3F, 0x73, 0x73, 0x63, 0x67, 0x67, 0xE7, 0x6E, 0x7C, 0x78,
  0x1E, 0x7B, 0xF3, 0xE1, 0xC3, 0x06, 0x0C, 0x38, 0x70, 0xC0, 0x0C, 0x3F,
  0x7F, 0x23, 0x07, 0x06, 0x0E, 0x1C, 0x38, 0x60, 0xFE, 0xFE, 0x0C, 0x3F,
  0x3F, 0x03, 0x07, 0x1E, 0x3E, 0x06, 0x06, 0x8E, 0xFE, 0xFC, 0x07, 0x0F,
  0x0F, 0x1E, 0x36, 0x66, 0xEE, 0xFF, 0xFF, 0x0C, 0x1C, 0x1F, 0x3F, 0x30,
  0x30, 0x7E, 0x7E, 0x07, 0x06, 0x8E, 0xFE, 0xFC, 0x07, 0x3E, 0x7E, 0x60,
  0xE8, 0xDC, 0xFE, 0xCE, 0xCE, 0xCC, 0xFC, 0x78, 0x3F, 0xBF, 0xC1, 0xC0,
  0xC0, 0xE0, 0x60, 0x70, 0x70, 0x38, 0x38, 0x3C, 0x00, 0x0C, 0x1F, 0x3B,
  0x33, 0x37, 0x3E, 0x3E, 0x76, 0xE7, 0xE6, 0xFE, 0x7C, 0x0C, 0x3E, 0x3F,
  0x73, 0x63, 0x77, 0x7F, 0x3F, 0x06, 0x0E, 0xFC, 0xF8, 0x37, 0x30, 0x00,
  0x4E, 0xE0, 0x19, 0xC6, 0x00, 0x00, 0x0E, 0x63, 0x30, 0x02, 0x1C, 0xF7,
  0x8E, 0x0F, 0x07, 0x83, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x81, 0xC1, 0xE0,
  0xF0, 0xE7, 0xBC, 0x60, 0x13, 0xF7, 0xC3, 0x1C, 0xE7, 0x18, 0x01, 0x0E,
  0x38, 0x02, 0x01, 0xFC, 0x30, 0x66, 0x22, 0xCF, 0xBD, 0x93, 0xDB, 0x29,
  0x36, 0xB3, 0x69, 0xFC, 0xC0, 0x0E, 0x10, 0x7F, 0x00, 0x07, 0x81, 0xE0,
  0xD8, 0x36, 0x1D, 0x86, 0x63, 0xF8, 0xFE, 0x71, 0x98, 0x6E, 0x1C, 0x3F,
  0x9F, 0xCE, 0x66, 0x73, 0xF3, 0xF9, 0xCC, 0xC6, 0x67, 0x3F, 0xBF, 0x00,
  0x06, 0x1F, 0xDF, 0xCE, 0x0E, 0x07, 0x03, 0x81, 0x80, 0xC0, 0x71, 0x3F,
  0x8F, 0xC0, 0x3F, 0x0F, 0xE3, 0x9C, 0xC7, 0x31, 0xDC, 0x67, 0x39, 0xCE,
  0x67, 0x1F, 0x8F, 0xC0, 0x3F, 0x9F, 0x8E, 0x06, 0x03, 0xE3, 0xF1, 0xC0,
  0xE0, 0x60, 0x3F, 0x3F, 0x00, 0x3F, 0x9F, 0x8E, 0x06, 0x03, 0xE3, 0xF1,
  0xF8, 0xE0, 0x60, 0x30, 0x38, 0x00, 0x06, 0x0F, 0xCF, 0xEE, 0x0E, 0x07,
  0x7F, 0xBD, 0x9E, 0xC7, 0x73, 0xBF, 0xCF, 0xC0, 0x38, 0xE7, 0x18, 0xE7,
  0x18, 0xE3, 0xFC, 0xFF, 0x1C, 0x63, 0x9C, 0x63, 0x8C, 0x73, 0x8C, 0x00,
  0x1F, 0x0E, 0x0C, 0x1C, 0x1C, 0x18, 0x18, 0x18, 0x38, 0x7C, 0xFC, 0x03,
  0x07, 0x07, 0x07, 0x06, 0x06, 0x0E, 0x0E, 0x0C, 0x0C, 0x1C, 0x1C, 0x78,
  0xF8, 0x39, 0xE7, 0x70, 0xEC, 0x1B, 0x83, 0xE0, 0xFC, 0x1F, 0x83, 0x30,
  0x67, 0x0C, 0xE3, 0x9C, 0x00, 0x38, 0x70, 0xE1, 0x83, 0x0E, 0x1C, 0x38,
  0x60, 0xFF, 0xF0, 0x3C, 0x3C, 0xF1, 0xE3, 0xC7, 0x8F, 0x3E, 0x3C, 0xF1,
  0xF6, 0xC6, 0xDB, 0x1B, 0xDC, 0x6F, 0x71, 0xB9, 0x8E, 0xE6, 0x00, 0x3C,
  0x73, 0xC6, 0x3C, 0x63, 0xEE, 0x3E, 0xC7, 0x6C, 0x66, 0xC6, 0x7C, 0x63,
  0xC6, 0x38, 0xE3, 0x80, 0x06, 0x1F, 0x9F, 0xEE, 0x3E, 0x1F, 0x0F, 0x8F,
  0x87, 0xC3, 0xF3, 0xBF, 0x8F, 0x80, 0x3F, 0x1F, 0xCE, 0x66, 0x33, 0x3B,
  0xF9, 0xF8, 0xC0, 0x60, 0x30, 0x38, 0x00, 0x06, 0x1F, 0x9F, 0xEE, 0x3E,
  0x1F, 0x0F, 0x8F, 0x87, 0xC3, 0xF3, 0xBF, 0x8F, 0x80, 0xC0, 0x70, 0x1C,
  0x3F, 0x1F, 0xCE, 0xE6, 0x73, 0x7B, 0xF9, 0xF8, 0xCC, 0x67, 0x33, 0xB9,
  0xC0, 0x0C, 0x3F, 0x3F, 0x70, 0x30, 0x38, 0x1C, 0x0E, 0x0E, 0x8E, 0xFC,
  0xF8, 0x7F, 0xFF, 0x38, 0x38, 0x38, 0x30, 0x30, 0x70, 0x70, 0x70, 0x60,
  0x71, 0xB9, 0xDC, 0xEC, 0x7E, 0x37, 0x1B, 0x9D, 0x8E, 0xE6, 0x7F, 0x1F,
  0x00, 0xE3, 0xF1, 0x99, 0xCC, 0xC6, 0xE3, 0x71, 0xB0, 0xF8, 0x78, 0x3C,
  0x1C, 0x00, 0xE3, 0x1F, 0x9C, 0x6E, 0x73, 0xBB, 0xCC, 0xEF, 0x73, 0xFD,
  0x8F, 0xB6, 0x3E, 0xF8, 0xF3, 0xC3, 0xCF, 0x0F, 0x38, 0x00, 0x1C, 0xE3,
  0xB8, 0x76, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0xC1, 0xD8, 0x3B, 0x0E, 0x73,
  0x8E, 0x00, 0xE3, 0xB3, 0x9B, 0x8F, 0x87, 0xC1, 0xC0, 0xE0, 0x60, 0x30,
  0x38, 0x1C, 0x00, 0x1F, 0xCF, 0xE0, 0x38, 0x1C, 0x0E, 0x07, 0x01, 0xC0,
  0xE0, 0x70, 0x1F, 0xCF, 0xF0, 0x1C, 0xF3, 0x0C, 0x31, 0xC6, 0x18, 0x61,
  0x8E, 0x30, 0xC3, 0xCE, 0x00, 0xCC, 0xCC, 0xCE, 0x66, 0x66, 0x67, 0x1E,
  0x38, 0x30, 0x60, 0xC3, 0x86, 0x0C, 0x18, 0x30, 0xC1, 0x83, 0x1E, 0x3C,
  0x00, 0x0C, 0x1E, 0x1E, 0x36, 0x36, 0x63, 0xC3, 0xFF, 0xF0, 0xE7, 0x3B,
  0x7F, 0xEE, 0xE6, 0xCE, 0xCE, 0xCC, 0xFC, 0xEC, 0x18, 0x38, 0x38, 0x36,
  0x3F, 0x73, 0x73, 0x63, 0x67, 0x67, 0xFE, 0xDC, 0x3E, 0xFB, 0x97, 0x0C,
  0x18, 0x31, 0x7C, 0x78, 0x03, 0x03, 0x07, 0x3F, 0x7E, 0xEE, 0xE6, 0xCE,
  0xCE, 0xCC, 0xFC, 0xEC, 0x3C, 0xFF, 0x9E, 0x7F, 0xDC, 0x30, 0x7E, 0x7C,
  0x07, 0x83, 0xC3, 0x81, 0xE1, 0xF0, 0x60, 0x30, 0x38, 0x1C, 0x0E, 0x06,
  0x03, 0x03, 0x81, 0xC3, 0xC1, 0xC0, 0x1D, 0x9F, 0xDD, 0xCE, 0x66, 0x73,
  0x39, 0x98, 0xFC, 0x76, 0x07, 0x23, 0x1F, 0x8F, 0x80, 0x18, 0x38, 0x38,
  0x37, 0x3F, 0x73, 0x73, 0x73, 0x67, 0x67, 0xE6, 0xE6, 0x39, 0xC0, 0x73,
  0x39, 0xCE, 0x63, 0x39, 0xC0, 0x06, 0x1C, 0x00, 0x70, 0xC3, 0x87, 0x0E,
  0x18, 0x30, 0xE1, 0xC3, 0x86, 0x3C, 0x70, 0x18, 0x1C, 0x0E, 0x06, 0x73,
  0x33, 0xB1, 0xF8, 0xF8, 0x7C, 0x37, 0x39, 0x9C, 0xE0, 0x19, 0xCE, 0x63,
  0x39, 0xCE, 0x63, 0x39, 0xC0, 0x37, 0x71, 0xFF, 0xDC, 0xEE, 0xE6, 0x77,
  0x73, 0x33, 0x99, 0x9C, 0xDC, 0xCE, 0xE6, 0x70, 0x37, 0x3F, 0x73, 0x73,
  0x73, 0x67, 0x67, 0xE6, 0xE6, 0x3C, 0xFF, 0x9F, 0x3C, 0x79, 0xF3, 0xFE,
  0x78, 0x1B, 0x0F, 0xCE, 0x67, 0x33, 0x19, 0x9C, 0xCE, 0xFE, 0x7E, 0x30,
  0x18, 0x0C, 0x0E, 0x00, 0x3B, 0x7E, 0xEE, 0xE6, 0xCE, 0xCE, 0xCC, 0xFC,
  0xEC, 0x1C, 0x1C, 0x18, 0x18, 0x36, 0x7D, 0xF3, 0x87, 0x0C, 0x18, 0x70,
  0xE0, 0x3C, 0xFD, 0xCB, 0x83, 0xC3, 0xA3, 0x7E, 0xF8, 0x30, 0xC7, 0xFE,
  0x63, 0x8E, 0x30, 0xC3, 0xCF, 0x00, 0x67, 0x67, 0xE6, 0xE6, 0xCE, 0xCE,
  0xCE, 0xFC, 0xEC, 0xC7, 0xCE, 0xCE, 0xCC, 0xDC, 0xD8, 0xF8, 0x70, 0x70,
  0xCE, 0x7C, 0xE6, 0xCE, 0xED, 0xEC, 0xDE, 0xCF, 0x78, 0xF7, 0x8E, 0x78,
  0xE7, 0x00, 0x39, 0xC6, 0xE1, 0xB0, 0x78, 0x0E, 0x07, 0x83, 0xE1, 0xDC,
  0xE7, 0x00, 0x31, 0xCC, 0x63, 0x38, 0xEC, 0x3F, 0x0F, 0x81, 0xE0, 0x70,
  0x1C, 0x06, 0x03, 0x83, 0xC0, 0xE0, 0x00, 0x3E, 0xFC, 0x30, 0xE3, 0x8E,
  0x18, 0x7E, 0xFC, 0x1E, 0x38, 0x61, 0xC3, 0x9E, 0x30, 0x70, 0x70, 0xC1,
  0x83, 0x87, 0x02, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x18, 0x78, 0x70, 0xC1,
  0x83, 0xC3, 0x1E, 0x30, 0x60, 0xC3, 0x8E, 0x10, 0x00, 0xF3, 0xFE, 0x30,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBoldItalic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 11, 4, 0, -11 },
  { 8, 7, 4, 7, 1, -11 },
  { 12, 10, 11, 9, 0, -11 },
  { 26, 8, 13, 8, 0, -12 },
  { 39, 12, 12, 13, 1, -12 },
  { 57, 10, 12, 11, 0, -12 },
  { 72, 3, 4, 4, 1, -11 },
  { 74, 6, 15, 5, 0, -12 },
  { 86, 6, 15, 5, -1, -12 },
  { 98, 7, 7, 8, 1, -12 },
  { 105, 7, 8, 9, 1, -10 },
  { 112, 4, 4, 4, -1, -2 },
  { 114, 5, 2, 5, 0, -5 },
  { 116, 3, 3, 4, 0, -3 },
  { 118, 9, 12, 7, -1, -12 },
  { 132, 8, 12, 8, 0, -12 },
  { 144, 7, 11, 8, 1, -11 },
  { 154, 8, 12, 8, 0, -12 },
  { 166, 8, 12, 8, 0, -12 },
  { 178, 8, 11, 8, 0, -11 },
  { 189, 8, 11, 8, 0, -11 },
  { 200, 8, 12, 8, 1, -12 },
  { 212, 9, 11, 8, 0, -11 },
  { 225, 8, 12, 8, 0, -12 },
  { 237, 8, 12, 8, 0, -12 },
  { 249, 4, 9, 4, 0, -9 },
  { 254, 5, 11, 4, -1, -9 },
  { 261, 7, 8, 9, 1, -10 },
  { 268, 7, 5, 9, 1, -8 },
  { 273, 7, 8, 9, 1, -10 },
  { 280, 6, 12, 7, 1, -12 },
  { 289, 12, 13, 13, 1, -12 },
  { 309, 10, 11, 10, -1, -11 },
  { 323, 9, 11, 9, 0, -11 },
  { 336, 9, 12, 9, 1, -12 },
  { 350, 10, 11, 10, 0, -11 },
  { 364, 9, 11, 8, 0, -11 },
  { 377, 9, 11, 8, 0, -11 },
  { 390, 9, 12, 10, 1, -12 },
  { 404, 11, 11, 10, 0, -11 },
  { 420, 8, 11, 6, -1, -11 },
  { 431, 8, 14, 5, -3, -11 },
  { 445, 11, 11, 9, 0, -11 },
  { 461, 7, 11, 8, 0, -11 },
  { 471, 14, 11, 13, 0, -11 },
  { 491, 12, 11, 11, 0, -11 },
  { 508, 9, 12, 11, 1, -12 },
  { 522, 9, 11, 9, 0, -11 },
  { 535, 9, 15, 11, 1, -12 },
  { 552, 9, 11, 9, 0, -11 },
  { 565, 8, 12, 8, 0, -12 },
  { 577, 8, 11, 8, 1, -11 },
  { 588, 9, 11, 10, 1, -11 },
  { 601, 9, 11, 9, 1, -11 },
  { 614, 14, 11, 13, 1, -11 },
  { 634, 11, 11, 9, -1, -11 },
  { 650, 9, 11, 9, 1, -11 },
  { 663, 10, 11, 8, -1, -11 },
  { 677, 6, 15, 5, 0, -12 },
  { 689, 4, 12, 7, 2, -12 },
  { 695, 7, 15, 5, -1, -12 },
  { 709, 8, 7, 8, 0, -11 },
  { 716, 6, 2, 6, -1, 1 },
  { 718, 4, 2, 5, 2, -12 },
  { 719, 8, 9, 9, 1, -9 },
  { 728, 8, 12, 9, 0, -12 },
  { 740, 7, 9, 7, 1, -9 },
  { 748, 8, 12, 9, 1, -12 },
  { 760, 7, 9, 8, 1, -9 },
  { 768, 9, 16, 6, -2, -12 },
  { 786, 9, 13, 9, 0, -9 },
  { 801, 8, 12, 9, 0, -12 },
  { 813, 5, 12, 5, 0, -12 },
  { 821, 7, 16, 5, -2, -12 },
  { 835, 9, 12, 9, 0, -12 },
  { 849, 5, 12, 5, 0, -12 },
  { 857, 13, 9, 13, 0, -9 },
  { 872, 8, 9, 9, 0, -9 },
  { 881, 7, 9, 9, 1, -9 },
  { 889, 9, 13, 9, -1, -9 },
  { 904, 8, 13, 9, 1, -9 },
  { 917, 7, 9, 6, 0, -9 },
  { 925, 7, 9, 7, 0, -9 },
  { 933, 6, 11, 6, 1, -11 },
  { 942, 8, 9, 9, 1, -9 },
  { 951, 8, 9, 8, 1, -9 },
  { 960, 12, 9, 12, 1, -9 },
  { 974, 10, 9, 8, -1, -9 },
  { 986, 10, 13, 8, -1, -9 },
  { 1003, 7, 9, 7, 0, -9 },
  { 1011, 7, 14, 6, 0, -11 },
  { 1024, 2, 16, 8, 3, -12 },
  { 1028, 7, 14, 6, -1, -11 },
  { 1041, 7, 3, 9, 1, -7 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBoldItalic16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBoldItalic16pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBoldItalic16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC16PT7B_H_
