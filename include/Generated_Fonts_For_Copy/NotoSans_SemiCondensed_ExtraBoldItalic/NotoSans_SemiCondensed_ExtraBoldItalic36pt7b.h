#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC36PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBoldItalic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBoldItalic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC1, 0xF8, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0xFC, 0x3F, 0x87, 0xF0, 0xFC, 0x0F,
  0x80, 0x3E, 0x7C, 0xF9, 0xF7, 0xC7, 0xDF, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0x8F, 0x9E, 0x3C, 0x78, 0xF3, 0xC3, 0xC0, 0x00, 0x78, 0xF0, 0x01, 0xE3,
  0xC0, 0x07, 0x8F, 0x00, 0x3E, 0x7C, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80,
  0x0F, 0x1E, 0x07, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF3, 0xFF,
  0xFF, 0xC0, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x1F, 0x1E, 0x00, 0x78, 0xF0,
  0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x03,
  0xC7, 0x80, 0x1F, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x8F,
  0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x0F, 0xE0, 0x0F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF8, 0x7D,
  0xCC, 0x3F, 0x70, 0x0F, 0xD8, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF0,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0,
  0x19, 0xF2, 0x06, 0x7C, 0xE1, 0xBF, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF,
  0xF0, 0xFF, 0xF0, 0x03, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x00, 0x07, 0xC0, 0x0F, 0x03, 0xFC, 0x03, 0xE0, 0xFF, 0xC0, 0x78, 0x1F,
  0xF8, 0x1E, 0x07, 0xCF, 0x07, 0xC0, 0xF1, 0xE1, 0xF0, 0x1E, 0x3C, 0x3C,
  0x07, 0xC7, 0x8F, 0x00, 0xF9, 0xF3, 0xE0, 0x1E, 0x3E, 0x78, 0x03, 0xC7,
  0x9E, 0x3C, 0x79, 0xF7, 0xCF, 0xEF, 0xFC, 0xF3, 0xFD, 0xFF, 0xBC, 0xFF,
  0xDF, 0xEF, 0xBE, 0x79, 0xF1, 0xE7, 0x8F, 0x00, 0x78, 0xF1, 0xE0, 0x1F,
  0x3E, 0x3C, 0x03, 0xC7, 0xCF, 0x80, 0xF0, 0xF1, 0xF0, 0x3E, 0x1E, 0x3C,
  0x07, 0x83, 0xCF, 0x81, 0xE0, 0x7F, 0xF0, 0x7C, 0x0F, 0xFC, 0x0F, 0x00,
  0xFF, 0x03, 0xC0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xE7, 0xE0, 0x07, 0xE3, 0xE0, 0x07,
  0xC3, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xEF, 0xC0, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0x0F, 0xFC, 0x7E, 0x1F,
  0xFC, 0x7E, 0x3F, 0x7E, 0xFC, 0x7E, 0x7F, 0xFC, 0x7E, 0x3F, 0xF8, 0x7C,
  0x3F, 0xF0, 0xFC, 0x1F, 0xF0, 0xFE, 0x0F, 0xE0, 0x7F, 0x3F, 0xE0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xF1, 0xFC, 0x3E,
  0x7D, 0xF3, 0xE7, 0xCF, 0x9E, 0x3C, 0x79, 0xE0, 0x00, 0xF8, 0x0F, 0x80,
  0xF8, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF8,
  0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0xC0,
  0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01,
  0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x07,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x01, 0x00, 0x01, 0xF0,
  0x01, 0xE0, 0x01, 0xE0, 0x61, 0xE0, 0x79, 0xC0, 0xFF, 0xC7, 0xFF, 0xFF,
  0x3F, 0xFF, 0x07, 0xFF, 0x0F, 0xEF, 0x1F, 0xE0, 0x3F, 0xF0, 0x7C, 0xF0,
  0x3C, 0xF8, 0x18, 0xF8, 0x08, 0x60, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x1F, 0x8F, 0x8F, 0xC7, 0xC3, 0xE3, 0xE1, 0xF0,
  0xF0, 0xF8, 0x00, 0x7F, 0xEF, 0xF9, 0xFF, 0x3F, 0xEF, 0xFC, 0x3C, 0xFB,
  0xFF, 0xFF, 0xDF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x87, 0xE3, 0xE3, 0xF0,
  0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0xDF, 0x83, 0xF7, 0xE0, 0xF9, 0xF8, 0x3E,
  0x7C, 0x1F, 0xBF, 0x07, 0xEF, 0xC1, 0xFB, 0xF0, 0x7E, 0xFC, 0x3F, 0x3F,
  0x0F, 0xCF, 0xC3, 0xF3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0xFF, 0x07, 0xFF,
  0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0x7C, 0x03, 0xF0,
  0x3F, 0xC1, 0xFF, 0x0F, 0xFC, 0xFF, 0xE7, 0xFF, 0xBF, 0xFE, 0x7D, 0xF8,
  0xC7, 0xC2, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x0F,
  0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0x8F, 0xC0, 0xC1, 0xF8, 0x10,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0x1F, 0xFF,
  0xE7, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0xFF,
  0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x0C, 0x1F, 0xC0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x03, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC8, 0x03, 0xF1, 0xF3, 0xFE,
  0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xEF, 0x80, 0x7F, 0xF0, 0x1F, 0x7E,
  0x07, 0xCF, 0x80, 0xF1, 0xF0, 0x3E, 0x7E, 0x0F, 0x8F, 0xC3, 0xE1, 0xF0,
  0x7F, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xFC,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x02, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x8C,
  0x07, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0x07,
  0xFF, 0xC3, 0xF8, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x9F,
  0x07, 0xEF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xE1, 0xFB,
  0xF8, 0x7E, 0xFC, 0x1F, 0xBF, 0x07, 0xCF, 0xC3, 0xF3, 0xF0, 0xFC, 0x7C,
  0x3F, 0x1F, 0xBF, 0x87, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x03, 0xF8,
  0x00, 0x1F, 0xFF, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F,
  0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F,
  0xF8, 0x3F, 0xFE, 0x1F, 0xDF, 0xC7, 0xE3, 0xF1, 0xF0, 0xFC, 0x7C, 0x3F,
  0x1F, 0x8F, 0x87, 0xE7, 0xE0, 0xFF, 0xF0, 0x3F, 0xF0, 0x07, 0xF8, 0x07,
  0xFF, 0x03, 0xFF, 0xE1, 0xFD, 0xF8, 0xFC, 0x3F, 0x3F, 0x0F, 0xCF, 0x81,
  0xF3, 0xE0, 0xFC, 0xF8, 0x3F, 0x3F, 0x1F, 0x8F, 0xFF, 0xE1, 0xFF, 0xF0,
  0x7F, 0xF8, 0x07, 0xFC, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC3,
  0xFF, 0xE1, 0xFF, 0xF9, 0xF8, 0xFC, 0xFC, 0x3E, 0xFC, 0x1F, 0x7E, 0x0F,
  0xBF, 0x0F, 0xDF, 0x87, 0xEF, 0xC7, 0xF7, 0xF7, 0xFB, 0xFF, 0xFC, 0xFF,
  0xFE, 0x7F, 0xBE, 0x0F, 0xBF, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0,
  0x0F, 0xC6, 0x3F, 0xC3, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0x80,
  0x00, 0x07, 0x83, 0xF1, 0xFC, 0x7F, 0x1F, 0x83, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC1, 0xF0, 0xFE, 0x3F, 0x8F,
  0xC3, 0xF0, 0x01, 0xE0, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C,
  0x0F, 0x80, 0xF8, 0x00, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x7F,
  0x01, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0xFF, 0x80, 0xFE, 0x00, 0xFC, 0x00,
  0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x3F,
  0x00, 0x0F, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x3F,
  0x01, 0xFF, 0x07, 0xFE, 0x3F, 0xF8, 0xFF, 0xC0, 0xFF, 0x00, 0xFC, 0x00,
  0xF0, 0x00, 0xC0, 0x00, 0x07, 0xF0, 0x7F, 0xF1, 0xFF, 0xF3, 0xFF, 0xE3,
  0xFF, 0xE6, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x0F, 0x80, 0x3F, 0x80, 0x7E,
  0x00, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0x00, 0xFC, 0x0F, 0x80,
  0x07, 0x83, 0xE0, 0x00, 0xF8, 0xF8, 0x7F, 0x8F, 0x1E, 0x1F, 0xF9, 0xE7,
  0x87, 0xFF, 0x3C, 0xF1, 0xF3, 0xC7, 0xBC, 0x7C, 0x78, 0xF7, 0x8F, 0x0F,
  0x1E, 0xF3, 0xE1, 0xE3, 0xDE, 0x78, 0x78, 0x7F, 0x8F, 0x0F, 0x0F, 0xF1,
  0xE1, 0xE3, 0xDE, 0x3C, 0x7C, 0x7B, 0xC7, 0xDF, 0xBE, 0x78, 0xFF, 0xFF,
  0x8F, 0x8F, 0xEF, 0xE0, 0xF0, 0xF8, 0xF8, 0x1E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x20, 0x03, 0xF8, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01,
  0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0xFD, 0xF0, 0x07, 0xCF, 0x80, 0x7E, 0x7C,
  0x03, 0xE3, 0xE0, 0x3F, 0x1F, 0x01, 0xF0, 0xF8, 0x1F, 0x87, 0xC0, 0xFC,
  0x3F, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF3,
  0xF0, 0x1F, 0x9F, 0x80, 0xFC, 0xFC, 0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x01,
  0xFF, 0xE0, 0x0F, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xF1, 0xFC, 0x1F, 0x07, 0xE1, 0xF8,
  0x3F, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x81,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xE1, 0xF8, 0x3F, 0x07,
  0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x1F, 0xC3, 0xE0, 0xFC, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x1F, 0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xC1, 0xFC, 0x0C, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x02, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF,
  0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0x8F, 0xE0, 0x7C,
  0x1F, 0x83, 0xF0, 0x7F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F,
  0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x87,
  0xC0, 0x7E, 0x3F, 0x03, 0xF8, 0xFC, 0x0F, 0xC3, 0xF0, 0x7F, 0x0F, 0xC3,
  0xF8, 0x3E, 0x1F, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F,
  0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF,
  0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFF, 0xFC, 0x1F, 0xFF,
  0x83, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x7F,
  0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xFF,
  0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F,
  0xF0, 0x30, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x7F, 0xEF, 0xC3, 0xFE, 0x7E, 0x1F, 0xF3, 0xF0,
  0xFF, 0x9F, 0x8F, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x3E, 0x3F, 0x03, 0xF1,
  0xF8, 0x1F, 0x8F, 0xE0, 0xFC, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x03, 0xE0,
  0x3F, 0x07, 0xE0, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xC0, 0x7E, 0x0F, 0xC0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xF0, 0x7E, 0x03,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFC, 0x07,
  0xE0, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xC0,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x01,
  0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x87, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x7F, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0xFC, 0x07,
  0xE1, 0xFC, 0x07, 0xE3, 0xF8, 0x07, 0xE3, 0xF0, 0x07, 0xC7, 0xE0, 0x0F,
  0xCF, 0xE0, 0x0F, 0xDF, 0xC0, 0x0F, 0xDF, 0x80, 0x0F, 0xBF, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x3F, 0xBF, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x3F,
  0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x7E, 0x1F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E,
  0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x07, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F,
  0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFD, 0xFF, 0xF8, 0x03, 0xF8, 0x03,
  0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x01, 0xFF,
  0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x83,
  0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1E, 0xF8, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF,
  0xC3, 0xDF, 0x07, 0xFF, 0x1F, 0x7C, 0x1F, 0x7C, 0x7B, 0xF0, 0x7D, 0xF3,
  0xEF, 0xC1, 0xF3, 0xCF, 0x3E, 0x07, 0xCF, 0x7C, 0xF8, 0x3F, 0x3D, 0xF3,
  0xE0, 0xF8, 0xFF, 0x9F, 0x83, 0xE3, 0xFE, 0x7E, 0x0F, 0x8F, 0xF1, 0xF0,
  0x3E, 0x3F, 0xC7, 0xC1, 0xF8, 0xFE, 0x1F, 0x07, 0xC3, 0xF8, 0xFC, 0x1F,
  0x0F, 0xC3, 0xE0, 0x7C, 0x3F, 0x0F, 0x83, 0xF0, 0xF8, 0x3E, 0x00, 0x03,
  0xF8, 0x07, 0xC0, 0xFE, 0x03, 0xF0, 0x7F, 0x80, 0xF8, 0x1F, 0xE0, 0x3E,
  0x07, 0xFC, 0x0F, 0x81, 0xFF, 0x07, 0xE0, 0x7F, 0xC1, 0xF8, 0x3F, 0xF0,
  0x7C, 0x0F, 0xFE, 0x1F, 0x03, 0xEF, 0x87, 0xC0, 0xFB, 0xE3, 0xF0, 0x7E,
  0xF8, 0xFC, 0x1F, 0x3F, 0x3E, 0x07, 0xC7, 0xCF, 0x81, 0xF1, 0xF3, 0xE0,
  0x7C, 0x7D, 0xF8, 0x3F, 0x1F, 0xFC, 0x0F, 0xC3, 0xFF, 0x03, 0xE0, 0xFF,
  0xC0, 0xF8, 0x3F, 0xF0, 0x3E, 0x0F, 0xFC, 0x1F, 0x81, 0xFE, 0x07, 0xC0,
  0x7F, 0x81, 0xF0, 0x1F, 0xE0, 0x7C, 0x07, 0xF8, 0x3F, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x0F, 0xE1, 0xFC, 0xFE, 0x07, 0xE7, 0xE0, 0x3F, 0x7F, 0x01, 0xFB,
  0xF0, 0x0F, 0xDF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xBF,
  0x01, 0xF9, 0xF8, 0x1F, 0xCF, 0xE1, 0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xFE,
  0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xF1,
  0xF8, 0x1F, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x1F, 0x83,
  0xF0, 0xFC, 0x3F, 0x0F, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xE1, 0xFC, 0xFE, 0x07,
  0xE7, 0xE0, 0x3F, 0x7F, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x7F, 0xFC,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x7E,
  0xFC, 0x03, 0xF7, 0xE0, 0x3F, 0xBF, 0x01, 0xF9, 0xF8, 0x1F, 0xCF, 0xE1,
  0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x7E, 0x3F, 0x07, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0x87, 0xF1, 0xF8, 0xFE,
  0x1F, 0xFF, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0x3F,
  0x03, 0xF3, 0xF0, 0x3F, 0x3F, 0x03, 0xF1, 0xF8, 0x3E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xCF, 0xC0, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F,
  0x83, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x40, 0x1F, 0x86, 0x07,
  0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xFC,
  0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0xFC,
  0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7C,
  0x07, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F,
  0xC3, 0xE0, 0x3E, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x87,
  0xE0, 0x7E, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0,
  0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x83, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x0F, 0xCF, 0xC0, 0xFC,
  0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0x7C, 0x1F, 0x07, 0xC3, 0xF0, 0x7C, 0x3E,
  0x07, 0xC7, 0xE0, 0x7C, 0x7C, 0x07, 0xCF, 0xC0, 0x7C, 0xF8, 0x07, 0xDF,
  0x80, 0x7D, 0xF8, 0x07, 0xDF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0xFC, 0x07, 0xC0, 0x7F, 0xF8, 0x1F, 0x81, 0xFB, 0xF0, 0x3F,
  0x03, 0xF7, 0xE0, 0xFE, 0x07, 0xCF, 0xC1, 0xFC, 0x1F, 0x9F, 0x03, 0xF8,
  0x3E, 0x3E, 0x0F, 0xF0, 0xFC, 0x7C, 0x1F, 0xE1, 0xF8, 0xF8, 0x7F, 0xC3,
  0xE1, 0xF0, 0xFF, 0x8F, 0xC3, 0xE3, 0xFF, 0x1F, 0x07, 0xC7, 0xFE, 0x7E,
  0x0F, 0x8F, 0x7C, 0xF8, 0x1F, 0x3E, 0xF9, 0xF0, 0x3E, 0x7D, 0xF7, 0xE0,
  0x7D, 0xF3, 0xEF, 0x80, 0xFB, 0xE7, 0xFF, 0x01, 0xF7, 0x8F, 0xFC, 0x03,
  0xFF, 0x1F, 0xF8, 0x07, 0xFC, 0x3F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x1F,
  0xF0, 0xFF, 0x80, 0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0xFE,
  0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0x81, 0xF8,
  0x1F, 0xC0, 0xFC, 0x1F, 0xC0, 0x3F, 0x0F, 0xC0, 0x1F, 0x8F, 0xC0, 0x0F,
  0xC7, 0xE0, 0x03, 0xE7, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x01, 0xFB, 0xF0, 0x01, 0xFC, 0xFC, 0x00, 0xFC, 0x7E,
  0x00, 0xFC, 0x3F, 0x00, 0xFE, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x7E, 0x03,
  0xF0, 0x7F, 0x01, 0xFC, 0x00, 0xFC, 0x07, 0xFF, 0x81, 0xFD, 0xF0, 0x3F,
  0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0xFC, 0x7E, 0x0F, 0x8F, 0xC1, 0xF3, 0xF0,
  0x3E, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0,
  0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0x80, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0x78, 0x7C, 0x7C,
  0x7C, 0x7C, 0x7C, 0x7C, 0x3C, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x1E,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0,
  0x3F, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x0F, 0xF8,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF8,
  0x07, 0xDF, 0x01, 0xE3, 0xC0, 0xF8, 0xF0, 0x7C, 0x3E, 0x1E, 0x0F, 0x8F,
  0x81, 0xE7, 0xC0, 0x79, 0xF0, 0x1F, 0xF8, 0x07, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xF0, 0xFC, 0x7C, 0x7E, 0x3E, 0x1E, 0x0F, 0x03, 0xE3, 0xE0,
  0xFE, 0x7C, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7E, 0x3F, 0x9F,
  0xC3, 0xE3, 0xF0, 0x7C, 0x7E, 0x1F, 0x8F, 0xC3, 0xF3, 0xF0, 0x7E, 0x7E,
  0x0F, 0x8F, 0xC1, 0xF1, 0xF8, 0x7E, 0x3F, 0x1F, 0xC7, 0xF7, 0xF8, 0xFF,
  0xFE, 0x0F, 0xFF, 0xC1, 0xFE, 0xF8, 0x1F, 0x9F, 0x00, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7E, 0xF8, 0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F,
  0xFF, 0xF1, 0xFC, 0x7E, 0x3F, 0x0F, 0xC7, 0xC1, 0xF8, 0xF8, 0x3F, 0x3F,
  0x07, 0xE7, 0xE0, 0xF8, 0xF8, 0x3F, 0x1F, 0x07, 0xE3, 0xE1, 0xFC, 0xFE,
  0x3F, 0x1F, 0xCF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0x7F, 0x83, 0xE7,
  0xE0, 0x00, 0x01, 0xFC, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0xFE, 0x3F, 0xFC,
  0x3F, 0x04, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x08, 0xFF, 0x78, 0x7F, 0xF8,
  0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x3E, 0x7E, 0x07, 0xF7, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x3F, 0x1F, 0xC3, 0xF0, 0xF8, 0x7E, 0x0F, 0x87, 0xE0, 0xF8, 0x7C, 0x1F,
  0x8F, 0xC1, 0xF8, 0xFC, 0x1F, 0x0F, 0xC1, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFE, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFB, 0xE0, 0x3F,
  0x3E, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xF1, 0xF9,
  0xF9, 0xF8, 0x7D, 0xF8, 0x3E, 0xFC, 0x3F, 0x7F, 0xFF, 0x3F, 0xFF, 0x3F,
  0xFF, 0x1F, 0xFE, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x18,
  0x7F, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xF1, 0xF0, 0x3F, 0x9F, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1,
  0xF8, 0xFE, 0x1F, 0x87, 0xC3, 0xF0, 0x7C, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x7E, 0x0F, 0xC7, 0xE0, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x3F,
  0x87, 0xF7, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFB,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x0C, 0x0F, 0xE0, 0xFF,
  0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x17, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0xFC, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8,
  0x3F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFC, 0x7E, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8,
  0xF8, 0x3E, 0x3F, 0x07, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F, 0x1F, 0x07, 0xE3,
  0xE0, 0xF8, 0xFC, 0x3F, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x7C, 0x1F, 0x8F,
  0x83, 0xE3, 0xF0, 0xFC, 0x00, 0x00, 0xC0, 0x7C, 0x1F, 0x83, 0xF0, 0x7E,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x7E, 0x00, 0x00, 0x06, 0x00, 0x0F,
  0x80, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xC0,
  0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x3F,
  0x0F, 0xC3, 0xF0, 0x7E, 0x3F, 0x03, 0xE3, 0xF0, 0x3F, 0x3F, 0x01, 0xFB,
  0xF8, 0x0F, 0xDF, 0x80, 0x7D, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xF7, 0xE0, 0x3F, 0x3F,
  0x01, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7C, 0x3F, 0x83, 0xE0, 0xFC, 0x3F,
  0x07, 0xF0, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x07,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0x8F, 0x87, 0xE0, 0x7D,
  0xFE, 0x7F, 0x83, 0xFF, 0xF7, 0xFC, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0x8F, 0xE3, 0xF8, 0xFC, 0x7E, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x3E,
  0x1F, 0x07, 0xC1, 0xF1, 0xF8, 0x7E, 0x1F, 0x8F, 0xC3, 0xF0, 0xFC, 0x7E,
  0x1F, 0x87, 0xE3, 0xE0, 0xF8, 0x3E, 0x1F, 0x07, 0xC1, 0xF1, 0xF8, 0x7E,
  0x1F, 0x8F, 0xC3, 0xF0, 0xFC, 0x7E, 0x1F, 0x87, 0xE3, 0xE0, 0xF8, 0x3E,
  0x1F, 0x07, 0xC1, 0xF1, 0xF8, 0x7E, 0x1F, 0x80, 0x0F, 0x9F, 0x81, 0xF7,
  0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0x8F, 0xC7, 0xE1,
  0xF8, 0xFC, 0x3F, 0x1F, 0x07, 0xC7, 0xE0, 0xF8, 0xFC, 0x3F, 0x1F, 0x87,
  0xE3, 0xE0, 0xFC, 0x7C, 0x1F, 0x1F, 0x83, 0xE3, 0xF0, 0xFC, 0x7E, 0x1F,
  0x8F, 0x83, 0xF1, 0xF0, 0x7C, 0x7E, 0x1F, 0x80, 0x01, 0xFC, 0x03, 0xFF,
  0x03, 0xFF, 0xC3, 0xFF, 0xF3, 0xFF, 0xF9, 0xF8, 0xFD, 0xF8, 0x3E, 0xFC,
  0x1F, 0x7E, 0x0F, 0xBE, 0x07, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF,
  0xE1, 0xFB, 0xF0, 0xFD, 0xFC, 0xFC, 0x7F, 0xFE, 0x3F, 0xFE, 0x0F, 0xFE,
  0x01, 0xFC, 0x00, 0x03, 0xE7, 0xC0, 0x1F, 0x7F, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xF8, 0xFC, 0x1F, 0x87, 0xE0, 0xF8, 0x3F,
  0x07, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0x07, 0xE0, 0xF8,
  0x3F, 0x07, 0xC3, 0xF8, 0x7F, 0x1F, 0x83, 0xF9, 0xFC, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFC, 0x0F, 0xDF, 0xC0, 0x7E, 0x7C, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE3, 0xE0, 0xFE,
  0x78, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7E, 0x3F, 0x8F, 0xC3,
  0xE3, 0xF0, 0x7C, 0x7E, 0x0F, 0x8F, 0x83, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F,
  0x8F, 0xC1, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC7, 0xF7, 0xF8, 0xFF, 0xFE,
  0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x1F, 0xBF, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x0F, 0x8F, 0x0F, 0xBE, 0x0F, 0xFE, 0x0F,
  0xFE, 0x1F, 0xFE, 0x1F, 0xFC, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x0F,
  0xFF, 0x1F, 0xFE, 0x1F, 0xFE, 0x3F, 0x8C, 0x3F, 0x04, 0x3F, 0x00, 0x3F,
  0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00,
  0xFC, 0x80, 0xFC, 0xE1, 0xFC, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F,
  0xC0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x01, 0xFF, 0xBF, 0xFF, 0xFF,
  0xDF, 0xFE, 0xFF, 0xF1, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF9, 0x0F, 0xF8, 0x7F,
  0xC3, 0xFE, 0x0F, 0xF0, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x7C, 0x1F, 0x8F,
  0x83, 0xE3, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xF1, 0xF0, 0x7C, 0x7E,
  0x0F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7E, 0x3E, 0x0F, 0xC7, 0xC1, 0xF0, 0xF8,
  0x7E, 0x3F, 0x1F, 0xC7, 0xF7, 0xF8, 0x7F, 0xFF, 0x0F, 0xFB, 0xC1, 0xFE,
  0xF8, 0x1F, 0x9F, 0x00, 0xF8, 0x0F, 0xFF, 0x07, 0xEF, 0xC1, 0xFB, 0xF0,
  0xFC, 0xFC, 0x3E, 0x3F, 0x1F, 0x8F, 0xC7, 0xC1, 0xF3, 0xF0, 0x7C, 0xF8,
  0x1F, 0x7E, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0xF8, 0x3F, 0x07, 0xFF, 0x07, 0xE0, 0xFB, 0xE1, 0xFC, 0x3F, 0x7C,
  0x3F, 0x87, 0xCF, 0x87, 0xF1, 0xF9, 0xF1, 0xFE, 0x3E, 0x3E, 0x3F, 0xC7,
  0xC7, 0xCF, 0xF9, 0xF0, 0xF9, 0xEF, 0x3E, 0x1F, 0x3D, 0xEF, 0xC3, 0xEF,
  0x3D, 0xF0, 0x7D, 0xE7, 0xBE, 0x0F, 0xBC, 0xFF, 0x81, 0xFF, 0x1F, 0xF0,
  0x3F, 0xE3, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1,
  0xFC, 0x01, 0xF8, 0x3F, 0x80, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xE1, 0xFC,
  0x1F, 0x87, 0xE0, 0x7E, 0x3F, 0x00, 0xF9, 0xFC, 0x03, 0xF7, 0xE0, 0x0F,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0xFD, 0xF0, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0xFC, 0x7E, 0x07, 0xF0,
  0xFC, 0x3F, 0x83, 0xF0, 0x0F, 0xC0, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x1F, 0x80, 0x7C, 0x7E, 0x01,
  0xF3, 0xF0, 0x07, 0xCF, 0xC0, 0x1F, 0x3E, 0x00, 0x7D, 0xF8, 0x01, 0xF7,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF0, 0x03,
  0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7F, 0xF8, 0x7F, 0xFC,
  0x3F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0xFC, 0x03,
  0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x7F,
  0x00, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xFC, 0x03,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0x80, 0x07, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x3F,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0x7E, 0x01, 0xFC, 0x07, 0xF8, 0x1F,
  0xE0, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x3E, 0x00, 0x7C, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0x70,
  0x00, 0x3E, 0x01, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0x80,
  0xFE, 0x80, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBoldItalic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 11, 26, 10, 0, -26 },
  { 37, 14, 10, 16, 3, -26 },
  { 55, 22, 26, 21, 0, -26 },
  { 127, 18, 29, 19, 1, -27 },
  { 193, 27, 26, 30, 2, -26 },
  { 281, 24, 26, 24, 0, -26 },
  { 359, 7, 10, 9, 3, -26 },
  { 368, 13, 32, 12, 1, -26 },
  { 420, 14, 32, 12, -3, -26 },
  { 476, 16, 17, 18, 3, -28 },
  { 510, 16, 17, 20, 2, -21 },
  { 544, 9, 9, 10, -2, -4 },
  { 555, 11, 5, 11, 0, -12 },
  { 562, 7, 6, 10, 0, -6 },
  { 568, 20, 26, 15, -2, -26 },
  { 633, 18, 26, 19, 1, -26 },
  { 692, 14, 26, 19, 3, -26 },
  { 738, 19, 26, 19, -1, -26 },
  { 800, 19, 26, 19, 0, -26 },
  { 862, 19, 26, 19, 0, -26 },
  { 924, 19, 26, 19, 0, -26 },
  { 986, 18, 26, 19, 1, -26 },
  { 1045, 20, 26, 19, 1, -26 },
  { 1110, 18, 26, 19, 1, -26 },
  { 1169, 17, 26, 19, 1, -26 },
  { 1225, 10, 20, 10, 0, -20 },
  { 1250, 12, 25, 10, -2, -20 },
  { 1288, 16, 18, 20, 2, -22 },
  { 1324, 16, 12, 20, 2, -19 },
  { 1348, 16, 18, 20, 2, -22 },
  { 1384, 15, 26, 15, 2, -26 },
  { 1433, 27, 29, 29, 1, -26 },
  { 1531, 21, 26, 21, -2, -26 },
  { 1600, 21, 26, 21, 0, -26 },
  { 1669, 20, 26, 20, 2, -26 },
  { 1734, 22, 26, 22, 0, -26 },
  { 1806, 19, 26, 18, 0, -26 },
  { 1868, 19, 26, 18, 0, -26 },
  { 1930, 21, 26, 23, 2, -26 },
  { 1999, 24, 26, 23, 0, -26 },
  { 2077, 17, 26, 14, -1, -26 },
  { 2133, 18, 34, 11, -6, -26 },
  { 2210, 24, 26, 21, 0, -26 },
  { 2288, 15, 26, 17, 0, -26 },
  { 2337, 30, 26, 30, 0, -26 },
  { 2435, 26, 26, 25, 0, -26 },
  { 2520, 21, 26, 24, 2, -26 },
  { 2589, 21, 26, 20, 0, -26 },
  { 2658, 21, 32, 24, 2, -26 },
  { 2742, 20, 26, 21, 0, -26 },
  { 2807, 19, 26, 18, 0, -26 },
  { 2869, 17, 26, 18, 3, -26 },
  { 2925, 22, 26, 23, 2, -26 },
  { 2997, 20, 26, 20, 3, -26 },
  { 3062, 31, 26, 30, 3, -26 },
  { 3163, 25, 26, 21, -2, -26 },
  { 3245, 19, 26, 19, 3, -26 },
  { 3307, 21, 26, 18, -1, -26 },
  { 3376, 15, 32, 12, -1, -26 },
  { 3436, 8, 26, 15, 4, -26 },
  { 3462, 15, 32, 12, -2, -26 },
  { 3522, 18, 17, 18, 0, -26 },
  { 3561, 15, 3, 14, -3, 3 },
  { 3567, 8, 6, 12, 5, -28 },
  { 3573, 19, 20, 20, 1, -20 },
  { 3621, 19, 27, 20, 0, -27 },
  { 3686, 16, 20, 16, 1, -20 },
  { 3726, 20, 27, 20, 1, -27 },
  { 3794, 17, 20, 19, 1, -20 },
  { 3837, 21, 37, 13, -4, -28 },
  { 3935, 20, 29, 20, 0, -20 },
  { 4008, 19, 27, 20, 0, -27 },
  { 4073, 11, 28, 10, 0, -28 },
  { 4112, 17, 37, 10, -5, -28 },
  { 4191, 21, 27, 19, 0, -27 },
  { 4262, 12, 27, 10, 0, -27 },
  { 4303, 29, 20, 30, 0, -20 },
  { 4376, 19, 20, 20, 0, -20 },
  { 4424, 17, 20, 20, 1, -20 },
  { 4467, 21, 29, 20, -2, -20 },
  { 4544, 19, 29, 20, 1, -20 },
  { 4613, 16, 20, 14, 0, -20 },
  { 4653, 16, 20, 16, 0, -20 },
  { 4693, 13, 24, 14, 2, -24 },
  { 4732, 19, 20, 20, 1, -20 },
  { 4780, 18, 20, 18, 2, -20 },
  { 4825, 27, 20, 27, 2, -20 },
  { 4893, 22, 20, 18, -2, -20 },
  { 4948, 22, 29, 18, -2, -20 },
  { 5028, 17, 20, 16, -1, -20 },
  { 5071, 15, 32, 13, 0, -26 },
  { 5131, 4, 35, 18, 7, -27 },
  { 5149, 15, 32, 13, -2, -26 },
  { 5209, 16, 7, 20, 2, -16 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBoldItalic36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBoldItalic36pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBoldItalic36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC36PT7B_H_
