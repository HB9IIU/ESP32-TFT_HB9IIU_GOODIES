#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC37PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBoldItalic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBoldItalic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0x80, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x03,
  0xF0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x07, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFC, 0x07, 0xC0, 0x3E, 0x7E, 0x7C, 0xF9, 0xF9, 0xF3, 0xE3, 0xE7,
  0xC7, 0x8F, 0x9F, 0x1E, 0x3E, 0x3C, 0x7C, 0xF8, 0xF0, 0x00, 0x7C, 0x78,
  0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x07, 0xC7, 0x80, 0x0F, 0x1F, 0x00,
  0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x1E, 0x3E, 0x00, 0x3C, 0x78, 0x00, 0x78,
  0xF0, 0x01, 0xE3, 0xE2, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xC0, 0x78, 0xF0, 0x01, 0xF1, 0xE0, 0x03, 0xC7, 0xC0,
  0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x3C, 0x7C, 0x00, 0x78, 0xF0, 0x00,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xC0, 0x7F, 0xFE,
  0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0xFD, 0x9C, 0x1F, 0x30, 0x83, 0xEE, 0x00,
  0x7D, 0xC0, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x80,
  0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0x7E, 0x00, 0xEF, 0xCC,
  0x19, 0xF1, 0xE3, 0x7E, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F,
  0xFF, 0x00, 0x1E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x80, 0xFE, 0x00, 0xF0, 0x1F, 0xF0, 0x1F, 0x03, 0xFF,
  0x01, 0xE0, 0x7C, 0xF0, 0x3C, 0x07, 0xCF, 0x87, 0xC0, 0x78, 0xF0, 0x78,
  0x0F, 0x8F, 0x0F, 0x00, 0xF8, 0xF1, 0xF0, 0x0F, 0x8F, 0x1E, 0x00, 0xF9,
  0xF3, 0xC0, 0x0F, 0x1E, 0x7C, 0xFC, 0xFB, 0xE7, 0x9F, 0xEF, 0xFC, 0xF3,
  0xFE, 0x7F, 0xDF, 0x7F, 0xF7, 0xF9, 0xE7, 0x9F, 0x1E, 0x3C, 0xF9, 0xF0,
  0x07, 0xCF, 0x9F, 0x00, 0x78, 0xF1, 0xF0, 0x0F, 0x0F, 0x1F, 0x01, 0xF0,
  0xF1, 0xE0, 0x1E, 0x1F, 0x1E, 0x03, 0xC0, 0xF3, 0xE0, 0x7C, 0x0F, 0xFC,
  0x0F, 0x80, 0xFF, 0xC0, 0xF0, 0x0F, 0xF8, 0x1F, 0x00, 0x7F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x03, 0xE3, 0xF0, 0x07, 0xE3, 0xE0, 0x07, 0xE3, 0xE0, 0x07,
  0xE7, 0xE0, 0x03, 0xEF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x3F, 0x1F, 0xFC, 0x3E, 0x3F, 0xFE, 0x7E, 0x3F,
  0x7F, 0x7E, 0x7E, 0x3F, 0xFC, 0x7E, 0x3F, 0xF8, 0xFC, 0x1F, 0xF8, 0xFC,
  0x1F, 0xF0, 0xFE, 0x0F, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xF1, 0xFC, 0x3E, 0x7D, 0xFB, 0xE7,
  0xCF, 0x9E, 0x3C, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F,
  0x80, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00,
  0x7C, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x00,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x61, 0xE0, 0x79, 0xE0, 0x7D, 0xE1,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x1F, 0xE0, 0x3F, 0xF0,
  0x7E, 0xF0, 0x7C, 0xF8, 0x3C, 0xF8, 0x08, 0x7C, 0x00, 0x60, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0x1F, 0x8F, 0xC7, 0xC7, 0xE3, 0xF1, 0xF1, 0xF8, 0xF8, 0x78, 0x7C,
  0x00, 0x7F, 0xEF, 0xFD, 0xFF, 0x3F, 0xEF, 0xFC, 0x3C, 0xFF, 0xFF, 0xFF,
  0xDF, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0xC7, 0xF3, 0xF1,
  0xF8, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0xCF, 0xC3, 0xF7, 0xE0, 0xFD, 0xF8,
  0x3F, 0x7E, 0x0F, 0xDF, 0x83, 0xFF, 0xC0, 0xFF, 0xF0, 0x7E, 0xFC, 0x1F,
  0xBF, 0x07, 0xEF, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0x1F, 0x8F,
  0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x00,
  0x7E, 0x03, 0xF8, 0x0F, 0xF0, 0x7F, 0xE1, 0xFF, 0xC7, 0xFF, 0xBF, 0xFE,
  0x3F, 0x7C, 0x79, 0xF8, 0x63, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF,
  0xF0, 0x7E, 0x7F, 0x03, 0x83, 0xF0, 0x30, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0x87, 0xFF, 0xF8,
  0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x7F,
  0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0x1F, 0xC0, 0x81,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xFF,
  0x80, 0x3F, 0xE0, 0x07, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF9, 0x80, 0x7F,
  0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x81, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xEF, 0x80, 0x7D,
  0xF0, 0x1F, 0x7E, 0x07, 0xCF, 0xC0, 0xF1, 0xF0, 0x3E, 0x3E, 0x0F, 0x8F,
  0xC3, 0xE1, 0xF8, 0x7F, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x81,
  0xFF, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0xC0, 0x3F, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x0F,
  0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xE0, 0x43, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF9, 0xF8, 0x3F, 0x7F,
  0x87, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xEF, 0xE3, 0xF0, 0xFC, 0xFE, 0x1F,
  0x9F, 0x83, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F, 0xCF, 0xC3, 0xF0, 0xF8, 0x7E,
  0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xC0, 0x7F,
  0xF8, 0x3F, 0xFF, 0x0F, 0xFF, 0xC7, 0xE3, 0xF1, 0xF8, 0x7C, 0x7E, 0x1F,
  0x1F, 0x8F, 0xC7, 0xE3, 0xE0, 0xFF, 0xF8, 0x3F, 0xFC, 0x07, 0xFC, 0x01,
  0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x7E, 0x3F, 0x3F, 0x0F, 0xCF, 0xC1,
  0xF3, 0xE0, 0x7E, 0xF8, 0x1F, 0x3F, 0x0F, 0xCF, 0xC7, 0xF3, 0xFF, 0xF8,
  0x7F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0x80,
  0xFF, 0xF0, 0x3F, 0xFE, 0x1F, 0xFF, 0x8F, 0xE7, 0xF3, 0xF0, 0xFC, 0xFC,
  0x3F, 0x7E, 0x0F, 0xDF, 0x83, 0xF7, 0xE0, 0xFD, 0xF8, 0x7F, 0x7E, 0x3F,
  0xDF, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xDF, 0x83, 0xE7, 0xC0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x0F, 0xFF, 0x83, 0xFF,
  0xE0, 0xFF, 0xF0, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x01, 0x03, 0xF0, 0xFC,
  0x7F, 0x1F, 0xC3, 0xE0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x7E, 0x3F, 0x8F, 0xE3, 0xF0, 0x7C, 0x00, 0x00,
  0x40, 0x3F, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x3E, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x81, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8,
  0x0F, 0x80, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x0F,
  0xF8, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0x00, 0x3F,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF,
  0x00, 0x1F, 0x80, 0x03, 0xC0, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x70,
  0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x3F, 0xF0, 0xFF,
  0xC1, 0xFF, 0x83, 0xFF, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x20,
  0x00, 0x00, 0x03, 0xE0, 0x3F, 0xF1, 0xFF, 0xF3, 0xFF, 0xF3, 0xFF, 0xE7,
  0x0F, 0xC8, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x3F,
  0xC0, 0xFF, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x1F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xF8, 0x0F, 0xC0, 0x7E,
  0x00, 0x3E, 0x0F, 0x80, 0x01, 0xE0, 0xF0, 0x3E, 0x1F, 0x1E, 0x0F, 0xFC,
  0xF3, 0xE1, 0xFF, 0x8F, 0x3C, 0x3F, 0xF8, 0xF3, 0xC7, 0xC7, 0x8F, 0x78,
  0xF8, 0xF8, 0xF7, 0x8F, 0x0F, 0x0F, 0x78, 0xF0, 0xF0, 0xF7, 0x9F, 0x0F,
  0x1F, 0xF1, 0xE1, 0xF1, 0xEF, 0x1E, 0x1E, 0x1E, 0xF1, 0xE3, 0xE3, 0xCF,
  0x1F, 0x7F, 0x7C, 0xF9, 0xFF, 0xFF, 0x87, 0x8F, 0xEF, 0xF0, 0x78, 0x7C,
  0x7C, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x03, 0x00,
  0x1F, 0xE7, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0x7E,
  0x00, 0xFD, 0xF8, 0x03, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0x7C, 0x3E, 0x03,
  0xF0, 0xF8, 0x0F, 0xC3, 0xE0, 0x7E, 0x0F, 0x81, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0x00, 0xF8,
  0xFC, 0x03, 0xE7, 0xF0, 0x0F, 0x9F, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF0,
  0x03, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0x7E, 0x3F, 0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xE1, 0xF8, 0x3F, 0x0F,
  0xC1, 0xF8, 0x7E, 0x1F, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xF0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8,
  0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0xFE, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1,
  0xFF, 0x3E, 0x1F, 0xC0, 0x43, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x20, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F,
  0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0x87, 0xF0,
  0x7E, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC,
  0x0F, 0xC7, 0xF0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x1F,
  0xC7, 0xE0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x0F, 0xE3, 0xF0, 0x7F, 0x0F,
  0xC3, 0xFC, 0x3F, 0x1F, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x81, 0xFF,
  0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F,
  0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xE7, 0xC1, 0xFC, 0x01,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x3F, 0xF3, 0xF0, 0xFF, 0xCF, 0xC3, 0xFF, 0x3F, 0x0F,
  0xF8, 0xFC, 0x3F, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF8,
  0xFE, 0x0F, 0xC3, 0xF8, 0x3F, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E,
  0x07, 0xE0, 0x3F, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x01,
  0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF,
  0xE0, 0x7F, 0xC0, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x03,
  0xFF, 0x00, 0xFF, 0x80, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x7F, 0x81, 0xF8,
  0x3F, 0x01, 0xF8, 0x3F, 0x80, 0xFC, 0x3F, 0x80, 0x7E, 0x3F, 0x80, 0x3F,
  0x1F, 0x80, 0x1F, 0x1F, 0x80, 0x1F, 0x9F, 0xC0, 0x0F, 0xDF, 0xC0, 0x07,
  0xEF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xBF, 0x80,
  0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xFC,
  0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0xC0, 0x7E, 0x0F,
  0xE0, 0x7E, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xFF, 0xDF, 0xFF,
  0xBF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF8,
  0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0,
  0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x0F,
  0xFE, 0x0F, 0xBC, 0x1F, 0xF8, 0x1F, 0x78, 0x7D, 0xF0, 0x3E, 0xF0, 0xFF,
  0xE0, 0xFD, 0xE1, 0xEF, 0xC1, 0xFB, 0xC7, 0xDF, 0x83, 0xE7, 0x8F, 0x3E,
  0x07, 0xCF, 0x3E, 0x7C, 0x0F, 0x9E, 0x79, 0xF8, 0x3F, 0x3D, 0xF3, 0xF0,
  0x7E, 0x7B, 0xC7, 0xC0, 0xF8, 0xFF, 0x8F, 0x81, 0xF1, 0xFF, 0x1F, 0x03,
  0xE3, 0xFC, 0x7E, 0x0F, 0xC7, 0xF8, 0xFC, 0x1F, 0x8F, 0xE1, 0xF0, 0x3E,
  0x1F, 0xC3, 0xE0, 0x7C, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x1F, 0x80, 0x03,
  0xF8, 0x07, 0xE0, 0x7F, 0x00, 0xF8, 0x1F, 0xF0, 0x1F, 0x03, 0xFE, 0x07,
  0xE0, 0x7F, 0xC0, 0xFC, 0x0F, 0xF8, 0x1F, 0x01, 0xFF, 0x83, 0xE0, 0x7F,
  0xF0, 0xFC, 0x0F, 0xBE, 0x1F, 0x81, 0xF7, 0xC3, 0xF0, 0x3E, 0xFC, 0x7C,
  0x0F, 0xCF, 0x8F, 0x81, 0xF9, 0xF3, 0xF0, 0x3E, 0x3E, 0x7E, 0x07, 0xC7,
  0xEF, 0x80, 0xF8, 0x7D, 0xF0, 0x3F, 0x0F, 0xBE, 0x07, 0xE1, 0xFF, 0xC0,
  0xF8, 0x3F, 0xF8, 0x1F, 0x03, 0xFE, 0x03, 0xE0, 0x7F, 0xC0, 0xFC, 0x0F,
  0xF8, 0x1F, 0x81, 0xFF, 0x03, 0xE0, 0x1F, 0xE0, 0x7C, 0x03, 0xF8, 0x1F,
  0x80, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0x01,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0x8F, 0xE1, 0xFC, 0x1F, 0xCF, 0xE0,
  0x7F, 0x3F, 0x00, 0xFD, 0xFC, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x3F,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7E, 0xFC,
  0x01, 0xFB, 0xF0, 0x0F, 0xEF, 0xC0, 0x3F, 0x3F, 0x01, 0xFC, 0xFC, 0x07,
  0xE3, 0xF8, 0x3F, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x01,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xF0, 0xFC, 0x1F, 0x87,
  0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0xFE, 0x3F,
  0x0F, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xE0,
  0x3F, 0xFC, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0x01,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0x8F, 0xE1, 0xFC, 0x1F, 0xCF, 0xE0,
  0x3F, 0x3F, 0x00, 0xFD, 0xFC, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x3F,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7E, 0xFC,
  0x01, 0xFB, 0xF0, 0x0F, 0xEF, 0xC0, 0x3F, 0x3F, 0x01, 0xFC, 0xFC, 0x0F,
  0xE3, 0xF8, 0x7F, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x03, 0xFF,
  0x80, 0x1F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7E, 0x7F, 0x83,
  0xF1, 0xFC, 0x1F, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xC3, 0xF8, 0x7E, 0x1F,
  0x83, 0xF1, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xC7, 0xE0,
  0x7E, 0x3F, 0x03, 0xF1, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1,
  0xFC, 0x7E, 0x07, 0xE7, 0xF0, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xF8,
  0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xCF, 0x83, 0xF0, 0x20,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x88, 0x03, 0xF0, 0xC0, 0xFE, 0x3F,
  0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x81,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x7E, 0x1F, 0x81,
  0xF8, 0x7E, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x03, 0xF0,
  0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x07, 0xE1, 0xF8,
  0x1F, 0x87, 0xE0, 0x7E, 0x3F, 0x81, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x3F,
  0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFE, 0x1F, 0x83, 0xFF, 0xFE, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFC,
  0x03, 0xFF, 0xE0, 0x1F, 0xBF, 0x01, 0xFD, 0xF8, 0x0F, 0xCF, 0xC0, 0xFE,
  0x3E, 0x07, 0xE1, 0xF0, 0x3F, 0x0F, 0x83, 0xF0, 0x7C, 0x1F, 0x83, 0xE1,
  0xF8, 0x1F, 0x0F, 0xC0, 0xF8, 0xFC, 0x07, 0xC7, 0xE0, 0x3E, 0x7E, 0x01,
  0xF3, 0xF0, 0x0F, 0x9F, 0x00, 0x7D, 0xF8, 0x03, 0xEF, 0x80, 0x1F, 0x7C,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x7F,
  0xF8, 0x1F, 0x80, 0xFF, 0xF0, 0x3F, 0x03, 0xF7, 0xE0, 0x7E, 0x07, 0xEF,
  0xC1, 0xFC, 0x0F, 0x9F, 0x83, 0xF8, 0x3F, 0x3F, 0x0F, 0xF0, 0x7E, 0x7E,
  0x1F, 0xE1, 0xF8, 0xFC, 0x7F, 0xC3, 0xF1, 0xF8, 0xFF, 0x87, 0xC3, 0xF1,
  0xEF, 0x1F, 0x87, 0xE7, 0xDE, 0x3F, 0x0F, 0xCF, 0xBC, 0xFC, 0x1F, 0xBE,
  0x79, 0xF8, 0x3F, 0x7C, 0xF3, 0xE0, 0x7D, 0xF1, 0xEF, 0xC0, 0xFB, 0xE3,
  0xDF, 0x01, 0xF7, 0xC7, 0xBE, 0x03, 0xFF, 0x0F, 0xFC, 0x07, 0xFE, 0x1F,
  0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0x80, 0x3F, 0xC0, 0xFF,
  0x00, 0x7F, 0x81, 0xFC, 0x00, 0xFF, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x1F, 0x87, 0xF0, 0x07,
  0xE1, 0xF8, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xDF, 0x80,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x7E, 0x7E, 0x00, 0x3F, 0x9F, 0x80, 0x0F, 0xC7, 0xE0, 0x07, 0xE1, 0xFC,
  0x03, 0xF8, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF8, 0x3F, 0x80,
  0xFE, 0x00, 0xFC, 0x07, 0xF7, 0xE0, 0xFE, 0x7E, 0x0F, 0xC7, 0xE1, 0xFC,
  0x7E, 0x1F, 0x83, 0xE3, 0xF0, 0x3E, 0x3F, 0x03, 0xF7, 0xE0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFE,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xF8, 0x7C,
  0x3E, 0x1F, 0x07, 0x83, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x07, 0x83,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x07, 0x83, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x07, 0xC3, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFE, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x80, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F,
  0x80, 0x3F, 0xF0, 0x0F, 0xBC, 0x07, 0xCF, 0x01, 0xE3, 0xE0, 0xF8, 0xF8,
  0x7C, 0x1E, 0x1E, 0x07, 0x8F, 0x81, 0xF7, 0xC0, 0x7D, 0xF0, 0x0F, 0xF8,
  0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0x7E, 0x3E, 0x1F,
  0x1F, 0x0F, 0x00, 0xC0, 0x00, 0xFE, 0x7C, 0x3F, 0xEF, 0x8F, 0xFF, 0xF1,
  0xFF, 0xFE, 0x7F, 0x3F, 0x8F, 0xC3, 0xF3, 0xF8, 0x7E, 0x7E, 0x0F, 0xCF,
  0xC1, 0xF1, 0xF8, 0x3E, 0x7E, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x3F, 0x3F,
  0x0F, 0xC7, 0xE1, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x1F,
  0xDF, 0x01, 0xF3, 0xE0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x38, 0x0F,
  0xDF, 0x81, 0xFF, 0xF8, 0x3F, 0xFF, 0x87, 0xFF, 0xF1, 0xFE, 0x7E, 0x3F,
  0x0F, 0xC7, 0xE1, 0xF8, 0xF8, 0x3F, 0x1F, 0x07, 0xE7, 0xE0, 0xFC, 0xFC,
  0x1F, 0x9F, 0x87, 0xF3, 0xF0, 0xFC, 0x7E, 0x1F, 0x9F, 0xC7, 0xF3, 0xFD,
  0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xEF, 0xF8, 0x7C, 0xFE, 0x00, 0x00,
  0x70, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xFE, 0x3F, 0x86, 0x3F,
  0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x08, 0x7F, 0xF8, 0x7F, 0xF8, 0x7F,
  0xF8, 0x3F, 0xF8, 0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x38, 0x7C, 0x07, 0xF7, 0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0x83, 0xF9, 0xFC, 0x1F, 0x87, 0xE1, 0xFC, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E,
  0x0F, 0x83, 0xF0, 0x7C, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8,
  0x7E, 0x1F, 0x83, 0xF8, 0xFC, 0x1F, 0xDF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF,
  0xF0, 0x0F, 0xF7, 0x80, 0x3E, 0x7C, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xC0,
  0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x8F, 0xE3, 0xF3, 0xF0, 0xFD, 0xF8,
  0x3E, 0x7E, 0x3F, 0x9F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xE0,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x08, 0x7E, 0x0E, 0x1F, 0xFF, 0x87,
  0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xF9, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x3F, 0x9F, 0x07, 0xFD, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF1, 0xFC, 0xFE,
  0x1F, 0x87, 0xE3, 0xF8, 0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0x7C, 0x3F, 0x07,
  0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFD, 0xF0, 0x1F,
  0xBF, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0xC0, 0xFE, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x38, 0x0F, 0xDF, 0xC1, 0xFF, 0xFC,
  0x3F, 0xFF, 0x87, 0xFF, 0xF1, 0xFE, 0x7E, 0x3F, 0x8F, 0xC7, 0xE1, 0xF8,
  0xFC, 0x3F, 0x1F, 0x87, 0xE7, 0xE0, 0xFC, 0xFC, 0x1F, 0x1F, 0x87, 0xE3,
  0xF0, 0xFC, 0x7C, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0x7C, 0x7E, 0x1F, 0x8F,
  0xC3, 0xF1, 0xF0, 0x7E, 0x7E, 0x0F, 0xC0, 0x03, 0xE0, 0x3F, 0x07, 0xF0,
  0x7E, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0xFF, 0xC0, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x01, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xC0,
  0xFC, 0x7E, 0x03, 0xE3, 0xF0, 0x1F, 0x9F, 0xC0, 0x7E, 0xFE, 0x01, 0xFB,
  0xF0, 0x07, 0xDF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFD, 0xFC, 0x07, 0xE3, 0xF0, 0x1F,
  0x8F, 0xC0, 0x7E, 0x3F, 0x81, 0xF8, 0x7E, 0x07, 0xC1, 0xF8, 0x3F, 0x07,
  0xF0, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0x00, 0xC0, 0x7C,
  0xFE, 0x3F, 0x83, 0xEF, 0xF3, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0x8F, 0xF3, 0xFC, 0xFC, 0x7F, 0x1F, 0xC3, 0xE3, 0xF0, 0xFC, 0x3F,
  0x1F, 0x87, 0xE1, 0xF8, 0xFC, 0x3F, 0x0F, 0xCF, 0xC1, 0xF0, 0x7E, 0x7E,
  0x0F, 0x83, 0xF3, 0xF0, 0xFC, 0x1F, 0x1F, 0x87, 0xE1, 0xF8, 0xF8, 0x3F,
  0x0F, 0xCF, 0xC1, 0xF0, 0x7E, 0x7E, 0x1F, 0x83, 0xF3, 0xF0, 0xFC, 0x1F,
  0x1F, 0x87, 0xE1, 0xF8, 0xF8, 0x3F, 0x0F, 0xCF, 0xC1, 0xF0, 0x7E, 0x00,
  0x00, 0x07, 0x01, 0xF3, 0xF8, 0x3E, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE,
  0x1F, 0xCF, 0xC7, 0xF1, 0xF8, 0xFC, 0x3F, 0x1F, 0x87, 0xE3, 0xF0, 0xFC,
  0xFC, 0x1F, 0x9F, 0x83, 0xE3, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F, 0x83, 0xF3,
  0xF0, 0x7E, 0x7E, 0x0F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7E, 0x3E, 0x0F, 0xCF,
  0xC1, 0xF8, 0x00, 0x78, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x1F,
  0xFF, 0x8F, 0xE7, 0xF3, 0xF0, 0xFD, 0xF8, 0x3F, 0x7E, 0x0F, 0xDF, 0x83,
  0xF7, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xBF, 0x07, 0xEF, 0xC1, 0xFB,
  0xF0, 0xFC, 0x7E, 0x7F, 0x1F, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0x80, 0x1F, 0x3F, 0x00, 0xFB, 0xFC, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0x83, 0xF8, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x07,
  0xE1, 0xF8, 0x3E, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0xFC, 0x1F,
  0x87, 0xE1, 0xF8, 0x3F, 0x0F, 0xC3, 0xF8, 0xFE, 0x1F, 0xEF, 0xE0, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x3E, 0xFF, 0x03, 0xF3, 0xF0, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x7E, 0x7C, 0x3F, 0xEF, 0x87, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0x3F, 0x8F,
  0xC3, 0xF3, 0xF8, 0x7E, 0x7E, 0x0F, 0xCF, 0xC1, 0xF1, 0xF8, 0x3E, 0x7E,
  0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x3F, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0xFF,
  0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xDF, 0x01, 0xF7, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x00, 0x07, 0x0F,
  0x9F, 0x0F, 0xBF, 0x0F, 0xFF, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0xE0, 0x1F,
  0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0x00, 0xE0, 0x07, 0xFE, 0x0F, 0xFF, 0x1F, 0xFF, 0x1F,
  0xFE, 0x3F, 0x06, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x80, 0xFC, 0xF1,
  0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xC0, 0x03, 0xC0, 0x3C,
  0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1,
  0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8,
  0x7F, 0x80, 0x1F, 0x83, 0xF1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF0, 0x7E,
  0x3F, 0x07, 0xE3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x7E, 0x0F,
  0xC7, 0xE0, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7C, 0x1F, 0x87, 0xC3,
  0xF8, 0xFC, 0x3F, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFD, 0xF0, 0x7F,
  0xDF, 0x03, 0xF1, 0xE0, 0xFC, 0x0F, 0xFF, 0x07, 0xEF, 0xC1, 0xFB, 0xF0,
  0xFC, 0xFC, 0x3F, 0x3F, 0x1F, 0x87, 0xC7, 0xE1, 0xF3, 0xF0, 0x7C, 0xFC,
  0x1F, 0x3E, 0x07, 0xDF, 0x81, 0xF7, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0xFC, 0x3F, 0x87, 0xFF, 0xC3, 0xF8, 0x7E, 0xFC, 0x7F, 0x87, 0xCF,
  0xC7, 0xF8, 0xFC, 0xFC, 0x7F, 0x8F, 0x8F, 0xCF, 0x79, 0xF8, 0xFC, 0xFF,
  0x9F, 0x0F, 0xDF, 0xF9, 0xF0, 0xFD, 0xEF, 0xBF, 0x0F, 0xDE, 0xFB, 0xE0,
  0xFB, 0xEF, 0x7E, 0x0F, 0xBC, 0xF7, 0xC0, 0xFB, 0xCF, 0x7C, 0x07, 0xF8,
  0xFF, 0x80, 0x7F, 0x8F, 0xF8, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x0F, 0xF0,
  0x07, 0xF0, 0xFF, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x07,
  0xE1, 0xFE, 0x0F, 0xC3, 0xF0, 0x0F, 0xCF, 0xE0, 0x1F, 0x9F, 0x80, 0x3F,
  0x7E, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xE0, 0x03, 0xF7, 0xE0, 0x0F, 0xEF, 0xC0, 0x1F, 0x9F, 0x80,
  0x7E, 0x1F, 0x81, 0xFC, 0x3F, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xC0, 0xFC,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x1F,
  0x1F, 0x80, 0x7C, 0x7E, 0x01, 0xF1, 0xF0, 0x07, 0xCF, 0xC0, 0x1F, 0x3E,
  0x00, 0x7D, 0xF8, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xF8,
  0x3F, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF8, 0x01, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0xC3,
  0xFF, 0xF0, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xF8,
  0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x0F, 0xC0, 0x7F, 0x80, 0x7F, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0xFF, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xE0, 0x07, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x1F,
  0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xC0,
  0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F,
  0x00, 0x7C, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0x78, 0x00,
  0x7F, 0x00, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFC, 0x03,
  0xF0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBoldItalic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 12, 26, 10, 0, -26 },
  { 40, 15, 9, 16, 3, -26 },
  { 57, 23, 26, 22, 0, -26 },
  { 132, 19, 30, 19, 1, -28 },
  { 204, 28, 27, 31, 2, -27 },
  { 299, 24, 27, 24, 0, -27 },
  { 380, 7, 9, 9, 3, -26 },
  { 388, 14, 33, 12, 1, -27 },
  { 446, 14, 33, 12, -3, -27 },
  { 504, 16, 17, 19, 3, -28 },
  { 538, 17, 18, 20, 2, -22 },
  { 577, 9, 10, 10, -2, -5 },
  { 589, 11, 5, 12, 0, -12 },
  { 596, 7, 6, 10, 0, -6 },
  { 602, 20, 27, 16, -2, -27 },
  { 670, 18, 27, 19, 1, -27 },
  { 731, 15, 26, 19, 3, -26 },
  { 780, 20, 27, 19, -1, -27 },
  { 848, 19, 27, 19, 0, -27 },
  { 913, 19, 26, 19, 0, -26 },
  { 975, 20, 26, 19, 0, -26 },
  { 1040, 19, 27, 19, 1, -27 },
  { 1105, 20, 26, 19, 1, -26 },
  { 1170, 18, 27, 19, 1, -27 },
  { 1231, 18, 27, 19, 1, -27 },
  { 1292, 10, 21, 10, 0, -21 },
  { 1319, 12, 26, 10, -2, -21 },
  { 1358, 17, 19, 20, 2, -23 },
  { 1399, 17, 12, 20, 2, -19 },
  { 1425, 17, 19, 20, 2, -23 },
  { 1466, 15, 27, 16, 2, -27 },
  { 1517, 28, 30, 30, 1, -27 },
  { 1622, 22, 26, 22, -2, -26 },
  { 1694, 21, 26, 21, 0, -26 },
  { 1763, 20, 27, 21, 2, -27 },
  { 1831, 22, 26, 23, 0, -26 },
  { 1903, 20, 26, 18, 0, -26 },
  { 1968, 20, 26, 18, 0, -26 },
  { 2033, 22, 27, 24, 2, -27 },
  { 2108, 25, 26, 24, 0, -26 },
  { 2190, 17, 26, 14, -1, -26 },
  { 2246, 18, 34, 12, -6, -26 },
  { 2323, 25, 26, 22, 0, -26 },
  { 2405, 15, 26, 18, 0, -26 },
  { 2454, 31, 26, 31, 0, -26 },
  { 2555, 27, 26, 26, 0, -26 },
  { 2643, 22, 27, 25, 2, -27 },
  { 2718, 21, 26, 21, 0, -26 },
  { 2787, 22, 33, 25, 2, -27 },
  { 2878, 21, 26, 21, 0, -26 },
  { 2947, 19, 27, 18, 0, -27 },
  { 3012, 18, 26, 18, 3, -26 },
  { 3071, 22, 26, 24, 2, -26 },
  { 3143, 21, 26, 21, 3, -26 },
  { 3212, 31, 26, 31, 3, -26 },
  { 3313, 26, 26, 21, -2, -26 },
  { 3398, 20, 26, 20, 3, -26 },
  { 3463, 21, 26, 18, -1, -26 },
  { 3532, 16, 33, 12, -1, -27 },
  { 3598, 9, 27, 16, 4, -27 },
  { 3629, 16, 33, 12, -3, -27 },
  { 3695, 18, 17, 19, 0, -26 },
  { 3734, 15, 3, 15, -3, 3 },
  { 3740, 8, 6, 12, 5, -28 },
  { 3746, 19, 21, 20, 1, -21 },
  { 3796, 19, 28, 20, 0, -28 },
  { 3863, 16, 21, 17, 1, -21 },
  { 3905, 21, 28, 20, 1, -28 },
  { 3979, 18, 21, 19, 1, -21 },
  { 4027, 21, 37, 13, -4, -28 },
  { 4125, 20, 30, 21, 0, -21 },
  { 4200, 19, 28, 21, 0, -28 },
  { 4267, 12, 28, 11, 0, -28 },
  { 4309, 17, 37, 11, -5, -28 },
  { 4388, 22, 28, 20, 0, -28 },
  { 4465, 12, 28, 11, 0, -28 },
  { 4507, 29, 21, 31, 0, -21 },
  { 4584, 19, 21, 21, 0, -21 },
  { 4634, 18, 21, 20, 1, -21 },
  { 4682, 21, 30, 20, -2, -21 },
  { 4761, 19, 30, 20, 1, -21 },
  { 4833, 16, 21, 15, 0, -21 },
  { 4875, 16, 21, 16, 0, -21 },
  { 4917, 13, 25, 14, 2, -25 },
  { 4958, 20, 20, 21, 1, -20 },
  { 5008, 18, 20, 18, 2, -20 },
  { 5053, 28, 20, 28, 2, -20 },
  { 5123, 23, 20, 19, -2, -20 },
  { 5181, 22, 29, 18, -2, -20 },
  { 5261, 18, 20, 16, -1, -20 },
  { 5306, 16, 32, 13, 0, -26 },
  { 5370, 4, 36, 18, 7, -28 },
  { 5388, 15, 32, 13, -2, -26 },
  { 5448, 17, 6, 20, 2, -16 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBoldItalic37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBoldItalic37pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBoldItalic37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC37PT7B_H_
