#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC71PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC71PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBoldItalic.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBoldItalic71pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x7F, 0xE7, 0xFE,
  0x1F, 0xFC, 0xFF, 0xC3, 0xFF, 0x9F, 0xF8, 0x7F, 0xE3, 0xFF, 0x0F, 0xFC,
  0xFF, 0xC1, 0xFF, 0x9F, 0xF8, 0x3F, 0xE3, 0xFF, 0x07, 0xFC, 0x7F, 0xC1,
  0xFF, 0x8F, 0xF8, 0x3F, 0xF1, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x87,
  0xF8, 0x1F, 0xF1, 0xFF, 0x03, 0xFC, 0x3F, 0xE0, 0x7F, 0x87, 0xF8, 0x1F,
  0xF0, 0xFF, 0x03, 0xFE, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x01, 0xFF,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xEF, 0x3F, 0xC0,
  0x3F, 0xF8, 0xF0, 0x78, 0x03, 0xFF, 0x9F, 0x00, 0x80, 0x3F, 0xF1, 0xF0,
  0x00, 0x03, 0xFF, 0x1E, 0x00, 0x00, 0x3F, 0xF1, 0xE0, 0x00, 0x03, 0xFF,
  0x9E, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0xF7, 0xFF, 0x80, 0x00, 0x1F, 0x3F, 0xF8, 0x00, 0x01,
  0xF3, 0xFF, 0x80, 0x00, 0x1E, 0x3F, 0xF8, 0x40, 0x01, 0xE3, 0xFF, 0x87,
  0x00, 0x3E, 0x3F, 0xF0, 0x7C, 0x03, 0xE7, 0xFF, 0x07, 0xF0, 0x3E, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xFF,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x1F,
  0xE0, 0x00, 0xFF, 0x83, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xF0,
  0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x81, 0xFF, 0x00, 0x01, 0xFE, 0x07,
  0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x80, 0x00, 0xFF,
  0x83, 0xFE, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0x80, 0x00,
  0x3F, 0xE0, 0xFF, 0x87, 0xFC, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x7F, 0xC0,
  0x00, 0x0F, 0xF0, 0x7F, 0xC3, 0xFC, 0x0F, 0xF0, 0x7F, 0x83, 0xFE, 0x3F,
  0xE1, 0xFF, 0xE3, 0xFE, 0x3F, 0xE3, 0xFE, 0x1F, 0xFF, 0x9F, 0xF3, 0xFF,
  0x1F, 0xE3, 0xFF, 0xFE, 0xFF, 0xFF, 0xF1, 0xFF, 0x1F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x9F, 0xF1, 0xFF, 0xFF, 0xDF, 0xFF, 0xF8, 0xFF, 0x1F, 0xFF, 0xFE,
  0xFF, 0xFF, 0x8F, 0xF8, 0xFF, 0x9F, 0xF3, 0xFF, 0xF8, 0xFF, 0x8F, 0xF8,
  0x7F, 0x8F, 0xFF, 0x87, 0xF8, 0x7F, 0xC3, 0xFC, 0x1F, 0xF0, 0x7F, 0xC7,
  0xFC, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x00, 0x00, 0x3F,
  0xC1, 0xFE, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x3F, 0xC0, 0x00,
  0x3F, 0xE0, 0xFF, 0x81, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x80, 0x01, 0xFF, 0x01, 0xFE, 0x07,
  0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x7F,
  0x83, 0xFE, 0x00, 0x0F, 0xF8, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x07, 0xFC, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF1, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xDF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xF0, 0xFF,
  0xFB, 0xFF, 0xE7, 0xFF, 0x07, 0xFF, 0x8F, 0xFF, 0x3F, 0xF8, 0x7F, 0xF8,
  0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x3F, 0xFC, 0x07,
  0xFF, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xDF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF8, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF9, 0xFF, 0xCF, 0xFC, 0x7F, 0xE3, 0xFF, 0x3F,
  0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xF8,
  0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x0C, 0x01, 0xFF, 0x00,
  0x1E, 0x03, 0xFC, 0x00, 0x3F, 0x07, 0xF8, 0x00, 0xFF, 0x8F, 0xF0, 0x01,
  0xFF, 0xDF, 0xC0, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xCF, 0xF0, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x00, 0x0F, 0xFE, 0xFF, 0x00, 0x3F, 0xF9, 0xFE, 0x00, 0xFF, 0xE3,
  0xFE, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x7F, 0x07, 0xFC, 0x00, 0x7C, 0x0F,
  0xFC, 0x00, 0x78, 0x1F, 0xF8, 0x00, 0x60, 0x1F, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x03, 0x80, 0x7F, 0x8F,
  0xFC, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFC, 0xFF, 0x81, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFC, 0x7F, 0xF8, 0x0F, 0xFF, 0x07,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFE, 0x1F, 0xFE,
  0x01, 0xFF, 0xC3, 0xFF, 0xC0, 0x3F, 0xF8, 0x7F, 0xF0, 0x07, 0xFF, 0x1F,
  0xFE, 0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0x3F, 0xFC, 0x7F, 0xF0, 0x07, 0xFF,
  0x9F, 0xFE, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x1F, 0xFC, 0x7F, 0xF0, 0x03,
  0xFF, 0x8F, 0xFE, 0x00, 0x7F, 0xF3, 0xFF, 0xC0, 0x0F, 0xFE, 0x7F, 0xF8,
  0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x7F, 0xF9, 0xFF, 0xC0, 0x0F, 0xFF, 0x3F,
  0xF8, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x3F, 0xF9, 0xFF, 0xE0, 0x0F, 0xFF,
  0x3F, 0xFC, 0x01, 0xFF, 0xE7, 0xFF, 0x00, 0x3F, 0xFC, 0xFF, 0xE0, 0x07,
  0xFF, 0x1F, 0xFC, 0x01, 0xFF, 0xE3, 0xFF, 0x80, 0x3F, 0xFC, 0x7F, 0xF0,
  0x07, 0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0xE1, 0xFF, 0xC0, 0x3F, 0xF8, 0x3F,
  0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8,
  0x0F, 0xFE, 0x1F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFD, 0xFF, 0x87, 0xFF, 0xBF, 0xF8, 0x3F, 0xE3, 0xFF,
  0x81, 0xFC, 0x3F, 0xF8, 0x1F, 0x87, 0xFF, 0x00, 0xE0, 0x7F, 0xF0, 0x0C,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xF7, 0xFF, 0xF0,
  0x03, 0xFE, 0x03, 0xFF, 0xC0, 0x07, 0xE0, 0x0F, 0xFF, 0x00, 0x0F, 0x00,
  0x3F, 0xFC, 0x00, 0x38, 0x00, 0xFF, 0xF0, 0x00, 0x40, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x0F,
  0xFF, 0x80, 0x0F, 0x80, 0x3F, 0xFE, 0x00, 0x30, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFE, 0x10, 0x00, 0x01, 0xFF, 0xE0, 0xE0, 0x00, 0x1F, 0xFF,
  0x07, 0xE0, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFE, 0xFF,
  0xC0, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x00, 0x7F, 0xDF, 0xFC, 0x00, 0x03,
  0xFE, 0x7F, 0xF0, 0x00, 0x1F, 0xF1, 0xFF, 0xC0, 0x00, 0x7F, 0xC7, 0xFE,
  0x00, 0x03, 0xFE, 0x3F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0xE0, 0x00, 0xFF,
  0x83, 0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0xF0,
  0x00, 0xFF, 0x81, 0xFF, 0xC0, 0x07, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0xF0,
  0x1F, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x88, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x00, 0x80, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFE, 0x08, 0x00, 0x03, 0xFF, 0xE0, 0xE0, 0x00, 0x7F, 0xFE, 0x0F,
  0xC0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x18, 0x07, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE1, 0xFF, 0x00,
  0x1F, 0xFC, 0xFF, 0xF8, 0x03, 0xFF, 0xBF, 0xFF, 0x80, 0x7F, 0xEF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0x0F, 0xFF, 0x8F, 0xFF, 0x80, 0xFF, 0xF1, 0xFF, 0xF0, 0x1F, 0xFE,
  0x3F, 0xFC, 0x03, 0xFF, 0xC7, 0xFF, 0x80, 0x7F, 0xF8, 0xFF, 0xE0, 0x0F,
  0xFF, 0x1F, 0xFC, 0x01, 0xFF, 0xE3, 0xFF, 0x80, 0x3F, 0xF8, 0x7F, 0xF0,
  0x07, 0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x3F, 0xFC, 0x3F,
  0xF8, 0x07, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xFC,
  0x1F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xF1, 0xFF, 0xF0, 0x1F, 0xFE, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF,
  0x80, 0x7F, 0xF0, 0x1F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xF0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xFC, 0x1F,
  0xFC, 0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0x7F,
  0xF0, 0x7F, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0xFF, 0xE0,
  0x03, 0xFF, 0x8F, 0xFE, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x03, 0xFF, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0xF0, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0xFF,
  0xF0, 0x7F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xF1, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x3F, 0xFC, 0x07,
  0xFF, 0x1F, 0xFE, 0x01, 0xFF, 0xC7, 0xFF, 0x80, 0x7F, 0xF1, 0xFF, 0xC0,
  0x1F, 0xFC, 0x7F, 0xF0, 0x07, 0xFF, 0x3F, 0xFC, 0x01, 0xFF, 0xCF, 0xFF,
  0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x3F, 0xFC, 0xFF, 0xE0, 0x0F, 0xFF, 0x3F,
  0xF8, 0x03, 0xFF, 0xCF, 0xFF, 0x01, 0xFF, 0xF3, 0xFF, 0xC0, 0x7F, 0xFC,
  0xFF, 0xF8, 0x3F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFE, 0xFF, 0xC0, 0x7F, 0xFF, 0x7F, 0xF0, 0x0F, 0xFF,
  0x9F, 0xFC, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x07, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xE0, 0x20, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x02, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0x7F,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x1F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x03,
  0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xFC, 0x03,
  0xFE, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x08, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0x03, 0xFF, 0xC3,
  0xE0, 0x0F, 0xFE, 0x18, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x07, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x3F, 0xE0, 0x07, 0xFF, 0xE0,
  0x7F, 0x80, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0xFF, 0x07, 0xFC, 0x07, 0xFF,
  0xFF, 0x83, 0xFC, 0x3F, 0xE0, 0x3F, 0xFF, 0xFE, 0x0F, 0xF0, 0xFF, 0x01,
  0xFF, 0xFF, 0xF8, 0x3F, 0xC3, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0x1F,
  0xE0, 0x3F, 0xE0, 0xFF, 0x03, 0xFC, 0x7F, 0x81, 0xFF, 0x03, 0xFC, 0x0F,
  0xF3, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x3F, 0xCF, 0xF0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x3F, 0xC1, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0xFE, 0x07, 0xF8,
  0x07, 0xF8, 0x0F, 0xF7, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0x9F, 0xE0,
  0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x7F, 0x83, 0xFC, 0x03, 0xFC, 0x07, 0xF9,
  0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE7, 0xF8, 0x3F, 0xC0, 0x3F, 0xC0,
  0xFF, 0x1F, 0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x7F, 0x07, 0xFC, 0x07,
  0xF8, 0x0F, 0xE1, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0x8F, 0xF0, 0x7F,
  0xC0, 0xFF, 0x83, 0xFE, 0x3F, 0xC0, 0xFF, 0x07, 0xFE, 0x1F, 0xF0, 0xFF,
  0x03, 0xFE, 0x3F, 0xF8, 0xFF, 0x81, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x7F, 0xFF, 0x7F,
  0xFF, 0x80, 0x7F, 0x81, 0xFF, 0xF9, 0xFF, 0xFC, 0x01, 0xFE, 0x03, 0xFF,
  0xC3, 0xFF, 0xC0, 0x07, 0xFC, 0x03, 0xFC, 0x07, 0xFE, 0x00, 0x0F, 0xF0,
  0x01, 0x00, 0x01, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xBF, 0xE0, 0x00, 0x00, 0x7F, 0xEF, 0xF8,
  0x00, 0x00, 0x3F, 0xFB, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x00, 0xFF,
  0xE3, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x3F,
  0xF0, 0x00, 0x07, 0xFF, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0x1F,
  0xFC, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x0F, 0xFC,
  0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x7F, 0xF8, 0x00, 0x0F, 0xFE,
  0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x8F, 0xFF, 0x00, 0x00, 0xFF, 0xE3, 0xFF,
  0xC0, 0x00, 0x3F, 0xFD, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xF0, 0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0xFF, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0,
  0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xFC,
  0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0,
  0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x3F,
  0xFC, 0x01, 0xFF, 0xF0, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x07,
  0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x8F, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xF0, 0x03,
  0xFF, 0xF0, 0x00, 0x30, 0x07, 0xFF, 0xE0, 0x00, 0x10, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x04, 0x00,
  0x7F, 0xFE, 0x00, 0x1C, 0x00, 0x3F, 0xFF, 0x81, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0x03, 0xFF, 0xF8, 0x03, 0xFF,
  0xC0, 0x7F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x01,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x1F,
  0xFC, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0x3F,
  0xFC, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x81,
  0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x1F, 0xFC,
  0x00, 0x1F, 0xFE, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0x3F, 0xFC,
  0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x81, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0x00,
  0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0xFF,
  0x80, 0x1F, 0xFF, 0xE0, 0x03, 0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0x30, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x7F, 0xFF, 0xF1, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x7F, 0xF8, 0x07, 0xFF, 0xFE, 0x1F, 0xFE, 0x03, 0xFF, 0xFF,
  0x87, 0xFF, 0x80, 0xFF, 0xFF, 0xE1, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x7F,
  0xF8, 0x0F, 0xFF, 0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0x01,
  0xFF, 0xFF, 0xC3, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x3F,
  0xF8, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x83,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x1F, 0xFE,
  0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x7F, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x07, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xE1,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x0F, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x7F, 0xFC, 0x00, 0x00,
  0xFF, 0xF1, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC7, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x8F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x3F, 0xFE, 0x00, 0x00, 0x0F,
  0xFE, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFD, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF7, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xDF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x7F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x81, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xDF, 0xF8, 0x01, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFE, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0xFF, 0xDF, 0xE0,
  0x1F, 0xFB, 0xFF, 0x00, 0x3F, 0xF3, 0xFC, 0x03, 0xFE, 0xFF, 0xE0, 0x07,
  0xFE, 0x7F, 0x80, 0xFF, 0xDF, 0xF8, 0x00, 0xFF, 0xCF, 0xF0, 0x1F, 0xF3,
  0xFF, 0x00, 0x1F, 0xF9, 0xFE, 0x03, 0xFE, 0x7F, 0xE0, 0x07, 0xFF, 0x3F,
  0xC0, 0xFF, 0x9F, 0xFC, 0x00, 0xFF, 0xE7, 0xF8, 0x1F, 0xF3, 0xFF, 0x80,
  0x1F, 0xF8, 0xFF, 0x07, 0xFC, 0x7F, 0xE0, 0x03, 0xFF, 0x1F, 0xE0, 0xFF,
  0x8F, 0xFC, 0x00, 0x7F, 0xE3, 0xFC, 0x3F, 0xE3, 0xFF, 0x80, 0x1F, 0xFC,
  0x7F, 0x87, 0xFC, 0x7F, 0xF0, 0x03, 0xFF, 0x0F, 0xF9, 0xFF, 0x0F, 0xFE,
  0x00, 0x7F, 0xE1, 0xFF, 0x3F, 0xE1, 0xFF, 0x80, 0x0F, 0xFC, 0x3F, 0xEF,
  0xF8, 0x3F, 0xF0, 0x01, 0xFF, 0x87, 0xFD, 0xFF, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F,
  0xF8, 0x01, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x7F,
  0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xF8, 0x01,
  0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xC0, 0x07, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0xFF, 0xFE, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xE0,
  0x07, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xFC,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x03, 0xFF,
  0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF,
  0x80, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0xFF,
  0xE0, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xE0,
  0x07, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xFE,
  0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFE, 0x00, 0x7F, 0xEF, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xFB,
  0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0xFF, 0xE0, 0x3F, 0xF0, 0x03, 0xFF,
  0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0xC7, 0xFE, 0x07, 0xFF, 0x00, 0x3F,
  0xF1, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xFC, 0x7F, 0xF0, 0x7F, 0xE0, 0x07,
  0xFF, 0x1F, 0xFC, 0x3F, 0xF8, 0x01, 0xFF, 0xC3, 0xFF, 0x0F, 0xFE, 0x00,
  0x7F, 0xE0, 0xFF, 0xE3, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xF8, 0xFF, 0xC0,
  0x07, 0xFE, 0x07, 0xFE, 0x3F, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0x8F, 0xFC,
  0x00, 0xFF, 0xE0, 0x7F, 0xF3, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xFD, 0xFF,
  0x80, 0x0F, 0xFC, 0x03, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xDF,
  0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFF,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F,
  0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xF8,
  0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x01,
  0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x3F, 0xFC, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0xC3, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x7F, 0xFC, 0x00,
  0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE3, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x8F, 0xFF, 0x00, 0x00, 0xFF, 0xF3,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xCF, 0xFF,
  0x00, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00,
  0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x00, 0x7F, 0xF9, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE7, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xBF, 0xFC, 0x00, 0x01, 0xFF, 0xE7, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x9F, 0xFE, 0x00,
  0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0x87, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0xFE, 0x00,
  0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xFC, 0x03,
  0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xE8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE3, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xE0,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC3, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xE3, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x7F, 0xF8, 0x00, 0x07,
  0xFF, 0x8F, 0xFF, 0x00, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x00, 0x7F, 0xFB, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xEF, 0xFF, 0x00,
  0x00, 0x7F, 0xF9, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xE7, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xBF, 0xFC, 0x00, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x9F, 0xFE, 0x00, 0x01, 0xFF, 0xE3, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x1F, 0xFE, 0x00, 0x1F, 0xFF,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xE1, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xE3, 0xFF, 0xF8, 0x03,
  0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0x80,
  0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0,
  0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xE0,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFE,
  0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0xFF,
  0x81, 0xFF, 0xE0, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x07, 0xFF,
  0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF,
  0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x3F,
  0xF8, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x03,
  0xFF, 0xE3, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xF7, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xF0, 0x03, 0xFF,
  0xC0, 0x03, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0x01, 0x00, 0x00, 0x7F, 0xF8, 0x0E, 0x00, 0x03, 0xFF, 0xC0,
  0x7E, 0x00, 0x3F, 0xFC, 0x03, 0xFE, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x3F,
  0xFC, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x0F, 0xFE,
  0x00, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00,
  0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x01, 0xFF,
  0xE0, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x07,
  0xFF, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x07, 0xFF,
  0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x00,
  0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0x0F, 0xFE,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x3F,
  0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFE, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x7F, 0xF0,
  0x00, 0xFF, 0xF0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x01, 0xFF,
  0xE0, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x07,
  0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x00, 0x3F,
  0xF0, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0xFF,
  0xE0, 0x00, 0x3F, 0xF1, 0xFF, 0xC0, 0x00, 0x3F, 0xF1, 0xFF, 0xC0, 0x00,
  0x3F, 0xF1, 0xFF, 0x80, 0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x00, 0x3F, 0xF3,
  0xFF, 0x80, 0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x00, 0x3F, 0xF7, 0xFF, 0x00,
  0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xCF, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xCF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xF0,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xF0, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0xFE,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xFE,
  0x0F, 0xFB, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xBF, 0xE0, 0xFF,
  0xE0, 0x0F, 0xFE, 0x1F, 0xFB, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xE1, 0xFF,
  0x3F, 0xE1, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xF3, 0xFE, 0x1F, 0xFC, 0x00,
  0xFF, 0xC3, 0xFE, 0x3F, 0xE3, 0xFF, 0x80, 0x0F, 0xFC, 0x3F, 0xE3, 0xFE,
  0x3F, 0xF8, 0x00, 0xFF, 0xC7, 0xFE, 0x3F, 0xE3, 0xFF, 0x00, 0x0F, 0xFC,
  0x7F, 0xC3, 0xFE, 0x7F, 0xF0, 0x00, 0xFF, 0xCF, 0xFC, 0x3F, 0xE7, 0xFF,
  0x00, 0x0F, 0xFC, 0xFF, 0x83, 0xFE, 0x7F, 0xE0, 0x00, 0xFF, 0xCF, 0xF8,
  0x3F, 0xEF, 0xFE, 0x00, 0x0F, 0xFD, 0xFF, 0x83, 0xFE, 0xFF, 0xC0, 0x00,
  0xFF, 0xDF, 0xF0, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xDF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xC7, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF9, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xBF, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xFB, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFE, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xF7, 0xFF, 0x00, 0x07, 0xFF, 0x9F, 0xFC, 0x00, 0x3F, 0xFC, 0x7F, 0xF8,
  0x01, 0xFF, 0xF1, 0xFF, 0xE0, 0x07, 0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xFC,
  0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x80,
  0x1F, 0xFC, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0xF0, 0x01, 0xFF, 0xC3,
  0xFF, 0x80, 0x03, 0xFF, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x7F, 0xF0, 0x00,
  0x3F, 0xFB, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00,
  0x1F, 0xF1, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x01, 0xFF, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xF0, 0x03, 0xFE, 0x01,
  0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x07, 0xFE,
  0x00, 0x7F, 0x80, 0xFF, 0x80, 0x0F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x0F,
  0xFC, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0x7F,
  0xCF, 0xF8, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xE0, 0x3F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xF0, 0xFF, 0xF1, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0x81, 0xFF,
  0x83, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x0F, 0xFF, 0x87, 0xFE,
  0x00, 0xFF, 0xFE, 0x3F, 0xE0, 0x0F, 0xFF, 0xFB, 0xFF, 0x00, 0xFF, 0xFF,
  0xDF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xE0, 0xFF,
  0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF,
  0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0x3F, 0xF8,
  0x3F, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xFE, 0x00,
  0xFF, 0xE0, 0xFF, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x3F,
  0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0xFF, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x3F, 0xFC,
  0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xE0,
  0x7F, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xE1, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xDF, 0xF8, 0x03, 0xFF, 0xFE, 0xFF,
  0x80, 0x0F, 0xFF, 0xE7, 0xFC, 0x00, 0x3F, 0xFE, 0x3F, 0xE0, 0x00, 0x7F,
  0xC1, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xC1, 0xE0, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0xFF,
  0xE7, 0xFF, 0x80, 0x07, 0xFF, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F,
  0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0x81, 0xFF,
  0x80, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xFF,
  0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x3F, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0x80,
  0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xFF, 0x07,
  0xFF, 0x00, 0x7F, 0xF8, 0x3F, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x3F,
  0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xFE, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFB, 0xFF, 0xFE, 0x00, 0xFF, 0x8F, 0xFF, 0xE0, 0x07, 0xFC, 0x3F, 0xFE,
  0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xC0, 0x7F, 0xF8, 0x00, 0x81, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x04, 0x0F, 0xFF, 0x00, 0x30, 0x1F, 0xFF, 0x01, 0xE0, 0x3F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xE0, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x3F, 0xF8, 0x00, 0x1F,
  0xFE, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x0F, 0xFF, 0x03, 0xFF, 0xE0,
  0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF,
  0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x7F,
  0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0,
  0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFE,
  0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xEF, 0xF8, 0x00, 0x1F, 0xFF, 0xCF, 0xF8, 0x00, 0x0F, 0xFF,
  0x8F, 0xF8, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xF7, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xF0, 0x1F, 0xFC,
  0x3F, 0xF8, 0x07, 0xFF, 0x1F, 0xFE, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x7F,
  0xE3, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xE0, 0x1F, 0xFE, 0x3F, 0xF8, 0x1F,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x04, 0x07, 0xFF, 0x80, 0x07,
  0x01, 0xFF, 0xF0, 0x07, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x02, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x06, 0x3F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x1F,
  0xFE, 0x1F, 0xF8, 0x00, 0xFF, 0xFE, 0x3F, 0xE0, 0x03, 0xFF, 0xFE, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFD, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x1F,
  0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x07,
  0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x07,
  0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x01,
  0xFF, 0xC0, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x81,
  0xFF, 0xF0, 0x0F, 0xFF, 0x87, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x7F, 0xE0,
  0x00, 0xFF, 0xFD, 0xFF, 0xC0, 0x00, 0xFF, 0xF3, 0xFF, 0x80, 0x00, 0xFF,
  0x87, 0xFF, 0x00, 0x00, 0x10, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x10, 0x00, 0x07, 0xFF, 0x00, 0x38, 0x00, 0x1F, 0xFE,
  0x00, 0x7E, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0xE0, 0x00,
  0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0xE7, 0xFF, 0xC0, 0x07, 0xFF, 0x7F,
  0xFF, 0x00, 0x3F, 0xF7, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xF0,
  0x3F, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xFC, 0x1F, 0xFE, 0x01,
  0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x3F,
  0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xFC, 0x1F, 0xFE, 0x01, 0xFF,
  0xC0, 0xFF, 0xE0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xF8,
  0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x3F, 0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0xFF, 0xE0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x03,
  0xFF, 0x83, 0xFF, 0xC0, 0x3F, 0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF,
  0xE0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x03, 0xFF,
  0x83, 0xFF, 0xC0, 0x3F, 0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xE0,
  0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xF8, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xC7,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x07,
  0xFF, 0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0xFF, 0xF0,
  0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x00, 0x1F,
  0xFC, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC7,
  0xFF, 0xC0, 0x00, 0xFF, 0xE1, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0xFF, 0xF0,
  0x00, 0x0F, 0xFE, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xBF, 0xFC, 0x00, 0x00,
  0xFF, 0xDF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xBF,
  0xFC, 0x00, 0x07, 0xFF, 0x8F, 0xFF, 0x00, 0x01, 0xFF, 0xC3, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x1F, 0xFE, 0x00, 0x0F,
  0xFE, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0xFF, 0xE0,
  0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xC0, 0xFF, 0xC0, 0x1F,
  0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x1F, 0xF1, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC0, 0x0F, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0x07,
  0xFD, 0xFF, 0xFF, 0x9F, 0xFF, 0xF8, 0x07, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFC, 0x1F, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFE, 0x03, 0xFF,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF,
  0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFF,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0xFF, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0x81, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x03, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xE1, 0xFF, 0xF0, 0x01, 0xFF,
  0x1F, 0xFF, 0xC0, 0x0F, 0xF9, 0xFF, 0xFF, 0x00, 0x7F, 0xDF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFE, 0x07,
  0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x1F,
  0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xFF, 0x07, 0xFF,
  0x80, 0x7F, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xFC,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x3F, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x3F,
  0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xFC, 0x1F, 0xFE, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xF9, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC,
  0x3F, 0xFC, 0x07, 0xFF, 0x1F, 0xFE, 0x01, 0xFF, 0xC7, 0xFF, 0x80, 0x7F,
  0xF3, 0xFF, 0xC0, 0x1F, 0xFC, 0xFF, 0xF0, 0x07, 0xFF, 0x3F, 0xF8, 0x01,
  0xFF, 0xDF, 0xFE, 0x00, 0x7F, 0xF7, 0xFF, 0x80, 0x1F, 0xFD, 0xFF, 0xE0,
  0x07, 0xFF, 0x7F, 0xF0, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0xFF, 0xF7, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xF0, 0x03, 0xFF, 0xBF,
  0xFC, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x7F, 0xF3, 0xFF, 0xC0, 0x3F, 0xFC,
  0xFF, 0xF0, 0x0F, 0xFF, 0x1F, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0x83, 0xFF,
  0xE1, 0xFF, 0xFB, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0F, 0xF0, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0xFF, 0xF0, 0x00,
  0x1F, 0xF1, 0xFF, 0xF8, 0x00, 0x1F, 0xF3, 0xFF, 0xFC, 0x00, 0x1F, 0xF7,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xBF, 0xFF, 0x00, 0x3F,
  0xFE, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x0F,
  0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0xFF, 0xF8, 0x07, 0xFF, 0xE1, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFE, 0xFF, 0xFF,
  0x00, 0x0F, 0xFE, 0xFF, 0xFE, 0x00, 0x0F, 0xFE, 0x7F, 0xFC, 0x00, 0x1F,
  0xFC, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x07, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x7F, 0xC0, 0x07, 0xFF, 0xC7, 0xFE, 0x00, 0xFF, 0xFE, 0x3F, 0xE0,
  0x0F, 0xFF, 0xF9, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFE, 0x07, 0xFF,
  0xC1, 0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF0,
  0x07, 0xFF, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x3F, 0xFC, 0x01, 0xFF, 0xC1,
  0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xF0, 0x07,
  0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x01, 0xFF, 0xC1, 0xFF,
  0xC0, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xF0, 0x07, 0xFF,
  0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x3F, 0xFC, 0x03, 0xFF, 0xC1, 0xFF, 0xE0,
  0x1F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x03,
  0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFD, 0xFF, 0x80, 0x0F, 0xFF, 0xDF, 0xFC,
  0x00, 0x3F, 0xFC, 0xFF, 0xE0, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x00, 0xF0,
  0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0x83,
  0xFC, 0x03, 0xFF, 0x1F, 0xF8, 0x07, 0xFC, 0x7F, 0xE0, 0x0F, 0xF9, 0xFF,
  0xC0, 0x1F, 0xF3, 0xFF, 0x80, 0x7F, 0xEF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFB, 0x80, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x03, 0xE0, 0x1F, 0xFC, 0x00, 0xC0, 0x7F,
  0xF8, 0x00, 0x80, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x18, 0x00, 0x1F, 0xFC,
  0x3C, 0x00, 0x7F, 0xF8, 0x7F, 0x03, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x04, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x7F, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x07,
  0xFF, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0xE1,
  0xFF, 0xC0, 0x1F, 0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x1F,
  0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0xFC, 0x3F, 0xF8,
  0x03, 0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xF8, 0x3F, 0xF8, 0x03, 0xFF, 0x83,
  0xFF, 0x80, 0x3F, 0xF8, 0x7F, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x7F, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xF0,
  0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F,
  0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xFE, 0x0F, 0xFE, 0x03, 0xFF,
  0xE0, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFE, 0xFF, 0x80, 0x7F, 0xFF, 0xEF, 0xF8, 0x07, 0xFF, 0xFC, 0xFF,
  0x80, 0x3F, 0xFF, 0x8F, 0xF8, 0x01, 0xFF, 0xF1, 0xFF, 0x00, 0x0F, 0xFC,
  0x1F, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFB, 0xFF, 0x80, 0x0F, 0xFF, 0x7F, 0xF0, 0x03, 0xFF,
  0xCF, 0xFE, 0x00, 0x7F, 0xF1, 0xFF, 0xC0, 0x1F, 0xFE, 0x3F, 0xF8, 0x03,
  0xFF, 0x87, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0xFC,
  0x03, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xFC, 0x07,
  0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF8, 0x3F, 0xF8,
  0x03, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xE1, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F,
  0xF8, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xF1, 0xFF, 0xC0, 0x03, 0xFE,
  0x3F, 0xF0, 0x00, 0x7F, 0xCF, 0xFE, 0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x01,
  0xFF, 0x7F, 0xF0, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x07, 0xFD, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xBF,
  0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xFD, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF,
  0xCF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFE, 0x7F, 0xF0, 0x1F, 0xFF, 0x80,
  0xFF, 0xE3, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0x1F, 0xFC, 0x0F, 0xFF,
  0xE0, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0x87, 0xFF, 0x07,
  0xFF, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF,
  0xC1, 0xFF, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0xEF, 0xF0, 0xFF, 0xE0,
  0x3F, 0xF0, 0xFF, 0x7F, 0x87, 0xFF, 0x01, 0xFF, 0x8F, 0xFB, 0xFC, 0x3F,
  0xF0, 0x0F, 0xFC, 0x7F, 0x9F, 0xE3, 0xFF, 0x80, 0x7F, 0xE3, 0xFC, 0xFF,
  0x1F, 0xF8, 0x03, 0xFE, 0x3F, 0xEF, 0xF9, 0xFF, 0xC0, 0x1F, 0xF1, 0xFE,
  0x7F, 0xCF, 0xFC, 0x00, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xE0, 0x07, 0xFC,
  0xFF, 0x1F, 0xF7, 0xFE, 0x00, 0x3F, 0xE7, 0xF8, 0xFF, 0x3F, 0xF0, 0x01,
  0xFF, 0x7F, 0xC7, 0xF9, 0xFF, 0x80, 0x0F, 0xFB, 0xFC, 0x3F, 0xDF, 0xF8,
  0x00, 0x7F, 0xDF, 0xE1, 0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x0F, 0xF7,
  0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x83,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFE,
  0x00, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC1,
  0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE3, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE7, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF7, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0xC7, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0x83, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x3F,
  0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xF0, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0x8F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0x9F, 0xFC, 0x00, 0x00, 0x1F, 0xF9, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x00, 0x1F, 0xFB, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xBF, 0xF0, 0x00, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x43, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x80, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x8F,
  0xFF, 0xC0, 0x00, 0xDF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xB0, 0x00, 0x1F, 0xFF, 0x90, 0x00, 0x01, 0xFF, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBoldItalic71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 23, 52, 20, 0, -51 },
  { 151, 27, 19, 31, 7, -51 },
  { 216, 42, 51, 42, 1, -51 },
  { 484, 36, 58, 37, 1, -54 },
  { 745, 53, 52, 59, 4, -51 },
  { 1090, 45, 52, 47, 1, -51 },
  { 1383, 13, 19, 17, 7, -51 },
  { 1414, 26, 62, 23, 2, -51 },
  { 1616, 26, 63, 23, -5, -52 },
  { 1821, 31, 33, 36, 6, -54 },
  { 1949, 33, 34, 39, 3, -42 },
  { 2090, 18, 18, 20, -4, -9 },
  { 2131, 20, 10, 22, 1, -24 },
  { 2156, 13, 13, 20, 0, -12 },
  { 2178, 38, 52, 30, -3, -51 },
  { 2425, 35, 52, 37, 2, -51 },
  { 2653, 28, 51, 37, 6, -51 },
  { 2832, 38, 51, 37, -2, -51 },
  { 3075, 37, 52, 37, 0, -51 },
  { 3316, 38, 51, 37, -1, -51 },
  { 3559, 36, 52, 37, 1, -51 },
  { 3793, 35, 52, 37, 3, -51 },
  { 4021, 38, 51, 37, 2, -51 },
  { 4264, 36, 52, 37, 1, -51 },
  { 4498, 34, 52, 37, 2, -51 },
  { 4719, 19, 41, 20, 0, -40 },
  { 4817, 23, 49, 20, -4, -40 },
  { 4958, 33, 37, 39, 3, -44 },
  { 5111, 33, 24, 39, 3, -37 },
  { 5210, 33, 37, 39, 3, -44 },
  { 5363, 29, 52, 30, 4, -51 },
  { 5552, 54, 57, 57, 2, -51 },
  { 5937, 42, 51, 42, -4, -51 },
  { 6205, 40, 51, 41, 1, -51 },
  { 6460, 40, 52, 40, 3, -51 },
  { 6720, 42, 51, 44, 1, -51 },
  { 6988, 37, 51, 35, 1, -51 },
  { 7224, 37, 51, 35, 1, -51 },
  { 7460, 42, 52, 45, 3, -51 },
  { 7733, 46, 51, 46, 1, -51 },
  { 8027, 33, 51, 27, -2, -51 },
  { 8238, 35, 66, 23, -11, -51 },
  { 8527, 47, 51, 41, 1, -51 },
  { 8827, 29, 51, 34, 1, -51 },
  { 9012, 59, 51, 59, 1, -51 },
  { 9389, 50, 51, 50, 1, -51 },
  { 9708, 43, 52, 48, 3, -51 },
  { 9988, 40, 51, 40, 1, -51 },
  { 10243, 43, 63, 48, 3, -51 },
  { 10582, 39, 51, 41, 1, -51 },
  { 10831, 37, 52, 35, 0, -51 },
  { 11072, 34, 51, 35, 6, -51 },
  { 11289, 42, 52, 45, 4, -51 },
  { 11562, 40, 51, 40, 6, -51 },
  { 11817, 60, 51, 60, 6, -51 },
  { 12200, 50, 51, 41, -4, -51 },
  { 12519, 38, 51, 38, 6, -51 },
  { 12762, 42, 51, 35, -3, -51 },
  { 13030, 30, 63, 23, -2, -51 },
  { 13267, 18, 52, 30, 7, -51 },
  { 13384, 30, 63, 23, -5, -51 },
  { 13621, 35, 33, 36, 0, -51 },
  { 13766, 30, 6, 28, -7, 6 },
  { 13789, 15, 11, 23, 10, -54 },
  { 13810, 37, 41, 39, 2, -40 },
  { 14000, 37, 55, 39, 0, -54 },
  { 14255, 31, 41, 32, 2, -40 },
  { 14414, 40, 55, 39, 2, -54 },
  { 14689, 34, 41, 37, 2, -40 },
  { 14864, 41, 71, 25, -8, -54 },
  { 15228, 39, 57, 39, 0, -40 },
  { 15506, 37, 54, 40, 0, -54 },
  { 15756, 23, 55, 20, 0, -55 },
  { 15915, 32, 72, 20, -9, -55 },
  { 16203, 42, 54, 38, 0, -54 },
  { 16487, 23, 54, 20, 0, -54 },
  { 16643, 57, 40, 59, 0, -40 },
  { 16928, 37, 40, 40, 0, -40 },
  { 17113, 34, 41, 39, 2, -40 },
  { 17288, 40, 57, 39, -3, -40 },
  { 17573, 37, 57, 39, 2, -40 },
  { 17837, 31, 40, 28, 0, -40 },
  { 17992, 31, 41, 32, 0, -40 },
  { 18151, 26, 48, 28, 3, -47 },
  { 18307, 36, 40, 40, 3, -39 },
  { 18487, 35, 39, 35, 4, -39 },
  { 18658, 53, 39, 53, 4, -39 },
  { 18917, 44, 39, 36, -4, -39 },
  { 19132, 44, 56, 35, -5, -39 },
  { 19440, 34, 39, 31, -2, -39 },
  { 19606, 30, 62, 25, 0, -51 },
  { 19839, 9, 70, 35, 13, -54 },
  { 19918, 29, 62, 25, -4, -51 },
  { 20143, 33, 12, 39, 3, -31 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBoldItalic71pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBoldItalic71pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBoldItalic71pt7bGlyphs,
  0x20, 0x7E, 97
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC71PT7B_H_
