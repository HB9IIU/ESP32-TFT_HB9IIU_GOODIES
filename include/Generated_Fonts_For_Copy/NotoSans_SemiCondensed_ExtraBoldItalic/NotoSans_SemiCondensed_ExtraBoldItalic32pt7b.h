#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC32PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBoldItalic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBoldItalic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0xC3, 0xF0, 0xFC, 0x3E, 0x0F, 0x83, 0xE1, 0xF8, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x83, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xC1, 0xF0, 0xFC, 0x3F, 0x0F, 0x80, 0x7C, 0xF7, 0xDF, 0x79, 0xF7, 0x9E,
  0x79, 0xEF, 0x1E, 0xF1, 0xEF, 0x3C, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x00,
  0xE3, 0xC0, 0x1E, 0x38, 0x01, 0xE7, 0x80, 0x1C, 0x78, 0x1F, 0xFF, 0xF3,
  0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x07, 0x8E, 0x00, 0x79, 0xE0,
  0x07, 0x1E, 0x07, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF,
  0x81, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xC7, 0x00, 0x3C, 0x70, 0x03, 0xCF,
  0x00, 0x38, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x60, 0x03, 0xFC, 0x0F, 0xFF,
  0x1F, 0xFE, 0x1F, 0xFE, 0x3E, 0xCC, 0x3E, 0xC0, 0x3E, 0xC0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFC, 0x03, 0x7C,
  0x03, 0x3C, 0x83, 0x7C, 0xF3, 0xFC, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xE0,
  0x1F, 0x80, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0F, 0x80, 0x78, 0x3F,
  0xC0, 0x78, 0x3F, 0xC0, 0xF0, 0x7B, 0xC1, 0xE0, 0x79, 0xE1, 0xC0, 0xF1,
  0xE3, 0xC0, 0xF3, 0xC7, 0x80, 0xF3, 0xC7, 0x00, 0xF3, 0xCF, 0x00, 0xF3,
  0xDE, 0x7C, 0xF7, 0x9C, 0xFE, 0xFF, 0xBD, 0xFF, 0x7F, 0x7B, 0xEF, 0x3E,
  0x73, 0xCF, 0x00, 0xF3, 0xCF, 0x01, 0xE7, 0x8F, 0x01, 0xC7, 0x8F, 0x03,
  0xC7, 0x9E, 0x07, 0x87, 0x9E, 0x07, 0x07, 0xBE, 0x0F, 0x07, 0xFC, 0x1E,
  0x03, 0xF8, 0x3C, 0x01, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7C, 0xF8, 0x03, 0xC7, 0xC0, 0x1E, 0x3E, 0x00,
  0xFB, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE1,
  0xF1, 0xFF, 0x9F, 0x1F, 0xFC, 0xF9, 0xF3, 0xFF, 0x8F, 0x8F, 0xFC, 0xFC,
  0x7F, 0xC7, 0xE1, 0xFC, 0x3F, 0x0F, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE0, 0x7F, 0x9F, 0x80, 0x7D, 0xF7, 0x9E, 0x7B, 0xCF, 0x3C,
  0x01, 0xF0, 0x3E, 0x07, 0xC0, 0x78, 0x0F, 0x81, 0xF0, 0x1E, 0x03, 0xE0,
  0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80,
  0xF8, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E,
  0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x78,
  0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xC0, 0x78, 0x0F, 0x80,
  0x02, 0x00, 0x03, 0xC0, 0x07, 0x81, 0x0E, 0x07, 0x1C, 0x0F, 0xF8, 0x5F,
  0xFF, 0xDF, 0xFF, 0x07, 0xFE, 0x1F, 0x9C, 0x7F, 0x81, 0xFF, 0x07, 0xCF,
  0x03, 0x1F, 0x02, 0x38, 0x00, 0x40, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x1F,
  0x1F, 0x3E, 0x3E, 0x3C, 0x7C, 0x78, 0xF8, 0x7F, 0xDF, 0xE7, 0xF9, 0xFE,
  0xFF, 0x80, 0x7B, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0x3E, 0x3F, 0x3E, 0x3E, 0x1F,
  0x7E, 0x3F, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E,
  0xF8, 0x3E, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0xF8, 0xF9, 0xF8,
  0xFF, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0x80, 0x00, 0xF0, 0x3F, 0x07,
  0xF0, 0xFF, 0x3F, 0xF7, 0xFE, 0xFF, 0xE7, 0xBE, 0x63, 0xE4, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0x81,
  0xFF, 0xE1, 0xFF, 0xF0, 0x79, 0xF8, 0x30, 0x7C, 0x08, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0xFF, 0xC7, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF0, 0x03, 0xFC, 0x0F, 0xFE,
  0x1F, 0xFF, 0x0F, 0xFF, 0x06, 0x1F, 0x04, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x3E, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xFC, 0x08, 0xFC,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0xC0, 0xFC, 0xFF, 0xFC,
  0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xC0, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F,
  0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x07,
  0xBE, 0x07, 0xDF, 0x03, 0xCF, 0x03, 0xCF, 0x83, 0xC7, 0xC3, 0xE3, 0xE1,
  0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xFF, 0x83, 0xFF, 0xC1,
  0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x1F, 0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC1, 0xDF, 0xE0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x40, 0x3F, 0x30, 0x3F, 0x1F,
  0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0x7F, 0x01, 0xFF,
  0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7C, 0xF0, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0xFE, 0x7E, 0xFC, 0x7E,
  0xFC, 0x7E, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xFC, 0xFC, 0x7F, 0xF8,
  0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xC0, 0x1F, 0xFF, 0x8F, 0xFF, 0xCF, 0xFF,
  0xE7, 0xFF, 0xE3, 0xFF, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0,
  0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x07, 0xFC, 0x0F,
  0xFE, 0x1F, 0xFF, 0x1F, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x1F, 0x3E, 0x1F,
  0x7E, 0x1F, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xF8, 0x7E, 0xF8, 0xFC,
  0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF0, 0x7C, 0xF8, 0x7C, 0xFF, 0xF8, 0xFF,
  0xF8, 0x7F, 0xF0, 0x3F, 0xC0, 0x03, 0xF0, 0x1F, 0xF8, 0x7F, 0xF1, 0xFF,
  0xF3, 0xF3, 0xEF, 0xC7, 0xDF, 0x0F, 0xBE, 0x1F, 0x7C, 0x3E, 0xF8, 0x7D,
  0xF1, 0xFB, 0xFF, 0xF7, 0xFF, 0xE7, 0xF7, 0x87, 0xDF, 0x00, 0x3E, 0x00,
  0xF8, 0x03, 0xF0, 0x0F, 0xC7, 0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0x80,
  0x00, 0x07, 0x07, 0xC7, 0xE3, 0xF1, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC3, 0xF1, 0xF8, 0xFC, 0x7C, 0x00, 0x01, 0xC0,
  0x7C, 0x1F, 0x83, 0xF0, 0x7C, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC0, 0xF0,
  0x3E, 0x07, 0x81, 0xF0, 0x00, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x78, 0x03,
  0xF0, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0x80, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xC0, 0x0F, 0x80, 0x03, 0x00,
  0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x01, 0xC0, 0x03,
  0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x3E, 0x01, 0xFC, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x1F, 0xE0, 0x3E, 0x00,
  0x70, 0x00, 0x80, 0x00, 0x1F, 0xC3, 0xFF, 0x9F, 0xFC, 0xFF, 0xF3, 0x0F,
  0xA0, 0x7C, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x03,
  0xE0, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x01, 0xF8,
  0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x07, 0xE0, 0x7E, 0x0F, 0x80, 0x1E, 0x1F, 0x00, 0x0F,
  0x1E, 0x1F, 0x8F, 0x3C, 0x7F, 0xE7, 0x38, 0xFF, 0xC7, 0x78, 0xF3, 0xC7,
  0x71, 0xE3, 0xC7, 0x71, 0xC3, 0x87, 0xF3, 0xC3, 0x8F, 0xF3, 0xC7, 0x8F,
  0xF3, 0xC7, 0x8E, 0xF3, 0xCF, 0x9E, 0xF3, 0xDF, 0xBC, 0xF3, 0xFF, 0xF8,
  0xF1, 0xFB, 0xF0, 0x70, 0x60, 0xC0, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x80,
  0x3F, 0x8F, 0x80, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xBC,
  0x00, 0xF7, 0x80, 0x3E, 0xF0, 0x07, 0x9E, 0x01, 0xF3, 0xC0, 0x3C, 0x78,
  0x0F, 0x8F, 0x01, 0xF1, 0xE0, 0x7C, 0x3C, 0x0F, 0x87, 0x83, 0xFF, 0xF8,
  0x7F, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFC, 0x0F, 0x9F, 0x01, 0xF7,
  0xE0, 0x3E, 0xF8, 0x07, 0xFF, 0x00, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xE0,
  0x7F, 0xFC, 0x1F, 0xFF, 0x0F, 0x8F, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x1F, 0x8F, 0xC7, 0xFF, 0xE1, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFF,
  0x0F, 0xC7, 0xC3, 0xE1, 0xF8, 0xF8, 0x7E, 0x3E, 0x1F, 0x8F, 0x87, 0xC7,
  0xC7, 0xF1, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x00, 0x01,
  0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xE1, 0xFC, 0x71, 0xF8, 0x09,
  0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3F, 0x06, 0x1F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xC0,
  0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xFE,
  0x1F, 0x0F, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x1F, 0x83, 0xE3, 0xE0, 0x7C,
  0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x7E, 0x7E, 0x0F, 0xCF, 0x81, 0xF1,
  0xF0, 0x7E, 0x3E, 0x0F, 0xC7, 0xC3, 0xF1, 0xFB, 0xFC, 0x3F, 0xFF, 0x07,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC1,
  0xFF, 0xE0, 0xFF, 0xE0, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC1, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F,
  0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xC0, 0x07, 0xFF, 0x83, 0xFF,
  0xC1, 0xFF, 0xE0, 0xFF, 0xE0, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC1,
  0xFF, 0xE0, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xC3, 0x8F, 0xC0, 0x27, 0xE0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x87, 0xFB, 0xE1, 0xFE,
  0xF8, 0xFF, 0xBE, 0x3F, 0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3F,
  0x07, 0xCF, 0xE3, 0xE3, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF,
  0x80, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x83, 0xF0,
  0xFC, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x1F, 0x83,
  0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F,
  0x83, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x7E,
  0x1F, 0x83, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC3, 0xF0,
  0x7E, 0x00, 0x07, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x3F, 0xC0, 0x3F, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x7E, 0x01, 0xFE, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0,
  0xDF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFC, 0x00, 0x07, 0xC1,
  0xF8, 0x3E, 0x0F, 0x81, 0xF0, 0xFC, 0x0F, 0x8F, 0xC0, 0xF8, 0xFC, 0x07,
  0xC7, 0xC0, 0x3E, 0x7E, 0x01, 0xF7, 0xE0, 0x1F, 0xFE, 0x00, 0xFB, 0xE0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFD,
  0xF0, 0x07, 0xCF, 0xC0, 0x3E, 0x7E, 0x01, 0xF1, 0xF0, 0x1F, 0x0F, 0x80,
  0xF8, 0x7E, 0x07, 0xC3, 0xF0, 0x3E, 0x0F, 0x83, 0xF0, 0x7E, 0x00, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xFF, 0xF7, 0xFF, 0xBF, 0xFF, 0xFF,
  0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x03, 0xFC, 0x1F, 0xC0, 0x7F, 0x83,
  0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x1F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xF0, 0xF7, 0x83, 0xFE, 0x1F, 0xF0, 0x7F,
  0xC7, 0xBE, 0x0F, 0x78, 0xF7, 0xC1, 0xEF, 0x3C, 0xF0, 0x7D, 0xE7, 0xBE,
  0x0F, 0xBD, 0xE7, 0xC1, 0xF3, 0xBC, 0xF8, 0x3C, 0x7F, 0x1F, 0x07, 0x8F,
  0xE3, 0xC1, 0xF1, 0xFC, 0xF8, 0x3E, 0x3F, 0x1F, 0x07, 0xC7, 0xE3, 0xE0,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x1F, 0x00, 0x07, 0xE0, 0x3E, 0x0F, 0xC0,
  0x7C, 0x1F, 0xC0, 0xF8, 0x3F, 0x81, 0xE0, 0xFF, 0x07, 0xC1, 0xFE, 0x0F,
  0x83, 0xFE, 0x1F, 0x07, 0xFC, 0x3C, 0x1F, 0x78, 0x78, 0x3E, 0xF9, 0xF0,
  0x7D, 0xF3, 0xE0, 0xF3, 0xE7, 0xC1, 0xE3, 0xCF, 0x07, 0xC7, 0xDE, 0x0F,
  0x8F, 0xFC, 0x1F, 0x1F, 0xF8, 0x3C, 0x1F, 0xF0, 0x78, 0x3F, 0xC1, 0xF0,
  0x7F, 0x83, 0xE0, 0xFF, 0x07, 0xC0, 0xFE, 0x0F, 0x01, 0xFC, 0x3E, 0x03,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE1,
  0xFC, 0xFC, 0x7E, 0x0F, 0x9F, 0x81, 0xFB, 0xF0, 0x3F, 0x7C, 0x07, 0xFF,
  0x80, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0xBE,
  0x03, 0xF7, 0xC0, 0x7C, 0xF8, 0x1F, 0x9F, 0x07, 0xF3, 0xF1, 0xFC, 0x7F,
  0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x01,
  0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFF, 0x0F, 0x9F, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x1F, 0x87, 0xC7, 0xC3, 0xF1, 0xF1, 0xF8, 0x7F, 0xFE,
  0x1F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0x80, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFC,
  0xFC, 0x7E, 0x0F, 0x9F, 0x81, 0xFB, 0xF0, 0x3F, 0x7C, 0x07, 0xFF, 0x80,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0xBE, 0x03,
  0xF7, 0xC0, 0x7C, 0xF8, 0x1F, 0x9F, 0x07, 0xE3, 0xF1, 0xFC, 0x7F, 0xFF,
  0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xFC, 0x01, 0xFF,
  0xC0, 0x7F, 0xF8, 0x1F, 0xFF, 0x0F, 0x8F, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x1F, 0x8F, 0xC7, 0xC3, 0xE1, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F,
  0xFE, 0x0F, 0xFE, 0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7E, 0x0F, 0x8F,
  0x87, 0xC3, 0xE1, 0xF0, 0xFC, 0x7C, 0x3F, 0x1F, 0x07, 0xCF, 0xC1, 0xF8,
  0x01, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xE1, 0xFC, 0xE0, 0xF8,
  0x10, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C,
  0x40, 0x7E, 0x3C, 0x7F, 0x1F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x81, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xC1, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x00, 0x1F, 0x03, 0xE3,
  0xE0, 0xFC, 0x7C, 0x1F, 0x1F, 0x83, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F,
  0x83, 0xF1, 0xF0, 0x7C, 0x7E, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3E,
  0x0F, 0xCF, 0xC1, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC1, 0xF8, 0xF8,
  0x3E, 0x1F, 0x07, 0xC3, 0xF1, 0xF8, 0x7F, 0xFE, 0x07, 0xFF, 0x80, 0xFF,
  0xE0, 0x07, 0xF8, 0x00, 0xF8, 0x0F, 0xFE, 0x03, 0xEF, 0x81, 0xFB, 0xE0,
  0x7C, 0xF8, 0x3F, 0x3E, 0x0F, 0x8F, 0x87, 0xE3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0xF8, 0x07,
  0xBE, 0x01, 0xEF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x1E, 0x03, 0xFF,
  0x07, 0xC0, 0xFB, 0xE0, 0xF8, 0x1F, 0x7C, 0x1F, 0x07, 0xCF, 0x87, 0xE0,
  0xF9, 0xF0, 0xFC, 0x1F, 0x3E, 0x3F, 0x87, 0xC7, 0xC7, 0xF0, 0xF8, 0xF1,
  0xFE, 0x3E, 0x1E, 0x3F, 0xC7, 0xC3, 0xC7, 0xF8, 0xF8, 0x79, 0xEF, 0x3E,
  0x0F, 0x3D, 0xE7, 0xC1, 0xEF, 0xBD, 0xF0, 0x3D, 0xE7, 0xBE, 0x07, 0xBC,
  0xF7, 0x80, 0xFF, 0x1F, 0xF0, 0x1F, 0xE3, 0xFE, 0x03, 0xFC, 0x7F, 0x80,
  0x7F, 0x0F, 0xF0, 0x0F, 0xE1, 0xFC, 0x01, 0xF8, 0x3F, 0x80, 0x3F, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x07, 0xC1, 0xF8, 0x0F, 0x87, 0xE0, 0x1F,
  0x8F, 0x80, 0x1F, 0x3F, 0x00, 0x3E, 0x7C, 0x00, 0x7D, 0xF0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x07, 0xDF, 0x00, 0x1F, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0xF8, 0x7C, 0x03,
  0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x3F, 0x01, 0xF0, 0x00, 0xF8, 0x1F, 0xFC,
  0x0F, 0xBE, 0x0F, 0x8F, 0x8F, 0xC7, 0xC7, 0xC3, 0xE7, 0xE1, 0xF3, 0xE0,
  0xFB, 0xE0, 0x3D, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x07, 0xFF,
  0xE0, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0xFF, 0x0F, 0xFF, 0xE1,
  0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78,
  0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xF8, 0x78, 0x78, 0x78, 0x78, 0x78,
  0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3E, 0x3E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1F, 0x1F, 0x1F, 0x0F, 0x03, 0xF8, 0x3F, 0xC1, 0xFE, 0x01, 0xF0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07,
  0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x07, 0xF8, 0x3F,
  0xC1, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x03, 0xF8, 0x07, 0xBC, 0x07, 0xBC, 0x0F, 0x3C, 0x1F, 0x1E, 0x1E,
  0x1E, 0x3C, 0x1E, 0x7C, 0x1E, 0x78, 0x0F, 0xF0, 0x0F, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFB, 0xE7, 0xDF, 0x3C, 0x70, 0x03, 0xCF, 0x87, 0xF7, 0x87,
  0xFB, 0xC7, 0xFF, 0xE3, 0xF7, 0xF3, 0xF1, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C,
  0xFC, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0x1F, 0x0F, 0x8F, 0x87, 0xC7, 0xE7,
  0xE3, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0x78, 0x1F, 0x3C, 0x00, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0xF0, 0x1F, 0xFC, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xE7, 0xE3, 0xE3, 0xF1,
  0xF0, 0xF9, 0xF0, 0xFC, 0xF8, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F,
  0x9F, 0x8F, 0x8F, 0xCF, 0xC7, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xE1, 0xE7,
  0xE0, 0x01, 0xF0, 0x1F, 0xF1, 0xFF, 0xC7, 0xFE, 0x3F, 0x19, 0xF8, 0x07,
  0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xF0, 0x8F, 0xFE, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0x00, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x38,
  0xF8, 0x3F, 0xFC, 0x1F, 0xFF, 0x0F, 0xFF, 0xC3, 0xF7, 0xF1, 0xF8, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE3, 0xE0, 0xF8, 0xF8, 0x3C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE3, 0xF0, 0xFF, 0xFC, 0x1F, 0xFE, 0x07, 0xF7,
  0x80, 0xF9, 0xE0, 0x01, 0xF0, 0x0F, 0xF8, 0x3F, 0xF8, 0xFF, 0xF3, 0xE3,
  0xEF, 0xC7, 0xDF, 0x0F, 0xBE, 0xFE, 0xFF, 0xFD, 0xFF, 0xF3, 0xFF, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x01, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF0, 0x3F,
  0xC0, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x9F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xC0,
  0x00, 0x01, 0xE7, 0xC1, 0xFD, 0xE0, 0xFF, 0x78, 0x7F, 0xFE, 0x1F, 0xBF,
  0x8F, 0xC7, 0xE3, 0xE1, 0xF0, 0xF8, 0x7C, 0x7E, 0x1F, 0x1F, 0x87, 0xC7,
  0xC1, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x9F, 0x87, 0xFF, 0xE1, 0xFF,
  0xF0, 0x3F, 0xFC, 0x07, 0xDF, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x80, 0xF8,
  0x38, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0x80, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x70, 0x1E, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0xC7, 0xF7, 0xE3,
  0xE1, 0xF1, 0xF0, 0xF9, 0xF8, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F,
  0x1F, 0x0F, 0x9F, 0x0F, 0x8F, 0x87, 0xC7, 0xC3, 0xE3, 0xE1, 0xF3, 0xF1,
  0xF9, 0xF0, 0xF8, 0x01, 0x81, 0xF0, 0x7C, 0x1F, 0x07, 0x80, 0x00, 0x00,
  0x3E, 0x0F, 0x87, 0xE1, 0xF0, 0x7C, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x1F, 0x07, 0xC3, 0xF0, 0xF8, 0x00, 0x00,
  0x10, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0,
  0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE1, 0xF8, 0x7C, 0x7E, 0x1F, 0x0F, 0x83, 0xE3, 0xE0, 0x7C, 0xF8, 0x0F,
  0xBE, 0x01, 0xEF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF8, 0x07, 0xFF, 0x01, 0xFB, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF8,
  0xFC, 0x3F, 0x0F, 0x87, 0xC1, 0xF8, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x1F, 0x87, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0xC3, 0xE0,
  0x0F, 0x1E, 0x1E, 0x07, 0xBF, 0x9F, 0xC7, 0xFF, 0xDF, 0xE3, 0xFF, 0xFF,
  0xF1, 0xFD, 0xFE, 0xF8, 0xF8, 0xFC, 0x7C, 0x7C, 0x7E, 0x3E, 0x7E, 0x3E,
  0x1F, 0x3E, 0x1F, 0x0F, 0x9F, 0x0F, 0x87, 0xCF, 0x87, 0xC3, 0xE7, 0xC7,
  0xC3, 0xE7, 0xC3, 0xE1, 0xF3, 0xE1, 0xF0, 0xF9, 0xF0, 0xF8, 0x7C, 0xF8,
  0x7C, 0x7E, 0xFC, 0x7C, 0x3E, 0x7C, 0x3E, 0x1F, 0x00, 0x0F, 0x1C, 0x07,
  0xBF, 0x87, 0xFF, 0xC3, 0xFF, 0xF1, 0xFD, 0xF8, 0xFC, 0x7C, 0x7C, 0x3E,
  0x7E, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0x87, 0xC7, 0xC3, 0xE7, 0xC3,
  0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0xFC, 0x3E, 0x7C, 0x3E, 0x00,
  0x01, 0xF0, 0x0F, 0xF0, 0x7F, 0xF0, 0xFF, 0xF3, 0xF3, 0xEF, 0xC7, 0xDF,
  0x0F, 0xBE, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0x87,
  0xDF, 0x1F, 0xBF, 0xFE, 0x3F, 0xFC, 0x3F, 0xF0, 0x3F, 0x80, 0x07, 0x9E,
  0x01, 0xEF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xCF, 0xC3, 0xE3, 0xF0,
  0xF8, 0x7C, 0x7C, 0x3F, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x3F, 0x1F, 0x0F, 0xCF, 0xC3, 0xFF, 0xF0, 0xFF, 0xF8, 0x7D, 0xFC,
  0x1F, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xCF, 0x87,
  0xF7, 0x87, 0xFF, 0xC7, 0xFF, 0xE3, 0xF7, 0xF3, 0xF1, 0xF1, 0xF0, 0xF8,
  0xF8, 0x7C, 0x7C, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0x1F, 0x0F, 0x8F, 0x87,
  0xC7, 0xE7, 0xE3, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0x7C, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x0F, 0x1C, 0x3D, 0xF1, 0xFF, 0xC7, 0xFE,
  0x1F, 0xF8, 0x7F, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x3F, 0xF1, 0xFF, 0xCF, 0xFE, 0x3E, 0x18, 0xF8, 0x03,
  0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFC, 0x01, 0xF2,
  0x07, 0xCF, 0xFF, 0x3F, 0xF8, 0xFF, 0xE1, 0xFE, 0x00, 0x07, 0x80, 0x78,
  0x0F, 0x00, 0xFF, 0x3F, 0xF7, 0xFF, 0xFF, 0xE3, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xF8,
  0x7F, 0x87, 0xF8, 0x3F, 0x80, 0x1F, 0x0F, 0x8F, 0x87, 0xCF, 0x87, 0xC7,
  0xC3, 0xE3, 0xE1, 0xF1, 0xF0, 0xF9, 0xF8, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E,
  0x3E, 0x1F, 0x1F, 0x0F, 0x9F, 0x0F, 0x8F, 0x87, 0xC7, 0xE7, 0xE3, 0xFF,
  0xF1, 0xFF, 0xF8, 0x7F, 0x78, 0x1F, 0x3C, 0x00, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE1, 0xF7, 0xC3, 0xEF, 0x8F, 0x9F, 0x1F, 0x3E, 0x7C, 0x7C, 0xF8, 0xFB,
  0xE0, 0xF7, 0xC1, 0xEF, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x7C, 0x1F, 0xF8, 0xFC, 0x3E,
  0xF8, 0xFC, 0x3E, 0xF8, 0xFC, 0x7C, 0xF9, 0xFC, 0x7C, 0xF9, 0xDC, 0xF8,
  0xFB, 0xFC, 0xF8, 0xFB, 0xFC, 0xF0, 0xFB, 0xBD, 0xF0, 0xFF, 0xBD, 0xE0,
  0xF7, 0xBF, 0xE0, 0xF7, 0x3F, 0xE0, 0xFF, 0x3F, 0xC0, 0xFE, 0x3F, 0xC0,
  0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00,
  0x0F, 0xC3, 0xF0, 0x7C, 0x7E, 0x07, 0xC7, 0xC0, 0x7C, 0xFC, 0x03, 0xFF,
  0x80, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xFB, 0xE0, 0x1F,
  0x3E, 0x03, 0xF3, 0xE0, 0x7E, 0x3F, 0x0F, 0xC1, 0xF0, 0x0F, 0x83, 0xF0,
  0xF8, 0x3E, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x8F, 0x80, 0xF8, 0xF8,
  0x0F, 0x9F, 0x00, 0xF9, 0xF0, 0x07, 0x9E, 0x00, 0x7B, 0xE0, 0x07, 0xBC,
  0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x10, 0x7C,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0,
  0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0xFF, 0xF0,
  0xFF, 0xF0, 0x00, 0x38, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3E, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x3F, 0x07, 0xF0, 0x7F,
  0x03, 0xE0, 0x1F, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF0, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x1E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x3E,
  0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0xC0,
  0x3F, 0x80, 0xFC, 0x07, 0xE0, 0xFF, 0x07, 0xE0, 0x7C, 0x03, 0xE0, 0x1E,
  0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x01,
  0xE0, 0x00, 0x3E, 0x02, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xF0,
  0x02, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBoldItalic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 10, 23, 9, 0, -23 },
  { 30, 12, 8, 14, 3, -23 },
  { 42, 20, 23, 19, 0, -23 },
  { 100, 16, 26, 17, 1, -24 },
  { 152, 24, 23, 27, 2, -23 },
  { 221, 21, 23, 21, 0, -23 },
  { 282, 6, 8, 8, 3, -23 },
  { 288, 12, 28, 10, 1, -23 },
  { 330, 12, 28, 10, -2, -23 },
  { 372, 15, 16, 16, 2, -25 },
  { 402, 15, 15, 17, 1, -19 },
  { 431, 8, 8, 9, -2, -4 },
  { 439, 10, 5, 10, 0, -11 },
  { 446, 6, 5, 9, 0, -5 },
  { 450, 18, 23, 14, -2, -23 },
  { 502, 16, 23, 17, 1, -23 },
  { 548, 12, 23, 17, 3, -23 },
  { 583, 17, 23, 17, -1, -23 },
  { 632, 16, 23, 17, 0, -23 },
  { 678, 17, 23, 17, 0, -23 },
  { 727, 17, 23, 17, 0, -23 },
  { 776, 16, 23, 17, 1, -23 },
  { 822, 17, 23, 17, 1, -23 },
  { 871, 16, 23, 17, 1, -23 },
  { 917, 15, 23, 17, 1, -23 },
  { 961, 9, 18, 9, 0, -18 },
  { 982, 11, 22, 9, -2, -18 },
  { 1013, 15, 17, 17, 1, -20 },
  { 1045, 15, 10, 17, 1, -16 },
  { 1064, 15, 17, 17, 1, -20 },
  { 1096, 13, 23, 14, 2, -23 },
  { 1134, 24, 26, 26, 1, -23 },
  { 1212, 19, 23, 19, -2, -23 },
  { 1267, 18, 23, 19, 0, -23 },
  { 1319, 17, 23, 18, 2, -23 },
  { 1368, 19, 23, 20, 0, -23 },
  { 1423, 17, 23, 16, 0, -23 },
  { 1472, 17, 23, 16, 0, -23 },
  { 1521, 18, 23, 20, 2, -23 },
  { 1573, 21, 23, 21, 0, -23 },
  { 1634, 15, 23, 12, -1, -23 },
  { 1678, 16, 30, 10, -5, -23 },
  { 1738, 21, 23, 19, 0, -23 },
  { 1799, 13, 23, 15, 0, -23 },
  { 1837, 27, 23, 27, 0, -23 },
  { 1915, 23, 23, 22, 0, -23 },
  { 1982, 19, 23, 21, 2, -23 },
  { 2037, 18, 23, 18, 0, -23 },
  { 2089, 19, 28, 21, 2, -23 },
  { 2156, 18, 23, 19, 0, -23 },
  { 2208, 17, 23, 16, 0, -23 },
  { 2257, 15, 23, 16, 3, -23 },
  { 2301, 19, 23, 20, 2, -23 },
  { 2356, 18, 23, 18, 3, -23 },
  { 2408, 27, 23, 27, 3, -23 },
  { 2486, 23, 23, 18, -2, -23 },
  { 2553, 17, 23, 17, 3, -23 },
  { 2602, 19, 23, 16, -1, -23 },
  { 2657, 14, 28, 10, -1, -23 },
  { 2706, 8, 23, 14, 3, -23 },
  { 2729, 13, 28, 10, -2, -23 },
  { 2775, 16, 15, 16, 0, -23 },
  { 2805, 13, 3, 13, -3, 2 },
  { 2810, 6, 6, 11, 5, -25 },
  { 2815, 17, 18, 18, 1, -18 },
  { 2854, 17, 24, 18, 0, -24 },
  { 2905, 14, 18, 14, 1, -18 },
  { 2937, 18, 24, 18, 1, -24 },
  { 2991, 15, 18, 17, 1, -18 },
  { 3025, 18, 32, 11, -3, -24 },
  { 3097, 18, 26, 18, 0, -18 },
  { 3156, 17, 24, 18, 0, -24 },
  { 3207, 10, 25, 9, 0, -25 },
  { 3239, 14, 33, 9, -4, -25 },
  { 3297, 19, 24, 17, 0, -24 },
  { 3354, 10, 24, 9, 0, -24 },
  { 3384, 25, 18, 27, 0, -18 },
  { 3441, 17, 18, 18, 0, -18 },
  { 3480, 15, 18, 17, 1, -18 },
  { 3514, 18, 26, 18, -1, -18 },
  { 3573, 17, 26, 18, 1, -18 },
  { 3629, 14, 18, 13, 0, -18 },
  { 3661, 14, 18, 14, 0, -18 },
  { 3693, 12, 21, 12, 1, -21 },
  { 3725, 17, 18, 18, 1, -18 },
  { 3764, 15, 18, 16, 2, -18 },
  { 3798, 24, 18, 24, 2, -18 },
  { 3852, 20, 18, 16, -2, -18 },
  { 3897, 20, 26, 16, -2, -18 },
  { 3962, 16, 18, 14, -1, -18 },
  { 3998, 13, 28, 11, 0, -23 },
  { 4044, 4, 31, 16, 6, -24 },
  { 4060, 13, 28, 11, -2, -23 },
  { 4106, 15, 6, 17, 1, -14 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBoldItalic32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBoldItalic32pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBoldItalic32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC32PT7B_H_
