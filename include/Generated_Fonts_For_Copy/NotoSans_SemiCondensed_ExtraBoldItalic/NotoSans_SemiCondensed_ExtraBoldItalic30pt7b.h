#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC30PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBoldItalic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBoldItalic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1E,
  0x07, 0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x1F, 0x0F,
  0xC3, 0xE0, 0xF8, 0x00, 0x79, 0xEF, 0x3F, 0xE7, 0xF9, 0xEF, 0x3D, 0xE7,
  0xB8, 0xE0, 0x00, 0xE7, 0x80, 0x79, 0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x03,
  0xCF, 0x0F, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xC1, 0xC7,
  0x00, 0x73, 0xC0, 0x3C, 0xF0, 0x7F, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xF0,
  0x79, 0xC0, 0x1C, 0x70, 0x07, 0x3C, 0x03, 0xCE, 0x00, 0xE3, 0x80, 0x39,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x07, 0x80, 0x3F, 0xF1, 0xFF, 0xC3,
  0xFF, 0x8F, 0xB7, 0x1E, 0x40, 0x3D, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xBC, 0x83, 0x79, 0x8D, 0xF3,
  0xFF, 0xE7, 0xFF, 0x8F, 0xFE, 0x07, 0xF0, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x10, 0xFE, 0x03, 0x83, 0xF8, 0x1E, 0x1E, 0xF0, 0xF0,
  0xF3, 0xC3, 0x83, 0xCF, 0x1E, 0x0F, 0x3C, 0xF0, 0x38, 0xE3, 0x80, 0xE3,
  0x9E, 0x03, 0x9E, 0xF3, 0xEF, 0xF3, 0x9F, 0xFF, 0xDE, 0xFF, 0x7E, 0xF7,
  0x9C, 0xE3, 0x9E, 0x70, 0x1E, 0x71, 0xC0, 0xF3, 0xCF, 0x03, 0x8F, 0x3C,
  0x1E, 0x3C, 0xF0, 0xF0, 0xF7, 0x83, 0x83, 0xFE, 0x1E, 0x07, 0xF0, 0xF0,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xF0,
  0x07, 0x9F, 0x00, 0xF9, 0xF0, 0x0F, 0x9F, 0x00, 0xFB, 0xE0, 0x07, 0xFC,
  0x00, 0x7F, 0x80, 0x07, 0xF1, 0xF1, 0xFE, 0x3E, 0x3F, 0xF3, 0xE7, 0xFF,
  0xFC, 0x7C, 0xFF, 0xCF, 0x87, 0xF8, 0xF8, 0x7F, 0x0F, 0xC3, 0xF0, 0x7F,
  0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFC, 0xFC, 0x7B, 0xFF, 0xEF,
  0x7B, 0x80, 0x01, 0xE0, 0x78, 0x1E, 0x07, 0xC0, 0xF0, 0x3C, 0x07, 0x81,
  0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x78,
  0x0F, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0,
  0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0x81,
  0xE0, 0x3C, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x18,
  0xE0, 0x7B, 0x81, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0x1F, 0x9C, 0xFF, 0x07,
  0xDC, 0x0E, 0x78, 0x19, 0xF0, 0x03, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x1F, 0x1E,
  0x3E, 0x3E, 0x3C, 0x7C, 0x78, 0xF0, 0x7F, 0xBF, 0xDF, 0xDF, 0xE0, 0x39,
  0xEF, 0xFE, 0xF8, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x1F, 0xE0, 0xFF, 0x87, 0xFF, 0x1F, 0x7C, 0xF8, 0xF3, 0xE3, 0xDF,
  0x0F, 0x7C, 0x3D, 0xE0, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF,
  0x8F, 0xBE, 0x3E, 0xF8, 0xFB, 0xE7, 0xCF, 0xFF, 0x1F, 0xF8, 0x7F, 0xC0,
  0xFE, 0x00, 0x03, 0xE0, 0xFC, 0x7F, 0x9F, 0xF7, 0xFD, 0xF7, 0xBD, 0xF3,
  0x3E, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x00, 0x78, 0x03, 0xFE, 0x07,
  0xFE, 0x0F, 0xFF, 0x0F, 0xBF, 0x06, 0x1F, 0x04, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7F, 0xFC, 0x7F, 0xFC, 0xFF,
  0xFC, 0xFF, 0xF8, 0x01, 0xF0, 0x1F, 0xF8, 0x7F, 0xF8, 0x7F, 0xF0, 0xE3,
  0xE1, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x0F, 0xF0, 0x1F, 0x80,
  0x7F, 0x80, 0xFF, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7D, 0x01,
  0xFB, 0xFF, 0xE7, 0xFF, 0x8F, 0xFE, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xBC, 0x07,
  0xFC, 0x0F, 0x7C, 0x1E, 0x78, 0x1C, 0x78, 0x3C, 0xF8, 0x78, 0xF8, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xE0, 0x03, 0xE0, 0x07, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F,
  0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x3F, 0xF8, 0x3F,
  0xFC, 0x10, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0xC0,
  0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0xC0, 0x00, 0x3C, 0x03,
  0xFC, 0x1F, 0xF8, 0x7F, 0xF1, 0xFC, 0x23, 0xE0, 0x0F, 0x80, 0x1E, 0x00,
  0x7D, 0xF0, 0xF7, 0xF1, 0xFF, 0xE7, 0xFF, 0xEF, 0xC7, 0xDF, 0x0F, 0xBE,
  0x1F, 0x7C, 0x3C, 0xF8, 0xF9, 0xF1, 0xF1, 0xFF, 0xC3, 0xFF, 0x83, 0xFE,
  0x03, 0xF8, 0x00, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFE, 0x3F, 0xFE, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x0F,
  0xF0, 0x3F, 0xF0, 0xFF, 0xF3, 0xE3, 0xE7, 0xC7, 0xCF, 0x8F, 0x9F, 0x3E,
  0x1F, 0xF8, 0x3F, 0xE0, 0x3F, 0x80, 0xFF, 0x03, 0xFF, 0x0F, 0x9F, 0x3E,
  0x3E, 0x78, 0x3C, 0xF0, 0x79, 0xE1, 0xF3, 0xE7, 0xE7, 0xFF, 0x87, 0xFE,
  0x07, 0xF8, 0x00, 0x03, 0xC0, 0x3F, 0xC1, 0xFF, 0x8F, 0xFF, 0x3E, 0x7D,
  0xF1, 0xF7, 0xC3, 0xDF, 0x1F, 0x7C, 0x7D, 0xF1, 0xF7, 0xCF, 0xDF, 0xFF,
  0x7F, 0xFC, 0xFD, 0xE0, 0xCF, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x8F, 0xFE,
  0x3F, 0xF0, 0xFF, 0x83, 0xF8, 0x00, 0x06, 0x1F, 0x1F, 0x1F, 0x1F, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x78, 0xFC, 0xF8, 0xF8, 0x01,
  0x81, 0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC1, 0xE0, 0xF8, 0x3C, 0x0F, 0x07, 0x81, 0xE0,
  0xF0, 0x00, 0x00, 0x04, 0x00, 0x30, 0x03, 0xC0, 0x3F, 0x03, 0xFC, 0x3F,
  0xC3, 0xF8, 0x3F, 0x80, 0xFC, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x01,
  0xFC, 0x01, 0xF0, 0x01, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x03,
  0x80, 0x0F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F,
  0x00, 0x7C, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x03, 0xF0, 0x0F, 0x00,
  0x20, 0x00, 0x07, 0x03, 0xFE, 0xFF, 0xE7, 0xFF, 0x71, 0xF4, 0x1F, 0x01,
  0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x3C, 0x03, 0xC0, 0x78,
  0x00, 0x00, 0x00, 0x07, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0x00,
  0x0C, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x3F, 0x0F, 0xC0, 0xF8,
  0x07, 0xC3, 0xC0, 0x07, 0x8F, 0x0F, 0xC7, 0x1E, 0x3F, 0xCF, 0x78, 0xFF,
  0x9E, 0xE3, 0xCF, 0x3D, 0xCF, 0x1C, 0x7F, 0x9E, 0x38, 0xEF, 0x38, 0x71,
  0xDC, 0x71, 0xE3, 0xB8, 0xE3, 0xCE, 0x71, 0xCF, 0xBC, 0xE3, 0xFF, 0xF1,
  0xE7, 0xEF, 0xC3, 0xC3, 0x8E, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x10, 0x07,
  0xE1, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xF7, 0x80, 0x3D,
  0xE0, 0x1F, 0x78, 0x07, 0x9E, 0x03, 0xE7, 0x80, 0xF1, 0xE0, 0x7C, 0x78,
  0x1E, 0x1E, 0x0F, 0xFF, 0x83, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x3E,
  0x07, 0xCF, 0x81, 0xF7, 0xC0, 0x7D, 0xF0, 0x1F, 0xFC, 0x07, 0xC0, 0x07,
  0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xE1, 0xF7, 0xF0, 0xF8, 0xF8, 0x78, 0x7C,
  0x7C, 0x3E, 0x3E, 0x3E, 0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x07, 0xFF,
  0xC3, 0xE3, 0xE1, 0xF0, 0xF8, 0xF8, 0x7C, 0x78, 0x7E, 0x7C, 0x3E, 0x3F,
  0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFE, 0x00, 0x00, 0x78, 0x00, 0xFF,
  0xC1, 0xFF, 0xE1, 0xFF, 0xE1, 0xFE, 0xF0, 0xFC, 0x08, 0xFC, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x04, 0x1F, 0xFE,
  0x07, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0x07, 0xFE, 0x03, 0xFF, 0xC0,
  0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0x8F, 0xC3, 0xE1, 0xF1, 0xF0, 0x7C, 0x7C,
  0x1F, 0x1F, 0x07, 0xC7, 0xC1, 0xF1, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x0F,
  0x8F, 0x83, 0xE3, 0xE1, 0xF8, 0xF0, 0xFC, 0x7C, 0x7E, 0x1F, 0xFF, 0x87,
  0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x0F, 0xFF, 0x0F,
  0xFF, 0x0F, 0xFE, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0xFC, 0x1F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF8, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0xFF,
  0xF0, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0x80, 0x0F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xF8, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x7F, 0xF0,
  0x7F, 0xFC, 0x3F, 0xFE, 0x0F, 0xE7, 0x87, 0xE0, 0x23, 0xF0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC7, 0xF9, 0xF1, 0xFE, 0x7C, 0x7F,
  0x3E, 0x3F, 0xCF, 0x81, 0xF3, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x87, 0x87,
  0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xC1, 0xF0,
  0xF8, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x1F, 0x03, 0xC1, 0xF0, 0x7C, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF,
  0xC3, 0xFF, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xC0,
  0xF8, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0xF8,
  0x1F, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x80, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7E, 0x0F, 0xFC, 0x3F,
  0xF0, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x3F, 0xE0,
  0xFF, 0x81, 0xFE, 0x03, 0xF8, 0x00, 0x80, 0x00, 0x07, 0xC3, 0xF0, 0xF8,
  0x7E, 0x0F, 0x8F, 0xC0, 0xF8, 0xF8, 0x0F, 0x9F, 0x00, 0xF3, 0xF0, 0x1F,
  0x7E, 0x01, 0xF7, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0x7C, 0x03, 0xC7, 0xC0,
  0x7C, 0x7C, 0x07, 0xC7, 0xE0, 0x7C, 0x3E, 0x07, 0x83, 0xE0, 0xF8, 0x3F,
  0x00, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0x80, 0x7C, 0x0B, 0xFF, 0x9F, 0xFC, 0xFF, 0xEF, 0xFF, 0x00,
  0x07, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x1F, 0xE1, 0xFC, 0x0F,
  0xF0, 0xFE, 0x0F, 0xF0, 0x7F, 0x07, 0xF8, 0x7F, 0x83, 0xBC, 0x3D, 0xC3,
  0xFE, 0x1E, 0xF1, 0xDE, 0x0F, 0x79, 0xEF, 0x07, 0xBC, 0xE7, 0x87, 0xDE,
  0xF7, 0xC3, 0xEF, 0x7B, 0xE1, 0xE7, 0xF9, 0xE0, 0xF3, 0xFC, 0xF0, 0x79,
  0xFC, 0xF8, 0x7C, 0xFE, 0x7C, 0x3C, 0x7E, 0x3E, 0x1E, 0x3F, 0x1E, 0x0F,
  0x1F, 0x0F, 0x0F, 0x8F, 0x8F, 0x80, 0x07, 0xE0, 0x7C, 0x3F, 0x81, 0xE0,
  0xFE, 0x07, 0x83, 0xF8, 0x3E, 0x0F, 0xF0, 0xF8, 0x3F, 0xC3, 0xC1, 0xFF,
  0x0F, 0x07, 0xBC, 0x7C, 0x1E, 0xF9, 0xF0, 0x79, 0xE7, 0x81, 0xE7, 0x9E,
  0x0F, 0x9F, 0x78, 0x3E, 0x7D, 0xE0, 0xF0, 0xFF, 0x83, 0xC3, 0xFC, 0x0F,
  0x0F, 0xF0, 0x7C, 0x3F, 0xC1, 0xE0, 0x7F, 0x07, 0x81, 0xFC, 0x1E, 0x07,
  0xE0, 0xF8, 0x1F, 0x80, 0x00, 0x78, 0x00, 0x7F, 0xC0, 0x7F, 0xF8, 0x3F,
  0xFE, 0x1F, 0xDF, 0xC7, 0xC1, 0xF3, 0xF0, 0x7C, 0xF8, 0x1F, 0x7E, 0x07,
  0xDF, 0x01, 0xF7, 0xC0, 0x7D, 0xF0, 0x1F, 0x7C, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0xFB, 0xE0, 0x3E, 0x7C, 0x1F, 0x1F, 0x0F, 0xC7, 0xFF, 0xE0, 0xFF,
  0xF0, 0x3F, 0xF8, 0x03, 0xFC, 0x00, 0x07, 0xFE, 0x07, 0xFF, 0x83, 0xFF,
  0xE1, 0xFF, 0xF0, 0xF8, 0xF8, 0x78, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F,
  0x1F, 0x8F, 0xBF, 0x87, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0x81, 0xFE, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE,
  0x1F, 0xFF, 0xC7, 0xC1, 0xF3, 0xF0, 0x7C, 0xF8, 0x1F, 0x7E, 0x07, 0xDF,
  0x01, 0xF7, 0xC0, 0x7D, 0xF0, 0x1F, 0x7C, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0xFB, 0xE0, 0x3E, 0x7C, 0x1F, 0x1F, 0x0F, 0xC7, 0xFF, 0xE0, 0xFF, 0xF0,
  0x3F, 0xF8, 0x03, 0xFC, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x07, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xF7,
  0xF0, 0xF8, 0xF8, 0x78, 0x7C, 0x7C, 0x3E, 0x3E, 0x3F, 0x1F, 0x1F, 0x0F,
  0xFF, 0x87, 0xFF, 0x87, 0xFF, 0x03, 0xFF, 0x81, 0xF7, 0xC0, 0xF9, 0xE0,
  0x78, 0xF8, 0x7C, 0x7C, 0x3E, 0x3F, 0x1F, 0x0F, 0x8F, 0x87, 0xCF, 0x83,
  0xF0, 0x00, 0xF0, 0x03, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0xFC, 0x1F,
  0x04, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x80, 0xF8, 0xE1,
  0xF8, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0x80, 0x7F, 0xFE, 0xFF,
  0xFD, 0xFF, 0xF7, 0xFF, 0xE0, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x00, 0x1F, 0x07, 0xCF, 0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F,
  0x9F, 0x07, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xCF,
  0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xC0,
  0x00, 0xF0, 0x1F, 0xF0, 0x3E, 0xF0, 0x3E, 0xF0, 0x3E, 0xF0, 0x7C, 0xF0,
  0x7C, 0xF0, 0xF8, 0xF0, 0xF8, 0xF9, 0xF0, 0xF9, 0xF0, 0xFB, 0xE0, 0xFB,
  0xE0, 0xFB, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xF7, 0x80, 0x7F, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF0, 0x3C, 0x0F, 0xF8, 0x3E,
  0x0F, 0xBC, 0x1F, 0x07, 0xDE, 0x0F, 0x83, 0xCF, 0x0F, 0xC3, 0xE7, 0x87,
  0xE1, 0xE3, 0xC7, 0xF1, 0xF1, 0xE3, 0xF8, 0xF8, 0xF3, 0xDC, 0x78, 0x79,
  0xFE, 0x7C, 0x3C, 0xEF, 0x3C, 0x1E, 0xF7, 0xBE, 0x0F, 0x7B, 0xDF, 0x07,
  0xF9, 0xEF, 0x03, 0xFC, 0xFF, 0x81, 0xFC, 0x7F, 0x80, 0xFE, 0x3F, 0xC0,
  0x7F, 0x1F, 0xC0, 0x3F, 0x0F, 0xE0, 0x1F, 0x87, 0xF0, 0x0F, 0x83, 0xF0,
  0x00, 0x07, 0xC1, 0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0xF8, 0x07, 0xC7, 0xC0,
  0x1E, 0x7C, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0x78, 0x01, 0xF3, 0xE0, 0x1F, 0x9F, 0x00, 0xF8, 0xF8,
  0x0F, 0x83, 0xE0, 0xFC, 0x1F, 0x0F, 0xC0, 0xF8, 0x00, 0xF8, 0x3F, 0xF8,
  0x7E, 0xF8, 0x7C, 0xF8, 0xF8, 0x78, 0xF8, 0x79, 0xF0, 0x7F, 0xE0, 0x7F,
  0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFC,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0,
  0xFF, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0x78, 0x03,
  0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07,
  0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7F, 0x07, 0xF0, 0x3F, 0x80, 0xF1,
  0xE3, 0xC3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF0, 0xF1, 0xE3, 0xC7, 0x8F,
  0x1E, 0x3E, 0x3C, 0x78, 0xF1, 0xE3, 0xC0, 0x03, 0xF8, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0xFE, 0x07,
  0xF0, 0x3F, 0x80, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F,
  0x80, 0xFF, 0x03, 0xCE, 0x07, 0x9C, 0x1E, 0x3C, 0x78, 0x78, 0xF0, 0x73,
  0xC0, 0xEF, 0x01, 0xE0, 0x7F, 0xFB, 0xFF, 0xFF, 0xFC, 0xF8, 0xF8, 0xF1,
  0xE1, 0xE0, 0x03, 0x80, 0x1F, 0xBC, 0x7F, 0xF9, 0xFF, 0xF3, 0xE7, 0xEF,
  0x8F, 0x9F, 0x1F, 0x3C, 0x3E, 0xF8, 0x7D, 0xF0, 0xFB, 0xE1, 0xE7, 0xC7,
  0xCF, 0x8F, 0x9F, 0xFF, 0x3F, 0xFE, 0x3F, 0xF8, 0x3E, 0xF0, 0x07, 0xC0,
  0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x38,
  0x1F, 0x7C, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0x3F, 0x1F, 0x1F, 0x3E, 0x1F,
  0x3E, 0x1F, 0x3C, 0x1E, 0x3C, 0x3E, 0x3C, 0x3E, 0x7C, 0x3E, 0x7C, 0x7C,
  0x7F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF0, 0xF3, 0xE0, 0x01, 0xE0, 0x7F, 0xC7,
  0xFE, 0x7F, 0xE3, 0xE3, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x82, 0x7F, 0xE1, 0xFF, 0x0F, 0xF8, 0x3F, 0x80,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x0E, 0x78, 0x1F, 0xBC, 0x1F, 0xFE, 0x1F, 0xFF, 0x0F, 0x9F, 0x8F,
  0x8F, 0x87, 0xC3, 0xC3, 0xC3, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8, 0x78,
  0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xFB,
  0xC0, 0x01, 0xE0, 0x3F, 0xE1, 0xFF, 0xCF, 0xFF, 0x3E, 0x3D, 0xF0, 0xF7,
  0xC7, 0xFF, 0xFE, 0xFF, 0xF3, 0xFF, 0x8F, 0x80, 0x3E, 0x00, 0xF8, 0x13,
  0xF1, 0xC7, 0xFF, 0x1F, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x3F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xFC,
  0x07, 0xFE, 0x07, 0xFE, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xC0, 0x00, 0x01,
  0xC0, 0x07, 0xEF, 0x0F, 0xFF, 0x1F, 0xFF, 0x1F, 0x3F, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3E, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3C, 0x7C, 0x7C, 0x7C,
  0x7C, 0x7F, 0xFC, 0x7F, 0xFC, 0x3F, 0x78, 0x1E, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x81, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0x80, 0x07,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x38, 0x1F, 0x7E, 0x1F, 0xFE, 0x1F, 0xFF, 0x1F, 0x9F, 0x1F, 0x1F, 0x3E,
  0x1F, 0x3E, 0x1E, 0x3E, 0x3E, 0x3C, 0x3E, 0x3C, 0x3E, 0x7C, 0x3C, 0x7C,
  0x3C, 0x7C, 0x7C, 0x78, 0x7C, 0xF8, 0x7C, 0xF8, 0x78, 0x07, 0x81, 0xF0,
  0xF8, 0x3E, 0x03, 0x00, 0x00, 0x00, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x78,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x1F, 0x07, 0xC1, 0xF0, 0x78, 0x3E,
  0x0F, 0x80, 0x00, 0x78, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x04, 0x7C,
  0x3E, 0x1F, 0x1F, 0x07, 0xCF, 0x81, 0xE7, 0xC0, 0x7B, 0xE0, 0x3F, 0xF0,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xBE, 0x07,
  0xCF, 0x81, 0xF3, 0xE0, 0x78, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xE0, 0x07,
  0xC1, 0xE0, 0x78, 0x3E, 0x0F, 0x83, 0xE0, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x78, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x1F, 0x07, 0xC1, 0xF0,
  0x78, 0x3E, 0x0F, 0x80, 0x00, 0x38, 0x1C, 0x1E, 0xFE, 0x7E, 0x1E, 0xFE,
  0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xBF, 0x9F, 0x1F, 0x1F, 0x1F, 0x3E, 0x1F,
  0x1F, 0x3E, 0x1E, 0x1F, 0x3E, 0x3E, 0x1E, 0x3C, 0x3E, 0x3E, 0x3C, 0x3E,
  0x3E, 0x7C, 0x3C, 0x3E, 0x7C, 0x7C, 0x3E, 0x7C, 0x7C, 0x3C, 0x78, 0x7C,
  0x7C, 0xF8, 0x7C, 0x7C, 0xF8, 0x78, 0x7C, 0x00, 0x38, 0x1E, 0xFE, 0x1E,
  0xFE, 0x1F, 0xFF, 0x1F, 0x9F, 0x1F, 0x1F, 0x3E, 0x1F, 0x3E, 0x1E, 0x3E,
  0x3E, 0x3C, 0x3E, 0x3C, 0x3E, 0x7C, 0x3C, 0x7C, 0x3C, 0x7C, 0x7C, 0x78,
  0x7C, 0xF8, 0x7C, 0xF8, 0x78, 0x03, 0xE0, 0x3F, 0xC1, 0xFF, 0x8F, 0xFF,
  0x3E, 0x7D, 0xF0, 0xF7, 0xC3, 0xFE, 0x0F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87,
  0xFE, 0x1F, 0xF8, 0xFB, 0xFF, 0xE7, 0xFF, 0x1F, 0xF8, 0x1F, 0x80, 0x00,
  0x1C, 0x07, 0xBF, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0xF9, 0xF8, 0x7C, 0x7C,
  0x7C, 0x3E, 0x3E, 0x1F, 0x1E, 0x0F, 0x0F, 0x0F, 0x87, 0x87, 0xC7, 0xC3,
  0xE3, 0xE3, 0xE1, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x7D, 0xF0, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0x03, 0x80, 0x1F, 0xBC, 0x7F, 0xF9, 0xFF, 0xF3, 0xE7, 0xEF,
  0x8F, 0x9F, 0x1F, 0x3C, 0x3E, 0xF8, 0x7D, 0xF0, 0xFB, 0xE1, 0xE7, 0xC7,
  0xCF, 0x8F, 0x9F, 0xFF, 0x3F, 0xFE, 0x3F, 0xF8, 0x3F, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x00,
  0x38, 0xF3, 0xC7, 0xBE, 0x3F, 0xE1, 0xFF, 0x0F, 0xC0, 0xFC, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x1F,
  0x00, 0xF8, 0x00, 0x03, 0xC0, 0x7F, 0xC7, 0xFE, 0x7F, 0xE3, 0xE1, 0x1F,
  0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x00, 0xF8, 0x07, 0xE8, 0x1E,
  0x7B, 0xF3, 0xFF, 0x9F, 0xF8, 0xFF, 0x80, 0x07, 0x00, 0xE0, 0x3C, 0x0F,
  0x87, 0xFE, 0xFF, 0xFF, 0xF9, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xFF, 0x1F, 0xE1, 0xFC, 0x1F, 0x80, 0x3E,
  0x1F, 0x3E, 0x1E, 0x3E, 0x3E, 0x3C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3C, 0x7C,
  0x7C, 0x7C, 0x7C, 0x78, 0x7C, 0xF8, 0x7C, 0xF8, 0xF8, 0xF8, 0xF8, 0xFF,
  0xF8, 0xFF, 0xF8, 0x7F, 0x70, 0x3E, 0xF0, 0xF0, 0x7F, 0xC3, 0xEF, 0x0F,
  0xBC, 0x3C, 0xF1, 0xF3, 0xC7, 0x8F, 0x3E, 0x3C, 0xF0, 0xFF, 0xC3, 0xFE,
  0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xF0,
  0xF8, 0x7F, 0xC7, 0xE3, 0xEF, 0x1F, 0x8F, 0xBC, 0x7E, 0x3C, 0xF3, 0xF9,
  0xF3, 0xCE, 0xE7, 0x8F, 0x7B, 0xBE, 0x3D, 0xEE, 0xF0, 0xF7, 0x3B, 0xC3,
  0xFC, 0xFE, 0x0F, 0xE7, 0xF8, 0x3F, 0x9F, 0xE0, 0xFE, 0x7F, 0x03, 0xF1,
  0xFC, 0x0F, 0xC7, 0xE0, 0x3E, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0xF9, 0xF0,
  0x1F, 0x7E, 0x03, 0xEF, 0x80, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x01,
  0xF7, 0xC0, 0x7C, 0x7C, 0x0F, 0x8F, 0x87, 0xE1, 0xF0, 0x0F, 0x07, 0xC3,
  0xC1, 0xE0, 0xF0, 0xF8, 0x3C, 0x3C, 0x0F, 0x9F, 0x03, 0xE7, 0x80, 0xFB,
  0xE0, 0x3E, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0x80,
  0x00, 0x0F, 0xFE, 0x1F, 0xF8, 0x7F, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xFF, 0x0F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0xFC,
  0x0F, 0xC0, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x0F,
  0xC0, 0xFC, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x00,
  0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0x80, 0x3E, 0x01, 0xF8, 0x1F, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xFA, 0x07, 0xE0, 0x0F, 0x01,
  0xF8, 0x1F, 0xC1, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0,
  0x1F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0x00, 0x00, 0x7E, 0x07, 0xFF,
  0xFF, 0xFF, 0xF9, 0xFF, 0x80, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBoldItalic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 10, 21, 8, 0, -21 },
  { 28, 11, 7, 13, 3, -21 },
  { 38, 18, 21, 18, 0, -21 },
  { 86, 15, 25, 16, 1, -23 },
  { 133, 22, 22, 25, 2, -22 },
  { 194, 20, 22, 20, 0, -22 },
  { 249, 5, 7, 7, 3, -21 },
  { 254, 11, 27, 10, 1, -22 },
  { 292, 11, 27, 10, -2, -22 },
  { 330, 14, 14, 15, 2, -23 },
  { 355, 14, 15, 16, 1, -18 },
  { 382, 8, 8, 8, -2, -4 },
  { 390, 9, 4, 9, 0, -10 },
  { 395, 6, 5, 8, 0, -5 },
  { 399, 16, 22, 13, -1, -22 },
  { 443, 14, 22, 16, 1, -22 },
  { 482, 11, 21, 16, 3, -21 },
  { 511, 16, 22, 16, -1, -22 },
  { 555, 15, 22, 16, 0, -22 },
  { 597, 16, 21, 16, 0, -21 },
  { 639, 16, 21, 16, 0, -21 },
  { 681, 15, 22, 16, 1, -22 },
  { 723, 16, 21, 16, 1, -21 },
  { 765, 15, 22, 16, 1, -22 },
  { 807, 14, 22, 16, 1, -22 },
  { 846, 8, 17, 8, 0, -17 },
  { 863, 10, 21, 8, -2, -17 },
  { 890, 14, 16, 16, 1, -19 },
  { 918, 14, 9, 16, 1, -15 },
  { 934, 14, 16, 16, 1, -19 },
  { 962, 12, 22, 13, 2, -22 },
  { 995, 23, 25, 24, 1, -22 },
  { 1067, 18, 21, 18, -2, -21 },
  { 1115, 17, 21, 17, 0, -21 },
  { 1160, 17, 22, 17, 1, -22 },
  { 1207, 18, 21, 19, 0, -21 },
  { 1255, 16, 21, 15, 0, -21 },
  { 1297, 16, 21, 15, 0, -21 },
  { 1339, 18, 22, 19, 1, -22 },
  { 1389, 20, 21, 19, 0, -21 },
  { 1442, 14, 21, 11, -1, -21 },
  { 1479, 15, 28, 10, -5, -21 },
  { 1532, 20, 21, 17, 0, -21 },
  { 1585, 13, 21, 14, 0, -21 },
  { 1620, 25, 21, 25, 0, -21 },
  { 1686, 22, 21, 21, 0, -21 },
  { 1744, 18, 22, 20, 1, -22 },
  { 1794, 17, 21, 17, 0, -21 },
  { 1839, 18, 27, 20, 1, -22 },
  { 1900, 17, 21, 17, 0, -21 },
  { 1945, 16, 22, 15, 0, -22 },
  { 1989, 15, 21, 15, 2, -21 },
  { 2029, 18, 21, 19, 2, -21 },
  { 2077, 16, 21, 17, 3, -21 },
  { 2119, 25, 21, 25, 3, -21 },
  { 2185, 21, 21, 17, -2, -21 },
  { 2241, 16, 21, 16, 3, -21 },
  { 2283, 18, 21, 15, -1, -21 },
  { 2331, 13, 27, 10, -1, -22 },
  { 2375, 7, 22, 13, 3, -22 },
  { 2395, 13, 27, 10, -2, -22 },
  { 2439, 15, 13, 15, 0, -21 },
  { 2464, 13, 3, 12, -3, 2 },
  { 2469, 7, 5, 10, 4, -23 },
  { 2474, 15, 17, 17, 1, -17 },
  { 2506, 16, 23, 17, 0, -23 },
  { 2552, 13, 17, 14, 1, -17 },
  { 2580, 17, 23, 17, 1, -23 },
  { 2629, 14, 17, 16, 1, -17 },
  { 2659, 17, 30, 11, -3, -23 },
  { 2723, 16, 24, 17, 0, -17 },
  { 2771, 16, 23, 17, 0, -23 },
  { 2817, 10, 23, 9, 0, -23 },
  { 2846, 14, 30, 9, -4, -23 },
  { 2899, 18, 23, 16, 0, -23 },
  { 2951, 10, 23, 9, 0, -23 },
  { 2980, 24, 17, 25, 0, -17 },
  { 3031, 16, 17, 17, 0, -17 },
  { 3065, 14, 17, 16, 1, -17 },
  { 3095, 17, 24, 17, -1, -17 },
  { 3146, 15, 24, 17, 1, -17 },
  { 3191, 13, 17, 12, 0, -17 },
  { 3219, 13, 17, 13, 0, -17 },
  { 3247, 11, 20, 12, 1, -20 },
  { 3275, 16, 16, 17, 1, -16 },
  { 3307, 14, 16, 15, 2, -16 },
  { 3335, 22, 16, 22, 2, -16 },
  { 3379, 19, 16, 15, -2, -16 },
  { 3417, 18, 23, 15, -2, -16 },
  { 3469, 15, 16, 13, -1, -16 },
  { 3499, 13, 26, 11, 0, -21 },
  { 3542, 3, 30, 15, 6, -23 },
  { 3554, 13, 26, 11, -2, -21 },
  { 3597, 14, 5, 16, 1, -13 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBoldItalic30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBoldItalic30pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBoldItalic30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC30PT7B_H_
