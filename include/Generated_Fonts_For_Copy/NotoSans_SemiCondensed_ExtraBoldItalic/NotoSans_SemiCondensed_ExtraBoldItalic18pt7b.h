#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC18PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBoldItalic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBoldItalic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x3C, 0xE3, 0x8E, 0x38, 0xC7, 0x1C, 0x70, 0x06, 0x38, 0xE0, 0xEF,
  0xDB, 0x36, 0xED, 0x80, 0x06, 0xC1, 0x98, 0x33, 0x06, 0xC7, 0xFE, 0xFF,
  0xC6, 0xC0, 0xD8, 0xFF, 0xC6, 0xC0, 0xD8, 0x33, 0x06, 0xE0, 0x02, 0x01,
  0x07, 0xE7, 0xF3, 0x49, 0xA0, 0xF0, 0x3E, 0x0F, 0x05, 0xD2, 0xDF, 0xEF,
  0xE0, 0x80, 0x40, 0x38, 0x31, 0xF1, 0x86, 0xCE, 0x33, 0x30, 0xCD, 0x83,
  0x7E, 0xEF, 0xB7, 0x9D, 0xB7, 0x0E, 0xDC, 0x33, 0x61, 0x8D, 0x8E, 0x3E,
  0x70, 0xF0, 0x0F, 0x01, 0xF8, 0x19, 0xC1, 0x98, 0x1B, 0x81, 0xF0, 0x3E,
  0x77, 0xEE, 0xE7, 0xEE, 0x7C, 0xE3, 0x87, 0xFC, 0x7F, 0xE0, 0xFF, 0x6C,
  0x0E, 0x18, 0x61, 0xC3, 0x0E, 0x1C, 0x30, 0x60, 0xC3, 0x87, 0x06, 0x0C,
  0x18, 0x38, 0x1C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x1C, 0x71, 0x8E, 0x39,
  0xC6, 0x30, 0x0C, 0x0C, 0x6C, 0xFF, 0x3F, 0x3C, 0x7C, 0x26, 0x04, 0x18,
  0x18, 0x18, 0x18, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x77, 0x6E, 0x7F, 0xC0,
  0x7F, 0x80, 0x01, 0xC0, 0x60, 0x38, 0x1C, 0x07, 0x03, 0x80, 0xC0, 0x70,
  0x18, 0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x00, 0x1E, 0x3F, 0x77, 0x77, 0xE7,
  0xE7, 0xE7, 0xC7, 0xC7, 0xCE, 0xEE, 0xFC, 0x78, 0x0E, 0x79, 0xF7, 0xED,
  0xC3, 0x86, 0x1C, 0x38, 0x70, 0xC3, 0x87, 0x00, 0x0F, 0x87, 0xF1, 0xDC,
  0x47, 0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x1E, 0x0F, 0x07, 0x81, 0xFE, 0xFF,
  0x80, 0x1F, 0x1F, 0xC4, 0xE0, 0x70, 0x38, 0xF8, 0x78, 0x7E, 0x07, 0x03,
  0xA1, 0xDF, 0xCF, 0xC0, 0x03, 0x81, 0xC1, 0xE1, 0xF1, 0xB1, 0xF8, 0xDC,
  0xCE, 0xFF, 0xFF, 0xC3, 0x81, 0xC0, 0xE0, 0x1F, 0x8F, 0xCF, 0xE7, 0x03,
  0x81, 0xF1, 0xFC, 0x0E, 0x07, 0x03, 0xA3, 0xDF, 0xCF, 0xC0, 0x0F, 0x8F,
  0x8E, 0x2E, 0x06, 0x07, 0xF3, 0xFD, 0xCE, 0xE7, 0x63, 0xBB, 0x9F, 0xC7,
  0xC0, 0x3F, 0xCF, 0xF3, 0xFC, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x1C,
  0x07, 0x03, 0x81, 0xE0, 0xF0, 0x00, 0x0F, 0x0F, 0xCE, 0x67, 0x33, 0xB8,
  0xF8, 0x78, 0xFE, 0x63, 0x71, 0xF9, 0xCF, 0xE3, 0xE0, 0x3E, 0x7F, 0x77,
  0xE7, 0xE7, 0xE7, 0xFF, 0x7F, 0x26, 0x0E, 0x9C, 0xF8, 0xF0, 0x39, 0xCE,
  0x00, 0x00, 0x0C, 0xE7, 0x00, 0x1C, 0x71, 0xC0, 0x00, 0x00, 0x00, 0x71,
  0xC6, 0x38, 0x01, 0x07, 0x1E, 0x78, 0xE0, 0xF8, 0x3E, 0x07, 0x01, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0x1F, 0x7C,
  0xE0, 0x80, 0x3D, 0xFD, 0xB8, 0x30, 0xE3, 0x8E, 0x38, 0x60, 0x01, 0x87,
  0x0E, 0x00, 0x07, 0xC0, 0xFF, 0x8E, 0x0E, 0xE2, 0x36, 0x7D, 0xE6, 0x6F,
  0x66, 0x7B, 0x33, 0xD9, 0xB6, 0xFF, 0xB3, 0xB9, 0x80, 0x07, 0x08, 0x1F,
  0xC0, 0x30, 0x00, 0x03, 0xC0, 0xF8, 0x1B, 0x03, 0x60, 0xEC, 0x19, 0x87,
  0x30, 0xC6, 0x3F, 0xC7, 0xF9, 0xC3, 0x38, 0x6E, 0x0E, 0x1F, 0x87, 0xF3,
  0x9C, 0xE7, 0x39, 0xCF, 0xE3, 0xF1, 0xCE, 0x73, 0x9C, 0xE7, 0x79, 0xFC,
  0xFE, 0x00, 0x0F, 0x8F, 0xF3, 0xD9, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0F, 0x21, 0xF8, 0x3E, 0x00, 0x1F, 0x03, 0xF8, 0xFF, 0x1C,
  0x73, 0x8E, 0x71, 0xCE, 0x3B, 0x8F, 0x71, 0xCE, 0x79, 0xDE, 0x3F, 0x8F,
  0xE0, 0x1F, 0xC7, 0xE3, 0xF8, 0xE0, 0x38, 0x0F, 0xC3, 0xF1, 0xFC, 0x70,
  0x1C, 0x07, 0x01, 0xF8, 0xFE, 0x00, 0x1F, 0xC7, 0xE3, 0xF8, 0xE0, 0x38,
  0x0E, 0x03, 0xF1, 0xFC, 0x70, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x00, 0x0F,
  0xE3, 0xF8, 0xF3, 0x3C, 0x07, 0x01, 0xC0, 0x39, 0xF7, 0x3C, 0xE3, 0x9C,
  0x73, 0xCE, 0x3F, 0xC3, 0xF0, 0x1C, 0x71, 0xC7, 0x38, 0x63, 0x8E, 0x38,
  0xE3, 0xFE, 0x3F, 0xE7, 0xFC, 0x71, 0xC7, 0x1C, 0x71, 0xC6, 0x1C, 0xE3,
  0x80, 0x1F, 0x8F, 0xC3, 0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x0C,
  0x0E, 0x0F, 0xCF, 0xC0, 0x03, 0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x1C,
  0x0C, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xC0, 0xE3, 0xF1, 0xF0, 0xF0, 0x00,
  0x1C, 0xF1, 0xCE, 0x39, 0xC3, 0xB8, 0x3B, 0x83, 0xF0, 0x3E, 0x07, 0xF0,
  0x77, 0x07, 0x70, 0x73, 0x86, 0x38, 0xE3, 0x80, 0x1C, 0x1C, 0x38, 0x38,
  0x38, 0x38, 0x30, 0x70, 0x70, 0x70, 0x71, 0x7E, 0xFE, 0x1E, 0x1E, 0x3C,
  0x3C, 0xF8, 0xF9, 0xF1, 0xE3, 0xE7, 0xC6, 0xCF, 0x8D, 0xBF, 0x3B, 0x6E,
  0x77, 0xD8, 0xEF, 0x31, 0x9E, 0xE3, 0x39, 0xCE, 0x73, 0x80, 0x1C, 0x38,
  0xF1, 0xCF, 0x8C, 0x7C, 0x63, 0x67, 0x1B, 0xB8, 0xDD, 0xCE, 0x6C, 0x73,
  0x63, 0x9F, 0x18, 0xF8, 0xC3, 0xCE, 0x1C, 0x00, 0x0F, 0x87, 0xF8, 0xF7,
  0x38, 0x77, 0x0F, 0xC1, 0xF8, 0x3F, 0x0E, 0xE1, 0xDC, 0x7B, 0xDE, 0x3F,
  0x83, 0xE0, 0x1F, 0x07, 0xF3, 0xFC, 0xE7, 0x39, 0xCE, 0x73, 0xF9, 0xFE,
  0x7C, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x00, 0x0F, 0x87, 0xF8, 0xF7, 0x38,
  0x77, 0x0F, 0xC1, 0xF8, 0x7F, 0x0E, 0xE1, 0xDC, 0x7B, 0xDE, 0x3F, 0x83,
  0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x1F, 0x07, 0xF3, 0xBC, 0xE7, 0x39, 0xCE,
  0xF3, 0xF9, 0xFC, 0x77, 0x1D, 0xC7, 0x39, 0x8E, 0xE3, 0x80, 0x0F, 0x9F,
  0xCF, 0xE7, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x03, 0xB3, 0xDF, 0xCF,
  0xC0, 0x7F, 0xBF, 0xFF, 0xE3, 0x81, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x1C, 0x0E, 0x07, 0x00, 0x38, 0xE6, 0x19, 0xC7, 0x38, 0xE7, 0x1C, 0xE3,
  0x98, 0x67, 0x1C, 0xE3, 0x9C, 0x73, 0x9C, 0x7F, 0x87, 0xE0, 0xC3, 0xF0,
  0xEC, 0x33, 0x1C, 0xC7, 0x3B, 0x8E, 0xE3, 0xF0, 0xFC, 0x36, 0x0F, 0x83,
  0xC0, 0xF0, 0x00, 0xC3, 0x0F, 0x8E, 0x3B, 0x1C, 0x76, 0x78, 0xCC, 0xF3,
  0x99, 0xE7, 0x37, 0xDC, 0x6D, 0xB8, 0xFB, 0x61, 0xE7, 0xC3, 0xCF, 0x07,
  0x1E, 0x0E, 0x3C, 0x00, 0x1C, 0x78, 0xE3, 0x83, 0x38, 0x1F, 0x80, 0xFC,
  0x07, 0xC0, 0x3C, 0x01, 0xF0, 0x1F, 0x81, 0xDC, 0x0E, 0xE0, 0xE3, 0x8E,
  0x1C, 0x00, 0xE3, 0xF3, 0xB9, 0xDD, 0xC6, 0xC3, 0xE1, 0xE0, 0xF0, 0x70,
  0x38, 0x1C, 0x0C, 0x0E, 0x00, 0x1F, 0xE3, 0xFC, 0x7F, 0x01, 0xC0, 0x78,
  0x0E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x3F, 0xCF, 0xF0, 0x0F,
  0x0F, 0x1C, 0x1C, 0x18, 0x18, 0x38, 0x38, 0x30, 0x30, 0x30, 0x70, 0x70,
  0x60, 0x78, 0xF8, 0xCC, 0xEE, 0x66, 0x66, 0x77, 0x73, 0x30, 0x1E, 0x3C,
  0x38, 0x70, 0xC1, 0x83, 0x0E, 0x1C, 0x30, 0x61, 0xC3, 0x86, 0x3C, 0x78,
  0x06, 0x07, 0x03, 0x83, 0x61, 0xB1, 0x99, 0xCD, 0xC3, 0x7F, 0xFF, 0xFD,
  0x80, 0x3B, 0xBF, 0xDD, 0xDC, 0xEE, 0x77, 0x3B, 0x9D, 0xDC, 0xFE, 0x7F,
  0x00, 0x1C, 0x0E, 0x06, 0x07, 0x03, 0xF1, 0xFC, 0xEE, 0xE7, 0x73, 0xB9,
  0xDC, 0xEE, 0xEF, 0xF7, 0xF0, 0x3E, 0xFD, 0xCF, 0x0E, 0x1C, 0x38, 0x72,
  0xFC, 0xF8, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0x3B, 0x9F, 0xE7, 0x73, 0x9C,
  0xE7, 0x39, 0xCC, 0x73, 0xB8, 0xFE, 0x3D, 0x80, 0x1E, 0x7F, 0x77, 0xE7,
  0xFE, 0xFC, 0xC0, 0xE2, 0xFE, 0x7C, 0x01, 0xC0, 0xF0, 0x74, 0x1C, 0x0F,
  0x87, 0xE0, 0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x03,
  0x80, 0xE0, 0xF8, 0x3C, 0x00, 0x1D, 0xCF, 0xF3, 0xB9, 0xCE, 0x73, 0x9C,
  0xE7, 0x39, 0xDC, 0x7F, 0x1F, 0xC0, 0x72, 0x38, 0xFE, 0x3F, 0x00, 0x1C,
  0x0E, 0x06, 0x07, 0x03, 0xF9, 0xFC, 0xEE, 0xE7, 0x73, 0xB9, 0xDC, 0xEC,
  0x7E, 0x77, 0x38, 0x18, 0x71, 0x80, 0x38, 0xE3, 0x9C, 0x71, 0xC7, 0x18,
  0xE3, 0x80, 0x06, 0x07, 0x06, 0x00, 0x0E, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x38, 0x38, 0x38, 0x38, 0xF0, 0xF0, 0x1C, 0x03, 0x80, 0x60,
  0x1C, 0x03, 0x9E, 0x77, 0x0D, 0xE3, 0xB8, 0x7E, 0x0F, 0xC1, 0xF8, 0x33,
  0x8E, 0x71, 0xCF, 0x00, 0x1C, 0x71, 0x8E, 0x38, 0xE3, 0x9C, 0x71, 0xC7,
  0x18, 0xE3, 0x80, 0x37, 0xBC, 0xFF, 0xF3, 0xBD, 0xDC, 0xE7, 0x73, 0x9D,
  0xCE, 0x77, 0x39, 0xD8, 0xC6, 0xE7, 0x3B, 0x9C, 0xE0, 0x37, 0x9F, 0xCE,
  0xEE, 0x77, 0x3B, 0x9D, 0xCE, 0xC7, 0xE7, 0x73, 0x80, 0x3E, 0x7F, 0x77,
  0xE7, 0xE7, 0xE7, 0xC7, 0xEE, 0xFE, 0x7C, 0x1B, 0x87, 0xF1, 0xDC, 0xE7,
  0x39, 0xCE, 0x73, 0x9C, 0xEE, 0x7F, 0x9D, 0xC7, 0x01, 0xC0, 0x60, 0x38,
  0x00, 0x3B, 0xBF, 0xDD, 0xDC, 0xEE, 0x77, 0x3B, 0x1D, 0xDC, 0xFE, 0x7F,
  0x03, 0x81, 0x81, 0xC0, 0xE0, 0x37, 0x37, 0x3E, 0x78, 0x70, 0x70, 0x70,
  0x60, 0xE0, 0xE0, 0x3E, 0x3F, 0x72, 0x70, 0x3C, 0x3E, 0x0E, 0x8E, 0xFC,
  0xFC, 0x18, 0xC7, 0xFF, 0x71, 0x8E, 0x38, 0xE3, 0x8F, 0xBE, 0x73, 0xB9,
  0xD8, 0xDC, 0xEE, 0x77, 0x3B, 0x9D, 0xDC, 0xFE, 0x7B, 0x00, 0xE3, 0xF3,
  0xB9, 0xDD, 0xCE, 0xE7, 0xE1, 0xF0, 0xF0, 0x78, 0x38, 0x00, 0xE7, 0x3F,
  0x39, 0xFB, 0xCD, 0xDE, 0xEF, 0xB6, 0x7D, 0xF3, 0xEF, 0x9E, 0x78, 0xF3,
  0xC7, 0x9C, 0x00, 0x38, 0xE3, 0xB8, 0x7E, 0x0F, 0x80, 0xF0, 0x3C, 0x07,
  0xC1, 0xF8, 0x73, 0x9E, 0x70, 0x38, 0xE7, 0x38, 0xE7, 0x1D, 0xC3, 0xB8,
  0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x1C, 0x0F, 0x01, 0xE0,
  0x00, 0x3F, 0x7F, 0x0E, 0x0E, 0x1C, 0x38, 0x70, 0xF0, 0xFE, 0xFC, 0x07,
  0x0E, 0x1C, 0x1C, 0x18, 0x18, 0x38, 0xF0, 0xE0, 0x70, 0x70, 0x70, 0x70,
  0x70, 0x78, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x18, 0x38, 0xF0, 0x61,
  0xC3, 0x87, 0x07, 0x1E, 0x70, 0xE1, 0x83, 0x0E, 0x3C, 0x60, 0xF1, 0xFF,
  0x9F,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBoldItalic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 6, 13, 5, 0, -13 },
  { 11, 7, 5, 8, 2, -13 },
  { 16, 11, 13, 11, 0, -13 },
  { 34, 9, 15, 9, 0, -14 },
  { 51, 14, 13, 15, 1, -13 },
  { 74, 12, 13, 12, 0, -13 },
  { 94, 3, 5, 4, 2, -13 },
  { 96, 7, 16, 6, 0, -13 },
  { 110, 6, 16, 6, -1, -13 },
  { 122, 8, 9, 9, 1, -14 },
  { 131, 8, 9, 10, 1, -11 },
  { 140, 4, 4, 5, -1, -2 },
  { 142, 5, 2, 6, 0, -6 },
  { 144, 3, 3, 5, 0, -3 },
  { 146, 10, 13, 8, -1, -13 },
  { 163, 8, 13, 9, 1, -13 },
  { 176, 7, 13, 9, 2, -13 },
  { 188, 10, 13, 9, -1, -13 },
  { 205, 9, 13, 9, 0, -13 },
  { 220, 9, 13, 9, 0, -13 },
  { 235, 9, 13, 9, 0, -13 },
  { 250, 9, 13, 9, 1, -13 },
  { 265, 10, 13, 9, 0, -13 },
  { 282, 9, 13, 9, 0, -13 },
  { 297, 8, 13, 9, 1, -13 },
  { 310, 5, 10, 5, 0, -10 },
  { 317, 6, 12, 5, -1, -10 },
  { 326, 8, 9, 10, 1, -11 },
  { 335, 8, 6, 10, 1, -9 },
  { 341, 8, 9, 10, 1, -11 },
  { 350, 7, 13, 8, 1, -13 },
  { 362, 13, 15, 14, 1, -13 },
  { 387, 11, 13, 11, -1, -13 },
  { 405, 10, 13, 10, 0, -13 },
  { 422, 10, 13, 10, 1, -13 },
  { 439, 11, 13, 11, 0, -13 },
  { 457, 10, 13, 9, 0, -13 },
  { 474, 10, 13, 9, 0, -13 },
  { 491, 11, 13, 11, 1, -13 },
  { 509, 12, 13, 12, 0, -13 },
  { 529, 9, 13, 7, -1, -13 },
  { 544, 9, 17, 6, -3, -13 },
  { 564, 12, 13, 10, 0, -13 },
  { 584, 8, 13, 9, 0, -13 },
  { 597, 15, 13, 15, 0, -13 },
  { 622, 13, 13, 13, 0, -13 },
  { 644, 11, 13, 12, 1, -13 },
  { 662, 10, 13, 10, 0, -13 },
  { 679, 11, 16, 12, 1, -13 },
  { 701, 10, 13, 10, 0, -13 },
  { 718, 9, 13, 9, 0, -13 },
  { 733, 9, 13, 9, 1, -13 },
  { 748, 11, 13, 11, 1, -13 },
  { 766, 10, 13, 10, 2, -13 },
  { 783, 15, 13, 15, 2, -13 },
  { 808, 13, 13, 10, -1, -13 },
  { 830, 9, 13, 10, 2, -13 },
  { 845, 11, 13, 9, -1, -13 },
  { 863, 8, 16, 6, -1, -13 },
  { 879, 4, 13, 8, 2, -13 },
  { 886, 7, 16, 6, -1, -13 },
  { 900, 9, 8, 9, 0, -13 },
  { 909, 8, 2, 7, -2, 1 },
  { 911, 3, 3, 6, 3, -14 },
  { 913, 9, 10, 10, 1, -10 },
  { 925, 9, 14, 10, 0, -14 },
  { 941, 7, 10, 8, 1, -10 },
  { 950, 10, 14, 10, 1, -14 },
  { 968, 8, 10, 9, 1, -10 },
  { 978, 10, 18, 6, -2, -14 },
  { 1001, 10, 14, 10, 0, -10 },
  { 1019, 9, 14, 10, 0, -14 },
  { 1035, 6, 14, 5, 0, -14 },
  { 1046, 8, 18, 5, -2, -14 },
  { 1064, 11, 14, 10, 0, -14 },
  { 1084, 6, 14, 5, 0, -14 },
  { 1095, 14, 10, 15, 0, -10 },
  { 1113, 9, 10, 10, 0, -10 },
  { 1125, 8, 10, 10, 1, -10 },
  { 1135, 10, 14, 10, -1, -10 },
  { 1153, 9, 14, 10, 1, -10 },
  { 1169, 8, 10, 7, 0, -10 },
  { 1179, 8, 10, 8, 0, -10 },
  { 1189, 6, 12, 7, 1, -12 },
  { 1198, 9, 10, 10, 1, -10 },
  { 1210, 9, 10, 9, 1, -10 },
  { 1222, 13, 10, 13, 1, -10 },
  { 1239, 11, 10, 9, -1, -10 },
  { 1253, 11, 14, 9, -1, -10 },
  { 1273, 8, 10, 8, 0, -10 },
  { 1283, 8, 16, 6, 0, -13 },
  { 1299, 2, 18, 9, 3, -14 },
  { 1304, 7, 16, 6, -1, -13 },
  { 1318, 8, 3, 10, 1, -8 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBoldItalic18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBoldItalic18pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBoldItalic18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC18PT7B_H_
