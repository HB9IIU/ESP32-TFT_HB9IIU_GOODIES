#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC47PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBoldItalic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBoldItalic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x01, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F,
  0x80, 0xFF, 0x00, 0xFC, 0x00, 0x40, 0x00, 0x3F, 0x8F, 0xE7, 0xF3, 0xF8,
  0xFE, 0x7F, 0x1F, 0x8F, 0xE3, 0xF1, 0xF8, 0xFE, 0x3F, 0x1F, 0x87, 0xE3,
  0xF0, 0xFC, 0x7E, 0x3F, 0x0F, 0xC7, 0xE1, 0xF0, 0xFC, 0x3E, 0x1F, 0x0F,
  0xC3, 0xE0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xF0, 0xFC, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0xFC, 0x3E, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x01,
  0xF0, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0x0F, 0x80,
  0x00, 0xF8, 0x7C, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x03,
  0xE1, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x80, 0x3E, 0x1F, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x1F, 0x0F,
  0x80, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFF,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC,
  0x0F, 0xE7, 0x1C, 0x0F, 0xCE, 0x00, 0x1F, 0xCE, 0x00, 0x1F, 0xEE, 0x00,
  0x0F, 0xEE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3B, 0xF8, 0x00, 0x3B, 0xF8, 0x80, 0x73, 0xF8,
  0xC0, 0x73, 0xF8, 0xF8, 0x77, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x01, 0xFF, 0x00, 0x0F, 0xC0,
  0x7F, 0xF0, 0x03, 0xF0, 0x0F, 0xFF, 0x00, 0x7C, 0x03, 0xFF, 0xE0, 0x1F,
  0x80, 0xFE, 0x7C, 0x07, 0xE0, 0x1F, 0x8F, 0x80, 0xF8, 0x03, 0xE1, 0xF0,
  0x3F, 0x00, 0xFC, 0x3E, 0x0F, 0xC0, 0x1F, 0x87, 0xC1, 0xF0, 0x03, 0xF1,
  0xF8, 0x7E, 0x00, 0x7C, 0x3F, 0x1F, 0x80, 0x0F, 0x87, 0xE3, 0xE0, 0x01,
  0xF0, 0xF8, 0xFC, 0x38, 0x3E, 0x3F, 0x3F, 0x1F, 0xE7, 0xCF, 0xE7, 0xCF,
  0xFE, 0xFF, 0xF9, 0xFB, 0xFF, 0xDF, 0xFE, 0x7E, 0x7F, 0xFD, 0xFF, 0xCF,
  0x9F, 0xDF, 0xBF, 0xE3, 0xF3, 0xF3, 0xF1, 0xF8, 0xFC, 0xFC, 0x7E, 0x00,
  0x1F, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF1, 0xF8, 0x01, 0xF8, 0x7C, 0x3F,
  0x00, 0x3E, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0xF8, 0x03, 0xF0, 0x7E,
  0x3F, 0x00, 0xFC, 0x0F, 0xC7, 0xE0, 0x1F, 0x81, 0xF9, 0xF8, 0x07, 0xE0,
  0x3F, 0xFF, 0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0x00, 0x7F, 0xF8, 0x0F,
  0xC0, 0x07, 0xFE, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x01,
  0xFF, 0xFE, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE,
  0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x3F, 0x8F,
  0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x83, 0xFC,
  0x3F, 0xFE, 0x0F, 0xE1, 0xFF, 0xF8, 0x7F, 0x8F, 0xFF, 0xF1, 0xFC, 0x7F,
  0xBF, 0xEF, 0xF1, 0xFC, 0x7F, 0xBF, 0x8F, 0xF0, 0xFF, 0xFE, 0x3F, 0x83,
  0xFF, 0xF0, 0xFE, 0x07, 0xFF, 0x83, 0xF8, 0x1F, 0xFE, 0x0F, 0xE0, 0x3F,
  0xF0, 0x3F, 0xC1, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xBF, 0xC0,
  0x3F, 0xF0, 0xFF, 0x80, 0x3F, 0x9F, 0xCF, 0xE7, 0xE3, 0xF3, 0xF9, 0xF8,
  0xFC, 0x7E, 0x3F, 0x1F, 0x0F, 0x8F, 0xC0, 0x00, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0,
  0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x70, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x02, 0x07, 0xC0, 0x38, 0x3E, 0x01,
  0xF1, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x87, 0xFE, 0x04, 0x7F, 0xF0, 0x07,
  0xF7, 0xC0, 0x7F, 0xBF, 0x03, 0xF9, 0xF8, 0x07, 0x8F, 0xE0, 0x1C, 0x3F,
  0x00, 0x41, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE3,
  0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x0F, 0xE3, 0xF8, 0x7E, 0x0F, 0xC3,
  0xF0, 0x7E, 0x00, 0x7F, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xEF, 0xFF, 0x7F,
  0xFB, 0xFF, 0xC0, 0x0E, 0x1F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFC, 0xFC,
  0x10, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFE, 0x7F, 0x87, 0xF8, 0x7F,
  0x0F, 0xE0, 0xFE, 0x3F, 0xC1, 0xFC, 0x7F, 0x03, 0xF9, 0xFE, 0x07, 0xF3,
  0xFC, 0x0F, 0xE7, 0xF0, 0x1F, 0xDF, 0xE0, 0x3F, 0xBF, 0xC0, 0xFF, 0x7F,
  0x81, 0xFE, 0xFE, 0x03, 0xFD, 0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xE7, 0xF0,
  0x3F, 0xDF, 0xE0, 0x7F, 0xBF, 0xC0, 0xFE, 0x7F, 0x83, 0xFC, 0xFF, 0x07,
  0xF9, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0xC3, 0xF8, 0xFF, 0x07, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x7F,
  0xE0, 0x1F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFF,
  0x9F, 0xFF, 0xF1, 0xFD, 0xFE, 0x3F, 0x3F, 0x83, 0xC7, 0xF0, 0x20, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xE0,
  0xFF, 0x01, 0xC0, 0x7F, 0x80, 0x40, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xF1, 0xFF, 0x01, 0x80, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x80, 0x07, 0xF8, 0xE0, 0x0F, 0xF8, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7D, 0xFC, 0x00, 0xFD, 0xFC, 0x01, 0xF9, 0xFC, 0x03,
  0xF3, 0xF8, 0x03, 0xF3, 0xF8, 0x07, 0xE3, 0xF8, 0x0F, 0xC3, 0xF8, 0x1F,
  0x87, 0xF8, 0x3F, 0x87, 0xF0, 0x3F, 0x07, 0xF0, 0x7F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE8, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x80, 0x0F, 0xF0, 0xE0, 0x3F, 0xF0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFC, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF,
  0x81, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF9, 0xF8, 0x0F, 0xE7, 0xFC, 0x1F, 0xDF, 0xFC,
  0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF3, 0xFF, 0x1F, 0xE7,
  0xFC, 0x3F, 0xCF, 0xF0, 0x7F, 0x9F, 0xE0, 0xFF, 0x3F, 0x81, 0xFE, 0x7F,
  0x03, 0xFC, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x3F, 0xC7, 0xF8,
  0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0xFF, 0x0F, 0xE0,
  0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF1, 0xFE, 0x07, 0xF3,
  0xFC, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xCF,
  0xF0, 0x7F, 0x87, 0xF8, 0xFF, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03,
  0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x8F,
  0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xFC, 0xFF,
  0x0F, 0xF0, 0xFF, 0x1F, 0xC1, 0xFE, 0x7F, 0x81, 0xFC, 0xFF, 0x03, 0xF9,
  0xFC, 0x0F, 0xF3, 0xF8, 0x1F, 0xE7, 0xF0, 0x3F, 0xCF, 0xE0, 0xFF, 0x9F,
  0xE1, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF,
  0xEF, 0xE0, 0xFF, 0xBF, 0x80, 0xFE, 0x7F, 0x00, 0x60, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x84, 0x03, 0xFE,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xF0, 0x3F, 0xC1, 0xFE, 0x1F,
  0xF0, 0xFF, 0x87, 0xF8, 0x1F, 0xC0, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x7E, 0x07, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xE0, 0xFF, 0x03, 0xF0,
  0x04, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFE, 0x00, 0xFE, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70,
  0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80,
  0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xF8,
  0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC,
  0x7F, 0xFF, 0xCF, 0x87, 0xF9, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x7E, 0x0F,
  0xE0, 0x00, 0x07, 0xC1, 0xF8, 0x0F, 0xE0, 0xFC, 0x7E, 0x0F, 0xFF, 0x9F,
  0x9F, 0x83, 0xFF, 0xF1, 0xF3, 0xE0, 0xFF, 0xFC, 0x3E, 0x7C, 0x3F, 0x9F,
  0x87, 0xDF, 0x07, 0xE1, 0xF0, 0xFB, 0xE1, 0xF8, 0x7E, 0x1F, 0x7C, 0x3E,
  0x0F, 0x83, 0xFF, 0x8F, 0xC1, 0xF0, 0x7F, 0xE1, 0xF0, 0x7E, 0x1F, 0x7C,
  0x3E, 0x0F, 0xC3, 0xEF, 0x8F, 0xC1, 0xF0, 0x7D, 0xF1, 0xF8, 0x3E, 0x1F,
  0xBE, 0x3F, 0x0F, 0xC3, 0xE7, 0xC7, 0xE3, 0xF8, 0xFC, 0xF8, 0xFE, 0xFF,
  0x3F, 0x1F, 0x0F, 0xFF, 0xFF, 0xC3, 0xE1, 0xFF, 0xBF, 0xF0, 0x7C, 0x1F,
  0xE7, 0xFC, 0x0F, 0xC1, 0xF8, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0x00,
  0x03, 0xFF, 0xBF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x0F,
  0xCF, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF8, 0xFE,
  0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x0F,
  0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xE0, 0xFE, 0x01, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF1, 0xFE, 0x00,
  0xFF, 0x1F, 0xE0, 0x0F, 0xF3, 0xFC, 0x00, 0xFF, 0x3F, 0xC0, 0x0F, 0xF7,
  0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xF0, 0x3F, 0xC1, 0xFC, 0x0F, 0xF0, 0x7F, 0x03, 0xFC, 0x3F, 0xC0,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x7F, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x3F, 0x83, 0xFC, 0x0F,
  0xF0, 0xFE, 0x03, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xE0, 0x7F, 0x87, 0xF8,
  0x1F, 0xE1, 0xFC, 0x1F, 0xF8, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xEF,
  0xC0, 0x7F, 0xE0, 0x18, 0x0F, 0xF8, 0x01, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x40, 0x3F, 0xF0, 0x78, 0x07,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xC3, 0xFF, 0x07,
  0xF8, 0x3F, 0xE0, 0xFE, 0x03, 0xFC, 0x1F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F,
  0xF0, 0xFF, 0x00, 0xFE, 0x1F, 0xE0, 0x3F, 0xC3, 0xF8, 0x07, 0xF8, 0xFF,
  0x00, 0xFF, 0x1F, 0xE0, 0x1F, 0xE3, 0xFC, 0x03, 0xFC, 0x7F, 0x00, 0x7F,
  0x8F, 0xE0, 0x0F, 0xF3, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xF0,
  0x1F, 0xF1, 0xFC, 0x03, 0xFC, 0x3F, 0x80, 0xFF, 0x8F, 0xF0, 0x3F, 0xE1,
  0xFE, 0x0F, 0xFC, 0x3F, 0xDF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x20, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x07, 0xFF, 0xCF, 0xC0, 0xFF, 0xC0, 0x1C, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x3F, 0xFC, 0x7F,
  0x83, 0xFF, 0xC7, 0xF8, 0x7F, 0xFC, 0xFF, 0x07, 0xFF, 0x8F, 0xF0, 0x7F,
  0xF8, 0xFF, 0x07, 0xFF, 0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x8F,
  0xF0, 0x07, 0xF0, 0xFF, 0x00, 0x7F, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80,
  0xFF, 0x07, 0xFE, 0x0F, 0xF0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0,
  0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x0F,
  0xE0, 0x7F, 0x80, 0x7F, 0x81, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xF8,
  0x1F, 0xC0, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x03, 0xFC, 0x03, 0xFC, 0x0F,
  0xF0, 0x0F, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF,
  0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x81,
  0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F,
  0x00, 0x7F, 0x01, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0,
  0x3F, 0xC0, 0xFF, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x10, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x03, 0xFE, 0x07,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0x3F,
  0x81, 0xFE, 0x00, 0x7F, 0x07, 0xFC, 0x01, 0xFE, 0x1F, 0xF0, 0x03, 0xFC,
  0x3F, 0xC0, 0x07, 0xF0, 0xFF, 0x00, 0x0F, 0xE3, 0xFE, 0x00, 0x1F, 0xCF,
  0xF8, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0xFF, 0x7F, 0x80, 0x01, 0xFD, 0xFE,
  0x00, 0x03, 0xFB, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x0F, 0xF3, 0xFC, 0x00,
  0x1F, 0xC3, 0xFC, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x01,
  0xFE, 0x1F, 0xE0, 0x03, 0xF8, 0x1F, 0xE0, 0x07, 0xF0, 0x3F, 0xC0, 0x0F,
  0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0xFE,
  0x01, 0xFE, 0x01, 0xFC, 0x03, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0x80, 0x17, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF,
  0xFF, 0xDF, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFF, 0x81, 0xFF, 0xE0,
  0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xF8,
  0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFC,
  0x0F, 0xDF, 0x80, 0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x7E, 0xFE,
  0x03, 0xF7, 0xE0, 0xFD, 0xFC, 0x0F, 0xEF, 0xC3, 0xF3, 0xF8, 0x1F, 0xDF,
  0x87, 0xEF, 0xE0, 0x3F, 0xBF, 0x1F, 0x9F, 0xC0, 0x7F, 0x7E, 0x3F, 0x3F,
  0x80, 0xFC, 0xFC, 0xFC, 0x7F, 0x03, 0xF9, 0xF9, 0xF9, 0xFC, 0x07, 0xF3,
  0xF3, 0xF3, 0xF8, 0x0F, 0xE3, 0xEF, 0xC7, 0xF0, 0x1F, 0xC7, 0xDF, 0x8F,
  0xE0, 0x3F, 0x0F, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xFC, 0x7F, 0x01, 0xFC,
  0x3F, 0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0xE1, 0xFC, 0x07, 0xF0, 0xFF, 0x83,
  0xF8, 0x0F, 0xC1, 0xFF, 0x07, 0xF0, 0x3F, 0x83, 0xFC, 0x1F, 0xC0, 0x7F,
  0x07, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0x81, 0xFF, 0x80, 0x1F, 0xC0, 0xFF,
  0xC0, 0x1F, 0xC0, 0x7F, 0xE0, 0x0F, 0xE0, 0x3F, 0xF0, 0x07, 0xF0, 0x1F,
  0xFC, 0x03, 0xF8, 0x1F, 0xFE, 0x01, 0xFC, 0x0F, 0xFF, 0x01, 0xFC, 0x07,
  0xFF, 0x80, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0x01, 0xFF, 0xF0, 0x3F, 0x81,
  0xFF, 0xF8, 0x1F, 0x80, 0xFE, 0xFC, 0x1F, 0xC0, 0x7E, 0x7F, 0x0F, 0xE0,
  0x3F, 0x3F, 0x87, 0xF0, 0x3F, 0x9F, 0xC3, 0xF8, 0x1F, 0xC7, 0xF3, 0xF8,
  0x0F, 0xE3, 0xF9, 0xFC, 0x07, 0xF1, 0xFC, 0xFE, 0x03, 0xF8, 0xFE, 0x7F,
  0x03, 0xF8, 0x3F, 0xBF, 0x81, 0xFC, 0x1F, 0xDF, 0x80, 0xFE, 0x0F, 0xEF,
  0xC0, 0x7F, 0x07, 0xFF, 0xE0, 0x3F, 0x01, 0xFF, 0xF0, 0x3F, 0x80, 0xFF,
  0xF8, 0x1F, 0xC0, 0x7F, 0xF8, 0x0F, 0xE0, 0x3F, 0xFC, 0x07, 0xF0, 0x0F,
  0xFE, 0x03, 0xF0, 0x07, 0xFF, 0x03, 0xF8, 0x03, 0xFF, 0x01, 0xFC, 0x01,
  0xFF, 0x80, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0x7F, 0xF0,
  0xFF, 0xC1, 0xFF, 0x0F, 0xF0, 0x0F, 0xF1, 0xFF, 0x00, 0xFF, 0x1F, 0xE0,
  0x07, 0xF3, 0xFC, 0x00, 0x7F, 0x3F, 0xC0, 0x07, 0xF3, 0xFC, 0x00, 0x7F,
  0x7F, 0x80, 0x07, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF7, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xEF, 0xF0, 0x03, 0xFC, 0xFF,
  0x00, 0x7F, 0xCF, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x87, 0xFC, 0x3F,
  0xF0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xE1, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xF0, 0x7F, 0x03, 0xFC, 0x3F, 0xC0,
  0xFF, 0x0F, 0xF0, 0x3F, 0xC3, 0xF8, 0x1F, 0xE0, 0xFE, 0x07, 0xF8, 0x7F,
  0x87, 0xFE, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF,
  0x7F, 0xF0, 0xFF, 0xC1, 0xFF, 0x0F, 0xF0, 0x0F, 0xF1, 0xFF, 0x00, 0xFF,
  0x1F, 0xE0, 0x07, 0xF3, 0xFC, 0x00, 0x7F, 0x3F, 0xC0, 0x07, 0xF3, 0xFC,
  0x00, 0x7F, 0x7F, 0x80, 0x07, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x0F,
  0xF7, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xEF, 0xF0, 0x03,
  0xFC, 0xFF, 0x00, 0x7F, 0xCF, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x87,
  0xFC, 0x3F, 0xF0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x1F,
  0xE7, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC1,
  0xFC, 0x0F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0x03, 0xFC,
  0x3F, 0x83, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFE, 0x7F,
  0x00, 0xFF, 0x3F, 0xC0, 0x7F, 0x1F, 0xE0, 0x3F, 0x87, 0xF0, 0x3F, 0xC3,
  0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x3F, 0xC3, 0xF8,
  0x1F, 0xE3, 0xFC, 0x0F, 0xF1, 0xFE, 0x03, 0xFC, 0xFE, 0x01, 0xFE, 0x7F,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x07, 0xF8, 0x0C, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x80, 0x07, 0xF0, 0x60, 0x0F, 0xF0,
  0x7C, 0x1F, 0xF0, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xE0, 0xFE, 0x01,
  0xFE, 0x0F, 0xE0, 0x1F, 0xE1, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xC1,
  0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0xC1, 0xFC, 0x03, 0xFC, 0x3F, 0xC0,
  0x3F, 0xC3, 0xFC, 0x03, 0xF8, 0x3F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF8,
  0x7F, 0x80, 0x7F, 0x87, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x07, 0xF8,
  0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFE,
  0x0F, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x1F, 0xE0, 0xFE,
  0x01, 0xFE, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0xFF,
  0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xFB, 0xFC, 0x01, 0xFE, 0xFF,
  0x00, 0x7F, 0x3F, 0xC0, 0x3F, 0xCF, 0xF0, 0x0F, 0xE3, 0xFC, 0x07, 0xF8,
  0xFF, 0x01, 0xFE, 0x1F, 0xC0, 0xFF, 0x07, 0xF0, 0x3F, 0xC1, 0xFC, 0x0F,
  0xE0, 0x7F, 0x07, 0xF8, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0xFF, 0x01, 0xFC,
  0x3F, 0x80, 0x7F, 0x1F, 0xE0, 0x1F, 0xC7, 0xF0, 0x07, 0xF3, 0xFC, 0x01,
  0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xDF, 0xC0, 0x07, 0xF7, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0xFE,
  0x00, 0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFE,
  0x01, 0xFC, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0xFE, 0x03, 0xFE, 0x03, 0xF8,
  0xFE, 0x03, 0xFE, 0x07, 0xF8, 0xFE, 0x07, 0xFE, 0x07, 0xF0, 0xFE, 0x07,
  0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F, 0xFE, 0x0F,
  0xE0, 0xFE, 0x1F, 0xFE, 0x1F, 0xE0, 0xFE, 0x1F, 0xFE, 0x1F, 0xC0, 0xFE,
  0x1F, 0xFE, 0x1F, 0xC0, 0xFE, 0x3F, 0x7E, 0x3F, 0xC0, 0xFE, 0x3F, 0x7E,
  0x3F, 0x80, 0xFE, 0x7F, 0x7E, 0x7F, 0x80, 0xFE, 0x7E, 0x7E, 0x7F, 0x00,
  0xFE, 0xFE, 0x7E, 0x7F, 0x00, 0xFE, 0xFC, 0x7E, 0xFE, 0x00, 0xFE, 0xFC,
  0x7E, 0xFE, 0x00, 0xFF, 0xFC, 0x7E, 0xFE, 0x00, 0xFF, 0xF8, 0x7F, 0xFC,
  0x00, 0xFF, 0xF8, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0xC0,
  0x1F, 0xC0, 0x3F, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xE0,
  0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x8F, 0xF0,
  0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x07, 0xF7, 0xF0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x01, 0xFE,
  0x3F, 0xC0, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF,
  0x03, 0xF8, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xDF, 0xC0, 0x3F, 0xCF, 0xE0, 0x3F,
  0xC7, 0xF0, 0x1F, 0xE3, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xE0, 0x7F, 0x0F,
  0xF0, 0x3F, 0x8F, 0xF0, 0x1F, 0xC7, 0xF8, 0x0F, 0xE7, 0xF8, 0x03, 0xFB,
  0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x20, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x00, 0xFC, 0x1F, 0x83, 0xF8, 0x7F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xE1, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x87, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFE, 0x1F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x10, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x01, 0xFB, 0xE0, 0x07, 0xE7, 0xC0, 0x0F, 0xCF, 0xC0, 0x3F, 0x1F, 0x80,
  0xFE, 0x1F, 0x01, 0xF8, 0x3E, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x3F,
  0x00, 0xF8, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF7, 0xE0, 0x07, 0xFF, 0x80,
  0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0x3F, 0xC7, 0xF0, 0xFE, 0x3F, 0x87, 0xE0, 0xFC, 0x1F, 0x01, 0xFC,
  0x3F, 0x03, 0xFE, 0x7F, 0x07, 0xFF, 0x7E, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xE3, 0xFC, 0x3F, 0xC3, 0xFC, 0x7F, 0x83,
  0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x03, 0xFC, 0xFF, 0x03, 0xF8, 0xFF, 0x03,
  0xF8, 0xFF, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF8, 0xFE, 0x07,
  0xF0, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F, 0xF0, 0xFF, 0x1F, 0xF0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xEF,
  0xE0, 0x1F, 0xCF, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF9,
  0xF8, 0x07, 0xFB, 0xFC, 0x07, 0xF7, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xF8, 0xFF, 0x0F, 0xF0, 0x7F, 0x0F, 0xE0,
  0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0,
  0x7F, 0x1F, 0xC0, 0xFF, 0x1F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFE, 0x3F, 0xC1,
  0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x7F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x7E, 0xFF, 0xE0, 0x7E, 0x7F,
  0xC0, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0x07, 0xFF, 0xF0,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xE0, 0xC3, 0xFC, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x01, 0x0F, 0xF0, 0x30, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xCF, 0xF0, 0x0F, 0xFB, 0xF8,
  0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x3F, 0xE3, 0xFC, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x03, 0xFC, 0x3F, 0xC0, 0xFE, 0x0F, 0xF0, 0x3F, 0x83,
  0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x81, 0xFE, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x3F, 0xC7, 0xFC, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFD, 0xF8, 0x03,
  0xFE, 0x7E, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x80,
  0x7F, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0x8F, 0xF3, 0xFC,
  0x1F, 0xCF, 0xE0, 0x7F, 0x7F, 0x83, 0xF9, 0xFC, 0x1F, 0xEF, 0xF1, 0xFF,
  0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFC, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0,
  0x30, 0xFF, 0x87, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFE, 0x20, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x0F,
  0xC0, 0x3F, 0xE7, 0xF0, 0x1F, 0xFD, 0xF8, 0x0F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0x8F, 0xF0, 0x3F, 0xC3, 0xFC, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xF8,
  0x3F, 0xC0, 0xFE, 0x0F, 0xF0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x07,
  0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0xFF, 0x03, 0xF8, 0x3F, 0xC0, 0xFF,
  0x1F, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0xEF, 0xE0, 0x1F, 0xF7, 0xF8, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x20, 0x03, 0xF8, 0x0E, 0x01,
  0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0xFF, 0x7F, 0xC0,
  0x7F, 0x7F, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x0F, 0xF8, 0x7F, 0x87, 0xFC, 0x3F, 0xC3, 0xFC, 0x1F, 0xC1, 0xFC, 0x0F,
  0xE0, 0xFE, 0x07, 0xF0, 0xFF, 0x03, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0x81,
  0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xE0, 0x7F, 0x0F, 0xF0, 0x7F, 0x87, 0xF0,
  0x3F, 0xC3, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE1, 0xFE, 0x07, 0xF0, 0xFF,
  0x07, 0xF8, 0x7F, 0x03, 0xFC, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x1F,
  0xE0, 0xFF, 0x00, 0x00, 0x7C, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0x80, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0,
  0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x1F, 0xF0, 0x7F, 0x83, 0xFE, 0x07, 0xF8, 0x3F,
  0xC0, 0x7F, 0x07, 0xF8, 0x07, 0xF0, 0xFF, 0x00, 0x7F, 0x1F, 0xE0, 0x0F,
  0xF3, 0xFC, 0x00, 0xFE, 0x7F, 0x80, 0x0F, 0xEF, 0xF0, 0x00, 0xFE, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0x8F, 0xF0, 0x03, 0xF8, 0x7F, 0x00,
  0x7F, 0x87, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x03, 0xFC, 0x07, 0xF0,
  0x3F, 0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFE, 0x01,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x07, 0xF8, 0x00, 0x03, 0xF1, 0xFC, 0x0F, 0xE0, 0x3F, 0x1F,
  0xF0, 0xFF, 0x81, 0xF9, 0xFF, 0x9F, 0xFE, 0x0F, 0xDF, 0xFE, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xE3, 0xFF,
  0x0F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x7F,
  0x03, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC0, 0xFE, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF1, 0xFE, 0x0F, 0xF0, 0x7F, 0x8F, 0xE0, 0x7F, 0x03, 0xF8, 0x7F, 0x03,
  0xF8, 0x1F, 0xC7, 0xF8, 0x1F, 0xC0, 0xFE, 0x3F, 0xC1, 0xFE, 0x0F, 0xF1,
  0xFC, 0x0F, 0xE0, 0x7F, 0x8F, 0xE0, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8,
  0x1F, 0xC7, 0xF8, 0x3F, 0xC0, 0xFE, 0x3F, 0xC1, 0xFE, 0x0F, 0xF1, 0xFC,
  0x0F, 0xE0, 0x7F, 0x8F, 0xE0, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x1F,
  0xC7, 0xF8, 0x3F, 0xC1, 0xFE, 0x00, 0x03, 0xF1, 0xFC, 0x03, 0xF1, 0xFF,
  0x01, 0xF9, 0xFF, 0xC0, 0xFD, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x3F, 0xF1, 0xFE, 0x1F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7F, 0x07, 0xF8,
  0x3F, 0x83, 0xF8, 0x1F, 0xC3, 0xFC, 0x0F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFE,
  0x07, 0xF8, 0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F,
  0xC0, 0xFF, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x87, 0xF8, 0x1F, 0xC3,
  0xFC, 0x1F, 0xE1, 0xFC, 0x0F, 0xF0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8,
  0x7F, 0x81, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x7F, 0xFF,
  0x03, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF3, 0xFC, 0x3F, 0xCF,
  0xE0, 0xFF, 0x7F, 0x83, 0xFD, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFE,
  0xFE, 0x07, 0xFB, 0xF8, 0x1F, 0xEF, 0xE0, 0xFF, 0x3F, 0xC3, 0xFC, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFE,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x7F, 0xC0, 0x1F,
  0xBF, 0xF8, 0x07, 0xEF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x3F, 0xE3, 0xFC, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xC1, 0xFC,
  0x0F, 0xF0, 0x7F, 0x03, 0xFC, 0x3F, 0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0x83,
  0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x1F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xDF,
  0xF0, 0x0F, 0xF3, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x3F, 0x03, 0xFE, 0x7E, 0x07,
  0xFF, 0x7E, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F,
  0xE3, 0xFC, 0x3F, 0xC3, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x83, 0xFC, 0x7F,
  0x03, 0xFC, 0xFF, 0x03, 0xF8, 0xFF, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE,
  0x03, 0xF8, 0xFE, 0x07, 0xF8, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE,
  0x0F, 0xF0, 0xFF, 0x1F, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xEF, 0xE0, 0x1F, 0x9F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xF1, 0xF8, 0x3F,
  0x9F, 0x81, 0xF9, 0xFC, 0x0F, 0xDF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0,
  0x3F, 0xFF, 0x81, 0xFF, 0xC4, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0x81, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xF0, 0xF0, 0x7F, 0x81, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF1, 0x80, 0x7F, 0x8F, 0xCF, 0xFC,
  0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0x3F, 0xFC, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xC3, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F,
  0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xE0, 0x7F, 0x1F,
  0xE0, 0xFF, 0x1F, 0xC0, 0xFF, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x3F,
  0xC0, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0x81, 0xFE, 0x3F, 0x81, 0xFC, 0x3F,
  0x81, 0xFC, 0x7F, 0x81, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x03, 0xF8, 0x7F,
  0x03, 0xF8, 0xFF, 0x03, 0xF8, 0xFF, 0x07, 0xF8, 0xFE, 0x07, 0xF8, 0xFE,
  0x0F, 0xF0, 0xFE, 0x0F, 0xF0, 0xFF, 0x1F, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x7F, 0xF7, 0xE0, 0x7F, 0xE7, 0xE0, 0x3F,
  0xC7, 0xE0, 0xFF, 0x00, 0xFF, 0x7F, 0x01, 0xFE, 0x7F, 0x01, 0xFC, 0x7F,
  0x03, 0xFC, 0x7F, 0x03, 0xF8, 0x7F, 0x07, 0xF8, 0x7F, 0x07, 0xF0, 0x7F,
  0x0F, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x1F, 0xC0, 0x7F,
  0x1F, 0xC0, 0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0x80, 0x3F, 0x7F, 0x00, 0x3F,
  0x7F, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x07, 0xF8, 0x1F,
  0xFF, 0xC1, 0xFF, 0x03, 0xFB, 0xF8, 0x3F, 0xE0, 0xFE, 0x7F, 0x07, 0xFC,
  0x1F, 0xCF, 0xE1, 0xFF, 0x87, 0xF9, 0xFC, 0x3F, 0xF0, 0xFE, 0x3F, 0x8F,
  0xFE, 0x1F, 0xC7, 0xF1, 0xFF, 0xC7, 0xF0, 0xFE, 0x3F, 0xF8, 0xFE, 0x1F,
  0xCF, 0xFF, 0x3F, 0x83, 0xF9, 0xF7, 0xE7, 0xF0, 0x7F, 0x7E, 0xFD, 0xFC,
  0x0F, 0xEF, 0xDF, 0xBF, 0x81, 0xFD, 0xF3, 0xF7, 0xF0, 0x3F, 0xFE, 0x7D,
  0xFC, 0x07, 0xEF, 0x8F, 0xBF, 0x80, 0xFD, 0xF1, 0xF7, 0xE0, 0x1F, 0xFE,
  0x3F, 0xFC, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x0F,
  0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xE0,
  0x07, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xE0, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xC1, 0xFE, 0x03, 0xFC, 0x3F,
  0xE0, 0x3F, 0xC3, 0xFC, 0x01, 0xFC, 0x7F, 0x80, 0x1F, 0xEF, 0xF0, 0x01,
  0xFE, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0x7F, 0x80,
  0x0F, 0xF3, 0xF8, 0x01, 0xFE, 0x3F, 0x80, 0x3F, 0xC3, 0xFC, 0x07, 0xFC,
  0x3F, 0xC0, 0x7F, 0x81, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x07,
  0xF8, 0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x3F, 0xC0,
  0x3F, 0x81, 0xFE, 0x01, 0xFC, 0x1F, 0xE0, 0x0F, 0xE0, 0xFF, 0x00, 0x7F,
  0x07, 0xF0, 0x03, 0xF8, 0x7F, 0x80, 0x1F, 0xC3, 0xF8, 0x00, 0x7E, 0x3F,
  0xC0, 0x03, 0xF1, 0xFC, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0xFE, 0xFE, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x80, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x07,
  0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xC0, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x80, 0x1F,
  0xF0, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x0F, 0xFE, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFE, 0x00, 0x00, 0x0E, 0x00, 0x04, 0xFF, 0x80, 0x1F, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x07,
  0xFC, 0x80, 0x00, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBoldItalic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 15, 35, 13, 0, -34 },
  { 67, 19, 13, 21, 4, -34 },
  { 98, 29, 34, 28, 0, -34 },
  { 222, 24, 39, 24, 1, -36 },
  { 339, 35, 34, 39, 3, -34 },
  { 488, 30, 34, 31, 1, -34 },
  { 616, 9, 13, 12, 4, -34 },
  { 631, 18, 41, 15, 1, -34 },
  { 724, 17, 41, 15, -3, -34 },
  { 812, 21, 22, 24, 4, -36 },
  { 870, 22, 23, 26, 2, -28 },
  { 934, 11, 12, 13, -2, -6 },
  { 951, 13, 7, 15, 1, -16 },
  { 963, 9, 9, 13, 0, -8 },
  { 974, 25, 34, 20, -2, -34 },
  { 1081, 23, 34, 24, 1, -34 },
  { 1179, 19, 34, 25, 4, -34 },
  { 1260, 25, 34, 24, -1, -34 },
  { 1367, 24, 34, 24, 0, -34 },
  { 1469, 24, 34, 25, 0, -34 },
  { 1571, 24, 34, 24, 1, -34 },
  { 1673, 23, 34, 24, 2, -34 },
  { 1771, 26, 34, 24, 1, -34 },
  { 1882, 24, 34, 24, 1, -34 },
  { 1984, 23, 34, 24, 1, -34 },
  { 2082, 13, 27, 13, 0, -26 },
  { 2126, 16, 32, 13, -3, -26 },
  { 2190, 22, 24, 26, 2, -29 },
  { 2256, 22, 15, 26, 2, -24 },
  { 2298, 22, 24, 26, 2, -29 },
  { 2364, 19, 35, 20, 3, -34 },
  { 2448, 35, 38, 38, 2, -34 },
  { 2615, 28, 34, 28, -3, -34 },
  { 2734, 26, 34, 27, 1, -34 },
  { 2845, 27, 34, 26, 2, -34 },
  { 2960, 27, 34, 29, 1, -34 },
  { 3075, 24, 34, 23, 1, -34 },
  { 3177, 24, 34, 23, 1, -34 },
  { 3279, 28, 34, 30, 2, -34 },
  { 3398, 30, 34, 30, 1, -34 },
  { 3526, 23, 34, 18, -2, -34 },
  { 3624, 23, 44, 15, -7, -34 },
  { 3751, 31, 34, 27, 1, -34 },
  { 3883, 19, 34, 22, 1, -34 },
  { 3964, 39, 34, 39, 1, -34 },
  { 4130, 33, 34, 33, 1, -34 },
  { 4271, 28, 34, 31, 2, -34 },
  { 4390, 26, 34, 26, 1, -34 },
  { 4501, 28, 42, 31, 2, -34 },
  { 4648, 25, 34, 27, 1, -34 },
  { 4755, 24, 34, 23, 0, -34 },
  { 4857, 23, 34, 23, 4, -34 },
  { 4955, 28, 34, 30, 3, -34 },
  { 5074, 26, 34, 26, 4, -34 },
  { 5185, 40, 34, 40, 4, -34 },
  { 5355, 33, 34, 27, -3, -34 },
  { 5496, 25, 34, 25, 4, -34 },
  { 5603, 28, 34, 23, -2, -34 },
  { 5722, 19, 42, 15, -1, -34 },
  { 5822, 11, 34, 20, 5, -34 },
  { 5869, 20, 42, 15, -3, -34 },
  { 5974, 23, 22, 24, 0, -34 },
  { 6038, 19, 4, 19, -4, 4 },
  { 6048, 10, 8, 15, 7, -36 },
  { 6058, 24, 26, 26, 2, -26 },
  { 6136, 24, 36, 26, 0, -36 },
  { 6244, 20, 26, 21, 2, -26 },
  { 6309, 26, 36, 26, 2, -36 },
  { 6426, 22, 26, 24, 2, -26 },
  { 6498, 27, 47, 17, -5, -36 },
  { 6657, 26, 37, 26, 0, -26 },
  { 6778, 25, 36, 26, 0, -36 },
  { 6891, 15, 36, 13, 0, -36 },
  { 6959, 21, 47, 13, -6, -36 },
  { 7083, 28, 36, 25, 0, -36 },
  { 7209, 15, 36, 13, 0, -36 },
  { 7277, 37, 26, 39, 0, -26 },
  { 7398, 25, 26, 26, 0, -26 },
  { 7480, 22, 26, 26, 2, -26 },
  { 7552, 26, 37, 26, -2, -26 },
  { 7673, 24, 37, 26, 2, -26 },
  { 7784, 21, 26, 19, 0, -26 },
  { 7853, 21, 26, 21, 0, -26 },
  { 7922, 17, 31, 18, 2, -31 },
  { 7988, 24, 26, 26, 2, -26 },
  { 8066, 24, 26, 23, 2, -26 },
  { 8144, 35, 26, 35, 3, -26 },
  { 8258, 28, 26, 24, -2, -26 },
  { 8349, 29, 37, 23, -3, -26 },
  { 8484, 22, 26, 20, -1, -26 },
  { 8556, 20, 41, 17, 0, -34 },
  { 8659, 5, 47, 23, 9, -36 },
  { 8689, 19, 41, 17, -3, -34 },
  { 8787, 22, 9, 26, 2, -21 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBoldItalic47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBoldItalic47pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBoldItalic47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC47PT7B_H_
