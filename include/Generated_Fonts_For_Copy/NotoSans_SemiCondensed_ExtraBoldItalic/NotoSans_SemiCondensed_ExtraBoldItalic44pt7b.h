#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC44PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC44PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBoldItalic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBoldItalic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x01, 0xFC, 0x07, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x07, 0xE0, 0x04, 0x00, 0x3F, 0x3F, 0xBF,
  0x9F, 0xDF, 0x8F, 0xCF, 0xC7, 0xE7, 0xE3, 0xF3, 0xF1, 0xF1, 0xF0, 0xF8,
  0xF8, 0xFC, 0xFC, 0x7E, 0x7C, 0x3E, 0x3E, 0x1F, 0x00, 0x00, 0x1F, 0x0F,
  0x80, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03,
  0xE1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF0,
  0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00,
  0x0F, 0x8F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x01, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x21,
  0xF1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF1, 0xF0,
  0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x3E,
  0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xEE, 0xF0, 0x7F, 0x30, 0x41, 0xFD, 0xC0,
  0x07, 0xF7, 0x00, 0x1F, 0xDC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xDF, 0xC0, 0x07, 0x7F, 0x20, 0x19, 0xFC,
  0xE0, 0xE7, 0xF3, 0xF3, 0xBF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x83, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0xFF, 0xC0, 0x0F, 0x80, 0x7F, 0xF8,
  0x07, 0xC0, 0x1F, 0xFE, 0x03, 0xF0, 0x0F, 0xCF, 0x80, 0xF8, 0x03, 0xE3,
  0xE0, 0x7C, 0x01, 0xF8, 0xF8, 0x3F, 0x00, 0x7C, 0x3E, 0x0F, 0x80, 0x1F,
  0x0F, 0x87, 0xC0, 0x07, 0xC7, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0xF8, 0x00,
  0xFC, 0x7C, 0x7C, 0x00, 0x3F, 0x1F, 0x3F, 0x3F, 0x8F, 0xCF, 0xCF, 0x9F,
  0xF1, 0xFF, 0xE7, 0xCF, 0xFE, 0x7F, 0xF3, 0xE7, 0xFF, 0x9F, 0xFD, 0xF9,
  0xFB, 0xE3, 0xFE, 0x7C, 0xFC, 0xFC, 0x3E, 0x3E, 0x3E, 0x3F, 0x00, 0x1F,
  0x9F, 0x8F, 0xC0, 0x07, 0xC7, 0xE3, 0xE0, 0x03, 0xE1, 0xF0, 0xF8, 0x01,
  0xF8, 0x7C, 0x3E, 0x00, 0x7C, 0x1F, 0x1F, 0x80, 0x3E, 0x07, 0xC7, 0xE0,
  0x1F, 0x81, 0xF1, 0xF0, 0x07, 0xC0, 0x7E, 0xFC, 0x03, 0xE0, 0x1F, 0xFE,
  0x01, 0xF8, 0x07, 0xFF, 0x00, 0x7C, 0x00, 0xFF, 0xC0, 0x3E, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x03, 0xF0,
  0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x7F, 0x1F, 0xC0,
  0x07, 0xF3, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x7F, 0x0F, 0xFF, 0x0F,
  0xE1, 0xFF, 0xF0, 0xFE, 0x3F, 0xFF, 0x9F, 0xC7, 0xFB, 0xF9, 0xFC, 0xFF,
  0x3F, 0xFF, 0x8F, 0xE1, 0xFF, 0xF8, 0xFE, 0x0F, 0xFF, 0x0F, 0xE0, 0xFF,
  0xE0, 0xFE, 0x07, 0xFE, 0x0F, 0xE0, 0x7F, 0xC0, 0xFF, 0x9F, 0xFC, 0x0F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x00, 0xFF, 0x87, 0xF8, 0x3F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C,
  0x7C, 0xFC, 0xF8, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07,
  0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x03,
  0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x60, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x20, 0x7C, 0x03, 0x87, 0xC0,
  0x3E, 0x78, 0x07, 0xFF, 0x83, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0xFB,
  0xE0, 0x7F, 0x3F, 0x01, 0xF1, 0xF0, 0x0E, 0x1F, 0x80, 0x41, 0xE0, 0x00,
  0x18, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0xE3, 0xF8, 0x7E, 0x1F,
  0xC3, 0xF8, 0x7E, 0x1F, 0xC3, 0xF0, 0x7C, 0x1F, 0x83, 0xE0, 0x00, 0x7F,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xEF, 0xFE, 0x3E, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7E, 0x10, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0x3F, 0x83,
  0xF8, 0x7F, 0x1F, 0xC1, 0xFC, 0x7F, 0x07, 0xF3, 0xFC, 0x1F, 0xCF, 0xE0,
  0x7F, 0x3F, 0x81, 0xFD, 0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0x9F, 0xC0, 0xFE,
  0x7F, 0x03, 0xF9, 0xFC, 0x0F, 0xEF, 0xF0, 0x3F, 0xBF, 0x81, 0xFE, 0xFE,
  0x07, 0xF3, 0xF8, 0x1F, 0xCF, 0xE0, 0xFF, 0x3F, 0x83, 0xF8, 0xFE, 0x1F,
  0xE3, 0xF8, 0x7F, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x3F,
  0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xF0, 0xFF, 0xF8, 0xFF, 0xFD, 0xFF,
  0xFE, 0xFF, 0x7E, 0x3F, 0x7F, 0x1F, 0x3F, 0x86, 0x1F, 0xC2, 0x0F, 0xE0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFE, 0x7F, 0x80, 0xE0,
  0x7F, 0x01, 0x80, 0xFE, 0x02, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x00, 0x3F,
  0x80, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x80, 0xF0, 0x7F, 0x80, 0x80, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80,
  0x3F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x80, 0x07, 0xF1, 0x80, 0x1F,
  0xE3, 0xF3, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x03,
  0xEF, 0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0x7F, 0x00, 0xFC, 0xFE, 0x01, 0xF1,
  0xFC, 0x07, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0xC1, 0xF8, 0x3F,
  0x83, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xBF,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x40, 0x07, 0xF8, 0xE0, 0x1F, 0xF1,
  0xFD, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF,
  0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xC3, 0x80, 0x7F, 0x7F, 0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFE, 0x3F, 0x8F, 0xF0, 0xFE, 0x3F, 0x83,
  0xFC, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xC0, 0xFE, 0x3F, 0x03, 0xF8,
  0xFE, 0x1F, 0xE3, 0xF8, 0x7F, 0x0F, 0xF7, 0xFC, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xEF, 0xF0,
  0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xC1, 0xFC, 0x3F, 0x07, 0xF0, 0xFE,
  0x1F, 0x83, 0xF8, 0xFE, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xFC,
  0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFE, 0x1F,
  0xE3, 0xF8, 0x7F, 0x0F, 0xE3, 0xF8, 0x1F, 0xCF, 0xE0, 0x7F, 0x3F, 0x81,
  0xFC, 0xFE, 0x07, 0xF3, 0xF8, 0x3F, 0x8F, 0xF0, 0xFE, 0x3F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFC, 0x7F, 0x8F, 0xE3, 0xF8, 0x7F, 0x3F, 0x83, 0xF9, 0xFC,
  0x0F, 0xCF, 0xE0, 0xFE, 0x7F, 0x07, 0xF7, 0xF8, 0x3F, 0xBF, 0xC1, 0xFC,
  0xFE, 0x1F, 0xE7, 0xFB, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC7, 0xFE,
  0xFC, 0x3F, 0xEF, 0xE0, 0x7E, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x38, 0x7F, 0xC1, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x00,
  0x80, 0x3E, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7E,
  0x01, 0x00, 0x00, 0x20, 0x03, 0xE0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0x80, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x07,
  0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07, 0xFF,
  0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0x80,
  0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFC,
  0x00, 0x0F, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x0F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xF7, 0xFF, 0xF9, 0xFF, 0xFC, 0xF0,
  0xFE, 0x40, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x1F, 0x0F, 0x81,
  0xFF, 0x8F, 0x8F, 0xC1, 0xFF, 0xE3, 0xE7, 0xC3, 0xFF, 0xF1, 0xF7, 0xE1,
  0xFF, 0xF0, 0xFB, 0xE1, 0xF8, 0xF8, 0x7D, 0xF1, 0xF8, 0x7C, 0x3F, 0xF0,
  0xF8, 0x3E, 0x1F, 0xF8, 0xFC, 0x3E, 0x0F, 0x7C, 0x7C, 0x1F, 0x0F, 0xBE,
  0x3E, 0x0F, 0x87, 0xDF, 0x1F, 0x0F, 0xC3, 0xEF, 0x0F, 0x87, 0xC3, 0xE7,
  0x87, 0xC3, 0xE1, 0xF3, 0xC3, 0xE3, 0xF1, 0xF1, 0xE1, 0xFF, 0xFF, 0xF0,
  0xF8, 0xFF, 0xFF, 0xF8, 0x7C, 0x3F, 0xCF, 0xF8, 0x3E, 0x0F, 0xC7, 0xF0,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x38, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0xFD,
  0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xE7, 0xE0, 0x03,
  0xF9, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x7F, 0x1F, 0x80, 0x1F, 0x87, 0xE0,
  0x0F, 0xE1, 0xF8, 0x03, 0xF8, 0x7E, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x07,
  0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x1F, 0xE0, 0x1F, 0xC7,
  0xF0, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F,
  0xDF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xF1,
  0xFF, 0x07, 0xF0, 0x7F, 0x0F, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0,
  0x7F, 0x0F, 0xE0, 0xFE, 0x0F, 0xE1, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0x8F,
  0xF8, 0x3F, 0x83, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81,
  0xFC, 0x7F, 0x03, 0xFC, 0x7F, 0x03, 0xFC, 0x7F, 0x07, 0xF8, 0x7F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x80, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F,
  0xF0, 0xF8, 0x1F, 0xE0, 0x08, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x30, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0x0F, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0,
  0x3F, 0x83, 0xF8, 0x0F, 0xF0, 0xFE, 0x03, 0xFC, 0x3F, 0x80, 0xFF, 0x1F,
  0xE0, 0x3F, 0xC7, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFE,
  0x1F, 0xC0, 0x3F, 0x8F, 0xF0, 0x1F, 0xE3, 0xF8, 0x07, 0xF0, 0xFE, 0x03,
  0xFC, 0x3F, 0x80, 0xFF, 0x0F, 0xE0, 0x7F, 0x87, 0xF0, 0x1F, 0xE1, 0xFC,
  0x0F, 0xF0, 0x7F, 0x0F, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF,
  0xFF, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xE0, 0xF0,
  0x3F, 0xE0, 0x0C, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0,
  0x7F, 0xF1, 0xFC, 0x1F, 0xFC, 0xFF, 0x0F, 0xFF, 0x3F, 0xC3, 0xFF, 0xCF,
  0xF0, 0xFF, 0xF3, 0xF8, 0x3F, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x3F,
  0x8F, 0xF0, 0x0F, 0xE3, 0xFC, 0x07, 0xF0, 0xFF, 0x01, 0xFC, 0x1F, 0xE0,
  0x7F, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x03, 0xF8, 0x07,
  0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFE, 0x07,
  0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0xFF, 0x01,
  0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0,
  0xFE, 0x01, 0xFC, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0,
  0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xF8,
  0x0F, 0xF0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE,
  0x07, 0xF0, 0x0F, 0xE0, 0xFF, 0x01, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE,
  0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x03, 0xFC, 0x00, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFC, 0x00,
  0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0xFE, 0x07,
  0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x0E, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x18, 0x00,
  0x00, 0x03, 0xF8, 0x0F, 0xF8, 0x1F, 0xC0, 0xFF, 0x00, 0xFE, 0x0F, 0xF0,
  0x0F, 0xE0, 0xFF, 0x00, 0x7F, 0x07, 0xF8, 0x03, 0xF8, 0x7F, 0x80, 0x1F,
  0xC7, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xE3, 0xFC, 0x00, 0x7F, 0x3F,
  0xC0, 0x03, 0xFB, 0xFC, 0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFD, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0x3F,
  0xC0, 0x03, 0xF9, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x3F, 0xC0,
  0x0F, 0xE1, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x3F,
  0xC1, 0xFE, 0x01, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x01,
  0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFC,
  0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0x00,
  0x7F, 0xF0, 0x7F, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x7F,
  0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFE,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x07,
  0xEF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x0F, 0xDF, 0x81, 0xFD,
  0xF0, 0xFD, 0xF8, 0x1F, 0x9F, 0x0F, 0xBF, 0x81, 0xF9, 0xF1, 0xFB, 0xF8,
  0x1F, 0x9F, 0x1F, 0x3F, 0x83, 0xF9, 0xF3, 0xF3, 0xF0, 0x3F, 0x9F, 0x3E,
  0x3F, 0x03, 0xF1, 0xF7, 0xE7, 0xF0, 0x3F, 0x1F, 0x7C, 0x7F, 0x03, 0xF1,
  0xFF, 0xC7, 0xF0, 0x7F, 0x1F, 0xF8, 0x7E, 0x07, 0xF1, 0xFF, 0x87, 0xE0,
  0x7E, 0x1F, 0xF0, 0xFE, 0x07, 0xE1, 0xFF, 0x0F, 0xE0, 0xFE, 0x1F, 0xF0,
  0xFC, 0x0F, 0xE1, 0xFE, 0x0F, 0xC0, 0xFC, 0x1F, 0xE1, 0xFC, 0x0F, 0xC1,
  0xFC, 0x1F, 0xC0, 0xFC, 0x1F, 0xC1, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0xFE,
  0x07, 0xFC, 0x01, 0xF8, 0x0F, 0xF8, 0x03, 0xF0, 0x3F, 0xF0, 0x0F, 0xE0,
  0x7F, 0xF0, 0x1F, 0xC0, 0xFF, 0xE0, 0x3F, 0x01, 0xFF, 0xC0, 0x7E, 0x07,
  0xFF, 0x80, 0xFC, 0x0F, 0xFF, 0x83, 0xF8, 0x1F, 0xFF, 0x07, 0xF0, 0x3F,
  0x7E, 0x0F, 0xC0, 0x7E, 0xFC, 0x1F, 0x81, 0xFD, 0xFC, 0x7F, 0x03, 0xFB,
  0xF8, 0xFE, 0x07, 0xE3, 0xF1, 0xFC, 0x0F, 0xC7, 0xE3, 0xF0, 0x1F, 0x8F,
  0xE7, 0xE0, 0x7F, 0x1F, 0xDF, 0xC0, 0xFE, 0x1F, 0xBF, 0x81, 0xF8, 0x3F,
  0xFE, 0x03, 0xF0, 0x7F, 0xFC, 0x07, 0xE0, 0xFF, 0xF8, 0x1F, 0xC0, 0xFF,
  0xF0, 0x3F, 0x81, 0xFF, 0xE0, 0x7E, 0x03, 0xFF, 0x80, 0xFC, 0x03, 0xFF,
  0x03, 0xF8, 0x07, 0xFE, 0x07, 0xF0, 0x0F, 0xFC, 0x0F, 0xE0, 0x1F, 0xF8,
  0x1F, 0x80, 0x1F, 0xE0, 0x3F, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0x1F, 0xF0, 0x7F, 0x81, 0xFE,
  0x1F, 0xE0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0xFF, 0x00, 0x7F, 0x1F, 0xC0,
  0x0F, 0xF7, 0xF8, 0x01, 0xFC, 0xFF, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xF3,
  0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x1F, 0xDF, 0xE0, 0x07, 0xFB, 0xFC, 0x00,
  0xFF, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x07, 0xF9, 0xFC, 0x00, 0xFF, 0x3F,
  0xC0, 0x1F, 0xC7, 0xF8, 0x07, 0xF8, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x7F,
  0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F,
  0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF,
  0x1F, 0xC1, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0x1F, 0xF0, 0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0x1F,
  0xC3, 0xFC, 0x03, 0xF8, 0xFF, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xF7, 0xF8,
  0x01, 0xFC, 0xFF, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xF3, 0xF8, 0x00, 0xFE,
  0xFF, 0x00, 0x1F, 0xDF, 0xE0, 0x07, 0xFB, 0xFC, 0x00, 0xFF, 0x7F, 0x00,
  0x1F, 0xCF, 0xE0, 0x07, 0xF9, 0xFC, 0x00, 0xFF, 0x3F, 0xC0, 0x3F, 0xC7,
  0xF8, 0x07, 0xF8, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x7F, 0xC1, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x03,
  0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xF1, 0xFF,
  0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0xFF, 0x0F, 0xE0, 0xFF,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xCF, 0xFC,
  0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC0, 0x3F, 0x9F, 0xC0, 0x3F, 0x9F, 0xC0, 0x3F, 0x8F, 0xE0,
  0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xF0, 0x7F, 0x0F, 0xF0, 0x7F, 0x07, 0xF0,
  0xFF, 0x07, 0xF8, 0xFE, 0x07, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xFC,
  0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFE, 0x3E, 0x07,
  0xF8, 0x0C, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x40, 0x0F, 0xE0, 0xE0, 0x3F, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x3F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFB, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x1F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0xC0, 0x7F, 0x07,
  0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x83, 0xF8, 0x0F,
  0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x7F,
  0x01, 0xFC, 0x1F, 0xE0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFE,
  0x0F, 0xE0, 0x3F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0x80, 0xFE, 0x0F, 0xE0,
  0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0xFF, 0x07, 0xF0, 0x1F, 0xC1,
  0xFE, 0x03, 0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0xFF, 0x07,
  0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x01,
  0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF8, 0xFE, 0x07,
  0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7E, 0x1F,
  0xC0, 0x7E, 0x1F, 0xC0, 0x7E, 0x3F, 0x80, 0x7E, 0x3F, 0x80, 0x7E, 0x3F,
  0x00, 0x7E, 0x7F, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xFF,
  0xE0, 0x0F, 0xC0, 0x3F, 0xBF, 0x00, 0xFE, 0x01, 0xFD, 0xF8, 0x07, 0xF0,
  0x1F, 0xCF, 0xC0, 0x7F, 0x80, 0xFE, 0x7E, 0x03, 0xFC, 0x07, 0xF3, 0xF0,
  0x3F, 0xE0, 0x7F, 0x1F, 0x81, 0xFF, 0x03, 0xF8, 0xFC, 0x0F, 0xF8, 0x3F,
  0x87, 0xE0, 0xFF, 0xC1, 0xFC, 0x3F, 0x07, 0xFE, 0x0F, 0xC1, 0xF8, 0x7F,
  0xF0, 0xFE, 0x0F, 0xC3, 0xEF, 0x87, 0xF0, 0x7E, 0x3F, 0x7C, 0x7F, 0x03,
  0xF1, 0xFB, 0xE3, 0xF8, 0x1F, 0x8F, 0x9F, 0x1F, 0x80, 0xFC, 0xFC, 0xF9,
  0xFC, 0x07, 0xE7, 0xE7, 0xCF, 0xE0, 0x3F, 0x7E, 0x3E, 0x7E, 0x01, 0xFB,
  0xF1, 0xF7, 0xF0, 0x0F, 0xDF, 0x0F, 0xBF, 0x00, 0x7F, 0xF8, 0x7F, 0xF8,
  0x03, 0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0xFF, 0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x01,
  0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x7F,
  0x80, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x00,
  0x7F, 0x0F, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0x9F, 0xE0, 0x00,
  0x3F, 0x9F, 0xC0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x03,
  0xFC, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x0F,
  0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x3F,
  0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0xFF, 0x80, 0x3F, 0xC0, 0xFE,
  0x01, 0xFF, 0xFC, 0x03, 0xFB, 0xFC, 0x0F, 0xF3, 0xF8, 0x3F, 0xC7, 0xF0,
  0x7F, 0x0F, 0xE1, 0xFE, 0x1F, 0xC3, 0xF8, 0x1F, 0x8F, 0xE0, 0x3F, 0x1F,
  0xC0, 0x7F, 0x7F, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7E, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x00, 0xF8, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x07, 0xC1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x0F, 0x83, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x1F, 0x07, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xC0,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F,
  0xF8, 0x01, 0xFB, 0xE0, 0x07, 0xCF, 0x80, 0x3F, 0x3E, 0x01, 0xF8, 0xFC,
  0x07, 0xC1, 0xF0, 0x3F, 0x07, 0xC1, 0xF8, 0x1F, 0x87, 0xC0, 0x7E, 0x3F,
  0x00, 0xF9, 0xF8, 0x03, 0xE7, 0xE0, 0x0F, 0xFF, 0x00, 0x1F, 0x7F, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xC7, 0xF0, 0xFE,
  0x1F, 0x83, 0xE0, 0xFC, 0x00, 0x20, 0x00, 0x03, 0xF8, 0xFC, 0x0F, 0xF9,
  0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xF9, 0xFF,
  0x1F, 0xE1, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0x07, 0xF1, 0xFE, 0x0F, 0xE3,
  0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0x7E, 0x1F, 0xC0, 0xFC, 0x7F,
  0x83, 0xF8, 0xFF, 0x07, 0xF1, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0x83, 0xFD,
  0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFD, 0xF8, 0x1F, 0xF7,
  0xE0, 0x1F, 0xCF, 0xC0, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0xC0, 0x0F, 0xEF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xFE, 0x7F, 0x87,
  0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0x81, 0xFC, 0x7F, 0x03, 0xF8, 0xFE,
  0x07, 0xF1, 0xF8, 0x0F, 0xE3, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F, 0x1F, 0xC0,
  0xFE, 0x3F, 0x83, 0xFC, 0x7F, 0x07, 0xF0, 0xFE, 0x1F, 0xE3, 0xFE, 0x7F,
  0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3E, 0x7F, 0xC0,
  0xFC, 0x7F, 0x00, 0x00, 0x1C, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0xF0, 0x7F,
  0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xF1, 0xC3, 0xFC, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x01, 0x07, 0xFD, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0x01, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x20, 0xFE, 0x00, 0xFE,
  0x7F, 0x00, 0xFF, 0xBF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0x7F, 0x9F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xC3, 0xF8, 0x1F,
  0xC1, 0xFC, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x83,
  0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xC1, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xF0,
  0x7F, 0x87, 0xF8, 0x3F, 0xC3, 0xF8, 0x0F, 0xF3, 0xFC, 0x07, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xDF, 0x80, 0x7F, 0xCF, 0x80, 0x1F, 0xC7,
  0xC0, 0x00, 0x00, 0x04, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x87, 0xFB, 0xFC, 0x7F, 0x07, 0xE7, 0xF8, 0x3F, 0x3F,
  0x83, 0xF9, 0xFC, 0x1F, 0xDF, 0xC7, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE,
  0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x10, 0xFF, 0x03, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE1, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x02, 0x3F, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFE, 0x3F, 0x01,
  0xFF, 0x3F, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F,
  0xF3, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F,
  0xC1, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xF8, 0x3F,
  0x81, 0xF8, 0x3F, 0x83, 0xF8, 0x7F, 0x83, 0xF8, 0x7F, 0x87, 0xF8, 0x7F,
  0x87, 0xF0, 0x3F, 0xDF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x1F, 0xF7, 0xE0, 0x0F, 0xEF, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x80, 0x1F, 0xC0, 0xE0, 0x3F, 0xC0, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x40, 0x0F, 0xEF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFE, 0x7F,
  0x87, 0xF8, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x7F, 0x03, 0xF8,
  0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x8F, 0xE0, 0x7F, 0x1F,
  0xC0, 0xFE, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE3, 0xF8,
  0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x83,
  0xF8, 0xFE, 0x07, 0xF0, 0x00, 0x70, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03,
  0xFC, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x7F, 0x80, 0x8F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x18, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x7F, 0x07, 0xF8, 0x1F, 0xC3, 0xFC,
  0x07, 0xE1, 0xFE, 0x03, 0xF8, 0xFF, 0x00, 0xFE, 0x7F, 0x80, 0x3F, 0x9F,
  0xC0, 0x0F, 0xCF, 0xE0, 0x03, 0xF7, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xDF, 0xC0, 0x0F, 0xE7, 0xF8, 0x03, 0xF0, 0xFE,
  0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0,
  0x7F, 0x01, 0xF8, 0x1F, 0xE0, 0xFE, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x00, 0x40, 0x04, 0x00,
  0xFC, 0xFF, 0x07, 0xF0, 0x1F, 0xBF, 0xF3, 0xFF, 0x03, 0xFF, 0xFE, 0xFF,
  0xE0, 0x7D, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFE, 0x7F,
  0xE7, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x0F, 0xE0, 0xFE, 0x0F, 0xE1, 0xFC,
  0x1F, 0xC1, 0xFC, 0x7F, 0x03, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x07, 0xE1,
  0xFC, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0x8F, 0xE0, 0x7F, 0x07,
  0xF1, 0xFC, 0x1F, 0xC0, 0xFE, 0x3F, 0x83, 0xF8, 0x3F, 0x87, 0xF0, 0x7F,
  0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x3F, 0x81, 0xFC, 0x1F, 0xC7, 0xF0,
  0x7F, 0x03, 0xF8, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x1F, 0xC3,
  0xF0, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x00, 0x40,
  0x0F, 0xCF, 0xF0, 0x1F, 0xBF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7D, 0xFF, 0xE1,
  0xFF, 0xFF, 0xC3, 0xFE, 0x7F, 0x87, 0xF8, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F,
  0xC1, 0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8,
  0x3F, 0x8F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x83, 0xF8, 0x7F, 0x07,
  0xF0, 0xFE, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0xFE,
  0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0xFE, 0x07, 0xF0, 0x00, 0x0E, 0x00,
  0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE1, 0xFE, 0x3F, 0x8F, 0xF0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x07,
  0xF7, 0xF0, 0x3F, 0xDF, 0xC0, 0xFE, 0x7F, 0x03, 0xF9, 0xFC, 0x0F, 0xE7,
  0xF0, 0x3F, 0xBF, 0xC0, 0xFE, 0xFE, 0x07, 0xF1, 0xFC, 0x1F, 0xC7, 0xF0,
  0xFF, 0x1F, 0xE7, 0xF8, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x20, 0x00, 0xFC, 0xFE,
  0x00, 0x7E, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFC, 0x0F, 0xF1, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xF8,
  0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7E, 0x03, 0xF8, 0x3F,
  0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFF, 0x07,
  0xF0, 0x7F, 0x03, 0xF8, 0x7F, 0x83, 0xFE, 0x7F, 0x81, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC0, 0x7E, 0xFF, 0xC0, 0x3F, 0x7F, 0xC0, 0x3F, 0x9F, 0xC0,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x03, 0xFC, 0xFC, 0x0F, 0xF9, 0xF8, 0x3F, 0xFB, 0xF0, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xF9, 0xFF, 0x0F, 0xE1, 0xFE, 0x3F, 0x83,
  0xFC, 0x7F, 0x07, 0xF1, 0xFE, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F,
  0x8F, 0xE0, 0x7E, 0x1F, 0xC0, 0xFC, 0x3F, 0x83, 0xF8, 0xFE, 0x07, 0xF1,
  0xFE, 0x0F, 0xE3, 0xFC, 0x3F, 0x83, 0xFC, 0xFF, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xF7, 0xE0, 0x1F, 0xDF, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x60, 0xFC, 0x7C,
  0x1F, 0xBF, 0x83, 0xF7, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0,
  0x7F, 0xE2, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x18, 0x00, 0x3F, 0xF0,
  0x1F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xF0, 0x60,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x80,
  0x07, 0xF2, 0x00, 0xFE, 0x78, 0x3F, 0xCF, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F,
  0xFF, 0x87, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFE, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x30, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F,
  0xF0, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0xC1, 0xFC, 0x7F, 0x07, 0xF1, 0xFC,
  0x1F, 0xCF, 0xE0, 0x7F, 0x3F, 0x81, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F,
  0x8F, 0xC0, 0xFE, 0x7F, 0x03, 0xF9, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F,
  0xC1, 0xFC, 0xFE, 0x07, 0xF3, 0xF8, 0x1F, 0xCF, 0xE0, 0xFE, 0x3F, 0x83,
  0xF8, 0xFE, 0x1F, 0xE3, 0xF8, 0x7F, 0x8F, 0xF7, 0xFC, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC3, 0xFF, 0xBF, 0x07, 0xFC, 0xFC, 0x0F, 0xE3, 0xE0, 0xFE,
  0x03, 0xFF, 0xF8, 0x0F, 0xE7, 0xE0, 0x7F, 0x9F, 0x81, 0xFC, 0x7E, 0x07,
  0xF1, 0xF8, 0x3F, 0x87, 0xE0, 0xFE, 0x1F, 0x87, 0xF0, 0x7E, 0x1F, 0xC1,
  0xF8, 0xFE, 0x07, 0xE3, 0xF8, 0x1F, 0x9F, 0xC0, 0x7F, 0x7F, 0x00, 0xFD,
  0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xBF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x7F, 0xFC, 0x1F, 0xE0,
  0x7E, 0xFC, 0x1F, 0xE0, 0xFE, 0xFC, 0x3F, 0xE0, 0xFC, 0xFC, 0x3F, 0xE1,
  0xFC, 0xFC, 0x3F, 0xE1, 0xFC, 0xFC, 0x7F, 0xE3, 0xF8, 0xFC, 0x7F, 0xE3,
  0xF8, 0xFC, 0x7F, 0xE3, 0xF0, 0xFC, 0xFB, 0xE7, 0xF0, 0xFC, 0xFB, 0xE7,
  0xE0, 0xFD, 0xF3, 0xEF, 0xE0, 0xFD, 0xF3, 0xEF, 0xC0, 0xFD, 0xF3, 0xEF,
  0xC0, 0xFF, 0xE3, 0xFF, 0xC0, 0xFF, 0xE3, 0xFF, 0x80, 0xFF, 0xE3, 0xFF,
  0x80, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x7F, 0x0F, 0xF0,
  0x0F, 0xE1, 0xFE, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xCF, 0xE0, 0x03, 0xFB,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xE3, 0xF8,
  0x03, 0xFC, 0x7F, 0x00, 0x7F, 0x0F, 0xF0, 0x1F, 0xE0, 0xFE, 0x07, 0xF8,
  0x1F, 0xE0, 0x07, 0xF0, 0x1F, 0xE0, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x7F,
  0x01, 0xF8, 0x1F, 0xC0, 0x3F, 0x03, 0xF8, 0x07, 0xF0, 0xFE, 0x00, 0xFE,
  0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x3F, 0x80,
  0x0F, 0xE7, 0xF0, 0x00, 0xFD, 0xFC, 0x00, 0x1F, 0xBF, 0x80, 0x03, 0xF7,
  0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x08, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xF8,
  0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xC0, 0x00, 0x3F,
  0xC0, 0x1F, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFA, 0x00, 0x7F, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBoldItalic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 14, 32, 12, 0, -31 },
  { 57, 17, 11, 19, 4, -31 },
  { 81, 27, 31, 26, 0, -31 },
  { 186, 22, 36, 23, 1, -33 },
  { 285, 34, 32, 37, 2, -32 },
  { 421, 28, 32, 29, 1, -32 },
  { 533, 8, 11, 11, 4, -31 },
  { 544, 17, 39, 14, 1, -32 },
  { 627, 16, 39, 14, -3, -32 },
  { 705, 20, 21, 22, 3, -34 },
  { 758, 20, 21, 24, 2, -26 },
  { 811, 11, 11, 12, -2, -5 },
  { 827, 12, 6, 14, 1, -15 },
  { 836, 8, 8, 12, 0, -7 },
  { 844, 24, 32, 19, -2, -32 },
  { 940, 22, 32, 23, 1, -32 },
  { 1028, 17, 31, 23, 4, -31 },
  { 1094, 23, 32, 23, -1, -32 },
  { 1186, 23, 32, 23, 0, -32 },
  { 1278, 23, 31, 23, 0, -31 },
  { 1368, 23, 31, 23, 0, -31 },
  { 1458, 22, 32, 23, 2, -32 },
  { 1546, 24, 31, 23, 1, -31 },
  { 1639, 22, 32, 23, 1, -32 },
  { 1727, 21, 32, 23, 1, -32 },
  { 1811, 12, 26, 12, 0, -25 },
  { 1850, 14, 31, 12, -2, -25 },
  { 1905, 20, 23, 24, 2, -27 },
  { 1963, 20, 15, 24, 2, -23 },
  { 2001, 21, 23, 24, 2, -27 },
  { 2062, 17, 33, 19, 3, -32 },
  { 2133, 33, 36, 35, 2, -32 },
  { 2282, 26, 31, 26, -3, -31 },
  { 2383, 24, 31, 25, 1, -31 },
  { 2476, 25, 32, 25, 2, -32 },
  { 2576, 26, 31, 27, 1, -31 },
  { 2677, 23, 31, 22, 1, -31 },
  { 2767, 23, 31, 22, 1, -31 },
  { 2857, 26, 32, 28, 2, -32 },
  { 2961, 28, 31, 29, 1, -31 },
  { 3070, 21, 31, 17, -2, -31 },
  { 3152, 22, 41, 14, -7, -31 },
  { 3265, 29, 31, 26, 1, -31 },
  { 3378, 17, 31, 21, 1, -31 },
  { 3444, 36, 31, 36, 1, -31 },
  { 3584, 31, 31, 31, 1, -31 },
  { 3705, 27, 32, 29, 2, -32 },
  { 3813, 24, 31, 25, 1, -31 },
  { 3906, 27, 39, 29, 2, -32 },
  { 4038, 24, 31, 25, 1, -31 },
  { 4131, 23, 32, 22, 0, -32 },
  { 4223, 22, 31, 22, 3, -31 },
  { 4309, 27, 31, 28, 2, -31 },
  { 4414, 24, 31, 25, 4, -31 },
  { 4507, 37, 31, 37, 4, -31 },
  { 4651, 32, 31, 25, -3, -31 },
  { 4775, 23, 31, 24, 4, -31 },
  { 4865, 26, 31, 22, -2, -31 },
  { 4966, 18, 39, 14, -1, -32 },
  { 5054, 10, 32, 19, 5, -32 },
  { 5094, 19, 39, 14, -3, -32 },
  { 5187, 22, 20, 22, 0, -31 },
  { 5242, 18, 4, 17, -4, 3 },
  { 5251, 10, 7, 14, 6, -34 },
  { 5260, 23, 25, 24, 1, -25 },
  { 5332, 23, 33, 24, 0, -33 },
  { 5427, 20, 25, 20, 1, -25 },
  { 5490, 25, 33, 24, 1, -33 },
  { 5594, 21, 25, 23, 1, -25 },
  { 5660, 25, 45, 16, -5, -34 },
  { 5801, 24, 36, 24, 0, -25 },
  { 5909, 23, 33, 25, 0, -33 },
  { 6004, 14, 34, 13, 0, -34 },
  { 6064, 20, 45, 13, -6, -34 },
  { 6177, 26, 33, 24, 0, -33 },
  { 6285, 14, 33, 13, 0, -33 },
  { 6343, 35, 25, 37, 0, -25 },
  { 6453, 23, 25, 25, 0, -25 },
  { 6525, 22, 25, 24, 1, -25 },
  { 6594, 25, 36, 24, -2, -25 },
  { 6707, 23, 36, 24, 1, -25 },
  { 6811, 19, 25, 17, 0, -25 },
  { 6871, 19, 25, 20, 0, -25 },
  { 6931, 16, 29, 17, 2, -29 },
  { 6989, 22, 24, 25, 2, -24 },
  { 7055, 22, 24, 22, 2, -24 },
  { 7121, 32, 24, 33, 3, -24 },
  { 7217, 27, 24, 22, -2, -24 },
  { 7298, 27, 35, 22, -3, -24 },
  { 7417, 21, 24, 19, -1, -24 },
  { 7480, 19, 38, 15, 0, -31 },
  { 7571, 5, 43, 22, 8, -33 },
  { 7598, 17, 38, 15, -2, -31 },
  { 7679, 21, 7, 24, 2, -19 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBoldItalic44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBoldItalic44pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBoldItalic44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC44PT7B_H_
