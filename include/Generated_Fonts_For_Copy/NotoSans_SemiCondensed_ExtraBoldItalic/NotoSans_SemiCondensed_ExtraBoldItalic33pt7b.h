#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC33PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBoldItalic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBoldItalic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0xFC,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xC0, 0x7C, 0xFB,
  0xE7, 0xDF, 0x3C, 0xF3, 0xE7, 0x9F, 0x3C, 0xF3, 0xC7, 0x9E, 0x3C, 0xF1,
  0xE0, 0x00, 0x71, 0xE0, 0x0F, 0x1C, 0x00, 0xF3, 0xC0, 0x0E, 0x3C, 0x01,
  0xE3, 0xC0, 0x1E, 0x38, 0x01, 0xE7, 0x81, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3,
  0xFF, 0xFF, 0x03, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x9E, 0x00, 0x71, 0xE0,
  0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x1E, 0x38,
  0x01, 0xE7, 0x80, 0x1C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0xF0, 0x03, 0xCF,
  0x00, 0x00, 0x30, 0x00, 0x30, 0x00, 0xF8, 0x07, 0xFF, 0x0F, 0xFF, 0x1F,
  0xFF, 0x1F, 0xFE, 0x3E, 0xE2, 0x3E, 0xC0, 0x3E, 0xC0, 0x3F, 0xC0, 0x1F,
  0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x01, 0xBE, 0x03,
  0x3E, 0xC3, 0x3C, 0xFB, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0x1F,
  0x80, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x3C, 0x0F, 0xE0,
  0x3C, 0x0F, 0xF0, 0x1E, 0x0F, 0xFC, 0x1E, 0x07, 0x9E, 0x1E, 0x07, 0xCF,
  0x0F, 0x03, 0xC7, 0x8F, 0x01, 0xE3, 0xCF, 0x00, 0xF3, 0xE7, 0x80, 0x79,
  0xE7, 0x80, 0x3C, 0xF7, 0x9F, 0x9F, 0xF3, 0xDF, 0xEF, 0xFB, 0xDF, 0xF3,
  0xFB, 0xCF, 0x3C, 0xF1, 0xEF, 0x9E, 0x01, 0xE7, 0x8F, 0x01, 0xE3, 0xC7,
  0x80, 0xF1, 0xE7, 0x80, 0xF0, 0xF3, 0xC0, 0xF0, 0x79, 0xE0, 0x78, 0x3D,
  0xE0, 0x78, 0x1F, 0xF0, 0x78, 0x0F, 0xF0, 0x7C, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xCF, 0x80,
  0x1F, 0x1E, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xDF, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x3F, 0x1F, 0xF8, 0xF8, 0xFF, 0xE7,
  0xE3, 0xEF, 0xDF, 0x1F, 0x1F, 0xFC, 0x7C, 0x7F, 0xE3, 0xF0, 0xFF, 0x0F,
  0xC3, 0xFC, 0x3F, 0x8F, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x07, 0xF9, 0xFC, 0x7D, 0xF7, 0xDE, 0x79, 0xEF, 0xBC, 0xF0, 0x01,
  0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x3E,
  0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0x78, 0x07, 0x80, 0x7C, 0x00, 0x03, 0xC0, 0x3E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xC0,
  0x7C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x1F, 0x03, 0xE0, 0x3C, 0x07,
  0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x18, 0xF0, 0xFB, 0x83,
  0xFE, 0xFF, 0xFF, 0xC7, 0xFF, 0x0F, 0xFC, 0x7F, 0x07, 0xFC, 0x3F, 0x78,
  0x79, 0xE0, 0x47, 0xC0, 0x0C, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x1F, 0x1F, 0x3E, 0x3E, 0x3C, 0x7C, 0x78, 0xF8, 0x7F, 0xDF, 0xE7, 0xFB,
  0xFE, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0x00,
  0xF8, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0xFF, 0x1F, 0x1F, 0x3E,
  0x1F, 0x3E, 0x1F, 0x7E, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7E, 0xF8, 0x7E, 0xF8, 0x7C, 0xF8,
  0xFC, 0xFD, 0xF8, 0xFF, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0x1F, 0x80, 0x00,
  0xF8, 0x0F, 0xC0, 0xFE, 0x1F, 0xE1, 0xFF, 0x3F, 0xFB, 0xFF, 0xDF, 0xFC,
  0x73, 0xE1, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x0F,
  0xFF, 0xC1, 0xC3, 0xF0, 0x20, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0xFC, 0x7F,
  0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF8, 0x01, 0xF8, 0x03, 0xFF,
  0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xF8, 0x20, 0xFC, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x3F, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0x7F, 0x80,
  0x3F, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x20, 0x1F,
  0x98, 0x1F, 0xCF, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0x80, 0x00,
  0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x03, 0xDE, 0x03, 0xDF, 0x03, 0xEF, 0x81, 0xE7,
  0xC1, 0xE3, 0xE1, 0xE3, 0xE1, 0xF1, 0xF1, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F,
  0xFF, 0xBF, 0xFF, 0xC0, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0,
  0x03, 0xE0, 0x03, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F,
  0xF8, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0xFC, 0x07,
  0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE0, 0x43, 0xF0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x1F, 0x20, 0x1F, 0x9C, 0x1F, 0xCF, 0xFF, 0xC7, 0xFF,
  0xC3, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xE0, 0xFF, 0x30, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x20,
  0x3E, 0xFC, 0x1F, 0xFF, 0x0F, 0xFF, 0xC7, 0xFF, 0xE7, 0xF1, 0xF3, 0xF0,
  0xF9, 0xF8, 0x7C, 0xF8, 0x3E, 0x7C, 0x3F, 0x3E, 0x1F, 0x1F, 0x9F, 0x87,
  0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0x80, 0x1F, 0xFF, 0xC7, 0xFF,
  0xF1, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x80, 0x07, 0xC0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x07, 0xFE, 0x0F, 0xFF, 0x1F, 0xFF, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x3E, 0x1F, 0xFE, 0x0F, 0xFC,
  0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x7E, 0xFC, 0xFC, 0x7C, 0xF8, 0x7E,
  0xF8, 0x3E, 0xF8, 0x7E, 0xF8, 0x7C, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xF0,
  0x3F, 0xE0, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xFE, 0x3F, 0xFE,
  0x3E, 0x3F, 0x7E, 0x1F, 0x7C, 0x1F, 0x7C, 0x3F, 0x7C, 0x3F, 0x7C, 0x3F,
  0x7E, 0xFF, 0x7F, 0xFE, 0x3F, 0xFE, 0x3F, 0xBE, 0x1F, 0x7C, 0x00, 0x7C,
  0x00, 0xFC, 0x01, 0xF8, 0x83, 0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0x80,
  0xFF, 0x00, 0x0F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE3, 0xF1, 0xF8, 0xFC, 0x7C, 0x00, 0x03,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC0,
  0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x00, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x3F,
  0x00, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x00, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x1F,
  0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xC0, 0x01, 0xE0, 0x03, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0x7F, 0x00, 0x7E, 0x07, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F,
  0xF8, 0x1F, 0x80, 0x3C, 0x00, 0x60, 0x00, 0x80, 0x00, 0x07, 0xC1, 0xFF,
  0x9F, 0xFE, 0xFF, 0xF7, 0xDF, 0x90, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0,
  0x1F, 0x83, 0xF8, 0x3F, 0x81, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0x1F,
  0xC0, 0x7C, 0x01, 0xF0, 0x78, 0x00, 0x78, 0x78, 0x0C, 0x1E, 0x7C, 0x3F,
  0xCF, 0x3C, 0x7F, 0xE7, 0x9C, 0x7F, 0xF3, 0xDE, 0x3C, 0x71, 0xEF, 0x3C,
  0x78, 0xF7, 0x1E, 0x3C, 0x7F, 0x9E, 0x1E, 0x3F, 0xCF, 0x0E, 0x1D, 0xE7,
  0x8F, 0x1E, 0xF3, 0xC7, 0x9E, 0x79, 0xFF, 0xFF, 0x3C, 0x7F, 0xFF, 0x1E,
  0x3F, 0x3F, 0x07, 0x86, 0x04, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x01, 0x00,
  0x7F, 0x1F, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFB, 0xC0, 0x0F, 0xBE, 0x01, 0xF3, 0xE0,
  0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x7C, 0x3E,
  0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE3, 0xF0, 0x3E, 0x3E, 0x03, 0xE7, 0xE0, 0x3E, 0x7C, 0x03, 0xEF, 0xC0,
  0x3F, 0x07, 0xF8, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F,
  0xFE, 0x1F, 0x8F, 0xC3, 0xE1, 0xF8, 0x7C, 0x3F, 0x0F, 0x87, 0xC3, 0xF3,
  0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xC7,
  0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x7E, 0x3F, 0x3F,
  0xC7, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0x80, 0x00, 0xFE,
  0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x8F, 0xE0, 0x43,
  0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0xE0, 0x7F, 0xF8, 0x1F, 0xFE, 0x03,
  0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xC0,
  0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0xFC, 0x7E, 0x0F, 0x83, 0xF0, 0xF8, 0x3F,
  0x0F, 0x83, 0xF1, 0xF8, 0x3F, 0x1F, 0x83, 0xF1, 0xF0, 0x3F, 0x1F, 0x03,
  0xF1, 0xF0, 0x3E, 0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x3E, 0x07, 0xC3, 0xE0,
  0xFC, 0x3E, 0x1F, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F,
  0xF8, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F,
  0xFE, 0x07, 0xFF, 0x83, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xFF,
  0xF0, 0x7F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x07, 0xFF,
  0xC1, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x83, 0xF0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xFF, 0xE0, 0x7F,
  0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0xFC, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xFC, 0x1F, 0xFF, 0x87,
  0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0x01, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x03, 0xF1, 0xFF, 0x7E, 0x3F, 0xEF, 0x87, 0xF9, 0xF0,
  0xFF, 0x3E, 0x3F, 0xE7, 0xC0, 0xFC, 0xF8, 0x1F, 0x9F, 0x03, 0xE3, 0xF0,
  0x7C, 0x7F, 0x0F, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x7F,
  0xE0, 0x07, 0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0xC1, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x3F, 0x03, 0xE0, 0xF8, 0x1F, 0x83, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x83, 0xF0, 0x3E, 0x0F, 0xC1, 0xF8, 0x3E, 0x07, 0xE0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x81, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x3F, 0x03, 0xE0, 0x07, 0xFF, 0x07, 0xFE, 0x0F,
  0xFE, 0x0F, 0xFE, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x3F,
  0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x9F,
  0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0xFC,
  0x1F, 0x07, 0xE0, 0x7C, 0x1F, 0x81, 0xF0, 0xFC, 0x07, 0xC7, 0xE0, 0x3F,
  0x3F, 0x00, 0xF8, 0xF8, 0x03, 0xE7, 0xE0, 0x0F, 0xBF, 0x00, 0x7F, 0xF8,
  0x01, 0xF7, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xDF, 0x80, 0x3E, 0x7E, 0x00, 0xF8, 0xF8, 0x03, 0xE3,
  0xF0, 0x1F, 0x8F, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x7E, 0x07, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x1F, 0x80, 0x7F, 0xFD, 0xFF, 0xE7, 0xFF, 0xBF, 0xFE, 0x07, 0xF0, 0x07,
  0xF0, 0x7F, 0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x01, 0xFE, 0x07,
  0xF0, 0x1F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x87,
  0xFC, 0x0F, 0x78, 0x7F, 0xC1, 0xF7, 0x8F, 0xFC, 0x1F, 0x78, 0xF7, 0xC1,
  0xF7, 0x9F, 0x7C, 0x1F, 0x79, 0xEF, 0x81, 0xE7, 0x9E, 0xF8, 0x3E, 0x7B,
  0xCF, 0x83, 0xE7, 0xBC, 0xF8, 0x3E, 0x7F, 0x8F, 0x03, 0xE7, 0xF9, 0xF0,
  0x3C, 0x7F, 0x1F, 0x07, 0xC7, 0xF1, 0xF0, 0x7C, 0x7E, 0x1F, 0x07, 0xC7,
  0xE1, 0xE0, 0x7C, 0x7E, 0x3E, 0x0F, 0x87, 0xC3, 0xE0, 0x07, 0xE0, 0x1F,
  0x07, 0xF0, 0x1F, 0x07, 0xF0, 0x3E, 0x07, 0xF0, 0x3E, 0x07, 0xF8, 0x3E,
  0x0F, 0xF8, 0x3E, 0x0F, 0xF8, 0x3C, 0x0F, 0xF8, 0x7C, 0x0F, 0x7C, 0x7C,
  0x1F, 0x7C, 0x7C, 0x1F, 0x7C, 0x7C, 0x1F, 0x7C, 0x78, 0x1F, 0x3E, 0xF8,
  0x1E, 0x3E, 0xF8, 0x3E, 0x3E, 0xF8, 0x3E, 0x1E, 0xF8, 0x3E, 0x1F, 0xF0,
  0x3E, 0x1F, 0xF0, 0x3C, 0x1F, 0xF0, 0x7C, 0x0F, 0xF0, 0x7C, 0x0F, 0xF0,
  0x7C, 0x0F, 0xE0, 0x7C, 0x0F, 0xE0, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x7F, 0xE0, 0x1F, 0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0xFE, 0x7F, 0x0F, 0xCF,
  0xC0, 0xFB, 0xF0, 0x1F, 0x7E, 0x03, 0xEF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3E, 0xF8,
  0x0F, 0xDF, 0x01, 0xF3, 0xF0, 0x7E, 0x7F, 0x3F, 0x87, 0xFF, 0xF0, 0xFF,
  0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0xE0, 0x1F,
  0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0x8F, 0xC3, 0xE1, 0xF8, 0x7C,
  0x1F, 0x0F, 0x87, 0xE3, 0xF0, 0xFC, 0x7E, 0x3F, 0x0F, 0xFF, 0xE1, 0xFF,
  0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0x80, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x07, 0xFF,
  0xE1, 0xFF, 0xFE, 0x7F, 0x0F, 0xCF, 0xC0, 0xFB, 0xF0, 0x1F, 0x7E, 0x03,
  0xEF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x3E, 0xF8, 0x0F, 0xDF, 0x03, 0xF3, 0xF0, 0x7E,
  0x7F, 0x3F, 0x87, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF,
  0xE0, 0x7F, 0xFC, 0x1F, 0x8F, 0x83, 0xE1, 0xF8, 0x7C, 0x3F, 0x0F, 0x87,
  0xC3, 0xF1, 0xF8, 0x7E, 0x7F, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x01, 0xF3, 0xE0, 0x3E, 0x7E, 0x07, 0xC7, 0xC0, 0xF8, 0xF8,
  0x3F, 0x1F, 0x87, 0xC1, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xE7, 0xE0, 0xFC,
  0x00, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xF0, 0xFC,
  0x10, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x10, 0x1F, 0x1E, 0x3F, 0x8F, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF,
  0xC0, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0x1F, 0x83, 0xF1, 0xF0, 0x3E, 0x1F, 0x03, 0xE1, 0xF0,
  0x3E, 0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x3E,
  0x07, 0xC7, 0xE0, 0xFC, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x8F,
  0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x83, 0xF0,
  0xF8, 0x3F, 0x0F, 0xCF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xF8,
  0x01, 0xFE, 0x00, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0xFB, 0xE0, 0x7E,
  0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x8F, 0xC3, 0xE3, 0xE0, 0x79, 0xF8, 0x1E, 0x7C, 0x07, 0x9F,
  0x01, 0xEF, 0x80, 0x7B, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x1F, 0x03,
  0xFF, 0x81, 0xF0, 0x3E, 0xF8, 0x1F, 0x03, 0xEF, 0x83, 0xF0, 0x7C, 0xF8,
  0x3F, 0x07, 0xCF, 0x87, 0xF0, 0xFC, 0xF8, 0x7F, 0x0F, 0x8F, 0x8F, 0xF0,
  0xF8, 0xF8, 0xFF, 0x1F, 0x0F, 0x8F, 0xF1, 0xF0, 0xF9, 0xEF, 0x3F, 0x0F,
  0x9E, 0xF3, 0xE0, 0xFB, 0xEF, 0x3E, 0x0F, 0xBC, 0xF7, 0xC0, 0xFB, 0xCF,
  0x7C, 0x0F, 0xF8, 0xF7, 0x80, 0xF7, 0x8F, 0xF8, 0x0F, 0xF8, 0xFF, 0x80,
  0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0,
  0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x7E,
  0x07, 0xC0, 0xFC, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xC0, 0x1F, 0x1F, 0x80,
  0x3E, 0x7E, 0x00, 0x7C, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0x9F,
  0x00, 0x3F, 0x3E, 0x00, 0xFC, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE0, 0xF8,
  0x1F, 0x81, 0xF8, 0x7E, 0x03, 0xF0, 0xF8, 0x0F, 0xFE, 0x07, 0xEF, 0xC1,
  0xF1, 0xF0, 0xFC, 0x7C, 0x7E, 0x1F, 0x1F, 0x07, 0xCF, 0xC1, 0xF3, 0xE0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE2, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x00,
  0xF8, 0x78, 0x78, 0x78, 0x78, 0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3E,
  0x3E, 0x3E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1F, 0x1F, 0x1F, 0x0F, 0x0F, 0x0F,
  0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xFE, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x01,
  0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xBC, 0x07, 0x9E, 0x0F, 0x1E, 0x1F,
  0x1E, 0x1E, 0x1E, 0x3C, 0x0F, 0x7C, 0x0F, 0x78, 0x0F, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0x80, 0xF8, 0xF9, 0xF1, 0xE1, 0xE0, 0x07, 0xE7,
  0x87, 0xF7, 0xC7, 0xFF, 0xE7, 0xFF, 0xE3, 0xF3, 0xF3, 0xF1, 0xF9, 0xF8,
  0x7C, 0xF8, 0x7E, 0xFC, 0x3E, 0x7E, 0x1F, 0x3E, 0x0F, 0x9F, 0x0F, 0xCF,
  0x87, 0xC7, 0xE7, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0x7C, 0x1F, 0x3C,
  0x00, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x7C, 0x0F, 0xFF, 0x0F, 0xFF, 0xC7, 0xFF,
  0xE3, 0xF1, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x3E,
  0x1F, 0x9F, 0x0F, 0xCF, 0x87, 0xCF, 0xC7, 0xE7, 0xE7, 0xE3, 0xFF, 0xF1,
  0xFF, 0xF0, 0xF7, 0xF0, 0xF9, 0xF0, 0x00, 0x03, 0xFE, 0x1F, 0xF8, 0x7F,
  0xF1, 0xFF, 0xC3, 0xF0, 0x8F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x86, 0x1F, 0xFC, 0x3F,
  0xF8, 0x3F, 0xF0, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x3F, 0x7C,
  0x0F, 0xEF, 0x83, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0x9F, 0x87, 0xE1, 0xF0,
  0xF8, 0x3E, 0x1F, 0x0F, 0x87, 0xE1, 0xF0, 0xFC, 0x3E, 0x1F, 0x07, 0xC3,
  0xE0, 0xF8, 0x7C, 0x3E, 0x0F, 0xCF, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0x3E, 0x78, 0x00, 0x03, 0xFC, 0x0F, 0xFE, 0x1F, 0xFE, 0x3F,
  0x3F, 0x3E, 0x1F, 0x7E, 0x1F, 0x7C, 0x3E, 0x7F, 0xFE, 0xFF, 0xFC, 0xFF,
  0xF8, 0xFF, 0x80, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x08, 0x7F, 0xF8, 0x7F,
  0xF8, 0x3F, 0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xE0, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xFC,
  0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x0D,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF3, 0xC1, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0x9F, 0x8F,
  0xC7, 0xE3, 0xF0, 0xF8, 0xF8, 0x7E, 0x7E, 0x1F, 0x1F, 0x87, 0xC7, 0xC1,
  0xF1, 0xF0, 0xFC, 0x7C, 0x3E, 0x1F, 0x9F, 0x87, 0xFF, 0xE0, 0xFF, 0xF8,
  0x3F, 0xBE, 0x07, 0xDF, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x80, 0xFC, 0x38,
  0x7E, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x7E, 0x0F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xF1,
  0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0xFC, 0x3E, 0x7C, 0x3F, 0x3E, 0x1F, 0x1F,
  0x0F, 0x8F, 0x87, 0xCF, 0xC3, 0xE7, 0xC3, 0xF3, 0xE1, 0xF1, 0xF0, 0xF8,
  0xF8, 0x7C, 0xFC, 0x7E, 0x00, 0x03, 0xC0, 0xFC, 0x1F, 0x03, 0xE0, 0x38,
  0x00, 0x00, 0x00, 0x7C, 0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E,
  0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x0B, 0xF8, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x10,
  0xF8, 0x7E, 0x0F, 0x8F, 0xC1, 0xF9, 0xF8, 0x1F, 0x1F, 0x01, 0xF3, 0xE0,
  0x1F, 0x7C, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xE7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7,
  0xE0, 0x7C, 0x7E, 0x07, 0xC3, 0xE0, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x83, 0xF0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x3F,
  0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0x3F, 0x1F, 0x83,
  0xDF, 0xCF, 0xF1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x1F, 0x8F, 0xC7,
  0xC7, 0xE3, 0xF1, 0xF1, 0xF0, 0xF8, 0x7C, 0xFC, 0x3E, 0x1F, 0x3E, 0x1F,
  0x87, 0xCF, 0x87, 0xC3, 0xE3, 0xE1, 0xF0, 0xF8, 0xF8, 0x7C, 0x3E, 0x7E,
  0x1F, 0x0F, 0x9F, 0x0F, 0x87, 0xE7, 0xC3, 0xE1, 0xF1, 0xF0, 0xF8, 0x7C,
  0x7C, 0x3E, 0x1F, 0x3E, 0x1F, 0x87, 0xC0, 0x0F, 0x3F, 0x07, 0xBF, 0xC7,
  0xFF, 0xE3, 0xFF, 0xF1, 0xF8, 0xF8, 0xFC, 0x7C, 0x7C, 0x3E, 0x7E, 0x1F,
  0x3E, 0x1F, 0x9F, 0x0F, 0x8F, 0x87, 0xC7, 0xC3, 0xE7, 0xE1, 0xF3, 0xE1,
  0xF9, 0xF0, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x7E, 0x3F, 0x00, 0x03, 0xF8,
  0x0F, 0xFC, 0x1F, 0xFE, 0x3F, 0xFE, 0x3E, 0x3F, 0x7E, 0x1F, 0x7C, 0x1F,
  0x7C, 0x1F, 0xFC, 0x3F, 0xFC, 0x3F, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7E,
  0xFC, 0xFC, 0x7F, 0xFC, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x07, 0x9F,
  0x01, 0xEF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xC7, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xC7, 0xC3, 0xF1, 0xF0, 0xFC, 0x7C,
  0x3E, 0x3F, 0x1F, 0x8F, 0xCF, 0xC3, 0xFF, 0xF0, 0xFF, 0xF8, 0x7D, 0xFC,
  0x1F, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE7, 0x87,
  0xFF, 0xC7, 0xFF, 0xE7, 0xFF, 0xE3, 0xF3, 0xF3, 0xF0, 0xF9, 0xF0, 0x7C,
  0xF8, 0x7C, 0xFC, 0x3E, 0x7E, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x87,
  0xC7, 0xE7, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0x7C, 0x1F, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0x0F, 0x3C, 0x3D, 0xF1, 0xFF, 0xC7, 0xFF,
  0x1F, 0xF8, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0,
  0x00, 0x07, 0xF8, 0x7F, 0xF1, 0xFF, 0xCF, 0xFE, 0x3E, 0x08, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xFB,
  0x07, 0xEF, 0xFF, 0x3F, 0xFC, 0xFF, 0xE1, 0xFE, 0x00, 0x03, 0x80, 0x3C,
  0x01, 0xE0, 0x1F, 0x01, 0xFF, 0xBF, 0xF9, 0xFF, 0xDF, 0xFE, 0x3F, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE2, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0x1F, 0x0F, 0x8F,
  0x87, 0xCF, 0xC3, 0xE7, 0xC3, 0xF3, 0xE1, 0xF1, 0xF0, 0xF9, 0xF8, 0x7C,
  0xF8, 0x3E, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F, 0x9F, 0x8F, 0xCF, 0xC7,
  0xE7, 0xE7, 0xE3, 0xFF, 0xF0, 0xFF, 0x78, 0x7F, 0xBC, 0x1F, 0xBE, 0x00,
  0xF8, 0x3F, 0xF8, 0x3E, 0xF8, 0x7E, 0xF8, 0x7C, 0xF8, 0xFC, 0xF8, 0xF8,
  0xF9, 0xF8, 0xF9, 0xF0, 0x79, 0xF0, 0x7B, 0xE0, 0x7B, 0xE0, 0x7F, 0xC0,
  0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0xFE, 0x3E, 0xF8, 0xFE, 0x3E,
  0xF9, 0xFE, 0x7C, 0xF9, 0xFE, 0x7C, 0xF9, 0xDE, 0xF8, 0xFB, 0xDE, 0xF8,
  0xFB, 0xDE, 0xF0, 0xFF, 0x9F, 0xF0, 0xFF, 0x9D, 0xF0, 0xFF, 0x9D, 0xE0,
  0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0x80,
  0xFE, 0x1F, 0x80, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x7C, 0x7E, 0x07,
  0xE7, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0x80, 0x3F, 0xF0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0,
  0x0F, 0xFE, 0x00, 0xFB, 0xE0, 0x1F, 0x3F, 0x03, 0xF3, 0xF0, 0x7E, 0x1F,
  0x0F, 0xE1, 0xF8, 0x0F, 0x83, 0xF0, 0xF8, 0x3E, 0x0F, 0x87, 0xE0, 0xF8,
  0x7C, 0x0F, 0x8F, 0xC0, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0x79, 0xF0, 0x07,
  0x9F, 0x00, 0x7B, 0xE0, 0x07, 0xBE, 0x00, 0x7B, 0xC0, 0x07, 0xFC, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x0B, 0xF8, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFF, 0x0F, 0xFF,
  0x0F, 0xFF, 0x1F, 0xFE, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7F, 0xF8, 0x7F, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x00, 0x1C, 0x03, 0xF0,
  0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x78, 0x03, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x3F, 0x00,
  0xFE, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x02, 0x00, 0x1F, 0x00, 0x7E, 0x01, 0xFC, 0x07, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xF4, 0x07, 0xE0, 0x0F, 0x80, 0x7E, 0x07, 0xF8, 0x1F, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x00, 0xF8, 0x00, 0x08, 0x01, 0x7F, 0x81, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0x80, 0xFE,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBoldItalic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 11, 24, 9, 0, -24 },
  { 34, 13, 9, 15, 3, -24 },
  { 49, 20, 24, 20, 0, -24 },
  { 109, 16, 27, 17, 1, -25 },
  { 163, 25, 24, 28, 2, -24 },
  { 238, 22, 24, 22, 0, -24 },
  { 304, 6, 9, 8, 3, -24 },
  { 311, 12, 29, 11, 1, -24 },
  { 355, 12, 29, 11, -2, -24 },
  { 399, 14, 15, 17, 3, -25 },
  { 426, 15, 16, 18, 2, -20 },
  { 456, 8, 8, 9, -2, -4 },
  { 464, 10, 4, 10, 0, -11 },
  { 469, 6, 5, 9, 0, -5 },
  { 473, 18, 24, 14, -2, -24 },
  { 527, 16, 24, 17, 1, -24 },
  { 575, 13, 24, 17, 3, -24 },
  { 614, 18, 24, 17, -1, -24 },
  { 668, 17, 24, 17, 0, -24 },
  { 719, 17, 24, 17, 0, -24 },
  { 770, 17, 24, 17, 0, -24 },
  { 821, 17, 24, 17, 1, -24 },
  { 872, 18, 24, 17, 1, -24 },
  { 926, 16, 24, 17, 1, -24 },
  { 974, 16, 24, 17, 1, -24 },
  { 1022, 9, 18, 9, 0, -18 },
  { 1043, 11, 22, 9, -2, -18 },
  { 1074, 16, 17, 18, 1, -20 },
  { 1108, 15, 11, 18, 2, -17 },
  { 1129, 15, 17, 18, 2, -20 },
  { 1161, 13, 24, 14, 2, -24 },
  { 1200, 25, 27, 26, 1, -24 },
  { 1285, 20, 24, 20, -2, -24 },
  { 1345, 19, 24, 19, 0, -24 },
  { 1402, 18, 24, 18, 2, -24 },
  { 1456, 20, 24, 21, 0, -24 },
  { 1516, 18, 24, 16, 0, -24 },
  { 1570, 18, 24, 16, 0, -24 },
  { 1624, 19, 24, 21, 2, -24 },
  { 1681, 22, 24, 21, 0, -24 },
  { 1747, 16, 24, 13, -1, -24 },
  { 1795, 16, 31, 11, -5, -24 },
  { 1857, 22, 24, 19, 0, -24 },
  { 1923, 14, 24, 16, 0, -24 },
  { 1965, 28, 24, 27, 0, -24 },
  { 2049, 24, 24, 23, 0, -24 },
  { 2121, 19, 24, 22, 2, -24 },
  { 2178, 19, 24, 19, 0, -24 },
  { 2235, 19, 30, 22, 2, -24 },
  { 2307, 19, 24, 19, 0, -24 },
  { 2364, 17, 24, 16, 0, -24 },
  { 2415, 16, 24, 16, 3, -24 },
  { 2463, 20, 24, 21, 2, -24 },
  { 2523, 18, 24, 19, 3, -24 },
  { 2577, 28, 24, 28, 3, -24 },
  { 2661, 23, 24, 19, -2, -24 },
  { 2730, 18, 24, 18, 3, -24 },
  { 2784, 19, 24, 16, -1, -24 },
  { 2841, 14, 29, 11, -1, -24 },
  { 2892, 8, 24, 14, 3, -24 },
  { 2916, 14, 29, 11, -2, -24 },
  { 2967, 16, 16, 17, 0, -24 },
  { 2999, 14, 3, 13, -3, 3 },
  { 3005, 7, 5, 11, 5, -25 },
  { 3010, 17, 18, 18, 1, -18 },
  { 3049, 17, 25, 18, 0, -25 },
  { 3103, 15, 18, 15, 1, -18 },
  { 3137, 19, 25, 18, 1, -25 },
  { 3197, 16, 18, 17, 1, -18 },
  { 3233, 19, 33, 12, -4, -25 },
  { 3312, 18, 26, 18, 0, -18 },
  { 3371, 17, 25, 19, 0, -25 },
  { 3425, 11, 25, 9, 0, -25 },
  { 3460, 15, 33, 9, -4, -25 },
  { 3522, 20, 25, 18, 0, -25 },
  { 3585, 11, 25, 9, 0, -25 },
  { 3620, 26, 18, 28, 0, -18 },
  { 3679, 17, 18, 19, 0, -18 },
  { 3718, 16, 18, 18, 1, -18 },
  { 3754, 18, 26, 18, -1, -18 },
  { 3813, 17, 26, 18, 1, -18 },
  { 3869, 14, 18, 13, 0, -18 },
  { 3901, 14, 18, 15, 0, -18 },
  { 3933, 13, 22, 13, 1, -22 },
  { 3969, 17, 18, 18, 1, -18 },
  { 4008, 16, 18, 16, 2, -18 },
  { 4044, 24, 18, 25, 2, -18 },
  { 4098, 20, 18, 17, -2, -18 },
  { 4143, 20, 26, 16, -2, -18 },
  { 4208, 16, 18, 14, -1, -18 },
  { 4244, 14, 29, 12, 0, -24 },
  { 4295, 4, 32, 16, 6, -25 },
  { 4311, 14, 29, 12, -2, -24 },
  { 4362, 16, 6, 18, 1, -15 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBoldItalic33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBoldItalic33pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBoldItalic33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC33PT7B_H_
