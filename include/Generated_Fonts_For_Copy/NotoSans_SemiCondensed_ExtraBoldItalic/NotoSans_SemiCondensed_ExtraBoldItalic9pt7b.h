#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC9PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBoldItalic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBoldItalic9pt7bBitmaps[] PROGMEM = {
  0x00, 0x69, 0x21, 0x80, 0xF4, 0x29, 0xF7, 0x3E, 0x53, 0x80, 0x13, 0xD8,
  0xE3, 0x69, 0x88, 0x22, 0xE9, 0xA7, 0x75, 0xE5, 0x5B, 0x80, 0x11, 0xE7,
  0x8F, 0xFB, 0x6F, 0x80, 0xE0, 0x32, 0x44, 0xC8, 0xCC, 0x23, 0x33, 0x32,
  0x2C, 0x6C, 0x7A, 0x27, 0xC8, 0x40, 0xE0, 0xE0, 0xC0, 0x11, 0x22, 0x4C,
  0x80, 0x13, 0xD7, 0xBD, 0x69, 0x80, 0x75, 0xB4, 0x80, 0x23, 0xC6, 0x62,
  0x63, 0xC0, 0x23, 0xC6, 0xE1, 0x4B, 0x80, 0x19, 0x95, 0x6F, 0x10, 0x7A,
  0x1C, 0x2B, 0x70, 0x11, 0xD0, 0xED, 0x69, 0xC0, 0x78, 0x8C, 0x46, 0x60,
  0x23, 0xD6, 0xED, 0x6B, 0xC0, 0x23, 0x97, 0xB7, 0x1B, 0x80, 0x50, 0xC0,
  0x24, 0x07, 0x80, 0x09, 0xF8, 0xE1, 0x80, 0xF8, 0x3E, 0x87, 0x0E, 0xEC,
  0x00, 0x5C, 0xA8, 0x20, 0x3E, 0xBD, 0xAD, 0x5B, 0xC8, 0x0E, 0x00, 0x18,
  0x73, 0xCF, 0x7F, 0x30, 0x7A, 0x5C, 0xBD, 0xF8, 0x11, 0xD8, 0x8C, 0x25,
  0xC0, 0x7B, 0x52, 0x9D, 0xF8, 0x7B, 0x1C, 0x8C, 0x78, 0x7B, 0x1C, 0xEC,
  0x60, 0x08, 0xF6, 0x16, 0xD9, 0x27, 0x80, 0x6D, 0xB7, 0x92, 0xDB, 0x60,
  0x76, 0x64, 0x4E, 0x33, 0x22, 0x26, 0x4C, 0x6D, 0x67, 0x1C, 0xD3, 0x60,
  0x66, 0x44, 0xCF, 0x67, 0x66, 0x6A, 0x6E, 0xF6, 0xF4, 0x65, 0xD5, 0x57,
  0xDB, 0x60, 0x10, 0xF4, 0xD3, 0xCD, 0x67, 0x00, 0x7B, 0x56, 0xEC, 0x60,
  0x10, 0xF4, 0xD3, 0xCD, 0x67, 0x04, 0x18, 0x7A, 0x5E, 0xED, 0x6C, 0x13,
  0xD0, 0xC3, 0x5B, 0x80, 0xF4, 0x4C, 0xC8, 0x6D, 0x24, 0x92, 0xD9, 0xC0,
  0x9D, 0xA9, 0x4C, 0x60, 0x93, 0x6E, 0xD6, 0xED, 0x9B, 0x00, 0x36, 0x70,
  0x61, 0xC2, 0x99, 0x80, 0x9F, 0x38, 0x8C, 0x60, 0x79, 0x88, 0xCC, 0x78,
  0x74, 0x44, 0x4C, 0x8C, 0xAB, 0x54, 0x31, 0x13, 0x22, 0x2E, 0x37, 0x59,
  0xF0, 0xD0, 0x6A, 0xF5, 0xA7, 0x00, 0x63, 0x1C, 0xB5, 0xEB, 0xC0, 0x74,
  0xCC, 0x60, 0x08, 0x5E, 0xBD, 0x69, 0xC0, 0x72, 0xFD, 0x87, 0x00, 0x19,
  0x9E, 0x42, 0x11, 0x8C, 0xC0, 0x6A, 0xF5, 0xA7, 0x1B, 0x80, 0x63, 0x1E,
  0xB5, 0xEB, 0x40, 0x69, 0xA5, 0xB0, 0x32, 0x32, 0x26, 0x64, 0xC0, 0x63,
  0x16, 0xA6, 0x7B, 0x40, 0x6D, 0x25, 0xB0, 0x7E, 0xB5, 0x4E, 0xBD, 0x60,
  0x7A, 0xD7, 0xAD, 0x00, 0x72, 0xF7, 0xA7, 0x00, 0x72, 0xD7, 0xAF, 0x42,
  0x00, 0x6A, 0xF5, 0xA7, 0x18, 0xC0, 0x76, 0x4C, 0xC0, 0x74, 0x62, 0xE0,
  0x2F, 0x44, 0xC6, 0x4A, 0xD5, 0xA7, 0x00, 0xDA, 0x9C, 0xC6, 0x00, 0xB7,
  0x7F, 0xBE, 0xB0, 0x5B, 0x98, 0xCB, 0x00, 0x6C, 0xA3, 0x8C, 0x30, 0x8E,
  0x00, 0x73, 0x6C, 0xE0, 0x36, 0x68, 0x44, 0xC0, 0xFF, 0x80, 0x33, 0x21,
  0x26, 0xC0, 0xEC, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBoldItalic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 6, 3, 0, -6 },
  { 4, 3, 2, 4, 1, -6 },
  { 5, 6, 6, 5, 0, -6 },
  { 10, 5, 8, 5, 0, -7 },
  { 15, 7, 7, 8, 0, -7 },
  { 22, 6, 7, 6, 0, -7 },
  { 28, 2, 2, 2, 1, -6 },
  { 29, 4, 8, 3, 0, -7 },
  { 33, 4, 8, 3, -1, -7 },
  { 37, 4, 4, 5, 1, -7 },
  { 39, 5, 4, 5, 0, -5 },
  { 42, 2, 2, 3, 0, -1 },
  { 43, 3, 1, 3, 0, -3 },
  { 44, 2, 1, 3, 0, -1 },
  { 45, 4, 7, 4, 0, -7 },
  { 49, 5, 7, 5, 0, -7 },
  { 54, 3, 6, 5, 1, -6 },
  { 57, 5, 7, 5, 0, -7 },
  { 62, 5, 7, 5, 0, -7 },
  { 67, 5, 6, 5, 0, -6 },
  { 71, 5, 6, 5, 0, -6 },
  { 75, 5, 7, 5, 0, -7 },
  { 80, 5, 6, 5, 0, -6 },
  { 84, 5, 7, 5, 0, -7 },
  { 89, 5, 7, 5, 0, -7 },
  { 94, 2, 5, 3, 0, -5 },
  { 96, 3, 6, 3, -1, -5 },
  { 99, 5, 5, 5, 0, -6 },
  { 103, 5, 3, 5, 0, -5 },
  { 105, 5, 5, 5, 0, -6 },
  { 109, 3, 7, 4, 1, -7 },
  { 112, 7, 7, 7, 0, -6 },
  { 119, 6, 6, 5, -1, -6 },
  { 124, 5, 6, 5, 0, -6 },
  { 128, 5, 7, 5, 0, -7 },
  { 133, 5, 6, 6, 0, -6 },
  { 137, 5, 6, 4, 0, -6 },
  { 141, 5, 6, 4, 0, -6 },
  { 145, 6, 7, 6, 0, -7 },
  { 151, 6, 6, 6, 0, -6 },
  { 156, 4, 6, 3, 0, -6 },
  { 159, 4, 8, 3, -1, -6 },
  { 163, 6, 6, 5, 0, -6 },
  { 168, 4, 6, 4, 0, -6 },
  { 171, 8, 6, 7, 0, -6 },
  { 177, 6, 6, 6, 0, -6 },
  { 182, 6, 7, 6, 0, -7 },
  { 188, 5, 6, 5, 0, -6 },
  { 192, 6, 9, 6, 0, -7 },
  { 199, 5, 6, 5, 0, -6 },
  { 203, 5, 7, 4, 0, -7 },
  { 208, 4, 6, 4, 1, -6 },
  { 211, 6, 6, 6, 0, -6 },
  { 216, 5, 6, 5, 1, -6 },
  { 220, 7, 6, 8, 1, -6 },
  { 226, 7, 6, 5, -1, -6 },
  { 232, 5, 6, 5, 1, -6 },
  { 236, 5, 6, 4, 0, -6 },
  { 240, 4, 8, 3, 0, -7 },
  { 244, 2, 7, 4, 1, -7 },
  { 246, 4, 8, 3, -1, -7 },
  { 250, 4, 4, 5, 0, -6 },
  { 252, 4, 1, 4, -1, 1 },
  { 253, 2, 2, 3, 1, -7 },
  { 254, 5, 5, 5, 0, -5 },
  { 258, 5, 7, 5, 0, -7 },
  { 263, 4, 5, 4, 0, -5 },
  { 266, 5, 7, 5, 0, -7 },
  { 271, 5, 5, 5, 0, -5 },
  { 275, 5, 9, 3, -1, -7 },
  { 281, 5, 7, 5, 0, -5 },
  { 286, 5, 7, 5, 0, -7 },
  { 291, 3, 7, 3, 0, -7 },
  { 294, 4, 9, 3, -1, -7 },
  { 299, 5, 7, 5, 0, -7 },
  { 304, 3, 7, 3, 0, -7 },
  { 307, 7, 5, 8, 0, -5 },
  { 312, 5, 5, 5, 0, -5 },
  { 316, 5, 5, 5, 0, -5 },
  { 320, 5, 7, 5, 0, -5 },
  { 325, 5, 7, 5, 0, -5 },
  { 330, 4, 5, 4, 0, -5 },
  { 333, 4, 5, 4, 0, -5 },
  { 336, 4, 6, 4, 0, -6 },
  { 339, 5, 5, 5, 0, -5 },
  { 343, 5, 5, 4, 0, -5 },
  { 347, 6, 5, 7, 1, -5 },
  { 351, 5, 5, 5, 0, -5 },
  { 355, 6, 7, 4, -1, -5 },
  { 361, 4, 5, 4, 0, -5 },
  { 364, 4, 7, 3, 0, -6 },
  { 368, 1, 9, 4, 2, -7 },
  { 370, 4, 7, 3, -1, -6 },
  { 374, 5, 2, 5, 0, -4 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBoldItalic9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBoldItalic9pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBoldItalic9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC9PT7B_H_
