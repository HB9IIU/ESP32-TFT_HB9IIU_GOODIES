#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC34PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBoldItalic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBoldItalic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0xFC,
  0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x00,
  0x00, 0x00, 0x40, 0x3E, 0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xC0, 0x7C, 0xFB,
  0xE7, 0xDF, 0x3E, 0xF1, 0xE7, 0x8F, 0x3C, 0xFB, 0xE7, 0x9E, 0x3C, 0xF1,
  0xE0, 0x00, 0x79, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xE7, 0x80,
  0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF9, 0xFF, 0xFF, 0x80, 0xF3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03,
  0xCF, 0x01, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0x71, 0xE0,
  0x07, 0x8F, 0x00, 0x3C, 0x70, 0x01, 0xE7, 0x80, 0x1E, 0x3C, 0x00, 0xF1,
  0xE0, 0x07, 0x9E, 0x00, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x7F,
  0xE0, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0xFC, 0x7E, 0xCC, 0x3E, 0x60, 0x1F,
  0x70, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xDF, 0x20, 0x6F, 0x98, 0x67, 0xCF, 0xFF,
  0xE7, 0xFF, 0xE3, 0xFF, 0xE1, 0xFF, 0xE0, 0x0F, 0x80, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x02, 0x07, 0xF0, 0x0F, 0x03, 0xFE,
  0x03, 0xC0, 0xFF, 0x81, 0xE0, 0x7D, 0xE0, 0xF0, 0x1E, 0x78, 0x3C, 0x0F,
  0x9E, 0x1E, 0x03, 0xC7, 0x8F, 0x00, 0xF1, 0xE3, 0xC0, 0x3C, 0x79, 0xE0,
  0x0F, 0x3C, 0xF1, 0xE3, 0xCF, 0x3D, 0xFC, 0xFF, 0xDE, 0xFF, 0xBF, 0xEF,
  0x3F, 0xE7, 0xF7, 0xDF, 0x78, 0x21, 0xE7, 0x9F, 0x00, 0xF3, 0xE7, 0x80,
  0x7C, 0xF1, 0xE0, 0x1E, 0x3C, 0x78, 0x0F, 0x0F, 0x1E, 0x07, 0xC3, 0xCF,
  0x81, 0xE0, 0xFF, 0xC0, 0xF0, 0x3F, 0xF0, 0x7C, 0x07, 0xF8, 0x3E, 0x00,
  0xFC, 0x00, 0x00, 0x1C, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0,
  0x07, 0xCF, 0x80, 0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x0F,
  0xF8, 0x7C, 0x7F, 0xE3, 0xF3, 0xFF, 0xCF, 0x9F, 0xBF, 0x7E, 0x7C, 0x7F,
  0xF1, 0xF0, 0xFF, 0x8F, 0xC3, 0xFE, 0x3F, 0x07, 0xF0, 0xFE, 0x3F, 0xC1,
  0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xF3, 0xF0, 0x7E,
  0xF9, 0xF3, 0xC7, 0x8F, 0x3E, 0x78, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F,
  0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0xC0, 0x3E, 0x01,
  0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x3E,
  0x03, 0xE0, 0x7C, 0x0F, 0x80, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x02, 0x1E,
  0x07, 0x3C, 0x1F, 0xF0, 0xFF, 0xFF, 0xBF, 0xFF, 0x0F, 0xFE, 0x3F, 0xBC,
  0xFF, 0x03, 0xEF, 0x0F, 0xDE, 0x07, 0x1E, 0x04, 0x3C, 0x00, 0x40, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x1F, 0x8F, 0x8F, 0xC7, 0xC3, 0xE3, 0xE1,
  0xF1, 0xF0, 0x7F, 0xDF, 0xF7, 0xFF, 0xFE, 0x11, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x60, 0x01, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xF0, 0xFC,
  0xF8, 0xFC, 0x7C, 0x7C, 0x3F, 0x3E, 0x1F, 0xBF, 0x0F, 0x9F, 0x07, 0xCF,
  0x83, 0xEF, 0xC1, 0xF7, 0xE1, 0xFB, 0xF0, 0xFD, 0xF0, 0x7E, 0xF8, 0x3E,
  0x7C, 0x3F, 0x3E, 0x1F, 0x9F, 0x1F, 0x8F, 0xDF, 0xC7, 0xFF, 0xC1, 0xFF,
  0xC0, 0x7F, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0xF8, 0x1F, 0xC1, 0xFE, 0x1F,
  0xF3, 0xFF, 0x3F, 0xFB, 0xFF, 0xCF, 0x3E, 0x73, 0xF1, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x00, 0x18, 0x00,
  0x7F, 0xC0, 0x3F, 0xF8, 0x3F, 0xFF, 0x0F, 0xFF, 0xC1, 0xE3, 0xF0, 0x30,
  0x7C, 0x08, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF,
  0xF3, 0xFF, 0xF8, 0xFF, 0xFE, 0x00, 0x00, 0x70, 0x01, 0xFF, 0x03, 0xFF,
  0xC1, 0xFF, 0xF0, 0xFF, 0xF8, 0x30, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x00, 0x3F, 0xE0,
  0x1F, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xD0, 0x07,
  0xEE, 0x0F, 0xE7, 0xFF, 0xF3, 0xFF, 0xF1, 0xFF, 0xF0, 0x7F, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xDF, 0x01, 0xEF, 0xC0, 0xF3,
  0xE0, 0x7C, 0xF8, 0x1E, 0x3E, 0x0F, 0x0F, 0x87, 0x87, 0xE3, 0xFF, 0xFE,
  0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xF0, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F,
  0xF8, 0x1F, 0xFE, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0x60, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFF, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC8, 0x07,
  0xE3, 0xC7, 0xF8, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0x80,
  0x00, 0x0F, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0xFF, 0xF0, 0xFF, 0xF8, 0x7E,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x3C, 0x1F, 0x7F, 0x0F,
  0xFF, 0xC7, 0xFF, 0xE3, 0xFB, 0xFB, 0xF8, 0xFD, 0xF8, 0x7E, 0xFC, 0x3F,
  0x7E, 0x1F, 0x3F, 0x0F, 0x9F, 0x8F, 0xC7, 0xCF, 0xC3, 0xFF, 0xE1, 0xFF,
  0xE0, 0x7F, 0xE0, 0x1F, 0xE0, 0x00, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF,
  0xFC, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0x00, 0x70, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xF8, 0xF8,
  0xFC, 0x7C, 0x3E, 0x3E, 0x3F, 0x1F, 0x1F, 0x0F, 0xDF, 0x83, 0xFF, 0x81,
  0xFF, 0x00, 0x7F, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0xFC, 0xFC, 0xFC, 0x7E,
  0x7C, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x87, 0xE7, 0xFF, 0xE3, 0xFF,
  0xF0, 0xFF, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0xE0, 0x07, 0xFC, 0x0F, 0xFE,
  0x1F, 0xFE, 0x3F, 0xFF, 0x3F, 0x1F, 0x3E, 0x1F, 0x7E, 0x1F, 0x7E, 0x1F,
  0x7C, 0x1F, 0x7C, 0x3F, 0x7E, 0x3F, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xFE,
  0x1F, 0xBE, 0x0E, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x83, 0xF8,
  0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0x07, 0x07, 0xC7, 0xE3,
  0xF1, 0xF8, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x81,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3E, 0x00, 0x01, 0xC0, 0x7C, 0x1F, 0x83, 0xF0,
  0x7E, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0,
  0x3E, 0x00, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xF8, 0x07, 0xF0, 0x3F, 0xE1,
  0xFF, 0x0F, 0xF8, 0x7F, 0x80, 0xFC, 0x01, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x1F, 0x80, 0x0F, 0x00, 0x06, 0x00, 0x04,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x01, 0xC0,
  0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF,
  0x00, 0x7E, 0x01, 0xFC, 0x0F, 0xF8, 0xFF, 0xC7, 0xFE, 0x1F, 0xE0, 0x3F,
  0x00, 0x78, 0x00, 0xC0, 0x01, 0x00, 0x00, 0x03, 0x80, 0x7F, 0xC7, 0xFF,
  0x9F, 0xFE, 0x7F, 0xFC, 0xC3, 0xF2, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0xE0, 0x1F, 0x80, 0x7C, 0x0F, 0x80, 0x0F, 0x83, 0xC0, 0x01, 0xE1, 0xE0,
  0xFE, 0x3C, 0xF0, 0xFF, 0xCF, 0x3C, 0x7F, 0xE3, 0xDE, 0x3E, 0x78, 0xF7,
  0x8F, 0x1E, 0x3D, 0xE7, 0x87, 0x8F, 0x71, 0xE1, 0xC3, 0xBC, 0x78, 0xF1,
  0xEF, 0x3C, 0x3C, 0x7B, 0xCF, 0x0F, 0x1C, 0xF3, 0xC7, 0xCF, 0x3C, 0x7F,
  0xFF, 0x8F, 0x1F, 0xDF, 0xC3, 0xC3, 0xE7, 0xE0, 0x78, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x04, 0x00, 0xFF, 0x1F, 0x00, 0x1F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFB,
  0xE0, 0x0F, 0xBE, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x03, 0xF3, 0xE0, 0x3E,
  0x3E, 0x07, 0xE3, 0xE0, 0x7C, 0x3E, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF3, 0xF0, 0x1F, 0x3E, 0x01, 0xF7,
  0xE0, 0x1F, 0x7C, 0x01, 0xFF, 0xC0, 0x1F, 0x07, 0xFF, 0x80, 0x7F, 0xFC,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xC7, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xE0, 0xF8, 0x3E, 0x0F, 0x87, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xFF,
  0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3E,
  0x0F, 0xC3, 0xE0, 0xFC, 0x3E, 0x1F, 0x87, 0xE7, 0xF8, 0x7F, 0xFF, 0x87,
  0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x3F, 0xF0,
  0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0x87, 0x0F, 0xE0, 0x21,
  0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x7E, 0x02, 0x0F, 0xF3, 0xC0, 0xFF, 0xF8, 0x1F,
  0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFE,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7C, 0xFF, 0x07, 0xE1, 0xF8, 0x3F,
  0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7C,
  0x3F, 0x03, 0xE1, 0xF0, 0x3F, 0x0F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0,
  0xFC, 0x3F, 0x07, 0xE1, 0xF0, 0x7E, 0x0F, 0x87, 0xF0, 0xFF, 0xFF, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x07, 0xFF,
  0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F,
  0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x83, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07,
  0xFF, 0x83, 0xFF, 0xE0, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F,
  0xFE, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x01, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x83,
  0xFF, 0xE0, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x1C,
  0x00, 0x0F, 0xFE, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFE,
  0x1C, 0x3F, 0x80, 0x43, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xC7, 0xFC, 0xFC, 0x7F, 0xCF, 0xC7, 0xFC, 0xF8, 0x7F, 0xCF,
  0x87, 0xFC, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8,
  0xFF, 0x3F, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFC,
  0x00, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x07,
  0xE0, 0x7C, 0x0F, 0xC1, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x07, 0xC0, 0xFC,
  0x0F, 0x81, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x3F,
  0x03, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x1F, 0x83, 0xF0, 0x3E, 0x07, 0xE0,
  0x7C, 0x0F, 0x81, 0xF8, 0x1F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x07, 0xFF,
  0x07, 0xFF, 0x0F, 0xFE, 0x03, 0xFC, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x3F, 0xE0, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0,
  0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x9F, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0xFE, 0x0F, 0xC3, 0xF0, 0x1F, 0x0F, 0xE0, 0x3E, 0x1F, 0x80,
  0x7C, 0x7E, 0x01, 0xF9, 0xF8, 0x03, 0xF7, 0xF0, 0x07, 0xCF, 0xC0, 0x0F,
  0xBF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0x9F, 0x00, 0x3E, 0x3F,
  0x00, 0x7C, 0x7E, 0x00, 0xF8, 0xFC, 0x03, 0xF0, 0xF8, 0x07, 0xE1, 0xF8,
  0x0F, 0x83, 0xF0, 0x1F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x1F,
  0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F,
  0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0xFF, 0x7F, 0xFD, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x81, 0xFE,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0x81, 0xFF, 0x07, 0xFC, 0x0F,
  0xF8, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x0F, 0x78, 0x7F, 0xE0,
  0xFB, 0xC3, 0xDF, 0x07, 0xDE, 0x3F, 0xF0, 0x3E, 0xF1, 0xEF, 0x81, 0xF7,
  0x9F, 0x7C, 0x0F, 0xBC, 0xF3, 0xE0, 0xF9, 0xEF, 0x9F, 0x07, 0xCF, 0x79,
  0xF0, 0x3E, 0x7F, 0xCF, 0x81, 0xF3, 0xFC, 0x7C, 0x0F, 0x9F, 0xE3, 0xE0,
  0xF8, 0xFE, 0x3F, 0x07, 0xC7, 0xF1, 0xF0, 0x3E, 0x3F, 0x0F, 0x81, 0xF1,
  0xF8, 0x7C, 0x1F, 0x8F, 0x83, 0xE0, 0x07, 0xF0, 0x1F, 0x07, 0xF0, 0x1F,
  0x07, 0xF8, 0x1F, 0x07, 0xF8, 0x1F, 0x07, 0xF8, 0x3E, 0x0F, 0xF8, 0x3E,
  0x0F, 0xFC, 0x3E, 0x0F, 0xFC, 0x3E, 0x0F, 0x7C, 0x3E, 0x1F, 0x7C, 0x7C,
  0x1F, 0x3E, 0x7C, 0x1F, 0x3E, 0x7C, 0x1F, 0x3E, 0x7C, 0x1F, 0x3E, 0x7C,
  0x3E, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8,
  0x3E, 0x0F, 0xF0, 0x7C, 0x0F, 0xF0, 0x7C, 0x0F, 0xF0, 0x7C, 0x0F, 0xF0,
  0x7C, 0x07, 0xF0, 0xF8, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x1F, 0xF8, 0x07,
  0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFC, 0x7F, 0x3F, 0x83, 0xF3,
  0xF0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xEF, 0x80, 0x7E, 0xF8, 0x07,
  0xEF, 0x80, 0xFC, 0xFC, 0x0F, 0xCF, 0xC1, 0xF8, 0xFF, 0x7F, 0x87, 0xFF,
  0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7C, 0x7E, 0x1F, 0x87, 0xC3,
  0xF0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE3, 0xF0, 0xFC, 0x7E, 0x3F, 0x8F,
  0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0xF8, 0x07,
  0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFC, 0x7F, 0x3F, 0x83, 0xF3,
  0xF0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xEF, 0x80, 0x7E, 0xF8, 0x07,
  0xEF, 0x80, 0xFC, 0xFC, 0x0F, 0xCF, 0xC1, 0xF8, 0xFF, 0x7F, 0x87, 0xFF,
  0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7C, 0x7E,
  0x1F, 0x8F, 0xC3, 0xF0, 0xF8, 0x7C, 0x3F, 0x0F, 0x87, 0xE3, 0xF1, 0xF8,
  0x7E, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x81,
  0xFB, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xE0, 0xF8, 0xFC, 0x3F, 0x0F, 0x87,
  0xE1, 0xF8, 0xF8, 0x3F, 0x1F, 0x07, 0xE7, 0xE0, 0x7E, 0x00, 0x30, 0x00,
  0x7F, 0xE0, 0x7F, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x87, 0xF1, 0xC1, 0xF8,
  0x10, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE3, 0x01, 0xF8, 0xF9, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF,
  0x83, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80,
  0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x1F, 0x81, 0xF1, 0xF8, 0x3F, 0x1F,
  0x03, 0xF1, 0xF0, 0x3E, 0x3F, 0x03, 0xE3, 0xF0, 0x7E, 0x3E, 0x07, 0xE3,
  0xE0, 0x7E, 0x3E, 0x07, 0xC7, 0xE0, 0x7C, 0x7E, 0x0F, 0xC7, 0xC0, 0xFC,
  0x7C, 0x0F, 0xCF, 0xC0, 0xF8, 0xFC, 0x0F, 0x8F, 0xC1, 0xF8, 0xF8, 0x1F,
  0x8F, 0x81, 0xF0, 0xFC, 0x3F, 0x0F, 0xEF, 0xF0, 0xFF, 0xFE, 0x07, 0xFF,
  0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0xF8, 0x07, 0xFF, 0x01, 0xFB, 0xE0,
  0x3F, 0x7C, 0x07, 0xCF, 0x81, 0xF9, 0xF0, 0x3E, 0x3E, 0x0F, 0xC7, 0xC1,
  0xF0, 0xF8, 0x7E, 0x1F, 0x8F, 0x81, 0xF3, 0xF0, 0x3E, 0x7C, 0x07, 0xCF,
  0x80, 0xFB, 0xE0, 0x1F, 0x7C, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0x78,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0xF8, 0x0F, 0x81, 0xFF, 0xC0, 0xFC, 0x0F, 0xBE, 0x07,
  0xE0, 0xFD, 0xF0, 0x7F, 0x07, 0xCF, 0x83, 0xF8, 0x7E, 0x7C, 0x3F, 0xC3,
  0xE3, 0xE1, 0xFE, 0x1F, 0x1F, 0x0F, 0xF1, 0xF0, 0xF8, 0xFF, 0x8F, 0x87,
  0xC7, 0xFC, 0xFC, 0x3E, 0x7F, 0xE7, 0xC1, 0xF3, 0xDF, 0x3E, 0x0F, 0xBE,
  0xFB, 0xE0, 0x7D, 0xF7, 0xDF, 0x03, 0xEF, 0x3F, 0xF8, 0x1F, 0xF9, 0xFF,
  0x80, 0xFF, 0x8F, 0x7C, 0x07, 0xFC, 0x7F, 0xC0, 0x3F, 0xC3, 0xFE, 0x01,
  0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x07, 0xF8, 0x03, 0xF8,
  0x3F, 0x80, 0x1F, 0x81, 0xFC, 0x00, 0x03, 0xF0, 0x7F, 0x03, 0xF0, 0x7E,
  0x03, 0xF0, 0xFC, 0x01, 0xF0, 0xF8, 0x01, 0xF1, 0xF8, 0x01, 0xFB, 0xF0,
  0x01, 0xFB, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xEF, 0x80, 0x0F, 0xCF, 0x80,
  0x0F, 0xCF, 0xC0, 0x1F, 0x8F, 0xC0, 0x3F, 0x07, 0xC0, 0x3F, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x0F, 0xFF, 0x07, 0xE7, 0xC1,
  0xF1, 0xF0, 0xFC, 0x7C, 0x7E, 0x1F, 0x1F, 0x87, 0xEF, 0xC0, 0xFB, 0xE0,
  0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1F,
  0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xF0, 0xF0, 0xF0, 0xF8, 0xF8,
  0xF8, 0xF8, 0x78, 0x78, 0x78, 0x7C, 0x7C, 0x7C, 0x7C, 0x3C, 0x3C, 0x3C,
  0x3E, 0x3E, 0x3E, 0x3E, 0x1E, 0x1E, 0x1E, 0x1F, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC1, 0xFE, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0x78, 0x0F, 0x3C, 0x0F, 0x9E, 0x07, 0x8F,
  0x07, 0xC3, 0xC7, 0xC1, 0xE3, 0xC0, 0xF3, 0xE0, 0x7B, 0xE0, 0x1E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0xF9, 0xF1, 0xF1, 0xE0, 0x03, 0xC7,
  0xC3, 0xF9, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xBF, 0x8F, 0xC7, 0xE7,
  0xE1, 0xF1, 0xF8, 0x7C, 0x7C, 0x1F, 0x3F, 0x07, 0xCF, 0xC3, 0xF3, 0xF0,
  0xF8, 0xFC, 0x3E, 0x3F, 0x1F, 0x8F, 0xCF, 0xE3, 0xFF, 0xF0, 0x7F, 0xFC,
  0x1F, 0xFF, 0x03, 0xF7, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x78, 0x0F,
  0xBF, 0x03, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0x7F, 0x1F, 0x8F, 0xC7, 0xC3,
  0xF1, 0xF0, 0xFC, 0xF8, 0x3F, 0x3E, 0x0F, 0x8F, 0x83, 0xE3, 0xE1, 0xF8,
  0xF8, 0x7E, 0x7E, 0x3F, 0x1F, 0xCF, 0xC7, 0xFF, 0xE1, 0xFF, 0xF8, 0x7B,
  0xFC, 0x3E, 0x7C, 0x00, 0x01, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xE3,
  0xFB, 0xC7, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x82, 0x3F, 0x8C, 0x3F, 0xF8, 0x7F, 0xF0,
  0x7F, 0xE0, 0x7F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x1E, 0x7E, 0x0F,
  0xEF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xDF, 0xC3, 0xF1, 0xF8, 0xFC,
  0x3E, 0x1F, 0x87, 0xC3, 0xE0, 0xF8, 0xFC, 0x1F, 0x1F, 0x87, 0xC3, 0xF0,
  0xF8, 0x7E, 0x1F, 0x0F, 0xC7, 0xE1, 0xF9, 0xFC, 0x3F, 0xFF, 0x03, 0xFF,
  0xE0, 0x7F, 0xBC, 0x07, 0xEF, 0x80, 0x01, 0xF8, 0x07, 0xFE, 0x0F, 0xFE,
  0x1F, 0xFF, 0x3F, 0x1F, 0x3E, 0x1F, 0x7E, 0x1F, 0x7C, 0x7F, 0x7F, 0xFE,
  0xFF, 0xFC, 0xFF, 0xF0, 0xFE, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x08,
  0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF0, 0x00, 0x07, 0xE0, 0x01,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0x20, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x09, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xE3, 0xE0,
  0xFF, 0x78, 0x3F, 0xFF, 0x07, 0xFF, 0xE1, 0xFD, 0xFC, 0x3F, 0x1F, 0x8F,
  0xC3, 0xE1, 0xF8, 0x7C, 0x3E, 0x0F, 0x8F, 0xC1, 0xF1, 0xF8, 0x7E, 0x3F,
  0x0F, 0x87, 0xE1, 0xF0, 0xFC, 0x7E, 0x1F, 0x9F, 0xC3, 0xFF, 0xF0, 0x3F,
  0xFE, 0x07, 0xF7, 0xC0, 0x7C, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC1, 0x00,
  0xF8, 0x38, 0x7F, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x7C, 0x0F, 0xBF, 0x83, 0xFF,
  0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF0, 0xFC,
  0xFC, 0x3E, 0x3F, 0x0F, 0x8F, 0x83, 0xE3, 0xE1, 0xF8, 0xF8, 0x7C, 0x7E,
  0x1F, 0x1F, 0x87, 0xC7, 0xC3, 0xF1, 0xF0, 0xFC, 0x7C, 0x3E, 0x3F, 0x0F,
  0x80, 0x03, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x00, 0x00, 0x00, 0x7E,
  0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC1, 0xF8, 0x3F,
  0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x1F,
  0x80, 0x00, 0x3C, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x17, 0xF0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFE, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x3F, 0x0F, 0x87, 0xE0, 0xF8, 0xFC, 0x1F, 0x9F, 0x81, 0xF9, 0xF0, 0x1F,
  0x3E, 0x01, 0xF7, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7E, 0x7E, 0x07, 0xC7, 0xE0,
  0x7C, 0x7E, 0x07, 0xC3, 0xF0, 0x7C, 0x3F, 0x0F, 0xC3, 0xF8, 0x03, 0xE0,
  0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC1, 0xF8, 0x3F, 0x07, 0xC0, 0xF8,
  0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x80, 0x0F, 0x1F,
  0x0F, 0x81, 0xE7, 0xF3, 0xF8, 0x3D, 0xFE, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0x7E, 0x3F, 0x1F, 0xC7, 0xC7, 0xE3, 0xF0, 0xF8, 0xF8, 0x7E,
  0x3F, 0x3F, 0x0F, 0x87, 0xE7, 0xE1, 0xF0, 0xF8, 0xF8, 0x7E, 0x1F, 0x1F,
  0x0F, 0xC3, 0xE3, 0xE1, 0xF0, 0xFC, 0xFC, 0x3E, 0x1F, 0x9F, 0x07, 0xC3,
  0xE3, 0xE1, 0xF8, 0x7C, 0x7C, 0x3E, 0x0F, 0x8F, 0x87, 0xC3, 0xF3, 0xF0,
  0xF8, 0x7E, 0x00, 0x0F, 0x1E, 0x03, 0xCF, 0xE0, 0xF7, 0xF8, 0x7F, 0xFF,
  0x1F, 0xFF, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7C, 0x3F, 0x3F, 0x0F, 0x8F,
  0xC3, 0xE3, 0xE0, 0xF8, 0xF8, 0x7E, 0x3E, 0x1F, 0x1F, 0x87, 0xC7, 0xE1,
  0xF1, 0xF0, 0x7C, 0x7C, 0x3F, 0x1F, 0x0F, 0x8F, 0xC3, 0xE0, 0x01, 0xF8,
  0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xFF, 0x3F, 0xBF, 0x3E, 0x1F, 0x7E, 0x1F,
  0x7C, 0x1F, 0x7C, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x7E, 0xFC, 0x7E, 0x7F, 0xFC, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xE0,
  0x03, 0xC7, 0x80, 0x3D, 0xFC, 0x03, 0xDF, 0xE0, 0x7F, 0xFE, 0x07, 0xF7,
  0xF0, 0x7E, 0x3F, 0x07, 0xC3, 0xF0, 0x7C, 0x3F, 0x0F, 0xC3, 0xF0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x7E, 0x0F, 0x87, 0xE1, 0xF8, 0xFC, 0x1F,
  0xCF, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0x7E, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE7, 0xC3, 0xFD,
  0xE1, 0xFF, 0x78, 0x7F, 0xFE, 0x3F, 0xBF, 0x8F, 0xC7, 0xE7, 0xE1, 0xF1,
  0xF8, 0x7C, 0x7C, 0x1F, 0x3F, 0x07, 0xCF, 0xC3, 0xE3, 0xF0, 0xF8, 0xFC,
  0x3E, 0x3F, 0x1F, 0x8F, 0xCF, 0xE3, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF,
  0x03, 0xE7, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x1E, 0x1E,
  0x7C, 0x3D, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFC, 0x87, 0xE0, 0x0F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x1F,
  0xFC, 0x7F, 0xF0, 0xFF, 0xE3, 0xF1, 0x87, 0xE0, 0x0F, 0xC0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x30,
  0x7E, 0x7F, 0xFC, 0xFF, 0xF1, 0xFF, 0xC1, 0xFF, 0x00, 0x03, 0xC0, 0x1C,
  0x01, 0xE0, 0x0F, 0x00, 0xFF, 0x9F, 0xFD, 0xFF, 0xEF, 0xFE, 0x9F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x10, 0xFF, 0x87, 0xFC, 0x3F, 0xE0, 0xFF, 0x00, 0x1F,
  0x07, 0xC7, 0xC3, 0xF1, 0xF0, 0xF8, 0xFC, 0x3E, 0x3E, 0x0F, 0x8F, 0x87,
  0xE3, 0xE1, 0xF9, 0xF8, 0x7C, 0x7E, 0x1F, 0x1F, 0x07, 0xC7, 0xC3, 0xF1,
  0xF0, 0xFC, 0xFC, 0x3E, 0x3F, 0x1F, 0x8F, 0xCF, 0xE3, 0xFF, 0xF8, 0x7F,
  0xFC, 0x1F, 0xEF, 0x03, 0xF3, 0xC0, 0xF8, 0x1F, 0xFC, 0x1F, 0xBE, 0x0F,
  0x9F, 0x0F, 0xCF, 0x87, 0xC7, 0xC3, 0xE3, 0xE3, 0xE1, 0xF1, 0xF0, 0x79,
  0xF0, 0x3C, 0xF8, 0x1E, 0xF8, 0x0F, 0x7C, 0x07, 0xBC, 0x03, 0xFE, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x00, 0xF8,
  0x7E, 0x0F, 0xFC, 0x3F, 0x0F, 0xFE, 0x1F, 0x87, 0xDF, 0x1F, 0xC3, 0xEF,
  0x8F, 0xE3, 0xE7, 0xCF, 0xF1, 0xF3, 0xE7, 0xF9, 0xF1, 0xF3, 0xFC, 0xF8,
  0xFB, 0xDE, 0xF8, 0x7D, 0xEF, 0x7C, 0x3E, 0xF7, 0xBE, 0x1F, 0xF3, 0xFE,
  0x0F, 0xF9, 0xFF, 0x07, 0xF8, 0xFF, 0x03, 0xFC, 0x7F, 0x81, 0xFE, 0x3F,
  0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x00, 0x0F,
  0xC1, 0xF8, 0x3F, 0x1F, 0x81, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x3E, 0xFC,
  0x01, 0xF7, 0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00,
  0x3E, 0xFC, 0x03, 0xF7, 0xE0, 0x3F, 0x1F, 0x03, 0xF0, 0xFC, 0x3F, 0x87,
  0xE0, 0x0F, 0x81, 0xF8, 0x7C, 0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x0F, 0xC0,
  0xF8, 0x7E, 0x07, 0xC3, 0xE0, 0x3E, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xDF,
  0x00, 0x3E, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x02, 0x7E,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xE0, 0x03,
  0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFF, 0xF8, 0x7F, 0xF8,
  0x7F, 0xFC, 0x3F, 0xFE, 0x00, 0x00, 0x7C, 0x07, 0xF0, 0x1F, 0xC0, 0xFE,
  0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x03, 0xE0, 0x7F, 0x81, 0xFC, 0x0F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0xC0, 0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xF8,
  0x07, 0xF0, 0x07, 0xC0, 0xFE, 0x07, 0xF8, 0x1F, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x03, 0xFC, 0x0F, 0xE0,
  0x3F, 0x00, 0xF8, 0x00, 0x7E, 0x03, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x3F, 0xF0, 0x1F, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBoldItalic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 11, 24, 10, 0, -24 },
  { 34, 13, 9, 15, 3, -24 },
  { 49, 21, 24, 20, 0, -24 },
  { 112, 17, 28, 18, 1, -26 },
  { 172, 26, 25, 28, 2, -25 },
  { 254, 22, 25, 22, 0, -25 },
  { 323, 7, 9, 8, 3, -24 },
  { 331, 13, 30, 11, 1, -25 },
  { 380, 12, 30, 11, -2, -25 },
  { 425, 15, 16, 17, 3, -26 },
  { 455, 15, 16, 18, 2, -20 },
  { 485, 9, 8, 9, -2, -4 },
  { 494, 10, 4, 11, 0, -11 },
  { 499, 6, 6, 9, 0, -6 },
  { 504, 19, 25, 14, -2, -25 },
  { 564, 17, 25, 18, 1, -25 },
  { 618, 13, 24, 18, 3, -24 },
  { 657, 18, 25, 18, -1, -25 },
  { 714, 17, 25, 18, 0, -25 },
  { 768, 18, 24, 18, 0, -24 },
  { 822, 18, 24, 18, 0, -24 },
  { 876, 17, 25, 18, 1, -25 },
  { 930, 18, 24, 18, 1, -24 },
  { 984, 17, 25, 18, 1, -25 },
  { 1038, 16, 25, 18, 1, -25 },
  { 1088, 9, 19, 10, 0, -19 },
  { 1110, 11, 23, 10, -2, -19 },
  { 1142, 15, 18, 18, 2, -21 },
  { 1176, 15, 11, 18, 2, -17 },
  { 1197, 15, 18, 18, 2, -21 },
  { 1231, 14, 25, 15, 2, -25 },
  { 1275, 26, 27, 27, 1, -24 },
  { 1363, 20, 24, 20, -2, -24 },
  { 1423, 20, 24, 20, 0, -24 },
  { 1483, 19, 25, 19, 2, -25 },
  { 1543, 21, 24, 21, 0, -24 },
  { 1606, 18, 24, 17, 0, -24 },
  { 1660, 18, 24, 17, 0, -24 },
  { 1714, 20, 25, 22, 2, -25 },
  { 1777, 23, 24, 22, 0, -24 },
  { 1846, 16, 24, 13, -1, -24 },
  { 1894, 16, 31, 11, -5, -24 },
  { 1956, 23, 24, 20, 0, -24 },
  { 2025, 14, 24, 16, 0, -24 },
  { 2067, 29, 24, 28, 0, -24 },
  { 2154, 24, 24, 24, 0, -24 },
  { 2226, 20, 25, 23, 2, -25 },
  { 2289, 19, 24, 19, 0, -24 },
  { 2346, 20, 31, 23, 2, -25 },
  { 2424, 19, 24, 20, 0, -24 },
  { 2481, 18, 25, 17, 0, -25 },
  { 2538, 16, 24, 17, 3, -24 },
  { 2586, 20, 24, 22, 2, -24 },
  { 2646, 19, 24, 19, 3, -24 },
  { 2703, 29, 24, 29, 3, -24 },
  { 2790, 24, 24, 19, -2, -24 },
  { 2862, 18, 24, 18, 3, -24 },
  { 2916, 20, 24, 17, -1, -24 },
  { 2976, 14, 31, 11, -1, -25 },
  { 3031, 8, 25, 14, 4, -25 },
  { 3056, 14, 31, 11, -2, -25 },
  { 3111, 17, 15, 17, 0, -24 },
  { 3143, 14, 3, 14, -3, 3 },
  { 3149, 7, 5, 11, 5, -26 },
  { 3154, 18, 19, 19, 1, -19 },
  { 3197, 18, 26, 19, 0, -26 },
  { 3256, 15, 19, 15, 1, -19 },
  { 3292, 19, 26, 19, 1, -26 },
  { 3354, 16, 19, 18, 1, -19 },
  { 3392, 20, 34, 12, -4, -26 },
  { 3477, 19, 27, 19, 0, -19 },
  { 3542, 18, 26, 19, 0, -26 },
  { 3601, 11, 26, 10, 0, -26 },
  { 3637, 15, 34, 10, -4, -26 },
  { 3701, 20, 26, 18, 0, -26 },
  { 3766, 11, 26, 10, 0, -26 },
  { 3802, 27, 19, 28, 0, -19 },
  { 3867, 18, 19, 19, 0, -19 },
  { 3910, 16, 19, 19, 1, -19 },
  { 3948, 20, 27, 19, -2, -19 },
  { 4016, 18, 27, 19, 1, -19 },
  { 4077, 15, 19, 13, 0, -19 },
  { 4113, 15, 19, 15, 0, -19 },
  { 4149, 13, 23, 13, 1, -23 },
  { 4187, 18, 19, 19, 1, -19 },
  { 4230, 17, 19, 17, 2, -19 },
  { 4271, 25, 19, 25, 2, -19 },
  { 4331, 21, 19, 17, -2, -19 },
  { 4381, 21, 27, 17, -2, -19 },
  { 4452, 17, 19, 15, -1, -19 },
  { 4493, 14, 29, 12, 0, -24 },
  { 4544, 4, 34, 17, 6, -26 },
  { 4561, 14, 29, 12, -2, -24 },
  { 4612, 15, 6, 18, 2, -15 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBoldItalic34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBoldItalic34pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBoldItalic34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC34PT7B_H_
