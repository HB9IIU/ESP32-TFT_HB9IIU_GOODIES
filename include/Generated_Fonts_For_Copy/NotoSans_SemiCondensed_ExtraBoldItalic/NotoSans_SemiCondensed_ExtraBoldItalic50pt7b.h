#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC50PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBoldItalic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBoldItalic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03,
  0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x07,
  0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x3F,
  0x80, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0x7E,
  0x00, 0x18, 0x00, 0x7F, 0x8F, 0xEF, 0xF3, 0xFD, 0xFC, 0x7F, 0x3F, 0x8F,
  0xE7, 0xF1, 0xFC, 0xFC, 0x3F, 0x9F, 0x87, 0xE7, 0xF0, 0xFC, 0xFE, 0x3F,
  0x9F, 0x87, 0xE3, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F, 0x83, 0xF0, 0x00, 0x07,
  0xE1, 0xF0, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x7E, 0x1F,
  0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x1F, 0x80,
  0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x03, 0xE1, 0xF8, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x87, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xC2, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x7C,
  0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x07, 0xE1,
  0xF0, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x1F,
  0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x83, 0xFC, 0xE7, 0x81, 0xFC, 0xF0, 0x40, 0xFE, 0x70, 0x00, 0x7F,
  0x38, 0x00, 0x3F, 0xDC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1D, 0xFE,
  0x00, 0x1E, 0xFF, 0x00, 0x0E, 0x7F, 0x98, 0x07, 0x3F, 0xCF, 0x03, 0x9F,
  0xC7, 0xF1, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0xF0, 0x00, 0xFC,
  0x03, 0xFF, 0x80, 0x0F, 0xC0, 0x3F, 0xFE, 0x00, 0xFC, 0x03, 0xFF, 0xF0,
  0x07, 0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0x01, 0xFC, 0x7E, 0x07, 0xE0, 0x0F,
  0xC3, 0xF0, 0x3F, 0x00, 0x7E, 0x1F, 0x83, 0xF0, 0x07, 0xF1, 0xF8, 0x3F,
  0x00, 0x3F, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x7E, 0x1F, 0x80, 0x0F, 0xC3,
  0xF1, 0xF8, 0x00, 0x7E, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0xFC, 0x3F,
  0x1F, 0x8F, 0xCF, 0xC7, 0xFC, 0xFC, 0xFE, 0x7E, 0x7F, 0xF7, 0xFF, 0xE7,
  0xE7, 0xFF, 0xFF, 0xFE, 0x7E, 0x7F, 0xFE, 0xFF, 0xF3, 0xF3, 0xFB, 0xF3,
  0xFF, 0x3F, 0x3F, 0x9F, 0x8F, 0xE3, 0xF1, 0xF8, 0xFC, 0x00, 0x1F, 0x8F,
  0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE1, 0xF8, 0x00,
  0xFC, 0x3F, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x7E, 0x00, 0xFC, 0x0F, 0xC7,
  0xF0, 0x07, 0xE0, 0x7E, 0x3F, 0x00, 0x7E, 0x03, 0xF1, 0xF8, 0x07, 0xE0,
  0x1F, 0x9F, 0xC0, 0x3F, 0x00, 0xFF, 0xFC, 0x03, 0xF0, 0x07, 0xFF, 0xC0,
  0x3F, 0x00, 0x1F, 0xFE, 0x01, 0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0x80, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x3F, 0x80, 0x03, 0xFC,
  0x3F, 0x80, 0x03, 0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFC,
  0xFF, 0x00, 0x01, 0xFD, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0x03, 0xFF,
  0xC0, 0xFE, 0x0F, 0xFF, 0xC1, 0xFE, 0x1F, 0xFF, 0xE1, 0xFE, 0x3F, 0xFF,
  0xE3, 0xFC, 0x7F, 0xDF, 0xF3, 0xFC, 0x7F, 0x8F, 0xF7, 0xF8, 0xFF, 0x8F,
  0xFF, 0xF8, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0x03,
  0xFF, 0xE0, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x87,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xDF, 0xF0, 0x0F, 0xFE,
  0x1F, 0xF8, 0x00, 0x40, 0x00, 0x00, 0x7F, 0xBF, 0xDF, 0xCF, 0xE7, 0xF3,
  0xF9, 0xF9, 0xFC, 0xFE, 0x7E, 0x3F, 0x1F, 0x8F, 0xC0, 0x00, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07,
  0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x1F, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0x3E, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x20, 0x7E, 0x00, 0xE1, 0xF8, 0x07, 0xE7, 0xE0,
  0x1F, 0xFF, 0x01, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x3F, 0xDF, 0x01, 0xFE, 0x7E, 0x03, 0xF9, 0xF8, 0x07, 0xC7, 0xF0,
  0x0E, 0x0F, 0xE0, 0x18, 0x3E, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xF8, 0x7F,
  0x83, 0xFC, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x81,
  0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF,
  0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x80, 0x1F, 0x3F, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x18, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0x7F, 0x87, 0xF8, 0x3F, 0xC7, 0xF8, 0x1F, 0xE3, 0xFC, 0x0F, 0xF3, 0xFE,
  0x07, 0xF9, 0xFE, 0x03, 0xFC, 0xFF, 0x01, 0xFE, 0x7F, 0x80, 0xFF, 0x7F,
  0x80, 0xFF, 0x3F, 0xC0, 0x7F, 0x9F, 0xE0, 0x3F, 0xCF, 0xF0, 0x1F, 0xE7,
  0xF8, 0x0F, 0xF3, 0xFC, 0x0F, 0xF9, 0xFC, 0x07, 0xF9, 0xFE, 0x03, 0xFC,
  0xFF, 0x03, 0xFE, 0x7F, 0x81, 0xFE, 0x3F, 0xC0, 0xFF, 0x0F, 0xE0, 0xFF,
  0x07, 0xF8, 0xFF, 0x83, 0xFC, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE1, 0xFF,
  0xFE, 0x3F, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFB, 0xFC, 0x3E,
  0x3F, 0xC1, 0xC3, 0xF8, 0x10, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xE0,
  0xFF, 0x00, 0xE0, 0x3F, 0xC0, 0x30, 0x0F, 0xF0, 0x08, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xDF, 0xFC, 0x07, 0x01, 0xFF, 0x00, 0x80,
  0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE2,
  0x00, 0x0F, 0xF8, 0xC0, 0x07, 0xFE, 0x3E, 0x07, 0xFF, 0x0F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xF7, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0x7E, 0xFE, 0x00, 0x3F, 0x3F, 0x80, 0x1F, 0xDF, 0xE0, 0x07, 0xE7,
  0xF8, 0x03, 0xF1, 0xFE, 0x01, 0xF8, 0x7F, 0x00, 0xFE, 0x3F, 0xC0, 0x7F,
  0x0F, 0xF0, 0x1F, 0x83, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x10, 0x00, 0xFF, 0x8C, 0x00, 0xFF,
  0x87, 0xC1, 0xFF, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0x1C,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xFC, 0x10, 0x01, 0xFC, 0xFF, 0x01, 0xFE, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0x1F, 0xF8, 0x7F, 0x8F, 0xF8, 0x3F, 0xC7, 0xFC, 0x1F, 0xE3, 0xFC,
  0x0F, 0xF1, 0xFE, 0x07, 0xF8, 0xFF, 0x03, 0xFC, 0x7F, 0x81, 0xFE, 0x3F,
  0xC0, 0xFF, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xFC, 0x7F, 0xC1,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F,
  0xE1, 0xFE, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0x3F, 0x87, 0xF8, 0x3F, 0xC3,
  0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xE0, 0x7F, 0x8F, 0xF0, 0x3F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0x3F,
  0xE1, 0xFF, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0xFF, 0x01, 0xFE, 0x7F, 0x80,
  0xFF, 0x3F, 0xC0, 0x7F, 0x9F, 0xE0, 0x3F, 0xCF, 0xF0, 0x3F, 0xC7, 0xF8,
  0x1F, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xE1, 0xFE,
  0x3F, 0xC1, 0xFE, 0x3F, 0xC0, 0xFE, 0x7F, 0x80, 0xFE, 0x7F, 0x80, 0xFF,
  0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x83, 0xFE,
  0x7F, 0xC7, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE,
  0x3F, 0xFD, 0xFC, 0x1F, 0xFB, 0xFC, 0x0F, 0xF3, 0xFC, 0x03, 0xC3, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xE0, 0x80, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0xE0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC,
  0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x01, 0xFE, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE,
  0x0F, 0xF0, 0x1F, 0x80, 0x18, 0x00, 0x00, 0x1E, 0x00, 0x3F, 0x80, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x3F, 0x9F, 0xF1, 0xC0, 0xFF, 0x10, 0x07, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x07, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x7E, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x7F, 0x00, 0x60, 0x0F, 0xC3, 0xF0, 0x3F, 0xFC, 0x7E,
  0x3F, 0x03, 0xFF, 0xF1, 0xF1, 0xF0, 0x3F, 0xFF, 0x0F, 0x9F, 0x83, 0xFF,
  0xF8, 0x7C, 0xF8, 0x3F, 0x8F, 0xC3, 0xEF, 0xC3, 0xF0, 0x7C, 0x1F, 0x7E,
  0x1F, 0x83, 0xE0, 0xFB, 0xE1, 0xF8, 0x3F, 0x07, 0xFF, 0x0F, 0xC1, 0xF8,
  0x3F, 0xF8, 0x7C, 0x0F, 0x83, 0xFF, 0xC7, 0xE0, 0x7C, 0x1F, 0xFC, 0x3F,
  0x07, 0xE0, 0xFB, 0xE1, 0xF8, 0x3F, 0x0F, 0xDF, 0x0F, 0xC3, 0xF8, 0x7C,
  0xF8, 0x7E, 0x1F, 0x87, 0xE7, 0xC3, 0xF1, 0xFE, 0x7E, 0x3E, 0x1F, 0xFF,
  0xFF, 0xF1, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xC3, 0xFF, 0x7F, 0xF0, 0x7E,
  0x0F, 0xF1, 0xFE, 0x01, 0xF8, 0x1E, 0x03, 0xC0, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x02, 0x00, 0x0F, 0xF8,
  0x00, 0x70, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xF7, 0xF0,
  0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFF, 0x7F, 0x00, 0x03, 0xF9, 0xFC, 0x00,
  0x1F, 0xE7, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xFC, 0x7F, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x7F, 0x87, 0xF0, 0x01, 0xFE, 0x1F, 0xC0, 0x0F, 0xF0,
  0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F,
  0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0x8F, 0xF0,
  0x00, 0xFE, 0x3F, 0xC0, 0x03, 0xF9, 0xFF, 0x00, 0x0F, 0xE7, 0xF8, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xC1, 0xFF, 0x07, 0xF8, 0x1F,
  0xF0, 0x7F, 0x81, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07,
  0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFE, 0x0F, 0xF8, 0x3F, 0xC0,
  0x7F, 0x83, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x83, 0xFC, 0x07, 0xF8,
  0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF8, 0x7F, 0x81, 0xFF, 0x07, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3C, 0x0F, 0xFC, 0x00, 0x80, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x18, 0x07, 0xFF, 0x9F, 0x80, 0x3F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F,
  0x87, 0xFE, 0x07, 0xFC, 0x1F, 0xF8, 0x3F, 0xC0, 0x7F, 0xC1, 0xFE, 0x03,
  0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0x87, 0xF8, 0x03, 0xFC,
  0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x7F,
  0x80, 0x7F, 0xC7, 0xF8, 0x03, 0xFE, 0x3F, 0xC0, 0x1F, 0xF1, 0xFE, 0x00,
  0xFF, 0x0F, 0xF0, 0x0F, 0xF8, 0xFF, 0x80, 0x7F, 0xC7, 0xF8, 0x03, 0xFC,
  0x3F, 0xC0, 0x3F, 0xE1, 0xFE, 0x03, 0xFF, 0x0F, 0xF0, 0x1F, 0xF0, 0xFF,
  0x83, 0xFF, 0x07, 0xF8, 0x3F, 0xF8, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xC0, 0x38, 0x0F, 0xFE, 0x00, 0x20,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xC1, 0xFF, 0xF1, 0xFE, 0x07, 0xFF, 0xC7, 0xF8, 0x3F,
  0xFE, 0x1F, 0xE0, 0xFF, 0xF8, 0x7F, 0x83, 0xFF, 0xE3, 0xFE, 0x0F, 0xFF,
  0x8F, 0xF8, 0x01, 0xFE, 0x3F, 0xE0, 0x0F, 0xF0, 0xFF, 0x80, 0x3F, 0xC3,
  0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xF0, 0x0F, 0xF0, 0x7F,
  0xE0, 0x7F, 0x81, 0xFF, 0xE3, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x03, 0xFE, 0x01,
  0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x01,
  0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xF8, 0x03,
  0xFC, 0x07, 0xF8, 0x03, 0xFC, 0x07, 0xF8, 0x03, 0xFC, 0x07, 0xF8, 0x03,
  0xFC, 0x0F, 0xF8, 0x07, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x3F, 0xE0, 0x1F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x3F, 0xC0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x1F, 0xE0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0xC0, 0x3F,
  0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x3F,
  0xC0, 0x7F, 0x80, 0x7F, 0xC0, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x7F,
  0x80, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80,
  0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x01, 0x07,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0x80, 0xFF,
  0x80, 0x7F, 0x80, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0x80, 0x1F, 0xE0, 0xFF,
  0xC0, 0x0F, 0xF0, 0x7F, 0xC0, 0x07, 0xF8, 0x7F, 0xC0, 0x07, 0xF8, 0x7F,
  0xC0, 0x03, 0xFC, 0x7F, 0xC0, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0x3F,
  0xE0, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x3F, 0xDF,
  0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xDF, 0xE0, 0x00, 0x7F,
  0x8F, 0xF0, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x07, 0xF8, 0x3F, 0xE0, 0x03,
  0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x03, 0xFE, 0x00,
  0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x07,
  0xFF, 0x80, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x03, 0xFF, 0xE0,
  0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xDF,
  0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0x7E, 0x07, 0xEF, 0xE0, 0x3F,
  0xBF, 0x03, 0xF7, 0xF0, 0x1F, 0xDF, 0x83, 0xFB, 0xF8, 0x0F, 0xEF, 0xC1,
  0xFB, 0xFC, 0x07, 0xF7, 0xE1, 0xFD, 0xFE, 0x07, 0xFB, 0xF0, 0xFC, 0xFE,
  0x03, 0xF9, 0xF8, 0xFE, 0x7F, 0x01, 0xFC, 0xFC, 0x7E, 0x3F, 0x80, 0xFE,
  0x7E, 0x7F, 0x3F, 0xC0, 0xFF, 0x3F, 0x3F, 0x1F, 0xE0, 0x7F, 0x9F, 0xBF,
  0x8F, 0xE0, 0x3F, 0x8F, 0xDF, 0x87, 0xF0, 0x1F, 0xC7, 0xFF, 0xC7, 0xF8,
  0x0F, 0xE3, 0xFF, 0xC3, 0xFC, 0x0F, 0xF1, 0xFF, 0xE1, 0xFC, 0x07, 0xF0,
  0xFF, 0xE0, 0xFE, 0x03, 0xF8, 0x7F, 0xF0, 0x7F, 0x01, 0xFC, 0x3F, 0xF8,
  0x7F, 0x80, 0xFE, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xFC, 0x1F, 0xC0,
  0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x1F, 0xC0,
  0xFE, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x3F, 0xF0, 0x03,
  0xFC, 0x07, 0xFE, 0x00, 0x7F, 0x01, 0xFF, 0xC0, 0x0F, 0xE0, 0x3F, 0xF8,
  0x01, 0xFC, 0x07, 0xFF, 0x80, 0x3F, 0x80, 0xFF, 0xF0, 0x0F, 0xF0, 0x1F,
  0xFE, 0x01, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0x80, 0xFF, 0xFC, 0x07, 0xF0,
  0x1F, 0xFF, 0x81, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xC0, 0x7E, 0xFF, 0x07,
  0xF0, 0x1F, 0xDF, 0xE0, 0xFE, 0x03, 0xF9, 0xFC, 0x1F, 0xC0, 0x7F, 0x3F,
  0x87, 0xF8, 0x0F, 0xE7, 0xF8, 0xFF, 0x01, 0xFC, 0xFF, 0x1F, 0xC0, 0x7F,
  0x8F, 0xE3, 0xF8, 0x0F, 0xE1, 0xFC, 0x7F, 0x01, 0xFC, 0x3F, 0xDF, 0xE0,
  0x3F, 0x87, 0xFB, 0xF8, 0x0F, 0xF0, 0x7F, 0x7F, 0x01, 0xFE, 0x0F, 0xEF,
  0xE0, 0x3F, 0x81, 0xFF, 0xFC, 0x07, 0xF0, 0x1F, 0xFF, 0x80, 0xFE, 0x03,
  0xFF, 0xE0, 0x3F, 0xC0, 0x7F, 0xFC, 0x07, 0xF8, 0x0F, 0xFF, 0x80, 0xFE,
  0x00, 0xFF, 0xF0, 0x1F, 0xC0, 0x1F, 0xFE, 0x03, 0xF8, 0x03, 0xFF, 0x80,
  0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xC0, 0x07, 0xFE, 0x03, 0xF8, 0x00, 0xFF,
  0xC0, 0x7F, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0x83, 0xFF,
  0x0F, 0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xF1, 0xFF, 0x00, 0x3F, 0xC7,
  0xFC, 0x00, 0xFF, 0x3F, 0xE0, 0x03, 0xFC, 0xFF, 0x80, 0x0F, 0xF3, 0xFC,
  0x00, 0x3F, 0xDF, 0xF0, 0x00, 0xFF, 0x7F, 0xC0, 0x03, 0xFD, 0xFE, 0x00,
  0x0F, 0xF7, 0xF8, 0x00, 0x7F, 0xDF, 0xE0, 0x01, 0xFF, 0x7F, 0x80, 0x07,
  0xFB, 0xFE, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0xFF, 0xBF, 0xE0, 0x03, 0xFE,
  0xFF, 0x80, 0x1F, 0xF3, 0xFE, 0x00, 0x7F, 0xC7, 0xF8, 0x03, 0xFE, 0x1F,
  0xE0, 0x1F, 0xF8, 0x7F, 0xC0, 0xFF, 0xC1, 0xFF, 0xEF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xE0, 0x3F, 0xC3, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0x81, 0xFF,
  0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x81, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF,
  0x01, 0xFE, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x03, 0xFE, 0x0F, 0xF0, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0x83,
  0xFF, 0x0F, 0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xF1, 0xFF, 0x00, 0x3F,
  0xC7, 0xFC, 0x00, 0xFF, 0x3F, 0xE0, 0x03, 0xFC, 0xFF, 0x80, 0x0F, 0xF3,
  0xFC, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0xFF, 0x7F, 0xC0, 0x03, 0xFD, 0xFE,
  0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x7F, 0xDF, 0xE0, 0x01, 0xFF, 0x7F, 0x80,
  0x07, 0xFB, 0xFE, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0xFF, 0xBF, 0xE0, 0x03,
  0xFE, 0xFF, 0x80, 0x1F, 0xF3, 0xFE, 0x00, 0x7F, 0xC7, 0xF8, 0x03, 0xFE,
  0x1F, 0xE0, 0x1F, 0xF8, 0x7F, 0xC0, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x1F, 0xE1, 0xFF, 0x07,
  0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F,
  0xF0, 0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0x7F, 0xC3, 0xFC, 0x1F, 0xF0, 0x7F,
  0x87, 0xFE, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xC7, 0xF8, 0x07, 0xF8, 0xFF, 0x80,
  0xFF, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x03,
  0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF8, 0xFF, 0x01, 0xFF, 0x1F,
  0xE0, 0x1F, 0xE3, 0xFC, 0x03, 0xFE, 0x7F, 0x80, 0x7F, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xF0, 0x3C,
  0x07, 0xF8, 0x02, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC1, 0x00, 0x1F, 0xF0, 0x70, 0x0F, 0xF8, 0x1F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0x80, 0x7F, 0x83, 0xFC,
  0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xE0, 0xFF, 0x00,
  0xFF, 0x07, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F,
  0xC1, 0xFE, 0x01, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0,
  0xFF, 0x00, 0x7F, 0x83, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F,
  0xC0, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0,
  0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0x83, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x07,
  0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x83, 0xFC, 0x03, 0xFC,
  0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0x83, 0xFE, 0x03,
  0xFF, 0xBF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x03, 0xFE, 0x7F, 0x00, 0x3F, 0xC7,
  0xF0, 0x03, 0xFC, 0x7F, 0x00, 0x7F, 0x87, 0xF0, 0x07, 0xF8, 0x7F, 0x00,
  0xFF, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x01, 0xFE, 0x07, 0xF0, 0x1F, 0xE0,
  0x7F, 0x03, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x83, 0xFC, 0x07, 0xF8,
  0x7F, 0x80, 0x7F, 0x87, 0xF8, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x8F, 0xF0,
  0x07, 0xF9, 0xFE, 0x00, 0x7F, 0x9F, 0xE0, 0x07, 0xFB, 0xFC, 0x00, 0x3F,
  0xBF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x00, 0x3F, 0x7F, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x3F, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xF0, 0x07, 0xFB, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xCF, 0xF0, 0x0F,
  0xF8, 0x07, 0xF9, 0xFE, 0x01, 0xFF, 0x00, 0xFE, 0x3F, 0xC0, 0x7F, 0xE0,
  0x3F, 0xC7, 0xF8, 0x0F, 0xFC, 0x07, 0xF8, 0xFF, 0x03, 0xFF, 0x81, 0xFE,
  0x1F, 0xE0, 0x7F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xFE, 0x07, 0xF0, 0x7F,
  0x83, 0xFF, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0xF8, 0x3F, 0xC1, 0xFE, 0x1F,
  0xFF, 0x0F, 0xF0, 0x3F, 0xC3, 0xF7, 0xE1, 0xFE, 0x07, 0xF8, 0xFF, 0xFC,
  0x3F, 0x80, 0xFF, 0x1F, 0xFF, 0x8F, 0xF0, 0x1F, 0xE3, 0xF7, 0xF1, 0xFC,
  0x03, 0xFC, 0xFE, 0xFE, 0x7F, 0x80, 0x7F, 0x9F, 0x9F, 0xCF, 0xF0, 0x0F,
  0xF7, 0xF3, 0xF9, 0xFC, 0x01, 0xFC, 0xFE, 0x7F, 0x7F, 0x80, 0x3F, 0x9F,
  0x8F, 0xEF, 0xE0, 0x07, 0xF7, 0xF1, 0xFD, 0xFC, 0x00, 0xFE, 0xFC, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0xFF, 0xFC,
  0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x01,
  0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x07, 0xFC, 0x0F, 0xF0,
  0x00, 0x7F, 0x83, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x01, 0xFE, 0x1F,
  0xE0, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x7F,
  0xBF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x07, 0xF8, 0xFF, 0x00,
  0x01, 0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0x7F,
  0xC0, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x3F, 0xE0,
  0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x7F,
  0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xEF, 0xF0, 0x07, 0xF9, 0xFE,
  0x01, 0xFF, 0x3F, 0xC0, 0x3F, 0xC7, 0xF8, 0x0F, 0xF8, 0x7F, 0x03, 0xFE,
  0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x1F, 0xF0, 0x3F, 0xC3, 0xFC, 0x07, 0xF8,
  0xFF, 0x00, 0x7F, 0x1F, 0xE0, 0x0F, 0xE7, 0xF8, 0x01, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFE, 0x0F,
  0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0xFE,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xBF, 0x00, 0x1F,
  0x9F, 0x80, 0x1F, 0x8F, 0xC0, 0x1F, 0xC7, 0xE0, 0x0F, 0xC1, 0xF8, 0x0F,
  0xC0, 0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x3F, 0x07, 0xF0, 0x0F, 0xC7,
  0xF0, 0x07, 0xE3, 0xF0, 0x03, 0xF3, 0xF8, 0x01, 0xFB, 0xF8, 0x00, 0x7E,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0x8F, 0xF0, 0xFE, 0x1F, 0xE1, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x00, 0x7C,
  0x00, 0x00, 0xFF, 0x8F, 0xC0, 0xFF, 0xEF, 0xE0, 0xFF, 0xF7, 0xF0, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0xC3, 0xFE, 0x3F,
  0xC1, 0xFF, 0x3F, 0xE0, 0xFF, 0x9F, 0xE0, 0x7F, 0x8F, 0xF0, 0x3F, 0xCF,
  0xF8, 0x1F, 0xE7, 0xF8, 0x0F, 0xF3, 0xFC, 0x07, 0xF1, 0xFE, 0x03, 0xF8,
  0xFF, 0x03, 0xFC, 0x7F, 0x81, 0xFE, 0x3F, 0xC0, 0xFF, 0x1F, 0xE0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x87, 0xFC, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFD, 0xFC, 0x03, 0xF8,
  0xFE, 0x00, 0x20, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC7, 0xC0, 0x0F, 0xF7, 0xF8, 0x03, 0xFB, 0xFF, 0x01,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xC1, 0xFF, 0x1F, 0xF0, 0xFF, 0x83, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0,
  0x3F, 0xC3, 0xF8, 0x0F, 0xF0, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x1F,
  0xE0, 0x7F, 0xC7, 0xF0, 0x1F, 0xE1, 0xFC, 0x07, 0xF8, 0x7F, 0x01, 0xFE,
  0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x1F, 0xF0, 0xFF, 0x8F,
  0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0x7E, 0x7F, 0xE0, 0x3F, 0x8F, 0xF0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xF8, 0x08, 0x3F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x83, 0xFE, 0x0E,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x7C, 0x3F, 0x80, 0x1F,
  0xF7, 0xF8, 0x03, 0xFF, 0x7F, 0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0x3F,
  0xC1, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x7F, 0x80, 0xFE, 0x07, 0xF8, 0x1F,
  0xE0, 0xFF, 0x81, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x01, 0xFC, 0x0F,
  0xF0, 0x1F, 0xC0, 0xFF, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xF8, 0xFF, 0x80,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x07, 0xFF,
  0xBF, 0x00, 0x3F, 0xF3, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC7, 0xFC, 0x7F, 0x9F, 0xE0, 0x7F,
  0x3F, 0xC0, 0xFE, 0xFF, 0x03, 0xFD, 0xFE, 0x0F, 0xFB, 0xFC, 0x7F, 0xEF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF,
  0xFE, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x02, 0x1F, 0xF0, 0x0C, 0x3F, 0xFB, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xFC, 0x40, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0xF8, 0xFC, 0x03, 0xFF, 0xBF, 0x80, 0xFF, 0xF7, 0xF0, 0x3F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F,
  0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x3F,
  0xC3, 0xFE, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xE1, 0xFE,
  0x03, 0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC,
  0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x3F, 0xE0, 0x7F, 0xCF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xBF, 0x80,
  0x3F, 0xEF, 0xF0, 0x03, 0xF9, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0xC0, 0x0F, 0xF0, 0x1F,
  0x07, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC7, 0xC0, 0x0F,
  0xE7, 0xFC, 0x03, 0xFB, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0x0F, 0xF0, 0xFF, 0x83,
  0xFC, 0x3F, 0xE0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF,
  0x03, 0xF8, 0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0x7F, 0x87, 0xF8, 0x1F, 0xE1,
  0xFE, 0x07, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F,
  0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x7F, 0x81, 0xFE, 0x1F, 0xE0,
  0x7F, 0x87, 0xF8, 0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0x7F, 0x01, 0xFE, 0x3F,
  0xC0, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07,
  0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F,
  0x80, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x40, 0xFF, 0x03, 0xFE, 0x03, 0xFC,
  0x1F, 0xF0, 0x1F, 0xE0, 0xFF, 0x80, 0x7F, 0x87, 0xFC, 0x01, 0xFE, 0x1F,
  0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0xFF, 0x3F, 0xC0,
  0x03, 0xFD, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xBF, 0xC0, 0x00,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xF7,
  0xF8, 0x00, 0xFF, 0x1F, 0xE0, 0x03, 0xFC, 0x7F, 0xC0, 0x0F, 0xE1, 0xFF,
  0x00, 0x7F, 0x83, 0xFC, 0x01, 0xFE, 0x0F, 0xF8, 0x07, 0xF8, 0x3F, 0xE0,
  0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x01, 0xFF, 0x03, 0xFC, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC,
  0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80,
  0x7F, 0x80, 0xFF, 0x00, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xF1, 0xFF,
  0x07, 0xFC, 0x03, 0xF3, 0xFF, 0x8F, 0xFE, 0x07, 0xF7, 0xFF, 0x9F, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0xFC, 0x3F, 0xF0, 0xFF, 0x0F, 0xF8, 0x3F, 0xE0,
  0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0x7F,
  0x81, 0xFE, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0x7F, 0x81, 0xFE,
  0x1F, 0xE0, 0x7F, 0x03, 0xFC, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x03,
  0xF8, 0x3F, 0x80, 0xFE, 0x07, 0xF8, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x7F,
  0x81, 0xFE, 0x07, 0xF8, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x7F, 0x81, 0xFE,
  0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0xFC, 0x7F, 0xC0, 0x3F, 0x3F, 0xF8, 0x0F, 0xDF,
  0xFE, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F,
  0xF0, 0xFF, 0x0F, 0xF8, 0x3F, 0xC3, 0xFE, 0x0F, 0xF0, 0xFF, 0x03, 0xFC,
  0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0x87, 0xF8, 0x1F, 0xE1, 0xFE, 0x07,
  0xF8, 0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0x7F, 0x87, 0xF0, 0x1F, 0xC3, 0xFC,
  0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC7,
  0xF8, 0x0F, 0xE1, 0xFE, 0x07, 0xF8, 0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0x7F,
  0x87, 0xF0, 0x1F, 0xE3, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xE1, 0xFE, 0x3F, 0xC1, 0xFE, 0x7F, 0xC0,
  0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x80, 0xFF, 0xFF, 0x00, 0xFE, 0xFF, 0x01,
  0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x03,
  0xFE, 0xFF, 0x03, 0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x07, 0xF8, 0xFF, 0x8F,
  0xF8, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x0F, 0xC7, 0xF8, 0x00, 0xFC, 0xFF, 0xC0, 0x1F, 0xDF, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xBF, 0xF0, 0x1F,
  0xF0, 0xFF, 0x03, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0x80, 0xFF, 0x03, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x07,
  0xF8, 0x1F, 0xF0, 0x7F, 0x01, 0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0xFF, 0x01,
  0xFE, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x7F, 0xC0,
  0xFF, 0x8F, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFE, 0x01, 0xFD, 0xFF, 0xC0, 0x1F, 0xCF, 0xF8, 0x03, 0xFC, 0x7F, 0x00,
  0x3F, 0xC1, 0x80, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0x8F,
  0xC0, 0xFF, 0xEF, 0xE0, 0xFF, 0xF7, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0xC3, 0xFE, 0x3F, 0xC1, 0xFF, 0x3F, 0xE0,
  0x7F, 0x9F, 0xE0, 0x3F, 0x8F, 0xF0, 0x3F, 0xC7, 0xF8, 0x1F, 0xE7, 0xF8,
  0x0F, 0xF3, 0xFC, 0x07, 0xF1, 0xFE, 0x03, 0xF8, 0xFF, 0x01, 0xFC, 0x7F,
  0x81, 0xFE, 0x3F, 0xC0, 0xFF, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x87,
  0xFC, 0x7F, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFB, 0xF8, 0x0F, 0xFB, 0xFC, 0x03, 0xF9, 0xFE, 0x00, 0x20, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7C, 0x0F, 0xC7, 0xF0, 0x3F, 0x3F, 0x81, 0xFD, 0xFE, 0x07, 0xF7,
  0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFE, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0x0F, 0x07,
  0xF8, 0x08, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x80,
  0x1F, 0xE3, 0x80, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x43, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xFB,
  0xFF, 0xFE, 0x7F, 0xFF, 0xC1, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x03, 0xFE, 0x10, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F,
  0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x40, 0x00, 0x0F, 0xF0, 0x3F,
  0xC7, 0xF8, 0x0F, 0xE1, 0xFE, 0x07, 0xF8, 0x7F, 0x81, 0xFE, 0x1F, 0xE0,
  0x7F, 0x87, 0xF0, 0x1F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F,
  0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFE, 0x07, 0xF8,
  0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0x7F, 0x87, 0xF8, 0x1F, 0xE1, 0xFC, 0x0F,
  0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x7F, 0xC3, 0xFC,
  0x3F, 0xF0, 0xFF, 0x9F, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFB, 0xF0, 0x0F, 0xFC, 0xFC, 0x01, 0xFC, 0x3F,
  0x00, 0x08, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFE, 0xFE, 0x01,
  0xFE, 0xFE, 0x03, 0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x07, 0xF8, 0xFF, 0x07,
  0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7F, 0x1F, 0xE0, 0x7F, 0x1F,
  0xE0, 0x7F, 0x1F, 0xC0, 0x7F, 0x3F, 0xC0, 0x7F, 0x3F, 0x80, 0x7F, 0x7F,
  0x80, 0x7F, 0x7F, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0xFE, 0x03, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xE0, 0x7F, 0xBF, 0x81,
  0xFF, 0x03, 0xFD, 0xFC, 0x1F, 0xF8, 0x3F, 0xCF, 0xE0, 0xFF, 0xC1, 0xFE,
  0x7F, 0x07, 0xFE, 0x0F, 0xE3, 0xF8, 0x7F, 0xF0, 0xFF, 0x1F, 0xC3, 0xEF,
  0x87, 0xF0, 0xFE, 0x3F, 0x7C, 0x7F, 0x87, 0xF1, 0xFF, 0xE3, 0xF8, 0x3F,
  0x8F, 0xBF, 0x1F, 0xC1, 0xFC, 0xFD, 0xF9, 0xFE, 0x0F, 0xE7, 0xEF, 0xCF,
  0xE0, 0x7F, 0x7E, 0x7E, 0xFF, 0x03, 0xFB, 0xF3, 0xF7, 0xF0, 0x1F, 0xDF,
  0x9F, 0xBF, 0x80, 0xFF, 0xF8, 0xFF, 0xF8, 0x07, 0xFF, 0xC7, 0xFF, 0xC0,
  0x3F, 0xFC, 0x3F, 0xFC, 0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x0F, 0xFF, 0x0F,
  0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x0F,
  0xF8, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x03, 0xFE, 0x07, 0xFC,
  0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x07, 0xFE, 0x03, 0xFE,
  0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xE0, 0x07, 0xF8, 0xFF, 0x80, 0x0F, 0xF1,
  0xFE, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0x7F, 0xDF, 0xE0, 0x01, 0xFF, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F,
  0xF8, 0x7F, 0x80, 0x3F, 0xE0, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x03, 0xFF,
  0x01, 0xFE, 0x00, 0x03, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0,
  0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x01, 0xFC, 0x3F,
  0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x7F, 0x1F, 0xC0,
  0x01, 0xFC, 0xFF, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xDF, 0xE0, 0x00,
  0x7F, 0x7F, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x07,
  0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0x3F,
  0xF8, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFE, 0xC0, 0x0F, 0xFC, 0x80, 0x01, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBoldItalic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 16, 37, 14, 0, -36 },
  { 75, 19, 13, 22, 5, -36 },
  { 106, 31, 36, 30, 0, -36 },
  { 246, 25, 41, 26, 1, -38 },
  { 375, 37, 36, 42, 3, -36 },
  { 542, 32, 37, 33, 1, -36 },
  { 690, 9, 13, 12, 5, -36 },
  { 705, 19, 44, 16, 1, -36 },
  { 810, 19, 45, 16, -4, -37 },
  { 917, 22, 23, 25, 4, -38 },
  { 981, 24, 24, 27, 2, -30 },
  { 1053, 13, 13, 14, -3, -6 },
  { 1075, 14, 7, 16, 1, -17 },
  { 1088, 9, 9, 14, 0, -8 },
  { 1099, 27, 36, 21, -2, -36 },
  { 1221, 25, 37, 26, 1, -36 },
  { 1337, 20, 36, 26, 4, -36 },
  { 1427, 26, 36, 26, -1, -36 },
  { 1544, 26, 37, 26, 0, -36 },
  { 1665, 26, 36, 26, 0, -36 },
  { 1782, 25, 37, 26, 1, -36 },
  { 1898, 25, 37, 26, 2, -36 },
  { 2014, 28, 36, 26, 1, -36 },
  { 2140, 25, 37, 26, 1, -36 },
  { 2256, 24, 37, 26, 2, -36 },
  { 2367, 14, 29, 14, 0, -28 },
  { 2418, 17, 35, 14, -3, -28 },
  { 2493, 24, 26, 27, 2, -31 },
  { 2571, 24, 17, 27, 2, -26 },
  { 2622, 24, 26, 27, 2, -31 },
  { 2700, 20, 37, 21, 3, -36 },
  { 2793, 37, 40, 40, 2, -36 },
  { 2978, 30, 36, 30, -3, -36 },
  { 3113, 28, 36, 29, 1, -36 },
  { 3239, 28, 37, 28, 2, -36 },
  { 3369, 29, 36, 31, 1, -36 },
  { 3500, 26, 36, 25, 1, -36 },
  { 3617, 26, 36, 25, 1, -36 },
  { 3734, 30, 37, 32, 2, -36 },
  { 3873, 32, 36, 32, 1, -36 },
  { 4017, 24, 36, 19, -2, -36 },
  { 4125, 25, 47, 16, -8, -36 },
  { 4272, 33, 36, 29, 1, -36 },
  { 4421, 20, 36, 24, 1, -36 },
  { 4511, 41, 36, 41, 1, -36 },
  { 4696, 35, 36, 35, 1, -36 },
  { 4854, 30, 37, 33, 2, -36 },
  { 4993, 28, 36, 28, 1, -36 },
  { 5119, 30, 45, 33, 2, -36 },
  { 5288, 27, 36, 29, 1, -36 },
  { 5410, 26, 37, 25, 0, -36 },
  { 5531, 24, 36, 25, 4, -36 },
  { 5639, 30, 37, 32, 3, -36 },
  { 5778, 28, 36, 28, 4, -36 },
  { 5904, 43, 36, 42, 4, -36 },
  { 6098, 35, 36, 29, -3, -36 },
  { 6256, 27, 36, 27, 4, -36 },
  { 6378, 30, 36, 25, -2, -36 },
  { 6513, 22, 44, 16, -2, -36 },
  { 6634, 12, 36, 21, 5, -36 },
  { 6688, 21, 44, 16, -3, -36 },
  { 6804, 25, 23, 25, 0, -36 },
  { 6876, 21, 4, 20, -5, 4 },
  { 6887, 11, 8, 16, 7, -38 },
  { 6898, 25, 29, 28, 2, -28 },
  { 6989, 26, 39, 28, 0, -38 },
  { 7116, 22, 29, 23, 2, -28 },
  { 7196, 28, 39, 28, 2, -38 },
  { 7333, 23, 29, 26, 2, -28 },
  { 7417, 28, 50, 18, -5, -38 },
  { 7592, 27, 40, 28, 0, -28 },
  { 7727, 26, 38, 28, 0, -38 },
  { 7851, 16, 38, 14, 0, -38 },
  { 7927, 22, 50, 14, -6, -38 },
  { 8065, 30, 38, 27, 0, -38 },
  { 8208, 16, 38, 14, 0, -38 },
  { 8284, 40, 28, 42, 0, -28 },
  { 8424, 26, 28, 28, 0, -28 },
  { 8515, 24, 29, 27, 2, -28 },
  { 8602, 28, 40, 28, -2, -28 },
  { 8742, 25, 40, 28, 2, -28 },
  { 8867, 22, 28, 20, 0, -28 },
  { 8944, 22, 29, 22, 0, -28 },
  { 9024, 19, 34, 19, 2, -33 },
  { 9105, 26, 28, 28, 2, -27 },
  { 9196, 24, 27, 25, 3, -27 },
  { 9277, 37, 27, 37, 3, -27 },
  { 9402, 31, 27, 25, -3, -27 },
  { 9507, 30, 39, 25, -3, -27 },
  { 9654, 24, 27, 22, -1, -27 },
  { 9735, 21, 44, 18, 0, -36 },
  { 9851, 6, 49, 25, 9, -38 },
  { 9888, 21, 44, 18, -3, -36 },
  { 10004, 24, 9, 27, 2, -22 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBoldItalic50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBoldItalic50pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBoldItalic50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC50PT7B_H_
