#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC53PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC53PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBoldItalic.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBoldItalic53pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xF8, 0x00, 0x60, 0x00,
  0x3F, 0xC7, 0xF9, 0xFC, 0x7F, 0x8F, 0xE3, 0xFC, 0xFF, 0x1F, 0xE7, 0xF8,
  0xFE, 0x3F, 0x87, 0xF1, 0xFC, 0x3F, 0x8F, 0xE1, 0xF8, 0x7E, 0x1F, 0xC3,
  0xF0, 0xFE, 0x3F, 0x87, 0xF1, 0xFC, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F,
  0xC0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x7E, 0x1F, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F,
  0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0x80, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x1F, 0xF7, 0x7E, 0x07, 0xF9, 0xE1, 0x80, 0xFF, 0x38,
  0x00, 0x1F, 0xE7, 0x00, 0x03, 0xFC, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x73, 0xFC,
  0x00, 0x0E, 0x7F, 0x88, 0x01, 0xCF, 0xF1, 0xC0, 0x79, 0xFE, 0x3F, 0x0F,
  0x7F, 0xC7, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x07, 0xFF, 0x00, 0x0F, 0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xC0, 0x1F, 0xFF,
  0x80, 0x1F, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x3F,
  0x00, 0x3F, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0xFE, 0x00, 0x7F,
  0x1F, 0xC0, 0xFC, 0x00, 0x7E, 0x1F, 0xC1, 0xF8, 0x00, 0xFE, 0x1F, 0xC3,
  0xF8, 0x00, 0xFE, 0x1F, 0x83, 0xF0, 0x00, 0xFE, 0x1F, 0x87, 0xE0, 0x00,
  0xFC, 0x3F, 0x8F, 0xE0, 0x00, 0xFC, 0x3F, 0x8F, 0xC0, 0x00, 0xFC, 0x3F,
  0x1F, 0x87, 0xF0, 0xFC, 0x7F, 0x3F, 0x8F, 0xFC, 0xFE, 0xFF, 0x3F, 0x3F,
  0xFE, 0xFF, 0xFE, 0x7E, 0x3F, 0xFE, 0x7F, 0xFC, 0xFE, 0x7F, 0xFE, 0x7F,
  0xFC, 0xFC, 0xFF, 0x7F, 0x3F, 0xF1, 0xF8, 0xFE, 0x7F, 0x1F, 0xE3, 0xF9,
  0xFC, 0x7F, 0x00, 0x03, 0xF1, 0xFC, 0x7F, 0x00, 0x07, 0xE1, 0xF8, 0x7F,
  0x00, 0x0F, 0xE1, 0xF8, 0x7F, 0x00, 0x0F, 0xC3, 0xF8, 0x7F, 0x00, 0x1F,
  0x83, 0xF8, 0x7E, 0x00, 0x3F, 0x83, 0xF8, 0x7E, 0x00, 0x3F, 0x03, 0xF0,
  0xFE, 0x00, 0x7E, 0x03, 0xF0, 0xFE, 0x00, 0xFE, 0x03, 0xF1, 0xFC, 0x00,
  0xFC, 0x03, 0xF9, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xF8, 0x03, 0xF8, 0x01,
  0xFF, 0xF8, 0x03, 0xF0, 0x01, 0xFF, 0xF0, 0x07, 0xE0, 0x00, 0xFF, 0xE0,
  0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x07,
  0xF8, 0x7F, 0x80, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x07, 0xF8, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x01, 0xFE, 0x7F, 0xC0,
  0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x1F, 0xF0, 0x3F, 0xFE,
  0x07, 0xF8, 0x1F, 0xFF, 0x81, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0x0F, 0xFF,
  0xFC, 0x3F, 0xC3, 0xFE, 0xFF, 0x9F, 0xF1, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF,
  0x87, 0xFF, 0xFC, 0x3F, 0xE1, 0xFF, 0xFF, 0x0F, 0xF0, 0x3F, 0xFF, 0x83,
  0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xC0, 0x3F, 0xF8,
  0x0F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xCF, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x03,
  0x00, 0x00, 0x00, 0x3F, 0xCF, 0xE3, 0xF9, 0xFE, 0x7F, 0x9F, 0xC7, 0xF1,
  0xFC, 0x7E, 0x1F, 0x8F, 0xE3, 0xF8, 0xFC, 0x3F, 0x00, 0x00, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x30, 0x3F, 0x80, 0x38, 0x3F, 0x00, 0x3E,
  0x3F, 0x00, 0x7F, 0xBF, 0x00, 0x7F, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03,
  0xFF, 0x07, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x3F, 0xEF, 0xC0, 0x7F,
  0xCF, 0xC0, 0x3F, 0x8F, 0xE0, 0x0F, 0x8F, 0xE0, 0x07, 0x07, 0xF0, 0x02,
  0x07, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xF8, 0x3F, 0xC3, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F,
  0xF0, 0x7F, 0x83, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0,
  0x7F, 0x00, 0x7F, 0xFE, 0xFF, 0xF9, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xDF,
  0xFF, 0xBF, 0xFE, 0x00, 0x06, 0x0F, 0xE7, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFE, 0x7F, 0x06, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x1F, 0xF1, 0xFF,
  0x0F, 0xF0, 0x7F, 0x8F, 0xF8, 0x3F, 0xC7, 0xF8, 0x1F, 0xE7, 0xFC, 0x0F,
  0xF3, 0xFE, 0x07, 0xF9, 0xFE, 0x03, 0xFD, 0xFF, 0x01, 0xFE, 0xFF, 0x80,
  0xFF, 0x7F, 0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF0, 0x0F, 0xF7, 0xF8, 0x07, 0xFB, 0xFC, 0x07, 0xFD, 0xFE,
  0x03, 0xFE, 0xFF, 0x01, 0xFE, 0x7F, 0x81, 0xFF, 0x3F, 0xC0, 0xFF, 0x9F,
  0xE0, 0x7F, 0x8F, 0xF0, 0x7F, 0xC7, 0xF8, 0x3F, 0xE3, 0xFC, 0x3F, 0xE1,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0,
  0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF,
  0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0x7F, 0x87, 0xF3, 0xFC, 0x1E,
  0x1F, 0xE0, 0xE1, 0xFF, 0x02, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xC3, 0xFF, 0x00, 0x78,
  0x0F, 0xF8, 0x03, 0x80, 0x7F, 0xC0, 0x08, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x07,
  0x01, 0xFF, 0x00, 0x80, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF1, 0x00, 0x03, 0xFE, 0x38, 0x00, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x50, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0x7F, 0x80, 0x07, 0xF7, 0xF8,
  0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xCF, 0xF0, 0x01, 0xFC, 0xFF, 0x00, 0x3F,
  0x8F, 0xF0, 0x07, 0xF0, 0xFF, 0x00, 0xFE, 0x1F, 0xE0, 0x0F, 0xE1, 0xFE,
  0x01, 0xFC, 0x1F, 0xE0, 0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x3F, 0xE0, 0x7F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE1, 0x00, 0x0F, 0xFC, 0x38, 0x03, 0xFF, 0x87, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x3F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x87, 0xC0, 0x0F,
  0xF3, 0xFE, 0x01, 0xFE, 0xFF, 0xE0, 0x7F, 0xBF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x8F, 0xFE, 0x1F, 0xF1, 0xFF,
  0x83, 0xFE, 0x3F, 0xE0, 0x7F, 0xC7, 0xFC, 0x0F, 0xF8, 0xFF, 0x81, 0xFF,
  0x1F, 0xE0, 0x3F, 0xE3, 0xFC, 0x07, 0xFC, 0x7F, 0x80, 0xFF, 0x0F, 0xF0,
  0x3F, 0xE1, 0xFE, 0x07, 0xFC, 0x3F, 0xE1, 0xFF, 0x03, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x3F, 0xC1, 0xFF, 0x07, 0xF8, 0x1F,
  0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F,
  0x87, 0xFC, 0x0F, 0xF9, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFC, 0xFF, 0x83,
  0xFE, 0x0F, 0xF0, 0x7F, 0x81, 0xFF, 0x0F, 0xF0, 0x1F, 0xE3, 0xFC, 0x03,
  0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xF0, 0x0F, 0xF1, 0xFE, 0x01, 0xFE, 0x3F,
  0xE0, 0x7F, 0xC7, 0xFC, 0x1F, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xE1, 0xFF, 0x3F, 0xE0, 0xFF, 0x9F, 0xF0,
  0x3F, 0xCF, 0xF0, 0x1F, 0xEF, 0xF8, 0x0F, 0xF7, 0xFC, 0x07, 0xFB, 0xFE,
  0x07, 0xFD, 0xFF, 0x03, 0xFE, 0xFF, 0x81, 0xFF, 0x7F, 0xC1, 0xFF, 0xBF,
  0xE1, 0xFF, 0xDF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1,
  0xFF, 0xF7, 0xF8, 0x7F, 0xFF, 0xF8, 0x1F, 0xF3, 0xFC, 0x03, 0xF1, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x81, 0xE7, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x03, 0xF8,
  0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x03,
  0xF8, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x0F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFC,
  0x0F, 0xF8, 0x0F, 0xE0, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x0F, 0xE0,
  0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0x7F, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xE0,
  0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x7F,
  0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x3F, 0xFF, 0x83, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xC7, 0x81, 0xFF, 0x18, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x01, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x0F,
  0xE0, 0x1F, 0xF0, 0x7E, 0x0F, 0xC0, 0x7F, 0xFC, 0x3E, 0x1F, 0x81, 0xFF,
  0xFC, 0x3F, 0x1F, 0x83, 0xFF, 0xFC, 0x3F, 0x3F, 0x07, 0xFF, 0xFC, 0x3F,
  0x3F, 0x0F, 0xF0, 0xF8, 0x3F, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x7E, 0x1F,
  0xC1, 0xF8, 0x3F, 0x7E, 0x1F, 0x81, 0xF8, 0x3F, 0x7C, 0x3F, 0x83, 0xF0,
  0x3E, 0xFC, 0x3F, 0x03, 0xF0, 0x7E, 0xFC, 0x3F, 0x03, 0xF0, 0x7E, 0xFC,
  0x3F, 0x03, 0xF0, 0x7E, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0xFC, 0x3F, 0x07,
  0xE0, 0xFC, 0xFC, 0x3F, 0x0F, 0xE1, 0xF8, 0xFC, 0x3F, 0x0F, 0xE3, 0xF8,
  0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFC, 0x3F,
  0xFF, 0xFF, 0xC0, 0xFC, 0x1F, 0xF9, 0xFF, 0x80, 0xFE, 0x0F, 0xE0, 0xFF,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x10, 0x00, 0x1F, 0xE0, 0x00,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x1F, 0xEF, 0xE0, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x01,
  0xFC, 0x7F, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x7F, 0x87, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC,
  0x1F, 0xE0, 0x0F, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0xC0,
  0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0xC7, 0xFC, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0xFF,
  0x3F, 0xE0, 0x01, 0xFE, 0x7F, 0xC0, 0x03, 0xFD, 0xFF, 0x00, 0x07, 0xFB,
  0xFE, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xC3, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F,
  0xC1, 0xFF, 0x01, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x83,
  0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0x81, 0xFF, 0x03,
  0xFC, 0x07, 0xF8, 0x3F, 0xE0, 0x3F, 0xE1, 0xFF, 0x01, 0xFF, 0x0F, 0xF8,
  0x0F, 0xF8, 0x7F, 0x80, 0x7F, 0xC3, 0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x3F,
  0xE1, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xE0, 0x7C, 0x0F,
  0xFC, 0x00, 0xC0, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x02, 0x03, 0xFF, 0x80, 0xF0, 0x0F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x3F, 0xFE, 0x03,
  0xFC, 0x0F, 0xFC, 0x07, 0xF8, 0x0F, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F,
  0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0x00, 0x7F, 0xC1, 0xFE,
  0x00, 0xFF, 0x87, 0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x03, 0xFE, 0x1F, 0xF0,
  0x07, 0xFC, 0x3F, 0xC0, 0x0F, 0xF8, 0x7F, 0x80, 0x1F, 0xF1, 0xFF, 0x00,
  0x7F, 0xC3, 0xFE, 0x00, 0xFF, 0x87, 0xFC, 0x01, 0xFF, 0x0F, 0xF0, 0x07,
  0xFE, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xF0, 0xFF, 0x80, 0x7F,
  0xC1, 0xFE, 0x01, 0xFF, 0x83, 0xFC, 0x07, 0xFE, 0x0F, 0xF8, 0x1F, 0xFC,
  0x1F, 0xF1, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x78, 0x0F, 0xFE, 0x00,
  0x30, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC1, 0xFF, 0xF9, 0xFF, 0x03, 0xFF, 0xF3,
  0xFE, 0x07, 0xFF, 0xC7, 0xFC, 0x1F, 0xFF, 0x8F, 0xF8, 0x3F, 0xFF, 0x1F,
  0xF0, 0x7F, 0xFE, 0x3F, 0xE0, 0xFF, 0xFC, 0x7F, 0x80, 0x0F, 0xF0, 0xFF,
  0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0xFF, 0x87, 0xFC,
  0x01, 0xFF, 0x0F, 0xF8, 0x03, 0xFC, 0x1F, 0xF8, 0x07, 0xF8, 0x3F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF0, 0x07, 0xFC, 0x07,
  0xFC, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x1F, 0xE0,
  0x3F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF8, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF0, 0x07,
  0xFC, 0x07, 0xFC, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x1F, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF8, 0x03, 0xFE,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x0F,
  0xF0, 0x1F, 0xF0, 0x07, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x7F, 0x80, 0x1F, 0xE0, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF8,
  0x03, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xE0, 0x3F,
  0xC0, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x07, 0xFE, 0x00,
  0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xE0, 0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8,
  0x00, 0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x03, 0xFC, 0x1F,
  0xF0, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x03, 0xFE,
  0x7F, 0xE0, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x01,
  0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xDF, 0xE0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x07,
  0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x80,
  0x03, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xF0, 0x7F,
  0xE0, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x0F, 0xF0,
  0x1F, 0xF0, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F,
  0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x1F, 0xFF,
  0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xF7, 0xE0, 0x3F, 0xBF,
  0x80, 0x7F, 0x7E, 0x03, 0xFF, 0xF8, 0x07, 0xF7, 0xE0, 0x7F, 0x7F, 0x80,
  0xFF, 0x7E, 0x07, 0xF7, 0xF8, 0x0F, 0xF7, 0xE0, 0xFE, 0xFF, 0x00, 0xFF,
  0x7E, 0x0F, 0xEF, 0xF0, 0x0F, 0xE7, 0xE0, 0xFC, 0xFF, 0x00, 0xFE, 0x7E,
  0x1F, 0xCF, 0xF0, 0x1F, 0xE7, 0xE1, 0xF8, 0xFE, 0x01, 0xFE, 0x7F, 0x3F,
  0x9F, 0xE0, 0x1F, 0xE7, 0xF3, 0xF1, 0xFE, 0x01, 0xFC, 0x7F, 0x7F, 0x1F,
  0xE0, 0x3F, 0xC7, 0xF7, 0xF1, 0xFE, 0x03, 0xFC, 0x7F, 0xFE, 0x1F, 0xC0,
  0x3F, 0xC7, 0xFF, 0xE3, 0xFC, 0x03, 0xFC, 0x7F, 0xFC, 0x3F, 0xC0, 0x3F,
  0x87, 0xFF, 0xC3, 0xFC, 0x07, 0xF8, 0x7F, 0xF8, 0x3F, 0xC0, 0x7F, 0x87,
  0xFF, 0x87, 0xF8, 0x07, 0xF8, 0x7F, 0xF0, 0x7F, 0x80, 0x7F, 0x87, 0xFF,
  0x07, 0xF8, 0x07, 0xF0, 0x7F, 0xE0, 0x7F, 0x80, 0xFF, 0x07, 0xFE, 0x07,
  0xF0, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0x00, 0xFF, 0x07, 0xFC, 0x0F, 0xF0,
  0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x0F,
  0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0xF0, 0x01, 0xFE, 0x03, 0xFF, 0x80, 0x0F,
  0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xF8, 0x0F, 0xFF,
  0x80, 0x3F, 0xC0, 0x7F, 0xFC, 0x01, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xE0,
  0x1F, 0xFF, 0x80, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xF8, 0x0F, 0xFF, 0xE0,
  0x3F, 0xC0, 0x7F, 0x7F, 0x81, 0xFE, 0x03, 0xFB, 0xFC, 0x1F, 0xE0, 0x1F,
  0xDF, 0xE0, 0xFF, 0x01, 0xFE, 0x7F, 0x07, 0xF8, 0x0F, 0xF3, 0xFC, 0x3F,
  0xC0, 0x7F, 0x9F, 0xE1, 0xFC, 0x03, 0xF8, 0xFF, 0x1F, 0xE0, 0x1F, 0xC3,
  0xF8, 0xFF, 0x01, 0xFE, 0x1F, 0xE7, 0xF8, 0x0F, 0xF0, 0xFF, 0x3F, 0xC0,
  0x7F, 0x87, 0xF9, 0xFC, 0x03, 0xF8, 0x1F, 0xEF, 0xE0, 0x3F, 0xC0, 0xFF,
  0xFF, 0x01, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F,
  0x80, 0xFF, 0xFC, 0x03, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xC0, 0x3F, 0xFF,
  0x01, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0x80,
  0x3F, 0xFC, 0x03, 0xF8, 0x01, 0xFF, 0xE0, 0x3F, 0xC0, 0x0F, 0xFF, 0x01,
  0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xFC, 0x07,
  0xFE, 0x3F, 0xF0, 0x07, 0xFC, 0x7F, 0xC0, 0x0F, 0xF9, 0xFF, 0x80, 0x1F,
  0xF3, 0xFE, 0x00, 0x1F, 0xEF, 0xFC, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0xFF,
  0xBF, 0xE0, 0x01, 0xFF, 0x7F, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0xFF, 0xBF, 0xE0, 0x01, 0xFF, 0x7F, 0x80, 0x03, 0xFE, 0xFF,
  0x00, 0x0F, 0xFD, 0xFE, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x7F, 0xE7, 0xFC,
  0x00, 0xFF, 0x8F, 0xF8, 0x03, 0xFF, 0x1F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF8,
  0x3F, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xC7, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xC1, 0xFF,
  0x01, 0xFE, 0x0F, 0xF8, 0x0F, 0xF0, 0x7F, 0xC0, 0x7F, 0x83, 0xFC, 0x07,
  0xFC, 0x1F, 0xE0, 0x3F, 0xE1, 0xFF, 0x03, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0,
  0x7F, 0x83, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0x87, 0xFF, 0x0F,
  0xFC, 0x07, 0xFE, 0x3F, 0xF0, 0x07, 0xFC, 0x7F, 0xC0, 0x0F, 0xF9, 0xFF,
  0x80, 0x1F, 0xF3, 0xFE, 0x00, 0x1F, 0xEF, 0xFC, 0x00, 0x3F, 0xDF, 0xF0,
  0x00, 0xFF, 0xBF, 0xE0, 0x01, 0xFF, 0x7F, 0xC0, 0x03, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xBF, 0xC0, 0x01, 0xFF, 0x7F, 0x80, 0x03,
  0xFE, 0xFF, 0x00, 0x0F, 0xFD, 0xFE, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x7F,
  0xE7, 0xFC, 0x00, 0xFF, 0x8F, 0xF8, 0x03, 0xFF, 0x1F, 0xF0, 0x0F, 0xFC,
  0x3F, 0xF8, 0x7F, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xC3, 0xFF,
  0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0xC1, 0xFF, 0x03, 0xFE, 0x0F,
  0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x83, 0xFC, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0xC1, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xE3,
  0xFC, 0x01, 0xFF, 0x1F, 0xE0, 0x0F, 0xF8, 0xFF, 0x80, 0x7F, 0x87, 0xFC,
  0x03, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x7F, 0x80, 0xFF, 0x83, 0xFC, 0x07, 0xFC, 0x3F, 0xE0,
  0x1F, 0xF1, 0xFF, 0x00, 0xFF, 0x8F, 0xF0, 0x07, 0xFC, 0x7F, 0x80, 0x3F,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xE0, 0x78, 0x07, 0xFC, 0x01, 0x80, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x40, 0x03, 0xFE, 0x06, 0x00, 0x3F, 0xE0, 0x7C, 0x07,
  0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFE, 0x07, 0xFC, 0x01, 0xFE, 0x07, 0xF8,
  0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xF8,
  0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xFC, 0x0F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0,
  0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0,
  0x0F, 0xF8, 0x1F, 0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xE0,
  0x0F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xF0, 0x7F, 0xC0,
  0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xE0, 0x7F, 0xC0,
  0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x80,
  0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0x80,
  0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC1,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFD, 0xFE, 0x00, 0x3F,
  0xEF, 0xF0, 0x03, 0xFE, 0x7F, 0x80, 0x1F, 0xF3, 0xFC, 0x00, 0xFF, 0x1F,
  0xE0, 0x0F, 0xF8, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x07, 0xFC, 0x3F, 0xC0,
  0x3F, 0xC1, 0xFE, 0x03, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x81, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x03,
  0xF8, 0x3F, 0xC0, 0x1F, 0xC3, 0xFC, 0x00, 0xFE, 0x1F, 0xE0, 0x07, 0xF1,
  0xFF, 0x00, 0x3F, 0x8F, 0xF0, 0x01, 0xFC, 0xFF, 0x80, 0x0F, 0xE7, 0xF8,
  0x00, 0x7F, 0x3F, 0xC0, 0x03, 0xFB, 0xFC, 0x00, 0x1F, 0xDF, 0xE0, 0x00,
  0xFE, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xF0, 0x03,
  0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xEF, 0xF0, 0x07, 0xFC,
  0x01, 0xFE, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xEF, 0xF0, 0x0F, 0xFC, 0x03,
  0xFC, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xCF, 0xF0, 0x1F, 0xFC, 0x07, 0xF8,
  0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0x8F, 0xE0, 0x3F, 0xFC, 0x0F, 0xF0, 0xFE,
  0x03, 0xFF, 0xC0, 0xFF, 0x0F, 0xE0, 0x7F, 0xFC, 0x1F, 0xF0, 0xFE, 0x07,
  0xFF, 0xC1, 0xFE, 0x0F, 0xE0, 0x7F, 0xFC, 0x1F, 0xE0, 0xFE, 0x0F, 0xFF,
  0xC3, 0xFC, 0x0F, 0xE0, 0xFD, 0xFC, 0x3F, 0xC0, 0xFE, 0x1F, 0xDF, 0xC7,
  0xFC, 0x0F, 0xE1, 0xFD, 0xFC, 0x7F, 0x80, 0xFE, 0x3F, 0x9F, 0xC7, 0xF8,
  0x0F, 0xE3, 0xF9, 0xFC, 0xFF, 0x00, 0xFE, 0x3F, 0x9F, 0xCF, 0xF0, 0x0F,
  0xE7, 0xF1, 0xFD, 0xFE, 0x00, 0xFE, 0x7F, 0x1F, 0x9F, 0xE0, 0x0F, 0xEF,
  0xE1, 0xF9, 0xFE, 0x00, 0xFE, 0xFE, 0x1F, 0xBF, 0xC0, 0x0F, 0xEF, 0xE1,
  0xFB, 0xFC, 0x00, 0xFF, 0xFC, 0x1F, 0xBF, 0x80, 0x0F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x81, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xFC, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F,
  0xE0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x1F,
  0xE1, 0xFF, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x07, 0xFD, 0xFF, 0x00,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xEF,
  0xF8, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xF1, 0xFE, 0x00, 0x01,
  0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x83, 0xFE,
  0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xFC,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x7F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFE,
  0xFF, 0x80, 0x7F, 0xEF, 0xF8, 0x07, 0xFC, 0x7F, 0x80, 0xFF, 0x87, 0xF8,
  0x0F, 0xF8, 0x7F, 0x81, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0xC3, 0xFE,
  0x03, 0xFC, 0x7F, 0xC0, 0x3F, 0xC7, 0xF8, 0x03, 0xFC, 0xFF, 0x80, 0x3F,
  0xCF, 0xF0, 0x01, 0xFD, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x3F,
  0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F,
  0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFF, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x03, 0xF9, 0xF8, 0x00, 0xFE, 0x7E, 0x00, 0x7F, 0x1F,
  0x80, 0x3F, 0x87, 0xF0, 0x0F, 0xE0, 0xFC, 0x07, 0xF0, 0x3F, 0x03, 0xF8,
  0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x7F, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x8F,
  0xE0, 0x07, 0xF7, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0x7F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0x9F, 0xF1, 0xFE, 0x3F, 0xC3, 0xFC, 0x3F, 0x87, 0xF0, 0x7F, 0x07, 0xE0,
  0x00, 0x18, 0x00, 0x00, 0x1F, 0xE1, 0xFC, 0x07, 0xFE, 0x3F, 0x81, 0xFF,
  0xEF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0,
  0xFF, 0xCF, 0xFE, 0x3F, 0xF0, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0xFF, 0x81,
  0xFE, 0x3F, 0xE0, 0x3F, 0xC7, 0xFC, 0x0F, 0xF8, 0xFF, 0x01, 0xFE, 0x3F,
  0xE0, 0x3F, 0xC7, 0xFC, 0x07, 0xF8, 0xFF, 0x80, 0xFF, 0x1F, 0xE0, 0x3F,
  0xE3, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x3F, 0xE1, 0xFE,
  0x07, 0xFC, 0x3F, 0xE1, 0xFF, 0x87, 0xFE, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFD, 0xFC, 0x03, 0xFF,
  0x3F, 0x80, 0x3F, 0xC7, 0xF0, 0x00, 0x40, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x0C, 0x00,
  0x3F, 0xCF, 0xF0, 0x03, 0xFD, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xF3, 0xFE,
  0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF,
  0x01, 0xFF, 0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0x01, 0xFE, 0x0F, 0xE0, 0x1F,
  0xE1, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0xE1, 0xFE, 0x03, 0xFE, 0x1F,
  0xE0, 0x3F, 0xC1, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xC3, 0xFE, 0x0F,
  0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFF, 0xBF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xF7, 0xFF, 0xC0, 0x7F, 0x3F,
  0xF0, 0x0F, 0xE1, 0xFE, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFE, 0x7C, 0x3F, 0xF0, 0x10, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x04,
  0x3F, 0xE0, 0x30, 0x7F, 0xF3, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x06, 0x07, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x1F,
  0xF9, 0xFE, 0x01, 0xFF, 0xEF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xCF, 0xFE, 0x0F, 0xFC, 0x3F, 0xE0,
  0x7F, 0xC1, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x3F, 0xE0, 0x3F, 0xC1, 0xFF,
  0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x80, 0xFF, 0x07, 0xFC, 0x07,
  0xF8, 0x3F, 0xE0, 0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0,
  0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x87, 0xFC, 0x07, 0xFE, 0x7F, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFE, 0xFC, 0x00, 0xFF, 0xEF, 0xE0,
  0x03, 0xFC, 0x7F, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF8, 0x3F, 0xF7, 0xFE, 0x3F, 0xE0, 0xFF, 0x3F, 0xE0, 0x7F,
  0x9F, 0xE0, 0x3F, 0xDF, 0xF0, 0x3F, 0xCF, 0xF0, 0x3F, 0xE7, 0xF8, 0x7F,
  0xF3, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x41, 0xFF, 0x80, 0xE0, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0xFF, 0x88, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x02, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x21, 0xFF, 0x80, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x1F,
  0xF8, 0xFE, 0x01, 0xFF, 0xEF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xCF, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0,
  0x7F, 0xC1, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x3F, 0xE0, 0x3F, 0xC1, 0xFF,
  0x03, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x80, 0xFF, 0x07, 0xFC, 0x07,
  0xF8, 0x3F, 0xE0, 0x3F, 0xC1, 0xFE, 0x03, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0,
  0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x87, 0xFE, 0x07, 0xFE, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xDF, 0xE0,
  0x03, 0xFC, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x20, 0x01, 0xFF, 0x01, 0xE0, 0x3F,
  0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x0C, 0x00, 0x3F, 0xC7, 0xF8, 0x03, 0xFD, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF0, 0x7F, 0xF3, 0xFF, 0x07, 0xFE, 0x1F, 0xF0, 0x7F, 0xC1,
  0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFE, 0x0F, 0xF8, 0x1F, 0xE0,
  0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x3F, 0xE1, 0xFF, 0x03, 0xFE, 0x1F, 0xF0,
  0x3F, 0xC1, 0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xC1, 0xFE, 0x07, 0xFC,
  0x3F, 0xE0, 0x7F, 0xC3, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x83, 0xFC,
  0x07, 0xF8, 0x7F, 0xC0, 0xFF, 0x87, 0xFC, 0x0F, 0xF8, 0x7F, 0x80, 0xFF,
  0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0x00,
  0x1C, 0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFC, 0x01, 0xFC, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x8F, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0xC0,
  0x7F, 0x81, 0xFF, 0x00, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x07,
  0xFC, 0x7F, 0xC0, 0x0F, 0xF1, 0xFF, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x3F,
  0xCF, 0xF8, 0x00, 0xFF, 0xBF, 0xE0, 0x01, 0xFE, 0xFF, 0x80, 0x03, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFD, 0xFF, 0x00, 0x1F, 0xE1, 0xFF,
  0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x7F, 0x87, 0xFC, 0x01, 0xFF, 0x07, 0xFC,
  0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0xE0, 0x00, 0x7F, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0xFE, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0x9F, 0xFC, 0x3F,
  0xF8, 0x0F, 0xEF, 0xFF, 0x1F, 0xFE, 0x03, 0xFF, 0xFF, 0xEF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFC,
  0xFF, 0xF9, 0xFF, 0x07, 0xFE, 0x1F, 0xF8, 0x3F, 0xC1, 0xFF, 0x07, 0xFE,
  0x0F, 0xF0, 0xFF, 0x81, 0xFF, 0x03, 0xFC, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0xC3, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0xFF,
  0x03, 0xFE, 0x07, 0xF8, 0x7F, 0xC0, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0x3F, 0xE1, 0xFE, 0x07, 0xFC, 0x0F,
  0xF0, 0x7F, 0x81, 0xFF, 0x03, 0xFC, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC3, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0xFF, 0x03,
  0xFE, 0x07, 0xF8, 0x7F, 0xC0, 0xFF, 0x01, 0xFE, 0x1F, 0xF0, 0x3F, 0xC0,
  0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x0F, 0xF8,
  0x7F, 0x81, 0xFF, 0x03, 0xFC, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x3F, 0x8F, 0xF8, 0x03, 0xF9, 0xFF, 0xC0, 0x3F, 0xBF,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0,
  0x7F, 0xF3, 0xFF, 0x07, 0xFE, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x0F, 0xF8,
  0x1F, 0xF0, 0xFF, 0x81, 0xFE, 0x0F, 0xF8, 0x1F, 0xE0, 0xFF, 0x01, 0xFE,
  0x0F, 0xF0, 0x3F, 0xE1, 0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0x3F, 0xC1, 0xFE,
  0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xC1, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x7F,
  0xC3, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x83, 0xFC, 0x07, 0xF8, 0x7F,
  0xC0, 0xFF, 0x87, 0xFC, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x0F,
  0xF0, 0x7F, 0x80, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x03, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xF3, 0xFF, 0x3F, 0xE0, 0xFF,
  0x9F, 0xF0, 0x3F, 0xDF, 0xF0, 0x1F, 0xEF, 0xF8, 0x0F, 0xF7, 0xF8, 0x07,
  0xFB, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0x7F, 0xBF, 0xC0, 0x3F, 0xDF, 0xE0, 0x3F, 0xEF, 0xF0,
  0x1F, 0xF7, 0xF8, 0x1F, 0xF3, 0xFE, 0x1F, 0xF9, 0xFF, 0x9F, 0xF8, 0x7F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x03, 0xF8, 0xFF, 0x00, 0x0F, 0xE7, 0xFE, 0x00, 0x3F, 0xBF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80,
  0x7F, 0xE3, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x01, 0xFF, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x81, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x0F,
  0xF8, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x03,
  0xFF, 0xBF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF8, 0x07, 0xFB, 0xFF, 0xC0, 0x1F, 0xEF, 0xFE, 0x00, 0xFF, 0x9F,
  0xE0, 0x03, 0xFC, 0x08, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x1F, 0xE1, 0xFC, 0x07, 0xFF,
  0x3F, 0x81, 0xFF, 0xEF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xF0, 0xFF, 0xCF, 0xFE, 0x3F, 0xF0, 0xFF, 0x87, 0xFC, 0x1F,
  0xF0, 0xFF, 0x01, 0xFE, 0x3F, 0xE0, 0x3F, 0xC7, 0xFC, 0x07, 0xF8, 0xFF,
  0x01, 0xFE, 0x3F, 0xE0, 0x3F, 0xC7, 0xFC, 0x07, 0xF8, 0xFF, 0x80, 0xFF,
  0x1F, 0xE0, 0x1F, 0xE3, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x0F, 0xF0,
  0x1F, 0xE1, 0xFE, 0x07, 0xFC, 0x3F, 0xE1, 0xFF, 0x07, 0xFE, 0x7F, 0xE0,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x03, 0xFF, 0x7F, 0x80, 0x3F, 0xCF, 0xF0, 0x00, 0x81, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x07, 0xF0, 0xFC, 0x0F,
  0xE7, 0xF8, 0x1F, 0xDF, 0xF0, 0x3F, 0xBF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xF8, 0x1C, 0x1F, 0xF0, 0x08, 0x3F, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x30,
  0x07, 0xFC, 0x7C, 0x1F, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xF1, 0xFF, 0xFE, 0x7F, 0xFF,
  0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0x0F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F,
  0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07,
  0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0xCE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x10, 0x00, 0x0F, 0xF8, 0x1F, 0xE1,
  0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x8F, 0xF8, 0x1F, 0xF1, 0xFF, 0x03,
  0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0xFF, 0x03, 0xFE, 0x3F,
  0xE0, 0x7F, 0xC7, 0xFC, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x3F,
  0xC3, 0xFC, 0x0F, 0xF8, 0xFF, 0x81, 0xFF, 0x1F, 0xE0, 0x3F, 0xC3, 0xFC,
  0x07, 0xF8, 0x7F, 0x81, 0xFF, 0x0F, 0xF0, 0x3F, 0xE3, 0xFE, 0x07, 0xF8,
  0x7F, 0xC1, 0xFF, 0x0F, 0xF8, 0x3F, 0xE1, 0xFF, 0x0F, 0xFC, 0x3F, 0xF7,
  0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xBF, 0x81,
  0xFF, 0xE7, 0xF0, 0x1F, 0xFC, 0xFE, 0x01, 0xFE, 0x1F, 0x80, 0x02, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xEF, 0xF0, 0x0F, 0xFB,
  0xFC, 0x07, 0xFC, 0xFF, 0x01, 0xFF, 0x3F, 0xC0, 0x7F, 0x8F, 0xF0, 0x3F,
  0xE3, 0xFC, 0x0F, 0xF0, 0x7F, 0x07, 0xFC, 0x1F, 0xC1, 0xFE, 0x07, 0xF0,
  0xFF, 0x81, 0xFC, 0x3F, 0xC0, 0x7F, 0x1F, 0xF0, 0x1F, 0xC7, 0xF8, 0x07,
  0xF3, 0xFE, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xDF, 0xE0,
  0x07, 0xF7, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFE, 0x07, 0xFF, 0xFC,
  0x0F, 0xFC, 0x0F, 0xF7, 0xF8, 0x1F, 0xF8, 0x1F, 0xEF, 0xF0, 0x7F, 0xF0,
  0x7F, 0x9F, 0xE0, 0xFF, 0xE0, 0xFF, 0x3F, 0xC3, 0xFF, 0xC3, 0xFC, 0x7F,
  0x87, 0xFF, 0x87, 0xF8, 0xFF, 0x0F, 0xFF, 0x1F, 0xE1, 0xFE, 0x3F, 0x7E,
  0x3F, 0xC3, 0xFC, 0x7E, 0xFC, 0x7F, 0x87, 0xF9, 0xFD, 0xF9, 0xFE, 0x0F,
  0xF3, 0xF3, 0xF3, 0xFC, 0x1F, 0xE7, 0xEF, 0xEF, 0xF0, 0x3F, 0xDF, 0x9F,
  0xDF, 0xE0, 0x7F, 0xBF, 0x3F, 0xBF, 0x80, 0x7F, 0x7E, 0x7E, 0xFF, 0x00,
  0xFF, 0xF8, 0xFD, 0xFC, 0x01, 0xFF, 0xF1, 0xFB, 0xF8, 0x03, 0xFF, 0xC3,
  0xFF, 0xF0, 0x07, 0xFF, 0x87, 0xFF, 0xC0, 0x0F, 0xFF, 0x0F, 0xFF, 0x80,
  0x1F, 0xFC, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x3F, 0xFC, 0x00, 0x7F, 0xF0,
  0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x01, 0xFF, 0x81, 0xFF, 0x80,
  0x03, 0xFE, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x03, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xC1, 0xFF, 0x80,
  0x1F, 0xF0, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0x80, 0x03, 0xFC, 0xFF, 0x80,
  0x01, 0xFE, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x1F, 0xF1,
  0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xC0, 0x0F, 0xF8,
  0x1F, 0xF0, 0x0F, 0xFC, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0,
  0x07, 0xF8, 0x1F, 0xF0, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xF8,
  0x00, 0x7F, 0x87, 0xF8, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x03, 0xFC, 0xFF,
  0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x3F, 0xBF,
  0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x11, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x7F,
  0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0,
  0x07, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0x80, 0x01, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0x80, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xBF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x80, 0x1F, 0xFE, 0x80, 0x01, 0xFC, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBoldItalic53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 17, 39, 15, 0, -38 },
  { 84, 21, 14, 23, 5, -38 },
  { 121, 31, 38, 31, 1, -38 },
  { 269, 27, 43, 28, 1, -40 },
  { 415, 40, 38, 44, 3, -38 },
  { 605, 34, 39, 35, 1, -38 },
  { 771, 10, 14, 13, 5, -38 },
  { 789, 20, 46, 17, 1, -38 },
  { 904, 20, 47, 17, -4, -39 },
  { 1022, 24, 25, 27, 4, -41 },
  { 1097, 25, 26, 29, 2, -32 },
  { 1179, 13, 14, 15, -3, -7 },
  { 1202, 15, 7, 17, 1, -18 },
  { 1216, 10, 10, 15, 0, -9 },
  { 1229, 29, 38, 22, -3, -38 },
  { 1367, 25, 39, 28, 2, -38 },
  { 1489, 21, 38, 28, 5, -38 },
  { 1589, 29, 38, 28, -2, -38 },
  { 1727, 27, 39, 28, 0, -38 },
  { 1859, 28, 38, 28, 0, -38 },
  { 1992, 27, 39, 28, 1, -38 },
  { 2124, 27, 39, 28, 2, -38 },
  { 2256, 29, 38, 28, 1, -38 },
  { 2394, 27, 39, 28, 1, -38 },
  { 2526, 25, 39, 28, 2, -38 },
  { 2648, 15, 31, 15, 0, -30 },
  { 2707, 18, 37, 15, -3, -30 },
  { 2791, 25, 28, 29, 2, -33 },
  { 2879, 25, 17, 29, 2, -27 },
  { 2933, 25, 28, 29, 2, -33 },
  { 3021, 22, 39, 23, 3, -38 },
  { 3129, 40, 43, 43, 2, -38 },
  { 3344, 31, 38, 32, -3, -38 },
  { 3492, 29, 38, 31, 1, -38 },
  { 3630, 29, 39, 30, 3, -38 },
  { 3772, 31, 38, 33, 1, -38 },
  { 3920, 27, 38, 26, 1, -38 },
  { 4049, 27, 38, 26, 1, -38 },
  { 4178, 31, 39, 34, 3, -38 },
  { 4330, 34, 38, 34, 1, -38 },
  { 4492, 25, 38, 20, -2, -38 },
  { 4611, 26, 50, 17, -8, -38 },
  { 4774, 35, 38, 31, 1, -38 },
  { 4941, 21, 38, 25, 1, -38 },
  { 5041, 44, 38, 44, 1, -38 },
  { 5250, 37, 38, 37, 1, -38 },
  { 5426, 31, 39, 35, 3, -38 },
  { 5578, 29, 38, 30, 1, -38 },
  { 5716, 31, 47, 35, 3, -38 },
  { 5899, 29, 38, 31, 1, -38 },
  { 6037, 28, 39, 26, 0, -38 },
  { 6174, 26, 38, 26, 4, -38 },
  { 6298, 32, 39, 34, 3, -38 },
  { 6454, 29, 38, 30, 5, -38 },
  { 6592, 44, 38, 45, 5, -38 },
  { 6801, 37, 38, 30, -3, -38 },
  { 6977, 28, 38, 28, 5, -38 },
  { 7110, 31, 38, 26, -2, -38 },
  { 7258, 23, 47, 17, -2, -38 },
  { 7394, 12, 38, 22, 6, -38 },
  { 7451, 23, 47, 17, -4, -38 },
  { 7587, 26, 24, 27, 0, -38 },
  { 7665, 22, 5, 21, -5, 4 },
  { 7679, 11, 9, 17, 8, -41 },
  { 7692, 27, 31, 29, 2, -30 },
  { 7797, 28, 41, 29, 0, -40 },
  { 7941, 23, 31, 24, 2, -30 },
  { 8031, 29, 41, 29, 2, -40 },
  { 8180, 25, 31, 28, 2, -30 },
  { 8277, 31, 54, 19, -6, -41 },
  { 8487, 29, 43, 29, 0, -30 },
  { 8643, 28, 40, 30, 0, -40 },
  { 8783, 17, 41, 15, 0, -41 },
  { 8871, 24, 54, 15, -7, -41 },
  { 9033, 31, 40, 29, 0, -40 },
  { 9188, 17, 40, 15, 0, -40 },
  { 9273, 42, 30, 44, 0, -30 },
  { 9431, 28, 30, 30, 0, -30 },
  { 9536, 25, 31, 29, 2, -30 },
  { 9633, 30, 43, 29, -2, -30 },
  { 9795, 27, 43, 29, 2, -30 },
  { 9941, 23, 30, 21, 0, -30 },
  { 10028, 23, 31, 24, 0, -30 },
  { 10118, 20, 36, 21, 2, -35 },
  { 10208, 27, 30, 30, 2, -29 },
  { 10310, 26, 29, 26, 3, -29 },
  { 10405, 39, 29, 39, 3, -29 },
  { 10547, 33, 29, 27, -3, -29 },
  { 10667, 33, 42, 26, -4, -29 },
  { 10841, 25, 29, 23, -1, -29 },
  { 10932, 22, 46, 19, 0, -38 },
  { 11059, 6, 52, 26, 10, -40 },
  { 11098, 22, 46, 19, -3, -38 },
  { 11225, 25, 9, 29, 2, -23 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBoldItalic53pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBoldItalic53pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBoldItalic53pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC53PT7B_H_
