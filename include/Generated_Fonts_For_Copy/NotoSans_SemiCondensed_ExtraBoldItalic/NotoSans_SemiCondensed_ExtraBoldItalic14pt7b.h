#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC14PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBoldItalic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBoldItalic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x37, 0x66, 0x60, 0xEC, 0x6D, 0x6D, 0xB6, 0x0B, 0x0D, 0x84,
  0xAF, 0xE3, 0x61, 0xA3, 0xFC, 0xD8, 0x68, 0x2C, 0x00, 0x04, 0x18, 0xFB,
  0xD7, 0x87, 0x07, 0x0B, 0xDD, 0xF8, 0x81, 0x00, 0x71, 0xB4, 0x4D, 0x32,
  0x58, 0xF5, 0xFB, 0xD1, 0xB4, 0xCB, 0x32, 0xD8, 0xE0, 0x1E, 0x1F, 0x0D,
  0x87, 0xC3, 0xC3, 0xEF, 0xBD, 0x9E, 0xFE, 0x3F, 0x80, 0x6B, 0x60, 0x1C,
  0xC3, 0x18, 0x61, 0x84, 0x30, 0xC3, 0x06, 0x18, 0x18, 0xC6, 0x31, 0x8C,
  0x63, 0x31, 0x99, 0xC0, 0x1A, 0x4F, 0x5F, 0x73, 0xE4, 0x80, 0x30, 0xCF,
  0xFF, 0x30, 0xC0, 0x76, 0x6C, 0x7F, 0xF8, 0x03, 0x06, 0x06, 0x0C, 0x18,
  0x18, 0x30, 0x30, 0x60, 0xE0, 0x1C, 0x7D, 0xDB, 0x36, 0x6C, 0xFB, 0xF6,
  0x7C, 0xF0, 0x1C, 0xEF, 0x96, 0x18, 0xE3, 0x0C, 0x31, 0xC0, 0x3C, 0xFC,
  0x98, 0x30, 0xC3, 0x8C, 0x30, 0xFD, 0xF8, 0x7E, 0x7C, 0x18, 0x33, 0xC7,
  0x83, 0x86, 0xFD, 0xF0, 0x06, 0x1C, 0x79, 0xF2, 0xCD, 0xBF, 0xFF, 0x18,
  0x30, 0x3E, 0x7C, 0xC3, 0x87, 0xC9, 0xC3, 0x86, 0xFD, 0xF0, 0x1F, 0x3E,
  0x30, 0x68, 0x7E, 0x6E, 0xE6, 0x6E, 0x7C, 0x78, 0x3F, 0x7F, 0x06, 0x0E,
  0x0C, 0x18, 0x38, 0x30, 0x70, 0xE0, 0x1E, 0x7D, 0xD9, 0xB3, 0xCF, 0xBB,
  0xE7, 0xFC, 0xF0, 0x3C, 0xFD, 0x9B, 0x36, 0xEF, 0xCB, 0x06, 0xF9, 0xE0,
  0x37, 0x20, 0x00, 0xEC, 0x19, 0xC4, 0x00, 0x01, 0xCC, 0x66, 0x00, 0x04,
  0x33, 0xB8, 0xE0, 0xF0, 0xC1, 0xFC, 0x00, 0x3F, 0x83, 0x0F, 0x07, 0x1F,
  0xCC, 0x20, 0x7B, 0xE1, 0xC6, 0x71, 0x84, 0x00, 0xC3, 0x00, 0x0F, 0x83,
  0x18, 0xC1, 0xB7, 0xF4, 0x96, 0xB6, 0xF6, 0xD2, 0xFE, 0x49, 0x0C, 0x20,
  0xFC, 0x00, 0x07, 0x0F, 0x0F, 0x1B, 0x1B, 0x3B, 0x3F, 0x7F, 0x63, 0xE3,
  0x3E, 0x3F, 0x33, 0x37, 0x7E, 0x7E, 0x66, 0x66, 0xFE, 0xFC, 0x3F, 0x7E,
  0x60, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFC, 0x7C, 0x3E, 0x3F, 0x33, 0x33,
  0x73, 0x63, 0x67, 0x66, 0xFE, 0xF8, 0x3F, 0x3E, 0x30, 0x32, 0x7C, 0x7C,
  0x60, 0x60, 0xFC, 0xFC, 0x3E, 0x7C, 0xC1, 0x87, 0xCF, 0x98, 0x30, 0xE1,
  0xC0, 0x1F, 0x7E, 0x60, 0xE0, 0xCE, 0xDE, 0xC6, 0xCE, 0xFE, 0x7C, 0x39,
  0x98, 0xCC, 0x66, 0x77, 0xF3, 0xF9, 0x8C, 0xCE, 0xE7, 0x73, 0x00, 0x7C,
  0xE3, 0x0C, 0x30, 0xC7, 0x18, 0xF3, 0xC0, 0x0E, 0x18, 0x30, 0x61, 0xC3,
  0x86, 0x0C, 0x18, 0x70, 0xC7, 0x8E, 0x00, 0x3B, 0x99, 0x8D, 0x87, 0xC7,
  0xC3, 0xE1, 0xB0, 0xDC, 0xEE, 0x73, 0x00, 0x38, 0xC3, 0x0C, 0x71, 0x86,
  0x18, 0xFF, 0xF0, 0x38, 0x73, 0x8F, 0x38, 0xE2, 0x9E, 0x69, 0x66, 0xB6,
  0x6B, 0xC6, 0xEC, 0xEE, 0xCC, 0xCC, 0x38, 0xCE, 0x33, 0xDC, 0xB6, 0x6D,
  0x9B, 0x66, 0xF9, 0x9C, 0xE7, 0x31, 0xC0, 0x3E, 0x7F, 0x63, 0xE3, 0xC3,
  0xC7, 0xC7, 0xC6, 0xFC, 0x78, 0x3E, 0x3F, 0x33, 0x33, 0x77, 0x7E, 0x78,
  0x60, 0xE0, 0xE0, 0x3E, 0x7F, 0x63, 0xE3, 0xC3, 0xC7, 0xC7, 0xC6, 0xFC,
  0x78, 0x1C, 0x0E, 0x3E, 0x3F, 0x33, 0x37, 0x7E, 0x7C, 0x6C, 0x6C, 0xEE,
  0xE6, 0x3E, 0x7D, 0xC3, 0x83, 0x83, 0x83, 0x46, 0xFD, 0xF0, 0xFF, 0xFC,
  0xC1, 0x83, 0x0E, 0x18, 0x30, 0x61, 0xC0, 0x73, 0x63, 0x67, 0xE6, 0xE6,
  0xC6, 0xC6, 0xCE, 0xFC, 0x78, 0xC7, 0xC6, 0xC6, 0xEC, 0xEC, 0x78, 0x78,
  0x50, 0x70, 0x70, 0xC6, 0x3C, 0x66, 0xCE, 0x6C, 0xEE, 0xDE, 0xCD, 0xEC,
  0xF7, 0x8F, 0x78, 0xE7, 0x0E, 0x70, 0x39, 0xC6, 0x61, 0xB0, 0x7C, 0x0E,
  0x07, 0x81, 0xE0, 0xD8, 0x77, 0x38, 0xC0, 0xE7, 0x6E, 0x6C, 0x78, 0x78,
  0x70, 0x70, 0x70, 0x60, 0x60, 0x1F, 0x9F, 0x81, 0xC1, 0xC0, 0xC0, 0xC0,
  0xE0, 0x60, 0x7E, 0x7F, 0x00, 0x3C, 0xC3, 0x18, 0x61, 0x86, 0x10, 0xC3,
  0x0C, 0x38, 0xC6, 0x66, 0x66, 0x62, 0x33, 0x1C, 0xB1, 0x86, 0x18, 0x61,
  0x8C, 0x30, 0xC3, 0x38, 0x08, 0x38, 0x71, 0xA6, 0x58, 0xC0, 0xFC, 0xCC,
  0x80, 0x1B, 0x3E, 0x76, 0x66, 0x66, 0xEE, 0x7C, 0x7C, 0x38, 0x60, 0xC1,
  0xE7, 0xEE, 0xD9, 0xB3, 0x6F, 0xFB, 0xF0, 0x1E, 0x79, 0xC3, 0x06, 0x1C,
  0x1E, 0x3C, 0x03, 0x03, 0x03, 0x1F, 0x3E, 0x66, 0x66, 0x66, 0xEE, 0x7C,
  0x7C, 0x1C, 0x7D, 0x9B, 0xF7, 0x9C, 0x1F, 0x3E, 0x03, 0x83, 0x83, 0x01,
  0xE1, 0xE0, 0x60, 0x70, 0x30, 0x18, 0x0C, 0x0E, 0x06, 0x0F, 0x07, 0x80,
  0x1B, 0x3E, 0x76, 0x66, 0x66, 0xEE, 0x7C, 0x7C, 0x0C, 0x9C, 0xF8, 0x38,
  0x60, 0xC1, 0xF7, 0xEE, 0xD9, 0xB3, 0x67, 0xDF, 0x30, 0x13, 0x03, 0x76,
  0x66, 0x6E, 0xC0, 0x04, 0x30, 0x03, 0x1C, 0x71, 0x86, 0x18, 0xE3, 0x0C,
  0xF3, 0x80, 0x38, 0x30, 0x30, 0x33, 0x76, 0x6C, 0x78, 0x7C, 0x6C, 0xEC,
  0xCE, 0x39, 0x8C, 0x67, 0x31, 0x8C, 0x67, 0x30, 0x2E, 0xCF, 0xFD, 0xDD,
  0xB3, 0x36, 0x66, 0xDD, 0xFB, 0x36, 0x66, 0x2E, 0xFD, 0xDB, 0x36, 0x6C,
  0xFB, 0xE6, 0x1C, 0x7D, 0x9B, 0x36, 0x7D, 0xDF, 0x3C, 0x16, 0x3F, 0x3B,
  0x33, 0x33, 0x37, 0x7E, 0x6E, 0x60, 0x60, 0xE0, 0x1B, 0x3E, 0x66, 0x66,
  0x66, 0xEE, 0x7C, 0x7C, 0x0C, 0x0C, 0x1C, 0x2D, 0xF7, 0x58, 0x61, 0x8E,
  0x30, 0x39, 0xF6, 0x1C, 0x38, 0x6F, 0xBC, 0x23, 0xFD, 0xCC, 0x63, 0x1C,
  0xE0, 0x67, 0xDF, 0x36, 0x6C, 0xDB, 0xBE, 0x7C, 0xCF, 0x9B, 0x76, 0xCF,
  0x9E, 0x38, 0x70, 0xCC, 0xF7, 0x7D, 0xDB, 0xF6, 0xFF, 0x3B, 0xCE, 0xE3,
  0xB8, 0x33, 0x9D, 0x87, 0x83, 0x81, 0xC1, 0xE1, 0xF9, 0xCC, 0x33, 0x99,
  0x8D, 0xC6, 0xC3, 0xE1, 0xE0, 0xF0, 0x30, 0x38, 0x78, 0x38, 0x00, 0x7D,
  0xF1, 0x8E, 0x31, 0x8F, 0xBE, 0x1C, 0x73, 0x0C, 0x33, 0x8E, 0x18, 0x61,
  0x87, 0x1C, 0xFF, 0xFC, 0x38, 0xE1, 0x86, 0x18, 0x71, 0xCC, 0x30, 0xCE,
  0x38, 0xF7, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBoldItalic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 10, 4, 0, -10 },
  { 6, 6, 4, 6, 1, -10 },
  { 9, 9, 10, 8, 0, -10 },
  { 21, 7, 12, 7, 0, -11 },
  { 32, 10, 10, 12, 1, -10 },
  { 45, 9, 10, 9, 0, -10 },
  { 57, 3, 4, 3, 1, -10 },
  { 59, 6, 12, 5, 0, -10 },
  { 68, 5, 12, 5, -1, -10 },
  { 76, 6, 7, 7, 1, -11 },
  { 82, 6, 6, 8, 1, -8 },
  { 87, 4, 4, 4, -1, -2 },
  { 89, 4, 2, 4, 0, -5 },
  { 90, 3, 2, 4, 0, -2 },
  { 91, 8, 10, 6, -1, -10 },
  { 101, 7, 10, 7, 0, -10 },
  { 110, 6, 10, 7, 1, -10 },
  { 118, 7, 10, 7, 0, -10 },
  { 127, 7, 10, 7, 0, -10 },
  { 136, 7, 10, 7, 0, -10 },
  { 145, 7, 10, 7, 0, -10 },
  { 154, 8, 10, 7, 0, -10 },
  { 164, 8, 10, 7, 0, -10 },
  { 174, 7, 10, 7, 0, -10 },
  { 183, 7, 10, 7, 0, -10 },
  { 192, 4, 8, 4, 0, -8 },
  { 196, 5, 10, 4, -1, -8 },
  { 203, 6, 8, 8, 1, -9 },
  { 209, 6, 4, 8, 1, -7 },
  { 212, 6, 8, 8, 1, -9 },
  { 218, 6, 10, 6, 1, -10 },
  { 226, 11, 11, 11, 0, -10 },
  { 242, 8, 10, 8, -1, -10 },
  { 252, 8, 10, 8, 0, -10 },
  { 262, 8, 10, 8, 1, -10 },
  { 272, 8, 10, 9, 0, -10 },
  { 282, 8, 10, 7, 0, -10 },
  { 292, 7, 10, 7, 0, -10 },
  { 301, 8, 10, 9, 1, -10 },
  { 311, 9, 10, 9, 0, -10 },
  { 323, 6, 10, 5, 0, -10 },
  { 331, 7, 13, 4, -2, -10 },
  { 343, 9, 10, 8, 0, -10 },
  { 355, 6, 10, 7, 0, -10 },
  { 363, 12, 10, 12, 0, -10 },
  { 378, 10, 10, 10, 0, -10 },
  { 391, 8, 10, 9, 1, -10 },
  { 401, 8, 10, 8, 0, -10 },
  { 411, 8, 12, 9, 1, -10 },
  { 423, 8, 10, 8, 0, -10 },
  { 433, 7, 10, 7, 0, -10 },
  { 442, 7, 10, 7, 1, -10 },
  { 451, 8, 10, 9, 1, -10 },
  { 461, 8, 10, 8, 1, -10 },
  { 471, 12, 10, 12, 1, -10 },
  { 486, 10, 10, 8, -1, -10 },
  { 499, 8, 10, 8, 1, -10 },
  { 509, 9, 10, 7, -1, -10 },
  { 521, 6, 12, 5, 0, -10 },
  { 530, 4, 10, 6, 1, -10 },
  { 535, 6, 12, 5, -1, -10 },
  { 544, 7, 6, 7, 0, -10 },
  { 550, 6, 1, 6, -1, 1 },
  { 551, 3, 3, 5, 2, -11 },
  { 553, 8, 8, 8, 0, -8 },
  { 561, 7, 11, 8, 0, -11 },
  { 571, 7, 8, 6, 0, -8 },
  { 578, 8, 11, 8, 0, -11 },
  { 589, 7, 8, 7, 0, -8 },
  { 596, 9, 14, 5, -2, -11 },
  { 612, 8, 11, 8, 0, -8 },
  { 623, 7, 11, 8, 0, -11 },
  { 633, 4, 11, 4, 0, -11 },
  { 639, 6, 14, 4, -2, -11 },
  { 650, 8, 11, 8, 0, -11 },
  { 661, 5, 11, 4, 0, -11 },
  { 668, 11, 8, 12, 0, -8 },
  { 679, 7, 8, 8, 0, -8 },
  { 686, 7, 8, 8, 0, -8 },
  { 693, 8, 11, 8, -1, -8 },
  { 704, 8, 11, 8, 0, -8 },
  { 715, 6, 8, 6, 0, -8 },
  { 721, 6, 8, 6, 0, -8 },
  { 727, 5, 9, 5, 1, -9 },
  { 733, 7, 8, 8, 1, -8 },
  { 740, 7, 8, 7, 1, -8 },
  { 747, 10, 8, 10, 1, -8 },
  { 757, 9, 8, 7, -1, -8 },
  { 766, 9, 11, 7, -1, -8 },
  { 779, 6, 8, 6, 0, -8 },
  { 785, 6, 12, 5, 0, -10 },
  { 794, 1, 14, 7, 3, -11 },
  { 796, 6, 12, 5, -1, -10 },
  { 805, 6, 2, 8, 1, -6 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBoldItalic14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBoldItalic14pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBoldItalic14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC14PT7B_H_
