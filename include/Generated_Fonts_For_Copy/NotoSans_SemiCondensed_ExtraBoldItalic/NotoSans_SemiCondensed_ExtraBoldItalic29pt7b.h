#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC29PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBoldItalic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBoldItalic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0xC3, 0xE1, 0xE1, 0xF0, 0xF8, 0x7C, 0x3C, 0x1E, 0x0F,
  0x0F, 0x87, 0x83, 0xC1, 0xE0, 0x00, 0x00, 0x30, 0x3C, 0x3E, 0x1F, 0x0F,
  0x80, 0x79, 0xEF, 0x7F, 0xCF, 0x79, 0xEF, 0x3D, 0xE7, 0x38, 0xE7, 0x1C,
  0x01, 0xE7, 0x80, 0x71, 0xC0, 0x1C, 0x70, 0x07, 0x3C, 0x03, 0xCE, 0x00,
  0xE3, 0x83, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0x81, 0xC7, 0x00, 0x73,
  0x80, 0x3C, 0xE0, 0x7F, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF0, 0x71, 0xC0,
  0x1C, 0xF0, 0x0F, 0x38, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x79, 0xE0, 0x00,
  0x00, 0x60, 0x03, 0x00, 0x3F, 0x83, 0xFF, 0x1F, 0xFC, 0xFF, 0xE3, 0xD8,
  0x8F, 0x60, 0x3D, 0x80, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x2F, 0xA1, 0x9E, 0xC6, 0xFB, 0xFF, 0xCF, 0xFF, 0x3F, 0xF8, 0x7F,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1F, 0x00, 0xE1, 0xFC, 0x0E, 0x1F,
  0xE0, 0xF0, 0xE7, 0x07, 0x0F, 0x38, 0x70, 0x79, 0xC7, 0x83, 0x8E, 0x38,
  0x1C, 0xF3, 0x80, 0xE7, 0xBC, 0xE7, 0x39, 0xDF, 0xFF, 0xDD, 0xFF, 0xFD,
  0xEF, 0x77, 0xDE, 0xF3, 0x80, 0xE7, 0x9C, 0x0F, 0x38, 0xE0, 0xF1, 0xC7,
  0x07, 0x0E, 0x78, 0x78, 0x73, 0xC7, 0x83, 0xFC, 0x38, 0x1F, 0xC3, 0xC0,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0xF9, 0xE0, 0x1E, 0x3C, 0x03, 0xEF, 0x80, 0x7F, 0xE0, 0x07, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x8F, 0x9F, 0xF1, 0xE7, 0xFF, 0x7C, 0xF9, 0xFF, 0x1E,
  0x3F, 0xE7, 0xC3, 0xF8, 0xF8, 0x7E, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F,
  0xFF, 0x81, 0xFC, 0xF8, 0x7B, 0xFF, 0xEF, 0x7B, 0x9C, 0x03, 0xE0, 0xF0,
  0x1E, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x01, 0xE0,
  0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x78, 0x0F, 0x00, 0x07, 0x80, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3C, 0x07,
  0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0x1E,
  0x10, 0xE0, 0xE7, 0x07, 0xF8, 0xFF, 0xFC, 0xFF, 0xE1, 0xFF, 0x1F, 0x81,
  0xFE, 0x1E, 0x70, 0x73, 0xC1, 0x1C, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x1F, 0x1E, 0x3E, 0x3C,
  0x3C, 0x78, 0x78, 0xF0, 0x7F, 0xBF, 0x9F, 0xDF, 0xE0, 0x33, 0xFF, 0xFF,
  0x80, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0xE0, 0xFF, 0x87, 0xFF,
  0x3E, 0x7C, 0xF1, 0xF7, 0xC7, 0xDF, 0x1F, 0x78, 0x7F, 0xE1, 0xFF, 0x87,
  0xFE, 0x1E, 0xF8, 0xFB, 0xC3, 0xEF, 0x0F, 0xBC, 0x7C, 0xF9, 0xF3, 0xFF,
  0x8F, 0xFE, 0x1F, 0xF0, 0x3F, 0x00, 0x00, 0xF0, 0x3F, 0x07, 0xF0, 0xFE,
  0x3F, 0xEF, 0xFE, 0x7F, 0xE3, 0x3C, 0x23, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x01, 0xF0,
  0x1F, 0x00, 0x01, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0x1F,
  0x04, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x03, 0xF0, 0x1F, 0xF8,
  0x7F, 0xF0, 0x7F, 0xF0, 0xC3, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x01,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F,
  0x00, 0x3C, 0x80, 0xF9, 0xFF, 0xF3, 0xFF, 0xC7, 0xFF, 0x07, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0xFF, 0x03, 0xFE, 0x0F, 0x78, 0x3C, 0xF0, 0x73, 0xE1, 0xE7, 0xC7, 0x8F,
  0x1F, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0xFF, 0xFC, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x3E, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0,
  0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1F, 0xE0, 0x3F, 0xF0, 0xFF,
  0xE0, 0xEF, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x80, 0xF9,
  0xFF, 0xF3, 0xFF, 0xC7, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x07, 0xF8,
  0x1F, 0xF0, 0x7F, 0xE1, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x60, 0x7B,
  0xF0, 0xFF, 0xF3, 0xFF, 0xE7, 0xE7, 0xCF, 0x87, 0x9F, 0x1F, 0x3E, 0x3E,
  0x7C, 0x7C, 0xF8, 0xF1, 0xFF, 0xE1, 0xFF, 0x83, 0xFF, 0x01, 0xF8, 0x00,
  0x3F, 0xFF, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xF8, 0x3F, 0xF8,
  0x7F, 0xF1, 0xF1, 0xE3, 0xC3, 0xC7, 0xCF, 0x8F, 0x9E, 0x0F, 0xFC, 0x0F,
  0xE0, 0x3F, 0xC0, 0xFF, 0x83, 0xEF, 0x8F, 0x8F, 0x9E, 0x1F, 0x3C, 0x3E,
  0xF8, 0x7C, 0xF9, 0xF1, 0xFF, 0xE1, 0xFF, 0x81, 0xFC, 0x00, 0x07, 0xE0,
  0x3F, 0xC1, 0xFF, 0x8F, 0xFE, 0x7C, 0x7D, 0xF1, 0xF7, 0xC7, 0xDE, 0x1F,
  0x78, 0x7D, 0xF3, 0xF7, 0xFF, 0x9F, 0xFE, 0x3F, 0x78, 0x7B, 0xE0, 0x0F,
  0x00, 0x7C, 0x03, 0xE3, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0xFE, 0x00, 0x0E,
  0x1F, 0x1F, 0x1F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x78,
  0xF8, 0xF8, 0xF8, 0x03, 0x81, 0xF0, 0x7C, 0x1F, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x07, 0x83, 0xE0, 0xF0, 0x3C,
  0x1E, 0x07, 0x83, 0xC0, 0x00, 0x04, 0x00, 0x70, 0x07, 0xC0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x3F, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80,
  0x03, 0x80, 0x0F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0xC0,
  0x1F, 0x01, 0xFC, 0x1F, 0xE3, 0xFC, 0x3F, 0xC0, 0xFC, 0x03, 0xC0, 0x0C,
  0x00, 0x00, 0x1F, 0x9F, 0xF9, 0xFF, 0xBF, 0xF6, 0x1E, 0x03, 0xC0, 0x78,
  0x1F, 0x0F, 0xC3, 0xF0, 0xFC, 0x1E, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x00,
  0x70, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFF,
  0x00, 0x3F, 0xFF, 0x03, 0xE0, 0x3C, 0x1F, 0x00, 0x78, 0x70, 0x00, 0xE3,
  0xC7, 0xFB, 0xCE, 0x3F, 0xE7, 0x71, 0xE7, 0x1D, 0xCF, 0x1C, 0x7F, 0x38,
  0xF1, 0xF8, 0xE3, 0xCF, 0xE7, 0x8E, 0x3B, 0x9E, 0x38, 0xEE, 0x79, 0xE7,
  0x38, 0xFF, 0xFC, 0xE3, 0xFF, 0xE3, 0xC7, 0x9E, 0x07, 0x00, 0x00, 0x1E,
  0x00, 0x40, 0x3E, 0x1E, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x30,
  0x00, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0,
  0x07, 0xB8, 0x07, 0x9E, 0x03, 0xCF, 0x03, 0xE7, 0x81, 0xE3, 0xC1, 0xF1,
  0xE0, 0xF0, 0xF0, 0xF8, 0x78, 0x7F, 0xFC, 0x7F, 0xFE, 0x3F, 0xFF, 0x3E,
  0x07, 0x9F, 0x03, 0xDF, 0x01, 0xEF, 0x80, 0xFF, 0x80, 0x78, 0x07, 0xF0,
  0x07, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0xF1, 0xF8, 0x78, 0x7C, 0x7C,
  0x3C, 0x3E, 0x3E, 0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xFE, 0x07, 0xFF, 0x83,
  0xE3, 0xE1, 0xF1, 0xF0, 0xF0, 0xF8, 0xF8, 0x7C, 0x7C, 0x7E, 0x3F, 0xFE,
  0x1F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFE, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0xC1,
  0xFF, 0xC1, 0xFF, 0xE1, 0xF8, 0x61, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x08, 0x3F, 0xFC, 0x0F, 0xFE, 0x07,
  0xFF, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3F,
  0xFE, 0x0F, 0x9F, 0x83, 0xC3, 0xE1, 0xF0, 0x78, 0x7C, 0x1F, 0x1F, 0x07,
  0x87, 0x81, 0xE1, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x87, 0xE3,
  0xC1, 0xF1, 0xF0, 0xFC, 0x7C, 0x7E, 0x1F, 0xFF, 0x07, 0xFF, 0x81, 0xFF,
  0xC0, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE,
  0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x3F, 0xF8, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE0, 0x07, 0xFF,
  0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F,
  0xFE, 0x1F, 0x83, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x1F, 0x1F, 0xC7, 0xC7, 0xF3, 0xE3, 0xFC, 0xF8, 0xFF, 0x3E, 0x07, 0xCF,
  0x81, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF,
  0xF0, 0x0F, 0xF8, 0x00, 0x07, 0x81, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x87,
  0xC1, 0xF0, 0xF8, 0x3C, 0x1E, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x3E, 0x1F,
  0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC3, 0xE0, 0xF8, 0x7C,
  0x1E, 0x0F, 0x03, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xF0,
  0x78, 0x3C, 0x1F, 0x0F, 0x83, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x81,
  0xFC, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00,
  0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00,
  0x7C, 0x07, 0xFC, 0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8,
  0x01, 0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x03, 0xF8, 0x00, 0x07, 0x83,
  0xE1, 0xF0, 0xFC, 0x3E, 0x3F, 0x07, 0xC7, 0xC0, 0xF1, 0xF0, 0x1E, 0x7C,
  0x07, 0xDF, 0x80, 0xFB, 0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x7D, 0xF0, 0x0F, 0x3E, 0x03, 0xE3, 0xE0,
  0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3C, 0x1F, 0x0F, 0x83, 0xE0,
  0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x07, 0xC0,
  0x7C, 0x07, 0xFF, 0x7F, 0xF7, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x3F, 0x87,
  0xF0, 0x1F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x87, 0xF8, 0x3D, 0xC3, 0xBC, 0x1E, 0xE3, 0xFE,
  0x0F, 0x71, 0xFF, 0x07, 0xB9, 0xEF, 0x07, 0xDC, 0xF7, 0x83, 0xCE, 0xF3,
  0xC1, 0xE7, 0x7B, 0xE0, 0xF3, 0xF9, 0xE0, 0xF9, 0xFC, 0xF0, 0x7C, 0xFC,
  0x78, 0x3C, 0x7E, 0x3C, 0x1E, 0x3E, 0x3E, 0x0F, 0x1F, 0x1E, 0x0F, 0x8F,
  0x0F, 0x00, 0x07, 0xC0, 0x78, 0x7E, 0x07, 0xC3, 0xF8, 0x3C, 0x1F, 0xC1,
  0xE0, 0xFE, 0x0F, 0x07, 0xF0, 0xF8, 0x7F, 0xC7, 0xC3, 0xDE, 0x3C, 0x1E,
  0xF1, 0xE0, 0xF7, 0x8F, 0x07, 0xBE, 0xF8, 0x7C, 0xF7, 0x83, 0xC7, 0xBC,
  0x1E, 0x3F, 0xE0, 0xF1, 0xFF, 0x0F, 0x87, 0xF8, 0x7C, 0x3F, 0x83, 0xC1,
  0xFC, 0x1E, 0x07, 0xE0, 0xF0, 0x3F, 0x0F, 0x81, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFE, 0x1F, 0x8F, 0x8F, 0xC1, 0xF3,
  0xE0, 0x7D, 0xF8, 0x1F, 0x7C, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x7F, 0xE0,
  0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x81, 0xF3, 0xE0, 0x7C, 0x7C, 0x3E,
  0x1F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x07, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0xF9, 0xF0, 0x78, 0x7C, 0x7C,
  0x3E, 0x3E, 0x1E, 0x1F, 0x1F, 0x0F, 0x1F, 0x87, 0xFF, 0x87, 0xFF, 0xC3,
  0xFF, 0x81, 0xFF, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0,
  0x7F, 0xF0, 0x3F, 0xFE, 0x1F, 0x8F, 0x8F, 0xC1, 0xF3, 0xE0, 0x7D, 0xF8,
  0x1F, 0x7C, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x7F, 0xE0, 0x3E, 0xF8, 0x0F,
  0xBE, 0x03, 0xEF, 0x81, 0xF3, 0xE0, 0x7C, 0x7C, 0x3E, 0x1F, 0xFF, 0x83,
  0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x0F, 0xFC, 0x0F, 0xFE,
  0x0F, 0xFF, 0x0F, 0x1F, 0x0F, 0x0F, 0x1F, 0x0F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1E, 0xFE, 0x1F, 0xFE, 0x3F, 0xF8, 0x3F, 0xF0, 0x3E, 0xF8, 0x3C, 0xF8,
  0x7C, 0x78, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0x3E, 0xF8, 0x3E,
  0x01, 0xF8, 0x0F, 0xFC, 0x3F, 0xF8, 0xFF, 0xE1, 0xF0, 0xC3, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0xC1, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7,
  0xFF, 0x07, 0xF8, 0x00, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03,
  0xC0, 0x1F, 0x00, 0x7C, 0x00, 0x1E, 0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xE7,
  0xC1, 0xE3, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3C, 0x7C, 0x1E,
  0x3C, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xC7, 0xC3, 0xE3, 0xC1,
  0xF1, 0xE0, 0xF8, 0xF8, 0xF8, 0x7F, 0xFC, 0x3F, 0xFC, 0x0F, 0xFC, 0x03,
  0xFC, 0x00, 0xF8, 0x0F, 0xBC, 0x0F, 0x9E, 0x07, 0xCF, 0x07, 0xC7, 0x83,
  0xE3, 0xC1, 0xE1, 0xE1, 0xF0, 0xF0, 0xF0, 0x78, 0xF8, 0x3C, 0x78, 0x1E,
  0x7C, 0x0F, 0x3C, 0x07, 0xBE, 0x03, 0xDE, 0x01, 0xEF, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0xF8,
  0x1E, 0x0F, 0xBC, 0x1F, 0x07, 0xDE, 0x0F, 0x87, 0xCF, 0x0F, 0xC3, 0xE7,
  0x87, 0xE1, 0xE3, 0xC3, 0xF1, 0xF1, 0xE3, 0xF8, 0xF0, 0xF1, 0xFC, 0x78,
  0x79, 0xFE, 0x7C, 0x3C, 0xFF, 0x3C, 0x1E, 0xF7, 0xBE, 0x0F, 0x7B, 0xDE,
  0x07, 0xB9, 0xEF, 0x03, 0xFC, 0xFF, 0x81, 0xFE, 0x7F, 0x80, 0xFE, 0x3F,
  0xC0, 0x7F, 0x1F, 0xC0, 0x3F, 0x0F, 0xE0, 0x1F, 0x87, 0xE0, 0x0F, 0x83,
  0xF0, 0x07, 0xC1, 0xF8, 0x00, 0x07, 0xC1, 0xF8, 0x3E, 0x0F, 0x80, 0xF0,
  0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x7C, 0x01, 0xF7, 0xC0, 0x07, 0xBC, 0x00,
  0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xF7, 0xC0, 0x1F,
  0x1F, 0x00, 0xF8, 0xF8, 0x0F, 0x87, 0xC0, 0xF8, 0x3E, 0x0F, 0xC0, 0xF8,
  0x00, 0xF0, 0x3F, 0xF0, 0xFB, 0xE1, 0xF7, 0xC7, 0xCF, 0x8F, 0x0F, 0x3E,
  0x1E, 0xF8, 0x3D, 0xF0, 0x7F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0x80, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1,
  0xFF, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F,
  0xFF, 0x80, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x78, 0x07, 0x80, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x7F,
  0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xF1, 0xE3, 0xC3, 0x87, 0x8F, 0x1E, 0x3C,
  0x78, 0xF0, 0xE1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x38, 0x78, 0xF1, 0xE0,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x7E, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x7C, 0x03, 0xF0,
  0x1F, 0xC0, 0x77, 0x83, 0xDE, 0x1E, 0x38, 0x70, 0xE3, 0xC3, 0xDE, 0x0F,
  0x78, 0x1F, 0xC0, 0x70, 0x7F, 0xF7, 0xFF, 0xFF, 0xF0, 0xF9, 0xE3, 0xC7,
  0x0F, 0x9E, 0x3F, 0xBC, 0xFF, 0xF1, 0xFF, 0xE7, 0xC7, 0xCF, 0x8F, 0x9E,
  0x1F, 0x7C, 0x3C, 0xF8, 0x79, 0xF1, 0xF3, 0xE3, 0xE7, 0xCF, 0xCF, 0xFF,
  0x1F, 0xFE, 0x1F, 0xBC, 0x1E, 0x78, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xDE, 0x0F, 0xFE, 0x1F, 0xFE, 0x3F,
  0xFC, 0x7C, 0xF9, 0xF1, 0xF3, 0xE3, 0xE7, 0x87, 0xCF, 0x0F, 0x9E, 0x1F,
  0x7C, 0x7C, 0xF8, 0xF9, 0xFF, 0xE3, 0xFF, 0xCF, 0x7F, 0x1E, 0x7C, 0x00,
  0x07, 0xF8, 0xFF, 0x8F, 0xFC, 0x7F, 0xC7, 0xC0, 0x3E, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x8F, 0xFC, 0x3F, 0xE1, 0xFF,
  0x07, 0xF0, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3E, 0x0F, 0xBE, 0x1F, 0xFE, 0x3F, 0xFC, 0x3F, 0xFC, 0x7C, 0x7C,
  0x7C, 0x7C, 0x78, 0x7C, 0xF8, 0x78, 0xF8, 0x78, 0xF8, 0x78, 0xF8, 0xF8,
  0xF8, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3E, 0xF0, 0x07, 0xF0,
  0x3F, 0xE1, 0xFF, 0x8F, 0x9F, 0x7C, 0x7D, 0xE1, 0xEF, 0xBF, 0xBF, 0xFC,
  0xFF, 0xE3, 0xF8, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x61, 0xFF, 0x87, 0xFE,
  0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFA, 0x00, 0xF0,
  0x01, 0xF0, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0x07, 0xCF, 0x0F, 0xEF, 0x1F, 0xFE, 0x1F, 0xFE, 0x3E, 0x3E, 0x3E, 0x3E,
  0x3C, 0x3E, 0x7C, 0x3C, 0x7C, 0x3C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0xFC,
  0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x1E, 0xF8, 0x00, 0xF0, 0x00, 0xF0,
  0x81, 0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0x00, 0x07, 0x80,
  0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xDF, 0x0F,
  0xFF, 0x1F, 0xFE, 0x3F, 0xFC, 0x7C, 0xF9, 0xF1, 0xF3, 0xE3, 0xE7, 0xC7,
  0xCF, 0x0F, 0x1E, 0x1E, 0x7C, 0x7C, 0xF8, 0xF9, 0xE1, 0xF3, 0xC3, 0xCF,
  0x87, 0x9F, 0x1F, 0x00, 0x07, 0x87, 0xC3, 0xE1, 0xF0, 0x00, 0x00, 0x7C,
  0x3E, 0x1F, 0x0F, 0x07, 0x87, 0xC3, 0xE1, 0xF0, 0xF0, 0x78, 0x7C, 0x3E,
  0x1F, 0x0F, 0x0F, 0x87, 0xC0, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x07, 0xF8, 0x3F,
  0x81, 0xFC, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x3E, 0x3E, 0x3E, 0x1F, 0x3E,
  0x0F, 0x3E, 0x07, 0xBE, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xE0, 0x7F, 0xF0, 0x3E, 0x78, 0x1E, 0x3E, 0x0F, 0x1F, 0x0F,
  0x87, 0xC7, 0xC3, 0xE0, 0x07, 0x83, 0xC3, 0xE1, 0xF0, 0xF0, 0x78, 0x7C,
  0x3E, 0x1F, 0x0F, 0x07, 0x87, 0xC3, 0xE1, 0xF0, 0xF0, 0x78, 0x7C, 0x3E,
  0x1F, 0x0F, 0x0F, 0x87, 0xC0, 0x1E, 0x7C, 0x7C, 0x3D, 0xF9, 0xFC, 0x7F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xF3, 0xF3, 0xE7, 0xC7, 0xC7, 0xCF, 0x8F,
  0x8F, 0x9F, 0x1F, 0x1F, 0x3C, 0x3C, 0x3C, 0x78, 0x78, 0x79, 0xF1, 0xF1,
  0xF3, 0xE3, 0xE3, 0xE7, 0x87, 0xC7, 0xCF, 0x0F, 0x0F, 0x3E, 0x1E, 0x1E,
  0x7C, 0x7C, 0x7C, 0x1E, 0x7C, 0x3D, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xF3,
  0xE7, 0xC7, 0xCF, 0x8F, 0x9F, 0x1F, 0x3C, 0x3C, 0x78, 0x79, 0xF1, 0xF3,
  0xE3, 0xE7, 0x87, 0xCF, 0x0F, 0x3E, 0x1E, 0x7C, 0x7C, 0x07, 0xE0, 0x7F,
  0xC3, 0xFF, 0x8F, 0xFF, 0x7C, 0x7D, 0xF1, 0xF7, 0x87, 0xFE, 0x1F, 0xF8,
  0x7F, 0xE1, 0xEF, 0x8F, 0xBE, 0x3E, 0xFF, 0xF1, 0xFF, 0x87, 0xFE, 0x07,
  0xE0, 0x0F, 0x3C, 0x0F, 0x7E, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0x9F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1E, 0x1F, 0x1E, 0x1F, 0x1E, 0x1F, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3F, 0xFC, 0x3F, 0xFC, 0x7F, 0xF8, 0x7D, 0xF0, 0x7C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x0F,
  0x9E, 0x3F, 0xBC, 0xFF, 0xF1, 0xFF, 0xE7, 0xC7, 0xCF, 0x8F, 0x9E, 0x1F,
  0x7C, 0x3C, 0xF8, 0x79, 0xF0, 0xF3, 0xE3, 0xE7, 0xC7, 0x8F, 0xFF, 0x1F,
  0xFE, 0x1F, 0xFC, 0x1E, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x1E, 0x78, 0xF7, 0x87, 0xFC,
  0x3F, 0xE1, 0xF9, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0xE0, 0xFF,
  0xCF, 0xFC, 0x7C, 0xE3, 0xE0, 0x1F, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x00, 0xF9, 0x07, 0xCE, 0x7E, 0x7F, 0xF3, 0xFF, 0x0F, 0xE0, 0x07,
  0x01, 0xE0, 0x3C, 0x0F, 0xF7, 0xFF, 0xFF, 0xBF, 0xF1, 0xE0, 0x3C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0xF8, 0xFF, 0x0F, 0xE1,
  0xFC, 0x00, 0x3E, 0x3E, 0x7C, 0x7C, 0xF0, 0xF9, 0xE1, 0xE7, 0xC3, 0xCF,
  0x8F, 0x9F, 0x1F, 0x3C, 0x3E, 0x78, 0x79, 0xF1, 0xF3, 0xE3, 0xE7, 0xCF,
  0xCF, 0xFF, 0x1F, 0xFE, 0x1F, 0xFC, 0x3F, 0x78, 0xF0, 0x7F, 0xC3, 0xEF,
  0x0F, 0xBC, 0x7C, 0xF1, 0xF3, 0xC7, 0x8F, 0x3E, 0x3C, 0xF0, 0xF7, 0xC3,
  0xDE, 0x0F, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00,
  0xF0, 0xF8, 0xFF, 0x8F, 0xC7, 0xFC, 0x7E, 0x3D, 0xE7, 0xF3, 0xEF, 0x3F,
  0x9E, 0x79, 0xFD, 0xF3, 0xDF, 0xEF, 0x1E, 0xEF, 0x78, 0xF7, 0x7F, 0x87,
  0xFB, 0xBC, 0x3F, 0x9D, 0xC1, 0xFC, 0xFE, 0x0F, 0xC7, 0xF0, 0x7E, 0x3F,
  0x03, 0xF1, 0xF8, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC1, 0xE3, 0xE0, 0x7D,
  0xF0, 0x1F, 0x7C, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0x7C, 0x0F,
  0x9F, 0x03, 0xE3, 0xC3, 0xF0, 0xF8, 0x0F, 0x07, 0xC3, 0xC3, 0xE0, 0xF0,
  0xF8, 0x3C, 0x7C, 0x0F, 0x1F, 0x03, 0xC7, 0x80, 0xF3, 0xE0, 0x3C, 0xF0,
  0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFC,
  0x3F, 0xF1, 0xFF, 0xC7, 0xFE, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7F, 0xF1, 0xFF, 0xCF, 0xFE,
  0x3F, 0xF8, 0x00, 0x30, 0x1F, 0x03, 0xF0, 0x7F, 0x07, 0x80, 0x78, 0x07,
  0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x1F, 0x07, 0xE0, 0xFC, 0x0F, 0x80, 0xFC,
  0x03, 0xC0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3E,
  0x03, 0xE0, 0x1E, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x7C, 0x07,
  0xC0, 0xFC, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3F, 0x01, 0xF0, 0x3F, 0x07, 0xF0, 0xF8, 0x0F, 0x00, 0xF0, 0x1F,
  0x01, 0xE0, 0x1E, 0x03, 0xE0, 0xFE, 0x0F, 0xC0, 0xF8, 0x0E, 0x00, 0x3C,
  0x05, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x81, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBoldItalic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 9, 21, 8, 0, -21 },
  { 25, 11, 8, 13, 3, -21 },
  { 36, 18, 21, 17, 0, -21 },
  { 84, 14, 24, 15, 1, -22 },
  { 126, 21, 21, 24, 2, -21 },
  { 182, 19, 21, 19, 0, -21 },
  { 232, 5, 8, 7, 3, -21 },
  { 237, 11, 26, 9, 1, -21 },
  { 273, 11, 26, 9, -2, -21 },
  { 309, 13, 13, 15, 2, -22 },
  { 331, 14, 14, 16, 1, -17 },
  { 356, 8, 8, 8, -2, -4 },
  { 364, 9, 4, 9, 0, -10 },
  { 369, 5, 5, 8, 0, -5 },
  { 373, 15, 21, 12, -1, -21 },
  { 413, 14, 21, 15, 1, -21 },
  { 450, 12, 21, 15, 2, -21 },
  { 482, 16, 21, 15, -1, -21 },
  { 524, 15, 21, 15, 0, -21 },
  { 564, 15, 21, 15, 0, -21 },
  { 604, 15, 21, 15, 0, -21 },
  { 644, 15, 21, 15, 1, -21 },
  { 684, 16, 21, 15, 1, -21 },
  { 726, 15, 21, 15, 0, -21 },
  { 766, 14, 21, 15, 1, -21 },
  { 803, 8, 16, 8, 0, -16 },
  { 819, 10, 20, 8, -2, -16 },
  { 844, 14, 15, 16, 1, -18 },
  { 871, 14, 9, 16, 1, -15 },
  { 887, 14, 15, 16, 1, -18 },
  { 914, 11, 21, 12, 2, -21 },
  { 943, 22, 24, 23, 1, -21 },
  { 1009, 17, 21, 17, -2, -21 },
  { 1054, 17, 21, 17, 0, -21 },
  { 1099, 17, 21, 16, 1, -21 },
  { 1144, 18, 21, 18, 0, -21 },
  { 1192, 16, 21, 14, 0, -21 },
  { 1234, 16, 21, 14, 0, -21 },
  { 1276, 18, 21, 18, 1, -21 },
  { 1324, 19, 21, 19, 0, -21 },
  { 1374, 14, 21, 11, -1, -21 },
  { 1411, 15, 27, 9, -5, -21 },
  { 1462, 19, 21, 17, 0, -21 },
  { 1512, 12, 21, 14, 0, -21 },
  { 1544, 25, 21, 24, 0, -21 },
  { 1610, 21, 21, 20, 0, -21 },
  { 1666, 18, 21, 19, 1, -21 },
  { 1714, 17, 21, 16, 0, -21 },
  { 1759, 18, 26, 19, 1, -21 },
  { 1818, 16, 21, 17, 0, -21 },
  { 1860, 15, 21, 14, 0, -21 },
  { 1900, 14, 21, 14, 2, -21 },
  { 1937, 17, 21, 18, 2, -21 },
  { 1982, 17, 21, 16, 2, -21 },
  { 2027, 25, 21, 24, 2, -21 },
  { 2093, 21, 21, 17, -2, -21 },
  { 2149, 15, 21, 16, 3, -21 },
  { 2189, 17, 21, 14, -1, -21 },
  { 2234, 12, 26, 9, -1, -21 },
  { 2273, 7, 21, 12, 3, -21 },
  { 2292, 12, 26, 9, -2, -21 },
  { 2331, 14, 14, 15, 0, -21 },
  { 2356, 12, 3, 12, -3, 2 },
  { 2361, 6, 4, 10, 4, -22 },
  { 2364, 15, 16, 16, 1, -16 },
  { 2394, 15, 22, 16, 0, -22 },
  { 2436, 13, 16, 13, 1, -16 },
  { 2462, 16, 22, 16, 1, -22 },
  { 2506, 14, 16, 15, 1, -16 },
  { 2534, 16, 29, 10, -3, -22 },
  { 2592, 16, 23, 16, 0, -16 },
  { 2638, 15, 22, 16, 0, -22 },
  { 2680, 9, 22, 8, 0, -22 },
  { 2705, 13, 29, 8, -4, -22 },
  { 2753, 17, 22, 16, 0, -22 },
  { 2800, 9, 22, 8, 0, -22 },
  { 2825, 23, 16, 24, 0, -16 },
  { 2871, 15, 16, 16, 0, -16 },
  { 2901, 14, 16, 16, 1, -16 },
  { 2929, 16, 23, 16, -1, -16 },
  { 2975, 15, 23, 16, 1, -16 },
  { 3019, 13, 16, 11, 0, -16 },
  { 3045, 13, 16, 13, 0, -16 },
  { 3071, 11, 19, 11, 1, -19 },
  { 3098, 15, 16, 16, 1, -16 },
  { 3128, 14, 16, 14, 2, -16 },
  { 3156, 21, 16, 22, 2, -16 },
  { 3198, 18, 16, 15, -2, -16 },
  { 3234, 18, 23, 14, -2, -16 },
  { 3286, 14, 16, 13, -1, -16 },
  { 3314, 12, 26, 10, 0, -21 },
  { 3353, 4, 29, 14, 5, -22 },
  { 3368, 12, 26, 10, -2, -21 },
  { 3407, 14, 5, 16, 1, -13 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBoldItalic29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBoldItalic29pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBoldItalic29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC29PT7B_H_
