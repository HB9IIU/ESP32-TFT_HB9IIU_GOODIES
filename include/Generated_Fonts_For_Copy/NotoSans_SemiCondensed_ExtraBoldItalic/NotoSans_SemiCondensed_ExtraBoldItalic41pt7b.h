#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC41PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBoldItalic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBoldItalic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x40, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x0F, 0xC0, 0x7F, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x07, 0xC0,
  0x00, 0x7E, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7E, 0x7C, 0x7C, 0x7C,
  0x7C, 0xFC, 0x7C, 0xF8, 0xFC, 0xF8, 0xF8, 0xF8, 0xF8, 0x00, 0x3E, 0x3E,
  0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0x87, 0x80, 0x07, 0xC7,
  0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xE1, 0xE0, 0x01, 0xF1, 0xF0, 0x1F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0x1F,
  0x1F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x03,
  0xC3, 0xC0, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xC0, 0x7C, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x1E, 0x1E, 0x00,
  0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0x87, 0x80, 0x03, 0xC7, 0xC0,
  0x03, 0xE3, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x01, 0xFF, 0x80, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFC, 0x1F, 0xDC, 0xE0, 0xFC, 0xC1, 0x07, 0xE6, 0x00, 0x3F, 0x70, 0x01,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0E, 0xFC, 0x00,
  0x77, 0xE2, 0x03, 0xBF, 0x1E, 0x19, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x03, 0xE0, 0x3F, 0xE0, 0x0F, 0x80, 0xFF, 0xE0, 0x3E, 0x03, 0xFF,
  0xC0, 0xF8, 0x07, 0xCF, 0x81, 0xF0, 0x1F, 0x1F, 0x07, 0xC0, 0x3E, 0x3E,
  0x1F, 0x00, 0x7C, 0x7C, 0x3E, 0x01, 0xF8, 0xF8, 0xF8, 0x03, 0xE1, 0xF3,
  0xE0, 0x07, 0xC7, 0xC7, 0xC0, 0x0F, 0x8F, 0x9F, 0x1F, 0x1F, 0x3F, 0x7C,
  0xFF, 0xBF, 0xFC, 0xFB, 0xFF, 0x3F, 0xFB, 0xE7, 0xFF, 0x7F, 0xEF, 0x9F,
  0xBE, 0x7F, 0x9F, 0x3E, 0x7C, 0x18, 0x7C, 0xF8, 0xF8, 0x01, 0xF1, 0xF1,
  0xF0, 0x03, 0xE3, 0xE3, 0xE0, 0x0F, 0x87, 0xC7, 0xC0, 0x3E, 0x1F, 0x0F,
  0x80, 0x7C, 0x3E, 0x3E, 0x01, 0xF0, 0x7C, 0x7C, 0x07, 0xC0, 0xF9, 0xF8,
  0x0F, 0x80, 0xFF, 0xE0, 0x3E, 0x01, 0xFF, 0x80, 0xF8, 0x01, 0xFF, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xF3, 0xF8,
  0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0x7E,
  0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC3, 0xF8, 0x3F, 0xF0, 0x7E, 0x1F, 0xFF,
  0x1F, 0xC7, 0xFF, 0xF3, 0xF0, 0xFE, 0xFE, 0xFE, 0x3F, 0x8F, 0xFF, 0x87,
  0xE1, 0xFF, 0xF0, 0xFC, 0x1F, 0xFC, 0x3F, 0x83, 0xFF, 0x07, 0xF0, 0x3F,
  0xE0, 0x7F, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0xFF, 0x00, 0x7E, 0xFD,
  0xFB, 0xE7, 0xCF, 0xBF, 0x7C, 0xF9, 0xF0, 0x00, 0x3E, 0x00, 0xF8, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0,
  0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8,
  0x01, 0xF8, 0x00, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C,
  0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03,
  0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x07, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x10, 0x7C, 0x07, 0x8F, 0x80, 0xF9,
  0xE0, 0x1F, 0xFC, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F,
  0xFF, 0x87, 0xFC, 0x01, 0xFF, 0x80, 0x7E, 0xF8, 0x1F, 0xDF, 0x01, 0xF1,
  0xF0, 0x0C, 0x3F, 0x00, 0x87, 0x80, 0x00, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xC7, 0xE1, 0xF8, 0xFE,
  0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0x7C, 0x3E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0x80, 0x1C, 0x7E, 0x7F, 0xFF, 0xFE, 0xFE, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0,
  0xFF, 0xFF, 0x0F, 0xE7, 0xF1, 0xFC, 0x3F, 0x1F, 0x83, 0xF3, 0xF8, 0x3F,
  0x3F, 0x83, 0xF3, 0xF0, 0x3F, 0x7F, 0x03, 0xF7, 0xF0, 0x7F, 0x7E, 0x07,
  0xF7, 0xE0, 0x7F, 0x7E, 0x07, 0xEF, 0xE0, 0x7E, 0xFE, 0x0F, 0xEF, 0xE0,
  0xFE, 0xFE, 0x0F, 0xCF, 0xE1, 0xFC, 0xFE, 0x1F, 0xCF, 0xE3, 0xF8, 0xFE,
  0x7F, 0x87, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0xFE,
  0x3F, 0xFE, 0x7F, 0xFC, 0xFF, 0xFC, 0xFE, 0xFC, 0x79, 0xFC, 0x71, 0xFC,
  0x21, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x00, 0x07, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3E, 0x3F, 0xC0, 0xE0, 0x7F, 0x01, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x00, 0x00,
  0x1E, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x83, 0xFF, 0xFC, 0x0E, 0x0F, 0xE0, 0x40, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0,
  0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x90,
  0x03, 0xFC, 0xE0, 0x3F, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7D, 0xF8, 0x07,
  0xCF, 0xC0, 0x7C, 0xFE, 0x07, 0xE7, 0xE0, 0x3E, 0x3F, 0x03, 0xE1, 0xF8,
  0x3E, 0x1F, 0xC3, 0xF0, 0xFE, 0x1F, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF,
  0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x88,
  0x01, 0xFC, 0x3C, 0x1F, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x01, 0xFF,
  0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F,
  0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x7E, 0x03, 0xF7, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFC, 0x7F, 0x8F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF9, 0xFC, 0x1F, 0xCF,
  0xE0, 0xFE, 0x7F, 0x07, 0xF1, 0xF8, 0x3F, 0x0F, 0xC3, 0xF8, 0x7F, 0x3F,
  0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x07,
  0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0xFE,
  0x7F, 0x0F, 0xC3, 0xF1, 0xFC, 0x3F, 0x1F, 0xC3, 0xF1, 0xFC, 0x3F, 0x0F,
  0xC7, 0xF0, 0xFE, 0xFE, 0x0F, 0xFF, 0xC0, 0x7F, 0xF8, 0x03, 0xFE, 0x00,
  0x7F, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0x1F, 0xC7, 0xE0, 0xFC,
  0xFE, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0xFC, 0xFE, 0x1F,
  0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0xFF,
  0x80, 0x00, 0x3C, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xC7, 0xF3, 0xF8, 0x7F, 0x3F, 0x07, 0xF3,
  0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0xFF,
  0x7F, 0x9F, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0x7E, 0x1F, 0xEF,
  0xC0, 0x7C, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x81, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF,
  0xE0, 0x0F, 0xFC, 0x00, 0x03, 0xC0, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F,
  0xC3, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x0F, 0xC1, 0xFC, 0x7F, 0x8F, 0xE1, 0xFC, 0x1F, 0x00,
  0x00, 0xF0, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x80,
  0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x07, 0xFE, 0x03, 0xFF,
  0x81, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x03, 0xF8, 0x00,
  0x7F, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x70, 0x00, 0x02,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xC0, 0x00, 0x1E, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0xF0,
  0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0x80, 0x1F,
  0xC0, 0x03, 0xE0, 0x00, 0x70, 0x00, 0x08, 0x00, 0x00, 0x01, 0xE0, 0x07,
  0xFE, 0x0F, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF9, 0xFF, 0xFC, 0x60, 0x7E,
  0x20, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x3E, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0x80, 0x7F, 0x00, 0x3F,
  0x80, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0xF8, 0x3E,
  0x3E, 0x0F, 0xFE, 0x7C, 0x7C, 0x3F, 0xFC, 0x79, 0xF0, 0xFF, 0xF8, 0xF3,
  0xE3, 0xF1, 0xE1, 0xE7, 0x87, 0xC7, 0xC3, 0xDF, 0x1F, 0x0F, 0x87, 0xBE,
  0x3E, 0x1F, 0x0F, 0x78, 0xF8, 0x3C, 0x3E, 0xF1, 0xF0, 0xF8, 0x7D, 0xE3,
  0xE1, 0xF0, 0xF7, 0xC7, 0xC3, 0xE3, 0xEF, 0x8F, 0x8F, 0x87, 0x9F, 0x1F,
  0x3F, 0xBF, 0x3E, 0x3F, 0xFF, 0xFC, 0x3C, 0x3F, 0xDF, 0xF0, 0x7C, 0x3F,
  0x1F, 0xC0, 0xF8, 0x18, 0x1E, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0xC0, 0x03, 0xFF, 0x7F, 0x80, 0x03, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3F,
  0x7C, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0xFE, 0x7E, 0x00, 0xFC,
  0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x03, 0xF0,
  0x7E, 0x03, 0xF0, 0x7E, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0x80,
  0x7E, 0x3F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xF0, 0xFF, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xE1,
  0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xC7, 0xF8, 0x1F, 0x83, 0xF8, 0x1F, 0x81,
  0xF8, 0x3F, 0x81, 0xF8, 0x3F, 0x81, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x07,
  0xF8, 0x3F, 0x0F, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x03, 0xFC, 0x0E, 0x0F, 0xF0, 0x08, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x80, 0x40, 0x7F, 0xC7, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF0, 0x3F, 0x8F, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFF, 0x07,
  0xE0, 0x3F, 0x83, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0,
  0xFE, 0x03, 0xF8, 0x7E, 0x01, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x80, 0xFE,
  0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x87, 0xE0, 0x3F, 0x87, 0xF0, 0x1F,
  0xC3, 0xF8, 0x1F, 0xE1, 0xFC, 0x1F, 0xE0, 0xFE, 0x1F, 0xE0, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE,
  0x03, 0xFF, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x0F, 0xF8, 0x1C, 0x1F, 0xF0, 0x04, 0x1F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x0F, 0xFE, 0xFE, 0x0F, 0xFC, 0xFE, 0x1F, 0xFC, 0xFE, 0x1F, 0xFC,
  0xFE, 0x1F, 0xFC, 0xFE, 0x1F, 0xFC, 0xFE, 0x01, 0xF8, 0xFE, 0x01, 0xF8,
  0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFF, 0x03, 0xF0, 0x7F, 0x87, 0xF0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0x80, 0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0,
  0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x0F, 0xE0, 0x3F, 0x81,
  0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x03,
  0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xF8,
  0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xE0,
  0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x00,
  0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF,
  0x83, 0xFF, 0xE0, 0x1F, 0xF0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F,
  0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0x1F, 0xF0, 0x3F, 0x81, 0xFC, 0x03, 0xF8, 0x3F, 0x80,
  0x3F, 0x07, 0xF8, 0x03, 0xF0, 0xFF, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF1,
  0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xE7, 0xF8, 0x00, 0x7E, 0x7F, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0x9F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x3F,
  0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x07, 0xF0, 0x03, 0xF0, 0x7F,
  0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x07,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xFC, 0x00, 0x01, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0x7F, 0xFF,
  0xBF, 0xFF, 0xDF, 0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0xF0, 0x01, 0xFE, 0x00,
  0x7F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF8, 0x03, 0xFF, 0x01, 0xFF,
  0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF,
  0x80, 0xFB, 0xE0, 0xFB, 0xF0, 0x3F, 0x7C, 0x1F, 0xFC, 0x07, 0xEF, 0x87,
  0xDF, 0x80, 0xFD, 0xF0, 0xFB, 0xF0, 0x1F, 0xBE, 0x3E, 0x7E, 0x03, 0xF7,
  0xC7, 0xDF, 0xC0, 0xFC, 0xF9, 0xFB, 0xF0, 0x1F, 0x9F, 0x3E, 0x7E, 0x03,
  0xF3, 0xEF, 0xCF, 0xC0, 0x7E, 0x7D, 0xF1, 0xF8, 0x1F, 0x8F, 0xFE, 0x7E,
  0x03, 0xF1, 0xFF, 0x8F, 0xC0, 0x7E, 0x3F, 0xF1, 0xF8, 0x0F, 0xC7, 0xFC,
  0x3F, 0x01, 0xF8, 0xFF, 0x8F, 0xE0, 0x7E, 0x1F, 0xE1, 0xF8, 0x0F, 0xC3,
  0xFC, 0x3F, 0x01, 0xF8, 0x7F, 0x07, 0xE0, 0x3F, 0x0F, 0xE0, 0xFC, 0x0F,
  0xE1, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x01, 0xF8, 0x1F, 0xF0, 0x0F, 0xC0,
  0xFF, 0x80, 0x7E, 0x07, 0xFC, 0x03, 0xF0, 0x3F, 0xE0, 0x3F, 0x03, 0xFF,
  0x81, 0xF8, 0x1F, 0xFC, 0x0F, 0xC0, 0xFF, 0xE0, 0x7E, 0x07, 0xFF, 0x83,
  0xF0, 0x3E, 0xFC, 0x3F, 0x03, 0xF7, 0xE1, 0xF8, 0x1F, 0xBF, 0x0F, 0xC0,
  0xFC, 0xFC, 0x7E, 0x07, 0xE7, 0xE3, 0xF0, 0x3F, 0x3F, 0x3F, 0x03, 0xF1,
  0xF9, 0xF8, 0x1F, 0x87, 0xEF, 0xC0, 0xFC, 0x3F, 0x7E, 0x07, 0xE1, 0xFB,
  0xF0, 0x7F, 0x0F, 0xDF, 0x03, 0xF0, 0x3F, 0xF8, 0x1F, 0x81, 0xFF, 0xC0,
  0xFC, 0x0F, 0xFE, 0x07, 0xE0, 0x7F, 0xE0, 0x7E, 0x01, 0xFF, 0x03, 0xF0,
  0x0F, 0xF8, 0x1F, 0x80, 0x7F, 0xC0, 0xFC, 0x03, 0xFE, 0x0F, 0xE0, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xC3, 0xFC,
  0x3F, 0xC0, 0xFE, 0x3F, 0xC0, 0x7F, 0x1F, 0xC0, 0x1F, 0x8F, 0xE0, 0x0F,
  0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFB, 0xF8, 0x01,
  0xFD, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0x80,
  0x3F, 0xDF, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xE7, 0xF0, 0x0F, 0xE3, 0xF8,
  0x0F, 0xF1, 0xFE, 0x0F, 0xF0, 0x7F, 0x8F, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x07, 0xF1, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0x7F,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE1, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xC3,
  0xFC, 0x3F, 0xC0, 0xFE, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x1F, 0x8F, 0xE0,
  0x0F, 0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFB, 0xF8,
  0x01, 0xFD, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF,
  0x80, 0x3F, 0x9F, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xE7, 0xF0, 0x0F, 0xE3,
  0xF8, 0x0F, 0xF1, 0xFE, 0x0F, 0xF0, 0x7F, 0x9F, 0xF8, 0x3F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0xFE, 0x3F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xE0,
  0xFE, 0x0F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x0F, 0xE0, 0xFE, 0x7F,
  0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0x7E, 0x7F, 0x01, 0xFC, 0x7E, 0x03, 0xF8, 0xFE, 0x07,
  0xF1, 0xFC, 0x0F, 0xC3, 0xF8, 0x1F, 0x83, 0xF8, 0x7F, 0x07, 0xF0, 0xFE,
  0x0F, 0xE1, 0xFC, 0x0F, 0xE3, 0xF0, 0x1F, 0xCF, 0xE0, 0x3F, 0xC0, 0x00,
  0x1F, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0x03, 0xFF, 0xF8, 0x3F, 0xC3, 0x81, 0xFC, 0x04, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE2, 0x00, 0x7F, 0x0C,
  0x03, 0xF8, 0x7C, 0x7F, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC,
  0x0F, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x87, 0xF0,
  0x1F, 0x83, 0xF8, 0x0F, 0xC1, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE,
  0x03, 0xF8, 0x7F, 0x01, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0x80, 0xFE, 0x1F,
  0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0x83, 0xF0, 0x1F, 0xC1,
  0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF0, 0x7F, 0x01, 0xF8,
  0x3F, 0x01, 0xFC, 0x1F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F,
  0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x3F, 0xC1, 0xFE, 0x3F, 0xC0, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xBF, 0x00,
  0xFE, 0xFC, 0x07, 0xF3, 0xF0, 0x1F, 0xCF, 0xC0, 0x7E, 0x3F, 0x03, 0xF8,
  0xFC, 0x0F, 0xC3, 0xF0, 0x7F, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xE0, 0xFC,
  0x3F, 0x03, 0xF1, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0xFC,
  0x01, 0xF3, 0xF0, 0x07, 0xDF, 0xC0, 0x1F, 0x7E, 0x00, 0x7D, 0xF8, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x03,
  0xF0, 0x1F, 0xFF, 0x01, 0xFC, 0x07, 0xEF, 0xC0, 0x7F, 0x01, 0xFB, 0xF0,
  0x3F, 0xC0, 0xFE, 0xFC, 0x0F, 0xF0, 0x3F, 0x3F, 0x03, 0xFC, 0x1F, 0xCF,
  0xC1, 0xFF, 0x07, 0xE3, 0xF0, 0x7F, 0xC1, 0xF8, 0xFC, 0x3F, 0xF0, 0xFE,
  0x3F, 0x0F, 0xFC, 0x3F, 0x0F, 0xC7, 0xFF, 0x1F, 0xC3, 0xF1, 0xFF, 0xC7,
  0xE0, 0xFC, 0x7F, 0xF1, 0xF8, 0x3F, 0x3E, 0xFC, 0xFC, 0x0F, 0xCF, 0xBF,
  0x3F, 0x03, 0xE7, 0xEF, 0xDF, 0xC0, 0xF9, 0xF3, 0xF7, 0xE0, 0x3E, 0xFC,
  0xFD, 0xF8, 0x0F, 0xBE, 0x3F, 0xFC, 0x03, 0xEF, 0x8F, 0xBF, 0x00, 0xFF,
  0xE3, 0xEF, 0xC0, 0x3F, 0xF0, 0xFF, 0xE0, 0x0F, 0xFC, 0x3F, 0xF8, 0x03,
  0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80,
  0x0F, 0xF0, 0x3F, 0xE0, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0xFE, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x07,
  0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xC3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0,
  0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0xF7, 0xE0, 0x00, 0x7F, 0xBF, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0x8F,
  0xE0, 0x03, 0xFC, 0x3F, 0x00, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x0F, 0xE0,
  0x1F, 0xE0, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x00,
  0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xCF, 0xE0, 0x7F, 0x3F, 0x83, 0xF8, 0x7E,
  0x0F, 0xE1, 0xF8, 0x7F, 0x07, 0xE3, 0xF8, 0x1F, 0xCF, 0xE0, 0x3F, 0x7F,
  0x00, 0xFD, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7F,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0xFC, 0x3F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xE1, 0xF8, 0x7E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x07, 0xC1, 0xF0, 0x7E, 0x1F,
  0x87, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF0,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80,
  0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x1F, 0x78, 0x03, 0xF7, 0xC0, 0x3E, 0x7C, 0x07, 0xC7, 0xC0, 0x7C,
  0x3E, 0x0F, 0x83, 0xE1, 0xF8, 0x3E, 0x1F, 0x03, 0xE3, 0xE0, 0x1F, 0x7E,
  0x01, 0xF7, 0xC0, 0x1F, 0xF8, 0x01, 0xF0, 0x7F, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x3F, 0x1F, 0xC7, 0xE1, 0xF0, 0x7C, 0x00,
  0xF0, 0xFC, 0x0F, 0xF3, 0xE0, 0x7F, 0xDF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF8, 0x7F, 0xBF, 0xC3, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x07, 0xF1,
  0xFC, 0x1F, 0xC7, 0xF0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE3, 0xF8,
  0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x83, 0xF0, 0xFE, 0x1F, 0xC3, 0xFC, 0xFF,
  0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xEF, 0x80, 0xFF, 0x3E, 0x01,
  0xF9, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xE7, 0xC0, 0x3F, 0x7F, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x87, 0xFB, 0xFC, 0x3F, 0x8F, 0xE1, 0xF8, 0x3F, 0x1F, 0xC1, 0xF8,
  0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x07, 0xF3, 0xF8, 0x3F, 0x9F, 0x81,
  0xFC, 0xFC, 0x0F, 0xC7, 0xE0, 0xFE, 0x3F, 0x07, 0xF3, 0xFC, 0x7F, 0x1F,
  0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xDF, 0xF8, 0x3E, 0xFF, 0x83, 0xF3, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x7F, 0xF0, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF,
  0x87, 0xFD, 0xE3, 0xFC, 0x08, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x02, 0x1F, 0xC3, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE,
  0x07, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0xF1, 0xF8, 0x07, 0xFB, 0xF0, 0x1F, 0xF7,
  0xE0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFD, 0xFE, 0x0F, 0xF1, 0xFC,
  0x1F, 0xC3, 0xF8, 0x3F, 0x07, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0x83,
  0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x1F, 0xC0, 0xFC, 0x3F, 0x83, 0xF0, 0x7F,
  0x07, 0xE0, 0xFE, 0x1F, 0xC1, 0xFE, 0x7F, 0x81, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x07, 0xFD, 0xF0, 0x07, 0xE3, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1,
  0xFC, 0x7F, 0x3F, 0x83, 0xF3, 0xF0, 0x7E, 0x7F, 0x07, 0xE7, 0xF3, 0xFE,
  0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0x80, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x10, 0x7F, 0xFF, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x78, 0x7E, 0x03, 0xFC,
  0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFE, 0xFF,
  0x07, 0xF8, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0x83, 0xF8, 0x7F, 0x07, 0xF0,
  0xFE, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x0F, 0xE0, 0xFE, 0x1F,
  0xC1, 0xFC, 0x3F, 0x83, 0xF0, 0x7F, 0x0F, 0xE0, 0xFF, 0x3F, 0xC0, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x03, 0xFD, 0xF8, 0x03, 0xF7,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x02, 0x00, 0xFE,
  0x07, 0x87, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00,
  0x7F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xE3, 0xC0, 0x3F, 0x7F, 0x81, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0x87, 0xE1, 0xFC, 0x3F,
  0x1F, 0xC1, 0xF8, 0xFE, 0x0F, 0xC7, 0xE0, 0xFE, 0x3F, 0x07, 0xF3, 0xF8,
  0x3F, 0x1F, 0xC1, 0xF8, 0xFE, 0x0F, 0xC7, 0xE0, 0xFE, 0x3F, 0x07, 0xF3,
  0xF8, 0x3F, 0x1F, 0xC1, 0xF8, 0xFC, 0x1F, 0xC7, 0xE0, 0xFE, 0x3F, 0x07,
  0xF3, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x7F, 0x07, 0xE0, 0xFE, 0x07, 0xE1,
  0xFC, 0x0F, 0xE1, 0xFC, 0x0F, 0xE3, 0xF8, 0x0F, 0xC7, 0xF0, 0x0F, 0xCF,
  0xE0, 0x0F, 0xDF, 0xC0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x3F, 0xBF, 0x80, 0x3F, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F,
  0xC0, 0x7E, 0x0F, 0xE0, 0x7E, 0x0F, 0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x07,
  0xF0, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0,
  0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0,
  0x3F, 0x03, 0xF8, 0x00, 0x07, 0xC3, 0xC0, 0x7C, 0x03, 0xE7, 0xF8, 0xFF,
  0x01, 0xF7, 0xFC, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFB, 0xFC, 0x3F, 0x87, 0xF8, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7F, 0x1F, 0xC1, 0xF8, 0x3F, 0x0F, 0xE1, 0xFC, 0x1F, 0x87, 0xE0, 0xFE,
  0x0F, 0xC3, 0xF0, 0x7E, 0x0F, 0xE3, 0xF8, 0x3F, 0x07, 0xF1, 0xFC, 0x1F,
  0x83, 0xF0, 0xFC, 0x1F, 0xC1, 0xF8, 0x7E, 0x0F, 0xE0, 0xFC, 0x3F, 0x07,
  0xE0, 0xFE, 0x3F, 0x83, 0xF0, 0x7F, 0x1F, 0xC1, 0xF8, 0x3F, 0x0F, 0xC1,
  0xFC, 0x1F, 0x87, 0xE0, 0xFE, 0x0F, 0xC3, 0xF0, 0x7E, 0x0F, 0xE3, 0xF8,
  0x3F, 0x07, 0xF0, 0x07, 0xC3, 0xC0, 0x3E, 0x7F, 0x81, 0xF7, 0xFE, 0x1F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0x87, 0xE1, 0xFC, 0x3F,
  0x1F, 0xC1, 0xF8, 0xFE, 0x0F, 0xC7, 0xE0, 0xFE, 0x3F, 0x07, 0xF3, 0xF8,
  0x3F, 0x1F, 0xC1, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0xFE, 0x3F, 0x07, 0xF3,
  0xF8, 0x3F, 0x1F, 0xC1, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0xFE, 0x3F, 0x07,
  0xF3, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFC, 0xFF, 0x3F, 0x87, 0xF3, 0xF8, 0x7F,
  0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xE0, 0x7F, 0x7E, 0x07,
  0xFF, 0xE0, 0x7E, 0xFE, 0x0F, 0xEF, 0xE0, 0xFE, 0xFE, 0x1F, 0xC7, 0xF1,
  0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F,
  0xF8, 0x00, 0x01, 0xF1, 0xF0, 0x03, 0xE7, 0xF0, 0x07, 0xDF, 0xF0, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0x9F, 0xC0, 0xFE, 0x1F, 0x83, 0xF8,
  0x3F, 0x07, 0xF0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x07,
  0xF0, 0xFE, 0x0F, 0xE1, 0xF8, 0x1F, 0xC3, 0xF0, 0x3F, 0x07, 0xE0, 0xFE,
  0x0F, 0xC1, 0xFC, 0x3F, 0xC7, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81,
  0xFF, 0xFE, 0x03, 0xF7, 0xF8, 0x0F, 0xE7, 0xE0, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xF8, 0xF8, 0x1F, 0xE7, 0xC1, 0xFF, 0xBE, 0x1F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x8F, 0xF7, 0xF8, 0xFF, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x07,
  0xF3, 0xF8, 0x3F, 0x9F, 0xC1, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x7F,
  0x03, 0xF3, 0xF8, 0x3F, 0x9F, 0xC1, 0xF8, 0xFE, 0x1F, 0xC7, 0xF9, 0xFE,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xEF, 0xC0, 0x7E,
  0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xC3, 0xC1, 0xF3, 0xF0, 0x7D, 0xF8, 0x3F,
  0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0x80, 0x1F, 0xE0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x01, 0xFF,
  0xE0, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xF0, 0xC1, 0xF8, 0x10,
  0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x30, 0x1F,
  0xCF, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x07, 0xFF, 0x00,
  0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF8, 0xFE, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC4, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF,
  0xC0, 0xFF, 0x80, 0x1F, 0x83, 0xF8, 0xFC, 0x1F, 0xCF, 0xE0, 0xFC, 0x7F,
  0x07, 0xE3, 0xF0, 0x7F, 0x1F, 0x83, 0xF8, 0xFC, 0x1F, 0x8F, 0xE0, 0xFC,
  0x7F, 0x07, 0xE3, 0xF0, 0x7F, 0x1F, 0x83, 0xF9, 0xFC, 0x1F, 0x8F, 0xE0,
  0xFC, 0x7E, 0x0F, 0xE3, 0xF0, 0x7F, 0x1F, 0x83, 0xF8, 0xFC, 0x3F, 0x87,
  0xF3, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFD, 0xF8, 0x3F, 0xEF,
  0x80, 0xFC, 0x7C, 0x00, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xEF,
  0xE0, 0xFE, 0xFE, 0x0F, 0xC7, 0xE1, 0xFC, 0x7E, 0x1F, 0x87, 0xE3, 0xF8,
  0x7E, 0x3F, 0x07, 0xE7, 0xF0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0xFC,
  0x07, 0xEF, 0xC0, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x0F, 0xE0, 0xFF, 0xF8, 0x1F, 0xC1, 0xFB, 0xF0, 0x7F,
  0x87, 0xF7, 0xE0, 0xFF, 0x0F, 0xC7, 0xC3, 0xFE, 0x1F, 0x8F, 0x87, 0xFC,
  0x7E, 0x1F, 0x0F, 0xF8, 0xFC, 0x3E, 0x3F, 0xF3, 0xF8, 0x7C, 0x7B, 0xE7,
  0xE0, 0xF9, 0xF7, 0xCF, 0xC1, 0xF3, 0xEF, 0xBF, 0x03, 0xE7, 0x9F, 0x7E,
  0x07, 0xDF, 0x3F, 0xF8, 0x0F, 0xBE, 0x7B, 0xF0, 0x1F, 0x78, 0xF7, 0xC0,
  0x3F, 0xF1, 0xFF, 0x80, 0x7F, 0xC3, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x01,
  0xFF, 0x0F, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F,
  0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0x83,
  0xF8, 0x3F, 0x80, 0xFC, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x9F, 0xC0,
  0x0F, 0xDF, 0xC0, 0x07, 0xEF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xEF,
  0xC0, 0x07, 0xF7, 0xE0, 0x07, 0xF3, 0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF8,
  0x7E, 0x03, 0xF8, 0x3F, 0x83, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0x83,
  0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0x3F, 0x07, 0xE0,
  0x1F, 0x87, 0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xE3, 0xF8, 0x03, 0xF1, 0xF8,
  0x01, 0xF8, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x7E,
  0x00, 0x0F, 0xBF, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0xFF, 0x80,
  0x7F, 0x80, 0x7E, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x03, 0xF8, 0x03, 0xF8,
  0x03, 0xFC, 0x07, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xFC,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0xFF, 0x03, 0xFF, 0x07, 0xFC,
  0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xA0, 0x0F, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBoldItalic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 13, 29, 11, 0, -29 },
  { 49, 16, 10, 18, 4, -29 },
  { 69, 25, 29, 24, 0, -29 },
  { 160, 21, 33, 21, 1, -31 },
  { 247, 31, 30, 34, 2, -30 },
  { 364, 27, 30, 27, 0, -30 },
  { 466, 7, 10, 10, 4, -29 },
  { 475, 15, 36, 13, 1, -30 },
  { 543, 15, 36, 13, -3, -30 },
  { 611, 19, 19, 21, 3, -31 },
  { 657, 19, 19, 22, 2, -24 },
  { 703, 10, 10, 11, -2, -5 },
  { 716, 11, 6, 13, 1, -14 },
  { 725, 8, 7, 11, 0, -7 },
  { 732, 22, 30, 17, -2, -30 },
  { 815, 20, 30, 21, 1, -30 },
  { 890, 16, 29, 21, 4, -29 },
  { 948, 22, 30, 21, -1, -30 },
  { 1031, 21, 30, 21, 0, -30 },
  { 1110, 21, 29, 21, 0, -29 },
  { 1187, 22, 29, 21, 0, -29 },
  { 1267, 21, 30, 21, 1, -30 },
  { 1346, 22, 29, 21, 1, -29 },
  { 1426, 20, 30, 21, 1, -30 },
  { 1501, 20, 30, 21, 1, -30 },
  { 1576, 11, 23, 11, 0, -23 },
  { 1608, 13, 28, 11, -2, -23 },
  { 1654, 19, 21, 22, 2, -25 },
  { 1704, 19, 13, 22, 2, -21 },
  { 1735, 19, 21, 22, 2, -25 },
  { 1785, 17, 30, 18, 2, -30 },
  { 1849, 31, 34, 33, 1, -30 },
  { 1981, 24, 29, 24, -2, -29 },
  { 2068, 24, 29, 24, 0, -29 },
  { 2155, 23, 30, 23, 2, -30 },
  { 2242, 25, 29, 26, 0, -29 },
  { 2333, 22, 29, 20, 0, -29 },
  { 2413, 22, 29, 20, 0, -29 },
  { 2493, 24, 30, 26, 2, -30 },
  { 2583, 27, 29, 27, 0, -29 },
  { 2681, 19, 29, 16, -1, -29 },
  { 2750, 20, 38, 13, -6, -29 },
  { 2845, 28, 29, 24, 0, -29 },
  { 2947, 17, 29, 19, 0, -29 },
  { 3009, 35, 29, 34, 0, -29 },
  { 3136, 29, 29, 29, 0, -29 },
  { 3242, 25, 30, 27, 2, -30 },
  { 3336, 24, 29, 23, 0, -29 },
  { 3423, 25, 37, 27, 2, -30 },
  { 3539, 23, 29, 24, 0, -29 },
  { 3623, 21, 30, 20, 0, -30 },
  { 3702, 20, 29, 20, 3, -29 },
  { 3775, 25, 29, 26, 2, -29 },
  { 3866, 22, 29, 23, 4, -29 },
  { 3946, 34, 29, 35, 4, -29 },
  { 4070, 29, 29, 24, -2, -29 },
  { 4176, 22, 29, 22, 4, -29 },
  { 4256, 25, 29, 20, -2, -29 },
  { 4347, 17, 37, 13, -1, -30 },
  { 4426, 10, 30, 17, 4, -30 },
  { 4464, 17, 37, 13, -3, -30 },
  { 4543, 20, 19, 21, 0, -29 },
  { 4591, 17, 4, 16, -4, 3 },
  { 4600, 9, 6, 13, 6, -31 },
  { 4607, 22, 23, 23, 1, -23 },
  { 4671, 21, 31, 23, 0, -31 },
  { 4753, 18, 23, 19, 1, -23 },
  { 4805, 23, 31, 23, 1, -31 },
  { 4895, 20, 23, 21, 1, -23 },
  { 4953, 23, 41, 15, -4, -31 },
  { 5071, 23, 33, 23, 0, -23 },
  { 5166, 21, 31, 23, 0, -31 },
  { 5248, 13, 31, 12, 0, -31 },
  { 5299, 18, 41, 12, -5, -31 },
  { 5392, 24, 31, 22, 0, -31 },
  { 5485, 13, 31, 12, 0, -31 },
  { 5536, 33, 23, 34, 0, -23 },
  { 5631, 21, 23, 23, 0, -23 },
  { 5692, 20, 23, 22, 1, -23 },
  { 5750, 23, 33, 23, -2, -23 },
  { 5845, 21, 33, 23, 1, -23 },
  { 5932, 18, 23, 16, 0, -23 },
  { 5984, 18, 23, 18, 0, -23 },
  { 6036, 15, 27, 16, 2, -27 },
  { 6087, 21, 23, 23, 2, -23 },
  { 6148, 20, 23, 20, 2, -23 },
  { 6206, 31, 23, 31, 2, -23 },
  { 6296, 25, 23, 21, -2, -23 },
  { 6368, 25, 33, 20, -3, -23 },
  { 6472, 20, 23, 18, -1, -23 },
  { 6530, 17, 35, 14, 0, -29 },
  { 6605, 5, 40, 20, 8, -31 },
  { 6630, 16, 35, 14, -2, -29 },
  { 6700, 19, 7, 22, 2, -18 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBoldItalic41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBoldItalic41pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBoldItalic41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC41PT7B_H_
