#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC45PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBoldItalic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBoldItalic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xE0,
  0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0x80, 0x10, 0x00, 0x3F,
  0x9F, 0xCF, 0xC7, 0xE7, 0xF1, 0xF9, 0xFC, 0xFE, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xF1, 0xF0, 0xF8, 0x7C, 0x3E, 0x3F, 0x0F, 0x8F, 0xC7, 0xE0,
  0x00, 0x0F, 0x8F, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01,
  0xF1, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x1F,
  0x00, 0x07, 0xE3, 0xE0, 0x00, 0x7C, 0x3E, 0x10, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0x87,
  0xC0, 0x01, 0xF8, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00,
  0x1F, 0x1F, 0x00, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x3E, 0x00,
  0x0F, 0xC7, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8,
  0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x1F, 0x80,
  0x03, 0xE1, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C,
  0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xDC, 0x70, 0x7F, 0x38, 0x20,
  0xFE, 0x60, 0x01, 0xFD, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1D, 0xFC, 0x00, 0x39,
  0xF8, 0x80, 0x73, 0xF1, 0xC0, 0xEF, 0xE3, 0xFB, 0xBF, 0xC7, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0x80,
  0xFF, 0xC0, 0x0F, 0xC0, 0x3F, 0xF8, 0x03, 0xE0, 0x1F, 0xFE, 0x01, 0xF0,
  0x0F, 0xCF, 0x80, 0xFC, 0x03, 0xF3, 0xF0, 0x3E, 0x01, 0xF8, 0xFC, 0x1F,
  0x00, 0x7E, 0x3F, 0x0F, 0xC0, 0x1F, 0x0F, 0xC3, 0xE0, 0x07, 0xC3, 0xE1,
  0xF0, 0x01, 0xF0, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x3E, 0x00, 0x3F, 0x1F,
  0x9F, 0x0F, 0x0F, 0xC7, 0xCF, 0xCF, 0xF1, 0xF3, 0xF3, 0xE7, 0xFE, 0x7F,
  0xF9, 0xF3, 0xFF, 0xDF, 0xFE, 0xFC, 0xFF, 0xF3, 0xFF, 0x3E, 0x7E, 0x7C,
  0x7F, 0x1F, 0x1F, 0x1F, 0x02, 0x0F, 0xCF, 0xC7, 0xC0, 0x03, 0xE3, 0xE1,
  0xF0, 0x01, 0xF0, 0xF8, 0x7C, 0x00, 0xFC, 0x7E, 0x1F, 0x00, 0x3E, 0x1F,
  0x8F, 0xC0, 0x1F, 0x07, 0xE3, 0xF0, 0x0F, 0xC1, 0xF8, 0xF8, 0x03, 0xE0,
  0x7E, 0x7E, 0x01, 0xF0, 0x1F, 0xBF, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x3E,
  0x00, 0xFF, 0xE0, 0x1F, 0x00, 0x1F, 0xF0, 0x0F, 0xC0, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xF8, 0xFE,
  0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x0F, 0xC0, 0x03,
  0xF1, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x7F, 0x07, 0xFF, 0x07, 0xF1,
  0xFF, 0xF0, 0x7F, 0x3F, 0xFF, 0x8F, 0xE7, 0xFF, 0xF8, 0xFE, 0x7F, 0xBF,
  0xDF, 0xCF, 0xF1, 0xFF, 0xFC, 0xFE, 0x1F, 0xFF, 0x8F, 0xE0, 0xFF, 0xF8,
  0xFE, 0x07, 0xFF, 0x0F, 0xE0, 0x7F, 0xE0, 0xFE, 0x07, 0xFC, 0x0F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x03, 0xFF, 0xF7, 0xF8, 0x0F, 0xFC, 0x7F, 0xC0, 0x3F, 0x9F, 0x9F, 0xCF,
  0xE7, 0xE3, 0xF1, 0xF8, 0xF8, 0x7C, 0x7E, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F,
  0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80,
  0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0,
  0x03, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x00,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x40, 0xFC, 0x07,
  0x0F, 0x80, 0x78, 0xF8, 0x0F, 0xEF, 0x80, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0x81, 0x1F, 0xFC,
  0x03, 0xFF, 0xC0, 0xFF, 0x7E, 0x07, 0xE3, 0xE0, 0x1E, 0x3F, 0x00, 0xC3,
  0xF0, 0x04, 0x1C, 0x00, 0x01, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x0F, 0xE3, 0xF8, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F,
  0x0F, 0xC3, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7C, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0x3F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7E, 0x10, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7F,
  0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFC, 0x7F,
  0x1F, 0xE1, 0xFC, 0x7F, 0x07, 0xF1, 0xFC, 0x1F, 0xCF, 0xF0, 0x7F, 0x3F,
  0x81, 0xFC, 0xFE, 0x07, 0xF7, 0xF8, 0x1F, 0xDF, 0xC0, 0x7F, 0x7F, 0x01,
  0xFD, 0xFC, 0x0F, 0xF7, 0xF0, 0x3F, 0xBF, 0xC0, 0xFE, 0xFF, 0x03, 0xFB,
  0xF8, 0x1F, 0xEF, 0xE0, 0x7F, 0x3F, 0x81, 0xFC, 0xFE, 0x0F, 0xF3, 0xF8,
  0x3F, 0x87, 0xF1, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xE3, 0xFF,
  0xF1, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xDF, 0xC7, 0xE7, 0xF0, 0xE3, 0xF8,
  0x10, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xE0, 0xFF, 0x01, 0xC0, 0xFF,
  0x00, 0x80, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0x00, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFC, 0xFF, 0x80, 0xC0, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF9,
  0x00, 0x0F, 0xF3, 0x00, 0x3F, 0xC7, 0xF7, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0xFB, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xDF, 0xC0, 0x1F, 0x3F,
  0x80, 0x7E, 0x7E, 0x01, 0xF9, 0xFC, 0x07, 0xE3, 0xF8, 0x0F, 0x87, 0xF0,
  0x3F, 0x0F, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7F, 0x07, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0x01, 0xFF,
  0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xEC, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x06, 0x0F,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x80, 0x0F, 0xF0, 0xE0, 0x1F,
  0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x7F, 0xE1, 0x83, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x1F, 0x81, 0xFD, 0xFF, 0x07, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xF8, 0xFF, 0x3F,
  0xC1, 0xFC, 0xFE, 0x07, 0xF3, 0xF8, 0x1F, 0xCF, 0xE0, 0x7F, 0x3F, 0x83,
  0xFC, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE1, 0xFE, 0x3F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83,
  0xFC, 0x7F, 0x87, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xF8, 0x3F,
  0x87, 0xF0, 0x7F, 0x1F, 0xE0, 0xFF, 0x7F, 0x80, 0xFF, 0xFE, 0x01, 0xFF,
  0xF8, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7F, 0xFF,
  0x81, 0xFF, 0xFF, 0x07, 0xF8, 0xFF, 0x0F, 0xE0, 0xFE, 0x3F, 0x81, 0xFC,
  0x7F, 0x03, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7,
  0xF8, 0x7F, 0x8F, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x03, 0xFF, 0x00, 0x1F,
  0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0x7F,
  0x87, 0xF0, 0xFF, 0x3F, 0xC1, 0xFC, 0xFE, 0x07, 0xF3, 0xF8, 0x1F, 0xCF,
  0xE0, 0x7F, 0x3F, 0x83, 0xFC, 0xFE, 0x0F, 0xF3, 0xF8, 0x3F, 0xCF, 0xE1,
  0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFE, 0xFE,
  0x0F, 0xF3, 0xF0, 0x1F, 0x9F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x3C, 0xFF, 0xE0, 0xFF, 0xFF,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xE0, 0x7F, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x07, 0xE0, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0x7E, 0x01, 0x00, 0x00, 0x3C, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x3F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07,
  0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFE,
  0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x78,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x03, 0xFF, 0x83, 0xFF, 0xF1,
  0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xFF, 0xF3, 0xE3, 0xFC, 0xE0, 0x7F, 0x20,
  0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xF0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x7E, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0xFE, 0x0F,
  0x87, 0xC0, 0xFF, 0xF3, 0xE3, 0xF0, 0xFF, 0xF8, 0xF8, 0xF8, 0x7F, 0xFE,
  0x1E, 0x7E, 0x1F, 0x8F, 0x87, 0xDF, 0x0F, 0xC7, 0xE1, 0xE7, 0xC7, 0xE1,
  0xF0, 0xFB, 0xE1, 0xF0, 0x7C, 0x3E, 0xF8, 0x7C, 0x1F, 0x0F, 0xBE, 0x3E,
  0x0F, 0xC3, 0xEF, 0x8F, 0x83, 0xE0, 0xFB, 0xE3, 0xE0, 0xF8, 0x7C, 0xF8,
  0xF8, 0x7E, 0x1F, 0x3E, 0x3E, 0x1F, 0x8F, 0x8F, 0x8F, 0x8F, 0xE7, 0xE3,
  0xE3, 0xFF, 0xFF, 0xF0, 0xF8, 0xFF, 0xDF, 0xF8, 0x3E, 0x1F, 0xE7, 0xFC,
  0x0F, 0x83, 0xF0, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x60, 0x00, 0x7F, 0xEF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xDF, 0x80, 0x03, 0xFB, 0xF8, 0x00, 0x7E, 0x7F, 0x00, 0x1F, 0xCF, 0xE0,
  0x03, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x07, 0xF0,
  0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x01,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE3, 0xFC, 0x01, 0xFC, 0x7F,
  0x00, 0x3F, 0x9F, 0xE0, 0x07, 0xF3, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x1F,
  0xDF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFC, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x87,
  0xF8, 0x3F, 0xC3, 0xF8, 0x1F, 0xC1, 0xFC, 0x1F, 0xE0, 0xFE, 0x7F, 0xE0,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x1F,
  0xC1, 0xFC, 0x0F, 0xF0, 0xFE, 0x07, 0xF0, 0xFF, 0x03, 0xF8, 0x7F, 0x03,
  0xFC, 0x3F, 0x83, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xF0, 0x1C,
  0x1F, 0xF0, 0x02, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x18, 0x0F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xE0, 0x7F, 0x0F, 0xF8, 0x1F, 0xC1, 0xFF, 0x0F, 0xF0, 0x3F,
  0xC3, 0xFC, 0x0F, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0,
  0x1F, 0xC7, 0xF8, 0x07, 0xF1, 0xFE, 0x03, 0xFC, 0x7F, 0x00, 0xFF, 0x1F,
  0xC0, 0x3F, 0xC7, 0xF0, 0x0F, 0xF3, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xFE,
  0x3F, 0x80, 0x7F, 0x8F, 0xE0, 0x3F, 0xC3, 0xF8, 0x0F, 0xF1, 0xFE, 0x07,
  0xF8, 0x7F, 0x03, 0xFE, 0x1F, 0xC3, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xE0, 0x18, 0x0F, 0xF8,
  0x01, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x3F,
  0xFC, 0x7F, 0x07, 0xFF, 0x9F, 0xE0, 0xFF, 0xE3, 0xFC, 0x3F, 0xFC, 0x7F,
  0x87, 0xFF, 0x8F, 0xF0, 0x07, 0xF1, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x3F,
  0x87, 0xF8, 0x07, 0xF0, 0xFF, 0x00, 0xFE, 0x0F, 0xF0, 0x1F, 0xC1, 0xFF,
  0x07, 0xF8, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x03,
  0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0xC0, 0xFE, 0x01, 0xFC, 0x07, 0xF0,
  0x0F, 0xE0, 0x7F, 0x80, 0x7F, 0x03, 0xF8, 0x07, 0xF8, 0x1F, 0xC0, 0x3F,
  0xC0, 0xFE, 0x01, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0x7F, 0x80, 0x7F, 0x03,
  0xF8, 0x07, 0xF8, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFF, 0x03,
  0xF8, 0x07, 0xF8, 0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x0F, 0xF0,
  0x0F, 0xE0, 0x7F, 0x00, 0xFF, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F,
  0x81, 0xFE, 0x01, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFF, 0x03,
  0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x01, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x80,
  0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x31,
  0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x1F,
  0xC0, 0x7F, 0x80, 0xFE, 0x07, 0xF8, 0x07, 0xF0, 0x7F, 0x80, 0x7F, 0x87,
  0xFC, 0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0xC3, 0xFC, 0x00, 0xFE, 0x3F, 0xC0,
  0x0F, 0xF3, 0xFE, 0x00, 0x7F, 0x1F, 0xE0, 0x03, 0xF9, 0xFE, 0x00, 0x1F,
  0xDF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0xC0, 0x0F, 0xF1, 0xFE, 0x00, 0x7F, 0x07,
  0xF0, 0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xF0,
  0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x1F,
  0xC0, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF,
  0xFB, 0xFF, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x01, 0xFF,
  0xC0, 0xFF, 0xC0, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xF0,
  0x07, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0xC0,
  0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F,
  0xBF, 0x03, 0xF7, 0xC0, 0xFF, 0xF8, 0x1F, 0xBE, 0x07, 0xDF, 0xC0, 0xFD,
  0xF0, 0x7E, 0xFC, 0x0F, 0xEF, 0x83, 0xFF, 0xE0, 0x7F, 0x7C, 0x3F, 0x7F,
  0x03, 0xFB, 0xE1, 0xFB, 0xF8, 0x1F, 0x9F, 0x1F, 0x9F, 0x80, 0xFC, 0xF8,
  0xFC, 0xFC, 0x0F, 0xE7, 0xCF, 0xCF, 0xE0, 0x7F, 0x3E, 0x7E, 0x7F, 0x03,
  0xF9, 0xF7, 0xE3, 0xF8, 0x1F, 0x8F, 0xFF, 0x1F, 0x80, 0xFC, 0x7F, 0xF0,
  0xFC, 0x0F, 0xE3, 0xFF, 0x8F, 0xE0, 0x7F, 0x1F, 0xF8, 0x7F, 0x03, 0xF0,
  0xFF, 0xC3, 0xF8, 0x1F, 0x87, 0xFC, 0x1F, 0x81, 0xFC, 0x3F, 0xE1, 0xFC,
  0x0F, 0xE1, 0xFE, 0x0F, 0xE0, 0x7F, 0x0F, 0xF0, 0x7F, 0x03, 0xF0, 0x7F,
  0x83, 0xF8, 0x1F, 0x83, 0xF8, 0x1F, 0x80, 0x03, 0xFE, 0x00, 0x7E, 0x07,
  0xFC, 0x01, 0xFC, 0x0F, 0xF8, 0x03, 0xF8, 0x1F, 0xF8, 0x07, 0xF0, 0x7F,
  0xF0, 0x0F, 0xC0, 0xFF, 0xE0, 0x1F, 0x81, 0xFF, 0xC0, 0x7F, 0x03, 0xFF,
  0xC0, 0xFE, 0x0F, 0xFF, 0x81, 0xFC, 0x1F, 0xFF, 0x03, 0xF0, 0x3F, 0x7E,
  0x0F, 0xE0, 0x7E, 0xFE, 0x1F, 0xC0, 0xFD, 0xFC, 0x3F, 0x83, 0xF9, 0xF8,
  0x7E, 0x07, 0xF3, 0xF0, 0xFC, 0x0F, 0xE7, 0xF3, 0xF8, 0x1F, 0x8F, 0xE7,
  0xF0, 0x3F, 0x0F, 0xCF, 0xE0, 0xFE, 0x1F, 0xDF, 0x81, 0xFC, 0x3F, 0xBF,
  0x03, 0xF8, 0x7F, 0x7E, 0x07, 0xE0, 0x7E, 0xFC, 0x0F, 0xC0, 0xFF, 0xF8,
  0x3F, 0x81, 0xFF, 0xE0, 0x7F, 0x03, 0xFF, 0xC0, 0xFE, 0x03, 0xFF, 0x81,
  0xF8, 0x07, 0xFF, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xE0, 0x1F, 0xF8, 0x1F,
  0xC0, 0x1F, 0xF0, 0x3F, 0x00, 0x3F, 0xE0, 0x7E, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F,
  0xC1, 0xFF, 0x1F, 0xF0, 0x1F, 0xE3, 0xFC, 0x03, 0xFC, 0xFF, 0x00, 0x3F,
  0x9F, 0xE0, 0x07, 0xF3, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x1F, 0xDF, 0xE0,
  0x03, 0xFB, 0xF8, 0x00, 0xFF, 0x7F, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0x7F, 0x80, 0x0F, 0xEF, 0xF0, 0x03, 0xFD, 0xFE, 0x00,
  0x7F, 0xBF, 0xC0, 0x1F, 0xE7, 0xF8, 0x03, 0xFC, 0xFF, 0x00, 0xFF, 0x0F,
  0xE0, 0x3F, 0xE1, 0xFE, 0x0F, 0xF8, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xC3,
  0xFE, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xC3, 0xF8,
  0x1F, 0xE1, 0xFC, 0x0F, 0xF0, 0xFE, 0x07, 0xF0, 0xFF, 0x07, 0xF8, 0x7F,
  0x0F, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xC1, 0xFF, 0x1F, 0xF0,
  0x1F, 0xE3, 0xFC, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0x9F, 0xE0, 0x07, 0xF3,
  0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x1F, 0xDF, 0xE0, 0x03, 0xFB, 0xF8, 0x00,
  0xFF, 0x7F, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0x7F,
  0x80, 0x0F, 0xEF, 0xF0, 0x03, 0xFD, 0xFE, 0x00, 0x7F, 0xBF, 0xC0, 0x1F,
  0xE7, 0xF8, 0x03, 0xFC, 0xFF, 0x00, 0xFF, 0x0F, 0xE0, 0x3F, 0xE1, 0xFE,
  0x0F, 0xF8, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xF0, 0xFF, 0x07,
  0xF0, 0x7F, 0x0F, 0xF0, 0x7F, 0x0F, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F,
  0xE0, 0xFF, 0x0F, 0xE0, 0xFF, 0x1F, 0xE1, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0x3F, 0x9F, 0xE0, 0x3F, 0x8F, 0xE0, 0x3F, 0x8F, 0xE0, 0x7F,
  0x8F, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF8, 0xFF,
  0x07, 0xF8, 0xFF, 0x03, 0xF8, 0xFE, 0x03, 0xFC, 0xFE, 0x03, 0xFC, 0xFE,
  0x01, 0xFE, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFC,
  0x0C, 0x0F, 0xF0, 0x08, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x80, 0x1F, 0xC1, 0xE0, 0x7F, 0x83, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x87,
  0xF8, 0x0F, 0xF0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07,
  0xF0, 0x7F, 0x00, 0xFE, 0x1F, 0xE0, 0x3F, 0xC3, 0xF8, 0x07, 0xF0, 0x7F,
  0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC3, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0xFF,
  0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x0F, 0xF0,
  0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xE0,
  0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xE0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xBF, 0x80, 0x3F, 0xDF, 0xC0,
  0x1F, 0xCF, 0xE0, 0x1F, 0xE7, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xF1, 0xFC,
  0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x0F,
  0xC1, 0xFE, 0x07, 0xE0, 0xFE, 0x03, 0xF0, 0xFF, 0x01, 0xF8, 0x7F, 0x00,
  0xFC, 0x3F, 0x80, 0x7E, 0x3F, 0x80, 0x3F, 0x1F, 0xC0, 0x1F, 0x9F, 0xC0,
  0x0F, 0xCF, 0xE0, 0x07, 0xEF, 0xE0, 0x03, 0xF7, 0xF0, 0x01, 0xFB, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0xFC, 0x03, 0xFF, 0xF8, 0x07,
  0xF0, 0x0F, 0xEF, 0xE0, 0x1F, 0xC0, 0x3F, 0xBF, 0x80, 0xFF, 0x01, 0xFC,
  0xFE, 0x03, 0xFC, 0x07, 0xF3, 0xF8, 0x1F, 0xF0, 0x3F, 0xCF, 0xE0, 0x7F,
  0xC0, 0xFE, 0x3F, 0x83, 0xFF, 0x03, 0xF8, 0xFE, 0x0F, 0xFC, 0x1F, 0xC3,
  0xF8, 0x3F, 0xF0, 0x7F, 0x0F, 0xE1, 0xFF, 0xC1, 0xF8, 0x3F, 0x87, 0xFF,
  0x0F, 0xE0, 0xFE, 0x3F, 0xFC, 0x3F, 0x83, 0xF0, 0xFF, 0xF1, 0xFC, 0x0F,
  0xC7, 0xEF, 0xC7, 0xF0, 0x3F, 0x1F, 0xBF, 0x1F, 0x80, 0xFC, 0x7E, 0xFC,
  0xFE, 0x03, 0xF3, 0xF3, 0xF3, 0xF8, 0x0F, 0xCF, 0xCF, 0xDF, 0xC0, 0x3F,
  0x7E, 0x3F, 0x7F, 0x00, 0xFD, 0xF8, 0xFD, 0xF8, 0x03, 0xF7, 0xE3, 0xFF,
  0xE0, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x00, 0xFF,
  0xE0, 0xFF, 0xF0, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xFE,
  0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xFE,
  0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x7F, 0x87,
  0xF0, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x3F, 0x9F,
  0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x03, 0xFC, 0xFF,
  0x00, 0x03, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x0F, 0xF0, 0x7F,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0x3F,
  0x80, 0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x80, 0x3F, 0xC0, 0xFE, 0x00, 0xFF,
  0xFF, 0x01, 0xFE, 0x7F, 0x01, 0xFC, 0x7F, 0x03, 0xFC, 0x7F, 0x03, 0xF8,
  0x7F, 0x07, 0xF0, 0x7F, 0x0F, 0xF0, 0x3F, 0x8F, 0xE0, 0x3F, 0x9F, 0xE0,
  0x3F, 0x9F, 0xC0, 0x3F, 0xBF, 0x80, 0x3F, 0xBF, 0x80, 0x1F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xF0, 0x0F, 0xFE,
  0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x03, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFE, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7F, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0xFB, 0xE0, 0x07, 0xEF, 0x80, 0x3F, 0x3F, 0x00, 0xFC, 0x7C,
  0x07, 0xE1, 0xF0, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0x3E, 0x1F,
  0x00, 0xF8, 0xFC, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x1F, 0xFC, 0x00,
  0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0xFF,
  0x1F, 0xE3, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7C, 0x00, 0xFC, 0x3F, 0x01,
  0xFE, 0x7E, 0x07, 0xFF, 0x7E, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0xC1, 0xFC, 0x3F, 0xC1, 0xFC, 0x3F,
  0x81, 0xFC, 0x7F, 0x81, 0xFC, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F,
  0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x07, 0xF0, 0xFF, 0x07, 0xF0, 0xFF,
  0x07, 0xF0, 0x7F, 0x0F, 0xF0, 0x7F, 0xBF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0x3F, 0xF7, 0xE0, 0x3F, 0xE7, 0xE0, 0x1F, 0xC7, 0xE0, 0x01,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE7, 0xE0, 0x1F, 0xDF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xF8, 0x7F, 0x0F, 0xE0, 0xFE,
  0x1F, 0xC1, 0xFC, 0x3F, 0x03, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xE3,
  0xF8, 0x1F, 0xC7, 0xE0, 0x3F, 0x9F, 0xC0, 0xFF, 0x3F, 0x81, 0xFC, 0x7F,
  0x03, 0xF8, 0xFE, 0x0F, 0xF1, 0xFE, 0x3F, 0xC7, 0xFE, 0xFF, 0x8F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7C, 0xFF, 0xC1, 0xF8, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF,
  0xFC, 0x7F, 0xFF, 0x0F, 0xF0, 0x23, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x08, 0x7F, 0xDF,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0x1F, 0xC0, 0x1F, 0xE7,
  0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0x7F, 0x8F, 0xF0, 0x3F, 0xC1, 0xFC, 0x0F, 0xF0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC1, 0xFE, 0x07, 0xE0, 0x7F, 0x01, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0xC1,
  0xFC, 0x0F, 0xF0, 0x7F, 0x01, 0xFC, 0x3F, 0xC0, 0x7F, 0x9F, 0xF0, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xF7, 0xE0,
  0x03, 0xF1, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFE, 0x01, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xE1, 0xFC, 0xFE, 0x0F, 0xEF, 0xF0,
  0x7F, 0x7F, 0x07, 0xF3, 0xF8, 0x7F, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFC, 0x7F, 0xFF, 0x83, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x21, 0xFE, 0x07, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFC, 0x40, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x08, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x1F, 0x80, 0x7F, 0x9F, 0x80, 0xFF, 0xEF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xC7, 0xF8, 0x3F,
  0xC1, 0xFC, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7F, 0x0F, 0xF0, 0x3F, 0x87,
  0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x3F, 0xC3, 0xFC, 0x0F, 0xE1, 0xFE,
  0x07, 0xFB, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xC0, 0x3F, 0xEF, 0xE0, 0x0F, 0xE7, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x08, 0x01, 0xFE, 0x07, 0x01, 0xFE, 0x03, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF1, 0xF8,
  0x07, 0xF7, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x0F, 0xF8, 0xFF, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x1F, 0xE0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE,
  0x1F, 0xC1, 0xFC, 0x3F, 0xC1, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC,
  0x3F, 0x83, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x83, 0xF8, 0x7F, 0x03, 0xF8,
  0x7F, 0x03, 0xF8, 0x7F, 0x07, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x07, 0xF0,
  0x00, 0x20, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0x80, 0x10, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x07, 0xF8, 0x08, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF,
  0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x1F, 0xC0, 0xFF, 0x03, 0xF8,
  0x3F, 0xC0, 0x7F, 0x0F, 0xF0, 0x0F, 0xE3, 0xFC, 0x03, 0xF8, 0xFF, 0x00,
  0x7F, 0x3F, 0xC0, 0x0F, 0xE7, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0x7F,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFB, 0xFC,
  0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x07, 0xF0, 0xFF, 0x00, 0xFE,
  0x0F, 0xE0, 0x1F, 0xC1, 0xFE, 0x03, 0xF8, 0x3F, 0xC0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0x7F, 0x80, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F,
  0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x1F,
  0x80, 0x7E, 0x7F, 0xC7, 0xFC, 0x07, 0xEF, 0xFC, 0xFF, 0xE0, 0x7F, 0xFF,
  0xEF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0xF8, 0xFF, 0x8F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7F, 0x0F, 0xE0, 0xFF, 0x07,
  0xF0, 0xFE, 0x0F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFE, 0x0F, 0xE1, 0xFC, 0x0F,
  0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x0F, 0xE1, 0xFC, 0x1F, 0xC0, 0xFE, 0x3F,
  0xC1, 0xFC, 0x1F, 0xE3, 0xF8, 0x1F, 0xC1, 0xFC, 0x3F, 0x81, 0xFC, 0x1F,
  0xC3, 0xF8, 0x3F, 0x81, 0xFC, 0x3F, 0x83, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F,
  0x83, 0xF8, 0x7F, 0x03, 0xF8, 0x3F, 0x87, 0xF0, 0x3F, 0x83, 0xF8, 0x7F,
  0x07, 0xF0, 0x3F, 0x87, 0xF0, 0x7F, 0x03, 0xF8, 0xFE, 0x07, 0xF0, 0x7F,
  0x00, 0x07, 0xE1, 0xF8, 0x07, 0xE7, 0xFC, 0x07, 0xEF, 0xFE, 0x07, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xF8, 0xFF, 0x0F, 0xF0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xE0, 0xFE, 0x1F, 0xC0,
  0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0xC1, 0xFC, 0x3F, 0x81,
  0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x83,
  0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x07, 0xF8, 0x7F, 0x07,
  0xF0, 0xFE, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0xFF, 0x1F, 0xEF, 0xF0,
  0x7F, 0x7F, 0x03, 0xFB, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xDF, 0xC0, 0xFE, 0xFE, 0x0F,
  0xF7, 0xF0, 0x7F, 0x3F, 0x87, 0xF9, 0xFE, 0x7F, 0x8F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0xFC, 0xFF, 0x00, 0x7E, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xF0, 0xFE, 0x07, 0xF0, 0x7F, 0x03,
  0xF8, 0x3F, 0x81, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0,
  0x7F, 0x03, 0xF8, 0x3F, 0x01, 0xFC, 0x3F, 0x81, 0xFE, 0x1F, 0xC0, 0xFE,
  0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x83, 0xFC, 0x7F, 0x83, 0xFF, 0x7F,
  0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0x3F,
  0xE0, 0x3F, 0x8F, 0xC0, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x3F, 0x01, 0xFE, 0x7E, 0x03, 0xFF, 0x7E,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xE3, 0xFC,
  0x3F, 0xC1, 0xFC, 0x3F, 0xC1, 0xFC, 0x3F, 0x81, 0xFC, 0x7F, 0x81, 0xFC,
  0x7F, 0x01, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8,
  0x7F, 0x03, 0xF0, 0xFF, 0x07, 0xF0, 0xFF, 0x07, 0xF0, 0x7F, 0x0F, 0xF0,
  0x7F, 0xBF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0x3F, 0xEF, 0xE0, 0x1F, 0xCF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x07, 0xE1, 0xF0, 0x7E, 0x7E, 0x07, 0xEF, 0xE0, 0x7E,
  0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0x80, 0x0F,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFE, 0x07,
  0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC1, 0xFE, 0x3C, 0x1F, 0xC0, 0x41,
  0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x80, 0x3F, 0x8F, 0x87, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0xFF, 0xFC,
  0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0x83, 0xF8, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFF, 0xB0, 0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x01, 0xFF,
  0x80, 0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x07, 0xF8, 0xFE, 0x0F,
  0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F, 0x1F, 0xC1, 0xFC,
  0x3F, 0x83, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7,
  0xF0, 0x7F, 0x1F, 0xE0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x07, 0xF8, 0xFE,
  0x0F, 0xF1, 0xFC, 0x1F, 0xC3, 0xF8, 0x7F, 0x87, 0xFB, 0xFF, 0x0F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF8, 0x1F, 0xFB, 0xF0, 0x3F, 0xF7, 0xE0, 0x3F, 0x8F,
  0xC0, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xF9, 0xF8, 0x0F, 0xE3, 0xF0, 0x1F,
  0xC7, 0xE0, 0x7F, 0x0F, 0xC0, 0xFE, 0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0,
  0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0xFE, 0x03, 0xF9, 0xFC, 0x07,
  0xF3, 0xF0, 0x07, 0xEF, 0xE0, 0x0F, 0xDF, 0x80, 0x1F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0xFC, 0x0F, 0xF0, 0x3F, 0xFE, 0x07, 0xF8, 0x3F, 0xBF, 0x07, 0xFC,
  0x1F, 0xDF, 0x83, 0xFE, 0x0F, 0xCF, 0xC1, 0xFF, 0x0F, 0xE7, 0xE1, 0xFF,
  0x87, 0xF3, 0xF0, 0xFF, 0xC7, 0xF1, 0xF8, 0xFB, 0xE3, 0xF8, 0xFC, 0x7D,
  0xF1, 0xF8, 0x7E, 0x3E, 0xF9, 0xFC, 0x3F, 0x3E, 0xFC, 0xFC, 0x1F, 0x9F,
  0x7E, 0xFE, 0x0F, 0xDF, 0xBF, 0x7E, 0x07, 0xEF, 0x9F, 0xBF, 0x03, 0xF7,
  0xCF, 0xBF, 0x81, 0xFF, 0xE7, 0xDF, 0x80, 0xFF, 0xE3, 0xEF, 0xC0, 0x7F,
  0xF1, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xE0, 0x1F, 0xF8, 0x7F, 0xE0, 0x0F,
  0xFC, 0x3F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xF8, 0x01,
  0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x1F,
  0xE0, 0x7F, 0x07, 0xF8, 0x0F, 0xE0, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x1F,
  0xCF, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xDF,
  0xC0, 0x07, 0xF3, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x7F, 0x87, 0xF0, 0x1F,
  0xE0, 0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xF0,
  0x0F, 0xF0, 0x7F, 0x00, 0xFE, 0x03, 0xF0, 0x1F, 0xE0, 0x3F, 0x81, 0xFC,
  0x03, 0xF8, 0x3F, 0xC0, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x3F,
  0x87, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFC,
  0x00, 0x1F, 0x9F, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0xBF, 0x80, 0x01,
  0xFB, 0xF0, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x3E, 0x00,
  0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFE,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x0B, 0xFF, 0x00, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xD0, 0x01,
  0xFC,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBoldItalic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 14, 33, 13, 0, -32 },
  { 59, 18, 11, 20, 4, -32 },
  { 84, 28, 32, 27, 0, -32 },
  { 196, 23, 37, 23, 1, -34 },
  { 303, 34, 33, 38, 2, -33 },
  { 444, 28, 33, 30, 1, -33 },
  { 560, 9, 11, 11, 4, -32 },
  { 573, 17, 40, 15, 1, -33 },
  { 658, 17, 40, 15, -3, -33 },
  { 743, 20, 22, 23, 4, -35 },
  { 798, 21, 22, 24, 2, -27 },
  { 856, 11, 12, 13, -2, -6 },
  { 873, 12, 6, 14, 1, -15 },
  { 882, 8, 8, 13, 0, -7 },
  { 890, 24, 32, 19, -2, -32 },
  { 986, 22, 33, 23, 1, -33 },
  { 1077, 18, 32, 24, 4, -32 },
  { 1149, 24, 33, 23, -1, -33 },
  { 1248, 23, 33, 23, 0, -33 },
  { 1343, 23, 32, 24, 0, -32 },
  { 1435, 24, 32, 23, 0, -32 },
  { 1531, 22, 33, 23, 2, -33 },
  { 1622, 25, 32, 23, 1, -32 },
  { 1722, 23, 33, 23, 1, -33 },
  { 1817, 22, 33, 23, 1, -33 },
  { 1908, 12, 26, 13, 0, -25 },
  { 1947, 15, 31, 13, -3, -25 },
  { 2006, 21, 23, 24, 2, -28 },
  { 2067, 21, 14, 24, 2, -23 },
  { 2104, 21, 23, 24, 2, -28 },
  { 2165, 18, 34, 19, 3, -33 },
  { 2242, 34, 36, 36, 2, -32 },
  { 2395, 27, 32, 27, -3, -32 },
  { 2503, 25, 32, 26, 1, -32 },
  { 2603, 25, 33, 25, 2, -33 },
  { 2707, 26, 32, 28, 1, -32 },
  { 2811, 23, 32, 22, 1, -32 },
  { 2903, 23, 32, 22, 1, -32 },
  { 2995, 27, 33, 29, 2, -33 },
  { 3107, 29, 32, 29, 1, -32 },
  { 3223, 22, 32, 17, -2, -32 },
  { 3311, 22, 42, 14, -7, -32 },
  { 3427, 29, 32, 26, 1, -32 },
  { 3543, 18, 32, 21, 1, -32 },
  { 3615, 37, 32, 37, 1, -32 },
  { 3763, 31, 32, 32, 1, -32 },
  { 3887, 27, 33, 30, 2, -33 },
  { 3999, 25, 32, 25, 1, -32 },
  { 4099, 27, 41, 30, 2, -33 },
  { 4238, 24, 32, 26, 1, -32 },
  { 4334, 23, 33, 22, 0, -33 },
  { 4429, 21, 32, 22, 4, -32 },
  { 4513, 27, 32, 29, 2, -32 },
  { 4621, 25, 32, 25, 4, -32 },
  { 4721, 38, 32, 38, 4, -32 },
  { 4873, 32, 32, 26, -3, -32 },
  { 5001, 24, 32, 24, 4, -32 },
  { 5097, 27, 32, 22, -2, -32 },
  { 5205, 19, 40, 15, -1, -33 },
  { 5300, 11, 32, 19, 5, -32 },
  { 5344, 19, 40, 15, -3, -33 },
  { 5439, 22, 21, 23, 0, -32 },
  { 5497, 19, 4, 18, -4, 4 },
  { 5507, 10, 7, 15, 6, -34 },
  { 5516, 24, 25, 25, 1, -25 },
  { 5591, 23, 34, 25, 0, -34 },
  { 5689, 19, 25, 20, 2, -25 },
  { 5749, 26, 34, 25, 1, -34 },
  { 5860, 21, 25, 23, 2, -25 },
  { 5926, 26, 45, 16, -5, -34 },
  { 6073, 25, 36, 25, 0, -25 },
  { 6186, 24, 34, 25, 0, -34 },
  { 6288, 14, 35, 13, 0, -35 },
  { 6350, 20, 46, 13, -6, -35 },
  { 6465, 27, 34, 24, 0, -34 },
  { 6580, 15, 34, 13, 0, -34 },
  { 6644, 36, 25, 38, 0, -25 },
  { 6757, 24, 25, 25, 0, -25 },
  { 6832, 21, 25, 25, 2, -25 },
  { 6898, 25, 36, 25, -2, -25 },
  { 7011, 24, 36, 25, 1, -25 },
  { 7119, 20, 25, 18, 0, -25 },
  { 7182, 20, 25, 20, 0, -25 },
  { 7245, 17, 30, 18, 2, -30 },
  { 7309, 23, 25, 25, 2, -25 },
  { 7381, 23, 25, 22, 2, -25 },
  { 7453, 33, 25, 34, 3, -25 },
  { 7557, 27, 25, 23, -2, -25 },
  { 7642, 28, 36, 22, -3, -25 },
  { 7768, 22, 25, 20, -1, -25 },
  { 7837, 19, 39, 16, 0, -32 },
  { 7930, 6, 44, 22, 8, -34 },
  { 7963, 19, 39, 16, -3, -32 },
  { 8056, 21, 8, 24, 2, -20 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBoldItalic45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBoldItalic45pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBoldItalic45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC45PT7B_H_
