#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC46PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBoldItalic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBoldItalic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F,
  0x80, 0x7E, 0x00, 0x30, 0x00, 0x3F, 0x9F, 0xCF, 0xC7, 0xF3, 0xF1, 0xF8,
  0xFC, 0x7E, 0x7F, 0x1F, 0x9F, 0x8F, 0xE7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7C,
  0x3F, 0x1F, 0x0F, 0x87, 0xC3, 0xE3, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x8F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F,
  0x0F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE1, 0xF0,
  0x00, 0x3E, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x7C,
  0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01,
  0xF0, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x07, 0xC3, 0xE0, 0x00,
  0x7C, 0x7E, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x87,
  0xC0, 0x01, 0xF8, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00,
  0x3F, 0x1F, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFC, 0xF0, 0x3F, 0x38, 0x20,
  0xFE, 0x70, 0x01, 0xFC, 0xE0, 0x03, 0xFD, 0xC0, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x39,
  0xFC, 0x00, 0x73, 0xF9, 0x80, 0xE7, 0xF3, 0xC1, 0xDF, 0xC7, 0xFB, 0xFF,
  0x8F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x03, 0xFE,
  0x00, 0x3F, 0x01, 0xFF, 0xC0, 0x0F, 0x80, 0xFF, 0xF8, 0x07, 0xC0, 0x3F,
  0xFE, 0x03, 0xF0, 0x1F, 0x9F, 0x80, 0xF8, 0x07, 0xC3, 0xE0, 0x7C, 0x03,
  0xF1, 0xF8, 0x3F, 0x00, 0xFC, 0x7E, 0x1F, 0x80, 0x3F, 0x1F, 0x87, 0xC0,
  0x0F, 0x87, 0xE3, 0xF0, 0x03, 0xE1, 0xF1, 0xF8, 0x00, 0xF8, 0xFC, 0x7C,
  0x00, 0x3E, 0x3F, 0x3F, 0x1F, 0x8F, 0x8F, 0x9F, 0x9F, 0xFB, 0xFF, 0xE7,
  0xCF, 0xFE, 0xFF, 0xF3, 0xF7, 0xFF, 0xFF, 0xFD, 0xF9, 0xFF, 0xF7, 0xFE,
  0x7C, 0xFC, 0x7C, 0xFE, 0x3F, 0x3F, 0x1F, 0x00, 0x1F, 0x8F, 0x87, 0xC0,
  0x07, 0xC7, 0xE1, 0xF0, 0x03, 0xF1, 0xF8, 0xFC, 0x01, 0xF8, 0x7E, 0x3F,
  0x00, 0x7C, 0x1F, 0x0F, 0xC0, 0x3F, 0x07, 0xC3, 0xE0, 0x1F, 0x81, 0xF1,
  0xF8, 0x07, 0xC0, 0x7C, 0x7E, 0x03, 0xF0, 0x1F, 0xBF, 0x01, 0xF8, 0x07,
  0xFF, 0xC0, 0x7C, 0x00, 0xFF, 0xE0, 0x3F, 0x00, 0x3F, 0xF0, 0x1F, 0x80,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFC, 0x7F,
  0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0xFE, 0x00,
  0x1F, 0x87, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x7F, 0x0F, 0xFF, 0x07, 0xF8, 0xFF, 0xFC, 0x3F, 0x8F, 0xFF, 0xE3, 0xFC,
  0xFF, 0xFF, 0x9F, 0xC7, 0xF1, 0xFF, 0xFE, 0x7F, 0x8F, 0xFF, 0xE3, 0xF8,
  0x3F, 0xFF, 0x1F, 0xC1, 0xFF, 0xF0, 0xFE, 0x07, 0xFF, 0x07, 0xF0, 0x1F,
  0xF0, 0x3F, 0xC1, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xEF, 0xF8, 0x0F,
  0xFC, 0x3F, 0xE0, 0x3F, 0x9F, 0xCF, 0xC7, 0xE7, 0xF3, 0xF1, 0xF8, 0xFC,
  0x7E, 0x3E, 0x1F, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0,
  0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x60, 0xFC, 0x07, 0x8F,
  0x80, 0x7E, 0xF8, 0x0F, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xC0, 0x1F, 0xFC, 0x07,
  0xFF, 0xE0, 0x7F, 0x3E, 0x03, 0xE3, 0xF0, 0x1E, 0x3F, 0x80, 0xC1, 0xF0,
  0x00, 0x1C, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x0F, 0xE3, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x0F, 0xC3, 0xF8,
  0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFD, 0xFF,
  0xEF, 0xFF, 0x7F, 0xF0, 0x0C, 0x1F, 0x9F, 0xDF, 0xFF, 0xF7, 0xFB, 0xFC,
  0xFC, 0x18, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFC, 0x7F, 0x07, 0xF0, 0xFF, 0x1F, 0xE0,
  0xFE, 0x3F, 0x81, 0xFC, 0xFF, 0x03, 0xF9, 0xFE, 0x0F, 0xF3, 0xF8, 0x1F,
  0xE7, 0xF0, 0x3F, 0xDF, 0xE0, 0x7F, 0x3F, 0xC0, 0xFE, 0x7F, 0x01, 0xFC,
  0xFE, 0x03, 0xF9, 0xFC, 0x0F, 0xF7, 0xF8, 0x1F, 0xEF, 0xF0, 0x3F, 0x9F,
  0xE0, 0xFF, 0x3F, 0xC1, 0xFE, 0x7F, 0x83, 0xF8, 0xFF, 0x0F, 0xF1, 0xFE,
  0x1F, 0xC1, 0xFC, 0x7F, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xE1,
  0xFF, 0xF8, 0xFF, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xF7, 0xF0, 0xF1,
  0xFC, 0x38, 0xFF, 0x04, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xF0, 0xFF, 0x01, 0xE0,
  0x7F, 0x00, 0x80, 0x7F, 0x00, 0x80, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xC1,
  0xFF, 0x01, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xF8, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x80, 0x07, 0xF8, 0xE0, 0x0F,
  0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x7D, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF8, 0x03, 0xF3,
  0xF8, 0x03, 0xF3, 0xF8, 0x07, 0xE3, 0xF8, 0x0F, 0xC7, 0xF0, 0x1F, 0x87,
  0xF0, 0x1F, 0x87, 0xF0, 0x3F, 0x07, 0xF0, 0x7E, 0x0F, 0xF0, 0x7F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF8, 0x04, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF8, 0x80, 0x07, 0xF8, 0xE0, 0x1F, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x30, 0x07,
  0xF3, 0xFC, 0x0F, 0xEF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF1, 0xFF, 0x9F, 0xE3, 0xFE, 0x1F, 0xC7, 0xF8, 0x3F, 0xCF, 0xE0,
  0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x0F,
  0xF1, 0xFC, 0x1F, 0xC3, 0xFC, 0x7F, 0x87, 0xFF, 0xFF, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF,
  0x3F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1,
  0xFC, 0x3F, 0x87, 0xF0, 0x7F, 0x9F, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x80,
  0x7F, 0xFF, 0x81, 0xFE, 0x7F, 0x87, 0xF8, 0x7F, 0x0F, 0xE0, 0xFF, 0x3F,
  0x80, 0xFE, 0x7F, 0x01, 0xFC, 0xFE, 0x03, 0xF9, 0xFC, 0x0F, 0xF3, 0xF8,
  0x1F, 0xC7, 0xF8, 0x7F, 0x8F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFF,
  0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1,
  0xFE, 0x1F, 0xC7, 0xF0, 0x7F, 0x3F, 0xC1, 0xFC, 0xFE, 0x07, 0xF3, 0xF8,
  0x1F, 0xCF, 0xE0, 0x7F, 0x3F, 0x81, 0xFC, 0xFE, 0x0F, 0xF3, 0xF8, 0x3F,
  0xCF, 0xF3, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0x87,
  0xFE, 0xFE, 0x0F, 0xF3, 0xF8, 0x0F, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xC0, 0x1F, 0x81, 0xFC, 0x1F, 0xF0, 0xFF, 0x87, 0xF8,
  0x3F, 0xC0, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x7E, 0x07, 0xF0,
  0x7F, 0xC3, 0xFC, 0x1F, 0xE0, 0xFF, 0x03, 0xF0, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xFC,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x3F, 0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xF8,
  0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0xFE, 0x07, 0xFF, 0xC7, 0xFF, 0xF9,
  0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xF3, 0xC1, 0xFC, 0xC0, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0xC0, 0x7F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x0F,
  0xC7, 0xE0, 0x7F, 0xE1, 0xF1, 0xF0, 0x7F, 0xFC, 0x7C, 0xFC, 0x3F, 0xFF,
  0x1F, 0x3E, 0x1F, 0xFF, 0xC7, 0xDF, 0x07, 0xE3, 0xE1, 0xF7, 0xC3, 0xF0,
  0xF8, 0x7D, 0xF1, 0xF8, 0x3E, 0x1F, 0xF8, 0x7C, 0x1F, 0x87, 0xFE, 0x1F,
  0x07, 0xC1, 0xFF, 0x8F, 0xC1, 0xF0, 0x7F, 0xE3, 0xE0, 0x7C, 0x3E, 0xF8,
  0xF8, 0x3F, 0x0F, 0xBE, 0x3E, 0x0F, 0x87, 0xCF, 0x8F, 0x87, 0xE1, 0xF3,
  0xE3, 0xF3, 0xF9, 0xF8, 0xF8, 0xFF, 0xFF, 0xFE, 0x3E, 0x1F, 0xFF, 0xFF,
  0x0F, 0x87, 0xFC, 0xFF, 0x83, 0xF0, 0x7C, 0x1F, 0x80, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x1C, 0x00, 0x1F, 0xFD, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0xFC, 0xFC, 0x00,
  0x1F, 0xCF, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x8F, 0xC0, 0x03, 0xF8,
  0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0xFE, 0x0F, 0xC0,
  0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x03, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x1F, 0xE0, 0x0F, 0xE1, 0xFC,
  0x00, 0xFE, 0x3F, 0xC0, 0x0F, 0xE3, 0xFC, 0x00, 0xFE, 0x7F, 0x80, 0x0F,
  0xE7, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F,
  0x83, 0xF8, 0x1F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFC, 0x0F, 0xF0, 0xFE, 0x0F,
  0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x07, 0xF8, 0x3F, 0xC3, 0xFC,
  0x1F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x03, 0xFC, 0x7F,
  0x81, 0xFE, 0x3F, 0xC1, 0xFF, 0x1F, 0xC1, 0xFF, 0x0F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0,
  0xFF, 0xC0, 0xF0, 0x3F, 0xE0, 0x08, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x04, 0x07, 0xFC, 0x0F, 0x01, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x01, 0xFE, 0x7F, 0xF0, 0x3F, 0x83, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0xFE,
  0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0xFE, 0x01, 0xFE,
  0x1F, 0xC0, 0x3F, 0xC7, 0xF8, 0x07, 0xF8, 0xFF, 0x00, 0xFF, 0x1F, 0xE0,
  0x1F, 0xC3, 0xF8, 0x07, 0xF8, 0x7F, 0x00, 0xFF, 0x1F, 0xE0, 0x1F, 0xE3,
  0xFC, 0x07, 0xF8, 0x7F, 0x00, 0xFF, 0x0F, 0xE0, 0x3F, 0xE1, 0xFC, 0x07,
  0xF8, 0x7F, 0x81, 0xFF, 0x0F, 0xF0, 0x7F, 0xC1, 0xFC, 0x7F, 0xF0, 0x3F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF,
  0x81, 0xE0, 0x7F, 0xC0, 0x04, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0xFF, 0xF3, 0xFC, 0x3F, 0xFC, 0x7F, 0x07, 0xFF, 0x9F,
  0xE0, 0xFF, 0xF3, 0xFC, 0x1F, 0xFE, 0x7F, 0x87, 0xFF, 0xCF, 0xF0, 0x07,
  0xF1, 0xFE, 0x00, 0xFE, 0x3F, 0xC0, 0x1F, 0xC7, 0xF8, 0x07, 0xF8, 0xFF,
  0x00, 0xFE, 0x0F, 0xF0, 0x1F, 0xC1, 0xFF, 0x03, 0xF8, 0x3F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF0,
  0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x01, 0xFE, 0x03, 0xF8, 0x07,
  0xF8, 0x1F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0x7F, 0x01, 0xFC, 0x01, 0xFC,
  0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0xFE, 0x03,
  0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x3F,
  0x80, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xE0,
  0x7F, 0x80, 0x7F, 0x01, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x1F,
  0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xF8, 0x0F, 0xF0,
  0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x80, 0xFE, 0x01, 0xFE, 0x00, 0x01, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8,
  0x01, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x01, 0xFE, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0xC7, 0xFC, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0,
  0x3F, 0x80, 0xFF, 0x00, 0xFE, 0x07, 0xF8, 0x03, 0xF8, 0x3F, 0xE0, 0x1F,
  0xE1, 0xFF, 0x00, 0x7F, 0x07, 0xF8, 0x01, 0xFC, 0x3F, 0xC0, 0x07, 0xF1,
  0xFE, 0x00, 0x1F, 0xCF, 0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xF9, 0xFE,
  0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x3F, 0xBF, 0xC0, 0x01, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xEF, 0xE0, 0x00, 0xFE,
  0x3F, 0xC0, 0x03, 0xF8, 0xFF, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x7F, 0x87,
  0xF8, 0x01, 0xFC, 0x1F, 0xE0, 0x07, 0xF0, 0x7F, 0x80, 0x1F, 0xC0, 0xFE,
  0x00, 0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0,
  0x3F, 0x80, 0x7F, 0x80, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x1F,
  0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x3F,
  0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF,
  0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0xFD, 0xF8, 0x0F, 0xDF, 0x83, 0xF7,
  0xE0, 0x3F, 0x7E, 0x0F, 0xBF, 0x81, 0xFD, 0xF8, 0x7E, 0xFE, 0x07, 0xF7,
  0xE1, 0xF3, 0xF8, 0x1F, 0xDF, 0x8F, 0xCF, 0xC0, 0x7F, 0x7E, 0x3F, 0x7F,
  0x01, 0xF9, 0xF9, 0xF9, 0xFC, 0x0F, 0xE7, 0xE7, 0xE7, 0xF0, 0x3F, 0x9F,
  0xBF, 0x1F, 0xC0, 0xFE, 0x7E, 0xFC, 0xFE, 0x03, 0xF1, 0xFF, 0xE3, 0xF8,
  0x0F, 0xC7, 0xFF, 0x8F, 0xE0, 0x7F, 0x1F, 0xFC, 0x3F, 0x81, 0xFC, 0x7F,
  0xF0, 0xFC, 0x07, 0xF1, 0xFF, 0x87, 0xF0, 0x1F, 0x87, 0xFE, 0x1F, 0xC0,
  0xFE, 0x1F, 0xF0, 0x7F, 0x03, 0xF8, 0x7F, 0xC1, 0xFC, 0x0F, 0xE1, 0xFE,
  0x07, 0xE0, 0x3F, 0x83, 0xF8, 0x3F, 0x80, 0xFC, 0x0F, 0xC0, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x7F, 0x03, 0xFE, 0x00, 0x7F, 0x03, 0xFF, 0x00, 0x7F,
  0x03, 0xFF, 0x00, 0x7E, 0x03, 0xFF, 0x00, 0xFE, 0x07, 0xFF, 0x00, 0xFE,
  0x07, 0xFF, 0x80, 0xFE, 0x07, 0xFF, 0x80, 0xFE, 0x07, 0xFF, 0x80, 0xFC,
  0x07, 0xFF, 0x81, 0xFC, 0x0F, 0xFF, 0xC1, 0xFC, 0x0F, 0xDF, 0xC1, 0xFC,
  0x0F, 0xDF, 0xC1, 0xF8, 0x0F, 0xCF, 0xC3, 0xF8, 0x1F, 0xCF, 0xE3, 0xF8,
  0x1F, 0xCF, 0xE3, 0xF8, 0x1F, 0xCF, 0xE3, 0xF8, 0x1F, 0xC7, 0xF3, 0xF0,
  0x1F, 0x87, 0xF3, 0xF0, 0x3F, 0x87, 0xF7, 0xF0, 0x3F, 0x87, 0xF7, 0xF0,
  0x3F, 0x83, 0xFF, 0xF0, 0x3F, 0x83, 0xFF, 0xE0, 0x3F, 0x03, 0xFF, 0xE0,
  0x7F, 0x01, 0xFF, 0xE0, 0x7F, 0x01, 0xFF, 0xE0, 0x7F, 0x01, 0xFF, 0xE0,
  0x7E, 0x01, 0xFF, 0xC0, 0xFE, 0x00, 0xFF, 0xC0, 0xFE, 0x00, 0xFF, 0xC0,
  0xFE, 0x00, 0xFF, 0xC0, 0xFE, 0x00, 0xFF, 0x80, 0xFC, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFC, 0x3F,
  0xE0, 0xFF, 0x81, 0xFE, 0x1F, 0xF0, 0x0F, 0xF1, 0xFE, 0x00, 0xFF, 0x3F,
  0xC0, 0x0F, 0xF3, 0xFC, 0x00, 0xFF, 0x3F, 0xC0, 0x0F, 0xF7, 0xF8, 0x00,
  0xFF, 0x7F, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xEF,
  0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x00,
  0x1F, 0xEF, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0xCF, 0xF0, 0x07, 0xF8,
  0xFF, 0x00, 0xFF, 0x87, 0xF8, 0x0F, 0xF0, 0x7F, 0xC3, 0xFF, 0x07, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFC, 0x1F, 0xE3, 0xFE, 0x0F, 0xE0, 0xFF, 0x07, 0xF0, 0x3F,
  0x83, 0xF8, 0x1F, 0xC3, 0xFC, 0x0F, 0xE1, 0xFE, 0x07, 0xF0, 0xFE, 0x07,
  0xF8, 0x7F, 0x03, 0xFC, 0x7F, 0x83, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xFC, 0x01, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFE, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0x81, 0xFE, 0x1F, 0xF0, 0x0F, 0xF1,
  0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x0F, 0xF3, 0xFC, 0x00, 0xFF, 0x3F, 0xC0,
  0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0xFF,
  0x7F, 0x00, 0x0F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0,
  0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xCF, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x3F,
  0xCF, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0xFF, 0x87, 0xF8, 0x1F, 0xF0, 0x7F,
  0xC3, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F,
  0xE3, 0xFE, 0x0F, 0xE0, 0xFF, 0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x3F, 0xC3,
  0xFC, 0x1F, 0xE1, 0xFC, 0x0F, 0xF0, 0xFE, 0x0F, 0xF0, 0x7F, 0x07, 0xF8,
  0x7F, 0x8F, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x01, 0xFC, 0x7F,
  0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0xE0, 0x7F, 0x87, 0xF0, 0x3F, 0xC3,
  0xFC, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC7, 0xF8,
  0x1F, 0xE3, 0xF8, 0x0F, 0xF1, 0xFC, 0x03, 0xFC, 0xFE, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xF8, 0x3C, 0x0F, 0xF0, 0x08,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x80, 0x0F, 0xF0, 0x60, 0x0F, 0xF0, 0x78, 0x1F, 0xF0, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8,
  0x07, 0xF0, 0x7F, 0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0xFE,
  0x0F, 0xF0, 0x0F, 0xE0, 0xFF, 0x01, 0xFE, 0x0F, 0xE0, 0x1F, 0xE0, 0xFE,
  0x01, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFE, 0x01, 0xFC, 0x1F, 0xE0, 0x3F,
  0xC1, 0xFC, 0x03, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xFC, 0x03, 0xF8, 0x3F,
  0xC0, 0x3F, 0x83, 0xFC, 0x07, 0xF8, 0x3F, 0x80, 0x7F, 0x83, 0xF8, 0x07,
  0xF0, 0x7F, 0x80, 0x7F, 0x07, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFF, 0x07,
  0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0xFF, 0x01,
  0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0x7F, 0x87, 0xFC, 0x07, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xEF, 0xE0, 0x07, 0xFB, 0xF8, 0x03, 0xFC, 0xFE, 0x00, 0xFF, 0x3F, 0x80,
  0x3F, 0x8F, 0xE0, 0x1F, 0xE3, 0xF8, 0x07, 0xF0, 0xFE, 0x03, 0xFC, 0x3F,
  0x80, 0xFE, 0x07, 0xE0, 0x7F, 0x81, 0xF8, 0x1F, 0xC0, 0x7F, 0x0F, 0xF0,
  0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x1F,
  0xC0, 0x1F, 0xCF, 0xE0, 0x07, 0xF3, 0xF8, 0x01, 0xFD, 0xFC, 0x00, 0x7F,
  0x7F, 0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x7E, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFF, 0xFC,
  0x01, 0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xF8, 0x07, 0xF7, 0xF0, 0x0F, 0xF0,
  0x1F, 0xCF, 0xE0, 0x3F, 0xE0, 0x3F, 0x9F, 0xC0, 0x7F, 0xC0, 0xFF, 0x3F,
  0x81, 0xFF, 0x81, 0xFC, 0x7F, 0x03, 0xFF, 0x03, 0xF8, 0xFE, 0x07, 0xFE,
  0x0F, 0xE1, 0xFC, 0x1F, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0xF8, 0x7F, 0x87,
  0xF0, 0xFF, 0xF0, 0xFE, 0x0F, 0xE1, 0xFF, 0xE1, 0xFC, 0x1F, 0xC7, 0xEF,
  0xC7, 0xF0, 0x3F, 0x8F, 0xDF, 0x8F, 0xE0, 0x7F, 0x1F, 0xBF, 0x3F, 0x80,
  0xFE, 0x7E, 0x7E, 0x7F, 0x01, 0xFC, 0xFC, 0xFC, 0xFE, 0x03, 0xFB, 0xF9,
  0xF3, 0xF8, 0x07, 0xF7, 0xE3, 0xE7, 0xF0, 0x0F, 0xEF, 0xC7, 0xCF, 0xC0,
  0x1F, 0xBF, 0x0F, 0xBF, 0x80, 0x3F, 0x7E, 0x1F, 0x7F, 0x00, 0x7F, 0xF8,
  0x3E, 0xFC, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0xFF, 0xE0,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0x80,
  0x0F, 0xE0, 0x7F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0,
  0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x3F, 0xDF, 0xE0,
  0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x03, 0xFD,
  0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x01, 0xFE,
  0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFF,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0xFF,
  0x80, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0x9F, 0xC0,
  0x7F, 0x8F, 0xE0, 0x3F, 0xC7, 0xF0, 0x3F, 0xC3, 0xF8, 0x1F, 0xC1, 0xFE,
  0x1F, 0xE0, 0x7F, 0x1F, 0xE0, 0x3F, 0x8F, 0xE0, 0x1F, 0xCF, 0xF0, 0x0F,
  0xE7, 0xF0, 0x07, 0xF7, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7F, 0x07, 0xE0, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xF7, 0xE0, 0x07,
  0xE7, 0xC0, 0x1F, 0x8F, 0x80, 0x3F, 0x1F, 0x80, 0xFC, 0x3F, 0x03, 0xF0,
  0x3E, 0x07, 0xE0, 0x7C, 0x1F, 0x80, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x01,
  0xF3, 0xF0, 0x03, 0xEF, 0xE0, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0xFF, 0x3F, 0xC7, 0xF0, 0xFC, 0x3F, 0x87,
  0xE0, 0xFC, 0x00, 0x70, 0x00, 0x07, 0xF8, 0xFC, 0x1F, 0xF9, 0xF8, 0x7F,
  0xFF, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xF9, 0xFF, 0x1F, 0xE1,
  0xFE, 0x7F, 0x83, 0xFC, 0xFF, 0x07, 0xF1, 0xFC, 0x0F, 0xE7, 0xF8, 0x1F,
  0xCF, 0xF0, 0x3F, 0x9F, 0xC0, 0x7F, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF8,
  0xFE, 0x07, 0xF1, 0xFC, 0x1F, 0xE3, 0xF8, 0x3F, 0x87, 0xF0, 0xFF, 0x0F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F,
  0xEF, 0xC0, 0x3F, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0xE0, 0x07,
  0xF3, 0xF8, 0x07, 0xF7, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x0F, 0xF9, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0x7F, 0x0F,
  0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFF, 0x1F, 0xC0, 0xFF, 0x1F,
  0xC0, 0xFF, 0x1F, 0xC0, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x81, 0xFE, 0x3F,
  0x81, 0xFC, 0x3F, 0x83, 0xFC, 0x3F, 0xC7, 0xFC, 0x7F, 0xEF, 0xF8, 0x7F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x7E, 0xFF, 0xE0, 0x7E, 0xFF, 0xC0, 0xFC,
  0x7F, 0x80, 0x00, 0x3C, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xE3, 0xC3, 0xFC, 0x04, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xF0, 0x30, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x38, 0x7F, 0x00, 0xFF, 0x3F, 0x80, 0xFF, 0xDF, 0xC0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xCF, 0xF8, 0x3F, 0xC3, 0xFC,
  0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7F, 0x0F, 0xF0, 0x3F,
  0x87, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07,
  0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x83, 0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0xE1,
  0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0x3F, 0xF7, 0xE0, 0x07, 0xF3, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFC, 0xFF, 0x0F, 0xE7, 0xF0, 0x7F, 0x7F, 0x83, 0xFB, 0xF8, 0x1F, 0xDF,
  0xC3, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC,
  0x1F, 0xFF, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x01, 0x0F, 0xF0, 0x38, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x7F, 0x8F, 0xC0, 0x7F, 0xE7, 0xE0, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xE7, 0xFC, 0x1F, 0xE1,
  0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x3F, 0x87, 0xF8,
  0x1F, 0xC3, 0xFC, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0x7F,
  0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0xFF, 0x07,
  0xF0, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xE0, 0x1F, 0xF7, 0xF0, 0x07, 0xF3, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x04, 0x00, 0xFF, 0x03, 0x80, 0xFF,
  0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x70, 0x07, 0xF3, 0xFC, 0x07, 0xF7, 0xFE, 0x07, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFC, 0xFF, 0x0F, 0xF8, 0x7F, 0x0F,
  0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFE, 0x1F,
  0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F,
  0xC1, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x7F,
  0x83, 0xFC, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F,
  0x03, 0xF8, 0xFF, 0x07, 0xF8, 0x00, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0,
  0xFF, 0x83, 0xF8, 0x1F, 0xE0, 0x7F, 0x07, 0xF8, 0x0F, 0xE1, 0xFE, 0x01,
  0xFC, 0x7F, 0x80, 0x7F, 0x9F, 0xE0, 0x0F, 0xE7, 0xF8, 0x01, 0xFC, 0xFE,
  0x00, 0x3F, 0xBF, 0x80, 0x07, 0xEF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0,
  0x07, 0xFF, 0xFC, 0x00, 0xFF, 0x3F, 0x80, 0x1F, 0xC7, 0xF8, 0x03, 0xF8,
  0xFF, 0x00, 0xFF, 0x0F, 0xE0, 0x1F, 0xC1, 0xFE, 0x03, 0xF8, 0x3F, 0xC0,
  0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x00, 0x00,
  0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x3F, 0x1F,
  0xE0, 0xFF, 0x01, 0xF9, 0xFF, 0x9F, 0xFC, 0x0F, 0xDF, 0xFD, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xF3, 0xFF,
  0xBF, 0xE1, 0xFF, 0x1F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x7F,
  0x07, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0xC1, 0xFC, 0x3F, 0xC1, 0xFC, 0x0F,
  0xE1, 0xFC, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x7F, 0x07,
  0xF8, 0x3F, 0x87, 0xF8, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x0F, 0xE1,
  0xFC, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x7F, 0x07, 0xF8,
  0x3F, 0x87, 0xF8, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x0F, 0xE1, 0xFC,
  0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x7F, 0x07, 0xF8, 0x3F,
  0x87, 0xF8, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x07, 0xE3, 0xFC,
  0x07, 0xE7, 0xFE, 0x07, 0xEF, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x0F, 0xFC, 0xFF, 0x0F, 0xF8, 0x7F, 0x0F, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F,
  0x0F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE,
  0x1F, 0xC0, 0xFE, 0x1F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFC, 0x3F, 0x81, 0xFC,
  0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x03, 0xF8,
  0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0xFF, 0x07, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xE3, 0xFE, 0x7F, 0x8F, 0xF0, 0xFE, 0x7F, 0x83,
  0xF9, 0xFC, 0x0F, 0xF7, 0xF0, 0x3F, 0xFF, 0xC0, 0xFE, 0xFE, 0x03, 0xFB,
  0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0x81, 0xFE, 0xFE, 0x07, 0xFB, 0xF8,
  0x1F, 0xCF, 0xE0, 0xFF, 0x3F, 0x87, 0xF8, 0xFF, 0xBF, 0xE3, 0xFF, 0xFF,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x7E, 0x3F, 0x80, 0x1F, 0xBF, 0xF0, 0x07, 0xEF,
  0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xE3, 0xFC, 0x0F,
  0xF0, 0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x1F, 0xC0, 0xFF, 0x07, 0xF0, 0x3F, 0xC1, 0xFC, 0x0F, 0xF0, 0x7F, 0x03,
  0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0xFE,
  0x0F, 0xF0, 0x3F, 0xC7, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xDF, 0xF0, 0x0F, 0xE3, 0xF8,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x07, 0xF8, 0xFC, 0x1F, 0xF9, 0xF8, 0x7F, 0xFF,
  0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xF9, 0xFF, 0x1F, 0xE1, 0xFE,
  0x7F, 0x83, 0xFC, 0xFF, 0x07, 0xF1, 0xFC, 0x0F, 0xE7, 0xF8, 0x1F, 0xCF,
  0xF0, 0x3F, 0x9F, 0xC0, 0x7F, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF8, 0xFE,
  0x07, 0xF1, 0xFC, 0x1F, 0xE3, 0xF8, 0x3F, 0x87, 0xF0, 0xFF, 0x0F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xF7, 0xE0, 0x7F, 0xDF,
  0xC0, 0x3F, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x70, 0x7E, 0x3F, 0x07, 0xE7, 0xF0, 0x7E, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xF8, 0x00, 0xFF,
  0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xFC, 0x07, 0xFF,
  0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xE0, 0xC1, 0xFC,
  0x04, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xCC, 0x03, 0xFC, 0xFC, 0x7F, 0x8F, 0xFF, 0xF8,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0x80, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F,
  0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xC3, 0xF8, 0x01,
  0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x03,
  0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xE0, 0xFF, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0,
  0xFE, 0x1F, 0xC0, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0x81,
  0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x83, 0xFC, 0x7F, 0x83, 0xF8, 0x7F, 0x03,
  0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x07, 0xF8, 0xFE, 0x07,
  0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F, 0xF0, 0xFE, 0x1F,
  0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xF7, 0xE0, 0x7F, 0xF7,
  0xE0, 0x7F, 0xE7, 0xC0, 0x3F, 0xCF, 0xC0, 0xFF, 0x01, 0xFE, 0xFE, 0x03,
  0xF9, 0xFC, 0x0F, 0xF3, 0xF8, 0x1F, 0xC7, 0xF0, 0x7F, 0x8F, 0xE0, 0xFE,
  0x1F, 0xC3, 0xFC, 0x3F, 0x87, 0xF0, 0x7F, 0x1F, 0xE0, 0xFE, 0x3F, 0x81,
  0xFC, 0x7F, 0x03, 0xF9, 0xFC, 0x03, 0xF3, 0xF8, 0x07, 0xEF, 0xE0, 0x0F,
  0xDF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x0F, 0xF0, 0x3F, 0xFF,
  0x83, 0xFC, 0x0F, 0xEF, 0xC0, 0xFF, 0x07, 0xF3, 0xF0, 0x7F, 0xC1, 0xFC,
  0xFC, 0x1F, 0xF0, 0x7F, 0x3F, 0x0F, 0xFC, 0x3F, 0x8F, 0xC3, 0xFF, 0x0F,
  0xE3, 0xF0, 0xFF, 0xC7, 0xF0, 0xFC, 0x7D, 0xF1, 0xFC, 0x3F, 0x1F, 0x7C,
  0x7E, 0x0F, 0xCF, 0xDF, 0x3F, 0x83, 0xF3, 0xE7, 0xCF, 0xC0, 0xFC, 0xF9,
  0xF7, 0xF0, 0x3F, 0x7E, 0x7D, 0xFC, 0x0F, 0xDF, 0x1F, 0x7E, 0x03, 0xF7,
  0xC7, 0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0xC0, 0x3F, 0xF8, 0x7F, 0xF0, 0x0F,
  0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x00,
  0x3F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xF0, 0x03, 0xFE, 0x0F, 0xF8,
  0x00, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xC3,
  0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xC7, 0xF8, 0x01, 0xFC, 0xFF, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xF7, 0xF0,
  0x00, 0xFE, 0x7F, 0x80, 0x1F, 0xE3, 0xF8, 0x03, 0xFC, 0x3F, 0x80, 0x7F,
  0x83, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x3F, 0x81, 0xFC,
  0x03, 0xF8, 0x3F, 0xC0, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x7F, 0x80, 0x3F,
  0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xF8, 0xFE,
  0x00, 0x1F, 0x9F, 0xC0, 0x01, 0xF9, 0xFC, 0x00, 0x1F, 0xBF, 0x80, 0x01,
  0xFB, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xC0,
  0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0,
  0x00, 0x1F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x05,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xEC, 0x03, 0xFF, 0x20, 0x01, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBoldItalic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 15, 34, 13, 0, -33 },
  { 65, 18, 12, 20, 4, -33 },
  { 92, 28, 33, 27, 0, -33 },
  { 208, 23, 38, 24, 1, -35 },
  { 318, 34, 33, 39, 3, -33 },
  { 459, 29, 33, 30, 1, -33 },
  { 579, 9, 12, 11, 4, -33 },
  { 593, 17, 40, 15, 1, -33 },
  { 678, 17, 41, 15, -3, -34 },
  { 766, 20, 21, 23, 4, -35 },
  { 819, 21, 22, 25, 2, -27 },
  { 877, 11, 12, 13, -2, -6 },
  { 894, 13, 6, 14, 1, -15 },
  { 904, 9, 9, 13, 0, -8 },
  { 915, 25, 33, 19, -2, -33 },
  { 1019, 23, 33, 24, 1, -33 },
  { 1114, 18, 33, 24, 4, -33 },
  { 1189, 24, 33, 24, -1, -33 },
  { 1288, 24, 33, 24, 0, -33 },
  { 1387, 24, 33, 24, 0, -33 },
  { 1486, 24, 33, 24, 0, -33 },
  { 1585, 23, 33, 24, 2, -33 },
  { 1680, 25, 33, 24, 1, -33 },
  { 1784, 23, 33, 24, 1, -33 },
  { 1879, 22, 33, 24, 1, -33 },
  { 1970, 13, 27, 13, 0, -26 },
  { 2014, 16, 32, 13, -3, -26 },
  { 2078, 21, 24, 25, 2, -29 },
  { 2141, 22, 15, 25, 2, -24 },
  { 2183, 22, 24, 25, 2, -29 },
  { 2249, 18, 34, 20, 3, -33 },
  { 2326, 34, 37, 37, 2, -33 },
  { 2484, 28, 33, 27, -3, -33 },
  { 2600, 25, 33, 27, 1, -33 },
  { 2704, 26, 33, 26, 2, -33 },
  { 2812, 27, 33, 29, 1, -33 },
  { 2924, 24, 33, 23, 1, -33 },
  { 3023, 24, 33, 23, 1, -33 },
  { 3122, 27, 33, 29, 2, -33 },
  { 3234, 30, 33, 30, 1, -33 },
  { 3358, 22, 33, 18, -2, -33 },
  { 3449, 22, 43, 15, -7, -33 },
  { 3568, 30, 33, 27, 1, -33 },
  { 3692, 18, 33, 22, 1, -33 },
  { 3767, 38, 33, 38, 1, -33 },
  { 3924, 32, 33, 32, 1, -33 },
  { 4056, 28, 33, 31, 2, -33 },
  { 4172, 25, 33, 26, 1, -33 },
  { 4276, 28, 41, 31, 2, -33 },
  { 4420, 25, 33, 27, 1, -33 },
  { 4524, 24, 33, 23, 0, -33 },
  { 4623, 22, 33, 23, 4, -33 },
  { 4714, 28, 33, 29, 2, -33 },
  { 4830, 26, 33, 26, 4, -33 },
  { 4938, 39, 33, 39, 4, -33 },
  { 5099, 33, 33, 26, -3, -33 },
  { 5236, 25, 33, 25, 4, -33 },
  { 5340, 27, 33, 23, -2, -33 },
  { 5452, 19, 41, 15, -1, -33 },
  { 5550, 11, 33, 19, 5, -33 },
  { 5596, 19, 41, 15, -3, -33 },
  { 5694, 23, 21, 23, 0, -33 },
  { 5755, 19, 4, 18, -4, 4 },
  { 5765, 10, 7, 15, 7, -35 },
  { 5774, 23, 26, 25, 2, -26 },
  { 5849, 24, 35, 25, 0, -35 },
  { 5954, 20, 26, 21, 2, -26 },
  { 6019, 25, 35, 25, 2, -35 },
  { 6129, 21, 26, 24, 2, -26 },
  { 6198, 26, 46, 16, -5, -35 },
  { 6348, 25, 37, 25, 0, -26 },
  { 6464, 24, 35, 26, 0, -35 },
  { 6569, 15, 35, 13, 0, -35 },
  { 6635, 21, 46, 13, -6, -35 },
  { 6756, 27, 35, 25, 0, -35 },
  { 6875, 15, 35, 13, 0, -35 },
  { 6941, 37, 26, 38, 0, -26 },
  { 7062, 24, 26, 26, 0, -26 },
  { 7140, 22, 26, 25, 2, -26 },
  { 7212, 26, 37, 25, -2, -26 },
  { 7333, 23, 37, 25, 2, -26 },
  { 7440, 20, 26, 18, 0, -26 },
  { 7505, 20, 26, 20, 0, -26 },
  { 7570, 17, 31, 18, 2, -31 },
  { 7636, 24, 25, 26, 2, -25 },
  { 7711, 23, 25, 23, 2, -25 },
  { 7783, 34, 25, 34, 3, -25 },
  { 7890, 28, 25, 23, -2, -25 },
  { 7978, 28, 36, 23, -3, -25 },
  { 8104, 22, 25, 20, -1, -25 },
  { 8173, 19, 40, 16, 0, -33 },
  { 8268, 6, 45, 23, 8, -35 },
  { 8302, 19, 40, 16, -3, -33 },
  { 8397, 22, 8, 25, 2, -20 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBoldItalic46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBoldItalic46pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBoldItalic46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC46PT7B_H_
