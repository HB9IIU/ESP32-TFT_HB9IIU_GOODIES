#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC13PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBoldItalic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBoldItalic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x66, 0x66, 0x0C, 0xC0, 0x7E, 0xF4, 0x1A, 0x16, 0x7F, 0x7F,
  0x24, 0xFE, 0x68, 0x68, 0x58, 0x08, 0x7D, 0xF3, 0x47, 0x07, 0x87, 0x4E,
  0xFC, 0x40, 0x80, 0x73, 0xB4, 0x8B, 0x62, 0xF6, 0xEB, 0x87, 0xB3, 0x68,
  0x9E, 0x63, 0x00, 0x3E, 0x1B, 0x0D, 0x87, 0x97, 0xB7, 0xFB, 0x39, 0xFC,
  0x7F, 0x00, 0x7B, 0x00, 0x19, 0x98, 0xC6, 0x23, 0x18, 0xC2, 0x18, 0x38,
  0xC6, 0x31, 0x8C, 0x46, 0x33, 0x30, 0x12, 0xCF, 0xCF, 0xF1, 0x60, 0x20,
  0x82, 0x3F, 0x20, 0x82, 0x00, 0x76, 0x6C, 0xF0, 0xF0, 0x06, 0x08, 0x30,
  0xC1, 0x86, 0x0C, 0x30, 0xE0, 0x3C, 0x7D, 0x9B, 0x36, 0xF9, 0xB3, 0x3C,
  0x78, 0x3B, 0xF7, 0x63, 0x18, 0xC6, 0x60, 0x3C, 0xDC, 0x38, 0x61, 0x86,
  0x18, 0x7E, 0xF8, 0x7C, 0x5C, 0x19, 0xE3, 0x81, 0x83, 0x7E, 0xF8, 0x0E,
  0x38, 0x71, 0x66, 0xDF, 0xBF, 0x0C, 0x18, 0x3E, 0x79, 0x83, 0xC7, 0xC1,
  0x83, 0x7E, 0xF8, 0x1E, 0x61, 0x83, 0xE7, 0xDD, 0xBB, 0x3E, 0x78, 0x7E,
  0xFC, 0x30, 0x61, 0x87, 0x0C, 0x38, 0xE0, 0x3C, 0xED, 0x99, 0xE3, 0x8D,
  0xB3, 0x7E, 0x78, 0x3C, 0xDD, 0x9B, 0x77, 0xC7, 0x83, 0x7C, 0xF0, 0x76,
  0x00, 0x0C, 0xC0, 0x39, 0x80, 0x00, 0x31, 0x8C, 0xC0, 0x0C, 0xFF, 0x30,
  0x70, 0x70, 0x40, 0xFF, 0xF0, 0x3F, 0xFC, 0x83, 0x83, 0x87, 0x73, 0x08,
  0x00, 0xFC, 0xC6, 0x66, 0x60, 0x18, 0xC0, 0x1F, 0x8C, 0x36, 0x75, 0x2D,
  0x5A, 0x74, 0xBD, 0xF9, 0x24, 0x61, 0x0F, 0x80, 0x0E, 0x0E, 0x1B, 0x1B,
  0x33, 0x3F, 0x7F, 0x63, 0xE3, 0x3E, 0x6C, 0xDB, 0xF7, 0xCC, 0xD9, 0xFE,
  0xF8, 0x3E, 0xEB, 0x86, 0x0C, 0x18, 0x30, 0x7C, 0x78, 0x3E, 0x3F, 0x33,
  0x63, 0x63, 0x66, 0x66, 0xFC, 0xF8, 0x3E, 0x60, 0xC3, 0xE7, 0xCC, 0x18,
  0x7C, 0xF8, 0x3E, 0x60, 0xC3, 0x07, 0xCC, 0x18, 0x70, 0xC0, 0x3E, 0xE7,
  0x86, 0x0D, 0xF9, 0xB3, 0x7E, 0x7C, 0x33, 0x99, 0x8C, 0xCF, 0xE7, 0xF3,
  0x31, 0x99, 0xCC, 0xC6, 0x00, 0x7C, 0xC3, 0x0C, 0x31, 0x86, 0x18, 0xF0,
  0x0C, 0x30, 0xC7, 0x18, 0x61, 0x86, 0x30, 0xCF, 0x38, 0x33, 0x9B, 0x0F,
  0x8D, 0x87, 0x83, 0x61, 0xB1, 0xD8, 0xCE, 0x00, 0x31, 0x8C, 0xC6, 0x31,
  0x9F, 0xF8, 0x38, 0xE7, 0x3C, 0xE5, 0x3D, 0xE7, 0xBC, 0xFD, 0x9F, 0xB6,
  0x6C, 0xCD, 0x80, 0x39, 0x9C, 0xCE, 0x6D, 0x36, 0xF3, 0x79, 0xBD, 0x8E,
  0xC6, 0x00, 0x3E, 0xEF, 0x9E, 0x3C, 0x78, 0xF3, 0xFE, 0x78, 0x3E, 0x6C,
  0xDB, 0x37, 0xEF, 0x18, 0x70, 0xC0, 0x3E, 0xEF, 0x9E, 0x3C, 0x78, 0xF3,
  0xFE, 0x78, 0x30, 0x70, 0x3E, 0x6C, 0xDB, 0x37, 0xCD, 0x9B, 0x76, 0xCE,
  0x3E, 0xE9, 0x83, 0x83, 0x83, 0x83, 0x7C, 0xF8, 0xFF, 0xF3, 0x0C, 0x61,
  0x86, 0x18, 0xE0, 0x67, 0x66, 0xE6, 0xC6, 0xCC, 0xCC, 0xCC, 0xFC, 0x78,
  0xC7, 0x9F, 0x36, 0x6D, 0x9B, 0x1C, 0x38, 0x60, 0xCE, 0x79, 0x9B, 0x33,
  0x6E, 0x6D, 0x59, 0xEB, 0x3D, 0xC7, 0x38, 0xE6, 0x00, 0x39, 0x8D, 0x87,
  0x83, 0xC1, 0xC0, 0xF0, 0xD8, 0xEC, 0xE7, 0x00, 0xCE, 0xD9, 0xE3, 0xC7,
  0x0C, 0x18, 0x30, 0x60, 0x3F, 0x07, 0x0E, 0x0C, 0x18, 0x38, 0x30, 0x7E,
  0xFC, 0x39, 0x18, 0xC6, 0x31, 0x18, 0xC6, 0x38, 0xC4, 0x66, 0x66, 0x62,
  0x30, 0x3C, 0x61, 0x86, 0x18, 0x43, 0x0C, 0x30, 0x8E, 0x00, 0x18, 0x63,
  0xDB, 0x47, 0x10, 0xF8, 0xCC, 0x3E, 0xFD, 0x9B, 0x6E, 0xDF, 0x9F, 0x00,
  0x30, 0x60, 0xC3, 0x67, 0xEC, 0xD9, 0xB6, 0xFD, 0xF0, 0x3D, 0xD6, 0x18,
  0xE1, 0xE7, 0x80, 0x03, 0x06, 0x06, 0x3E, 0x7E, 0x66, 0x6C, 0xEC, 0xFC,
  0x7C, 0x3C, 0xCD, 0xB3, 0xEC, 0x0D, 0x1E, 0x00, 0x0E, 0x3C, 0x61, 0xE1,
  0x86, 0x0C, 0x18, 0x30, 0xE1, 0x87, 0x0C, 0x00, 0x3E, 0xFD, 0x9B, 0x6E,
  0xDF, 0x9F, 0x0E, 0xF9, 0xE0, 0x30, 0x60, 0xC3, 0xF7, 0xEC, 0xDB, 0xB6,
  0xCD, 0x98, 0x33, 0x07, 0x66, 0x66, 0xCC, 0x0C, 0x30, 0x07, 0x18, 0x61,
  0x86, 0x30, 0xC3, 0x3C, 0xE0, 0x30, 0x30, 0x31, 0x66, 0x6C, 0x78, 0x78,
  0x78, 0xCC, 0xCC, 0x33, 0x37, 0x66, 0x66, 0xCC, 0x7D, 0xDF, 0xB6, 0x6D,
  0xB3, 0x6C, 0xF3, 0x3C, 0xD8, 0x7E, 0xFD, 0x9B, 0x76, 0xD9, 0xB3, 0x00,
  0x3C, 0xFD, 0x9B, 0x7E, 0xCF, 0x9E, 0x00, 0x3E, 0x3F, 0x33, 0x33, 0x36,
  0x7E, 0x7C, 0x60, 0x60, 0xE0, 0x3E, 0xFD, 0x9B, 0x6E, 0xDF, 0x9F, 0x0E,
  0x18, 0x30, 0x6D, 0xE6, 0x18, 0x63, 0x0C, 0x00, 0x7D, 0xA7, 0x1E, 0x1B,
  0xEF, 0x00, 0x26, 0xFC, 0xCC, 0xCE, 0xE0, 0xEF, 0x3C, 0xF6, 0xDB, 0xEF,
  0x80, 0xCF, 0x6D, 0xBC, 0xF3, 0x8E, 0x00, 0xDD, 0xEE, 0xFF, 0xDD, 0xEE,
  0xA7, 0x73, 0x30, 0x37, 0x3E, 0x1C, 0x1C, 0x3C, 0x7C, 0xEE, 0x33, 0x36,
  0x36, 0x3C, 0x3C, 0x38, 0x38, 0x30, 0xF0, 0xE0, 0x7C, 0x63, 0x8C, 0x63,
  0xEF, 0x80, 0x19, 0x8C, 0x66, 0x61, 0x8C, 0x63, 0x18, 0xFF, 0xFF, 0xFF,
  0xC0, 0x38, 0x61, 0x84, 0x1C, 0x63, 0x0C, 0x23, 0x8E, 0x00, 0xC7, 0xF9,
  0x80,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBoldItalic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 9, 4, 0, -9 },
  { 6, 5, 3, 6, 1, -9 },
  { 8, 8, 9, 8, 0, -9 },
  { 17, 7, 11, 7, 0, -10 },
  { 27, 10, 9, 11, 1, -9 },
  { 39, 9, 9, 9, 0, -9 },
  { 50, 3, 3, 3, 1, -9 },
  { 52, 5, 11, 4, 0, -9 },
  { 59, 5, 11, 4, -1, -9 },
  { 66, 6, 6, 7, 1, -10 },
  { 71, 6, 7, 7, 1, -8 },
  { 77, 4, 4, 4, -1, -2 },
  { 79, 4, 1, 4, 0, -4 },
  { 80, 2, 2, 4, 0, -2 },
  { 81, 7, 9, 5, -1, -9 },
  { 89, 7, 9, 7, 0, -9 },
  { 97, 5, 9, 7, 1, -9 },
  { 103, 7, 9, 7, 0, -9 },
  { 111, 7, 9, 7, 0, -9 },
  { 119, 7, 9, 7, 0, -9 },
  { 127, 7, 9, 7, 0, -9 },
  { 135, 7, 9, 7, 0, -9 },
  { 143, 7, 9, 7, 0, -9 },
  { 151, 7, 9, 7, 0, -9 },
  { 159, 7, 9, 7, 0, -9 },
  { 167, 4, 7, 4, 0, -7 },
  { 171, 5, 9, 4, -1, -7 },
  { 177, 6, 7, 7, 1, -8 },
  { 183, 6, 5, 7, 1, -7 },
  { 187, 6, 7, 7, 1, -8 },
  { 193, 5, 9, 6, 1, -9 },
  { 199, 10, 10, 10, 0, -9 },
  { 212, 8, 9, 8, -1, -9 },
  { 221, 7, 9, 8, 0, -9 },
  { 229, 7, 9, 7, 1, -9 },
  { 237, 8, 9, 8, 0, -9 },
  { 246, 7, 9, 6, 0, -9 },
  { 254, 7, 9, 6, 0, -9 },
  { 262, 7, 9, 8, 1, -9 },
  { 270, 9, 9, 8, 0, -9 },
  { 281, 6, 9, 5, 0, -9 },
  { 288, 6, 12, 4, -2, -9 },
  { 297, 9, 9, 8, 0, -9 },
  { 308, 5, 9, 6, 0, -9 },
  { 314, 11, 9, 11, 0, -9 },
  { 327, 9, 9, 9, 0, -9 },
  { 338, 7, 9, 9, 1, -9 },
  { 346, 7, 9, 7, 0, -9 },
  { 354, 7, 11, 9, 1, -9 },
  { 364, 7, 9, 8, 0, -9 },
  { 372, 7, 9, 6, 0, -9 },
  { 380, 6, 9, 6, 1, -9 },
  { 387, 8, 9, 8, 1, -9 },
  { 396, 7, 9, 7, 1, -9 },
  { 404, 11, 9, 11, 1, -9 },
  { 417, 9, 9, 7, -1, -9 },
  { 428, 7, 9, 7, 1, -9 },
  { 436, 8, 9, 6, -1, -9 },
  { 445, 5, 11, 4, 0, -9 },
  { 452, 4, 9, 5, 1, -9 },
  { 457, 6, 11, 4, -1, -9 },
  { 466, 6, 6, 7, 0, -9 },
  { 471, 5, 1, 5, -1, 1 },
  { 472, 3, 2, 4, 2, -10 },
  { 473, 7, 7, 7, 0, -7 },
  { 480, 7, 10, 7, 0, -10 },
  { 489, 6, 7, 6, 0, -7 },
  { 495, 8, 10, 7, 0, -10 },
  { 505, 7, 7, 7, 0, -7 },
  { 512, 7, 13, 5, -1, -10 },
  { 524, 7, 10, 7, 0, -7 },
  { 533, 7, 10, 7, 0, -10 },
  { 542, 4, 10, 4, 0, -10 },
  { 547, 6, 13, 4, -2, -10 },
  { 557, 8, 10, 7, 0, -10 },
  { 567, 4, 10, 4, 0, -10 },
  { 572, 10, 7, 11, 0, -7 },
  { 581, 7, 7, 7, 0, -7 },
  { 588, 7, 7, 7, 0, -7 },
  { 595, 8, 10, 7, -1, -7 },
  { 605, 7, 10, 7, 0, -7 },
  { 614, 6, 7, 5, 0, -7 },
  { 620, 6, 7, 6, 0, -7 },
  { 626, 4, 9, 5, 1, -9 },
  { 631, 6, 7, 7, 1, -7 },
  { 637, 6, 7, 6, 1, -7 },
  { 643, 9, 7, 10, 1, -7 },
  { 651, 8, 7, 7, -1, -7 },
  { 658, 8, 10, 6, -1, -7 },
  { 668, 6, 7, 6, 0, -7 },
  { 674, 5, 11, 5, 0, -9 },
  { 681, 2, 13, 6, 2, -10 },
  { 685, 6, 11, 5, -1, -9 },
  { 694, 6, 3, 7, 1, -6 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBoldItalic13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBoldItalic13pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBoldItalic13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC13PT7B_H_
