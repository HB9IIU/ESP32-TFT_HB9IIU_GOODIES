#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC19PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBoldItalic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBoldItalic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0xF3, 0xCE, 0x38, 0xE3, 0x1C, 0x70, 0x00, 0x18, 0xF3, 0x80,
  0xEF, 0xDF, 0xBE, 0x6C, 0xC0, 0x06, 0x60, 0x6C, 0x0C, 0xC0, 0xCC, 0x7F,
  0xF7, 0xFE, 0x19, 0x81, 0x98, 0xFF, 0xEF, 0xFC, 0x33, 0x03, 0x70, 0x76,
  0x06, 0x60, 0x03, 0x03, 0xF1, 0xFC, 0xEA, 0x3E, 0x0F, 0x03, 0xE0, 0x7C,
  0x0F, 0x82, 0xE4, 0xBB, 0xFC, 0xFE, 0x06, 0x01, 0x00, 0x18, 0x19, 0xF0,
  0xC6, 0xC7, 0x3B, 0x18, 0xCC, 0xC3, 0x36, 0x0D, 0xDB, 0xFE, 0xDF, 0x76,
  0xEC, 0x1B, 0xB0, 0xCC, 0xC6, 0x37, 0x38, 0xF9, 0xC1, 0xC0, 0x07, 0x00,
  0xFC, 0x1D, 0xC1, 0xDC, 0x1D, 0xC1, 0xF8, 0x1F, 0x03, 0xE7, 0x77, 0x7E,
  0x7E, 0xE3, 0xCF, 0x3C, 0x7F, 0xC3, 0xEE, 0xFF, 0xEC, 0x0E, 0x38, 0xE1,
  0x87, 0x0C, 0x38, 0x70, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x70, 0xE0,
  0x1C, 0x18, 0x30, 0x70, 0xE1, 0xC3, 0x87, 0x0C, 0x18, 0x70, 0xE3, 0x87,
  0x1C, 0x30, 0xE0, 0x08, 0x07, 0x13, 0x0F, 0x9F, 0xF8, 0xFC, 0xF8, 0xEC,
  0x27, 0x00, 0x18, 0x0C, 0x06, 0x1F, 0xFF, 0xF8, 0xC0, 0x60, 0x30, 0x18,
  0x00, 0x7B, 0x99, 0xCC, 0x00, 0x7F, 0xE0, 0x6F, 0xE0, 0x00, 0xC0, 0x70,
  0x38, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x06, 0x03, 0x80, 0xC0,
  0x70, 0x38, 0x00, 0x0E, 0x1F, 0x8F, 0xEE, 0x77, 0x3F, 0x1F, 0x8F, 0xCF,
  0xE7, 0x73, 0xBB, 0xDD, 0xCF, 0xC3, 0xC0, 0x06, 0x3C, 0xFF, 0xFF, 0xCB,
  0x87, 0x0E, 0x38, 0x70, 0xE1, 0xC3, 0x8E, 0x00, 0x07, 0x81, 0xF8, 0x7F,
  0x8C, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F,
  0xC7, 0xF9, 0xFF, 0x00, 0x0F, 0x0F, 0xE3, 0xFC, 0x47, 0x01, 0xC0, 0xE1,
  0xF0, 0x7C, 0x07, 0x80, 0xE0, 0x3B, 0x3C, 0xFF, 0x3F, 0x00, 0x01, 0xC0,
  0xF0, 0x78, 0x1E, 0x0F, 0x86, 0xE3, 0xB9, 0xDC, 0x67, 0x3F, 0xEF, 0xF8,
  0x1C, 0x0E, 0x03, 0x80, 0x1F, 0xC7, 0xF1, 0xFC, 0xE0, 0x38, 0x0F, 0x83,
  0xF1, 0xFE, 0x03, 0x80, 0xE0, 0x3B, 0x3C, 0xFF, 0x3F, 0x00, 0x07, 0x8F,
  0xCF, 0xEF, 0x07, 0x07, 0x73, 0xFD, 0xFE, 0xE7, 0x73, 0xB9, 0xDD, 0xEF,
  0xE3, 0xE0, 0x7F, 0xDF, 0xF7, 0xF8, 0x0E, 0x07, 0x03, 0xC0, 0xE0, 0x78,
  0x1C, 0x0E, 0x03, 0x81, 0xC0, 0xF0, 0x38, 0x00, 0x07, 0x07, 0xE3, 0xFC,
  0xE7, 0x39, 0xCF, 0xE1, 0xF0, 0xFC, 0x7F, 0x9C, 0xEE, 0x3B, 0xCE, 0x7F,
  0x0F, 0x80, 0x1E, 0x1F, 0x9F, 0xCE, 0x7E, 0x3F, 0x3F, 0x9F, 0xFE, 0x7F,
  0x03, 0x83, 0x93, 0xCF, 0xC7, 0x80, 0x11, 0xCE, 0x60, 0x00, 0x00, 0x67,
  0xB8, 0x08, 0x71, 0xC6, 0x00, 0x00, 0x00, 0x09, 0xC7, 0x18, 0xE3, 0x00,
  0x00, 0x81, 0xC3, 0xE7, 0xCF, 0x87, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xC0,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x80, 0x60, 0x3E, 0x07, 0xC0,
  0xF8, 0x3C, 0x7D, 0xF8, 0xE0, 0x40, 0x00, 0x1C, 0x7E, 0x7F, 0x47, 0x07,
  0x0E, 0x3C, 0x38, 0x70, 0x00, 0x00, 0x60, 0xF0, 0xE0, 0x03, 0xC0, 0x3F,
  0xC1, 0xC3, 0x8C, 0x07, 0x63, 0xED, 0x9F, 0x3C, 0xCC, 0xF7, 0x33, 0xD9,
  0xDF, 0x66, 0x6D, 0xFF, 0x33, 0xB8, 0xE0, 0x01, 0xC3, 0x03, 0xFC, 0x03,
  0x80, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0xEE, 0x1D, 0xC7, 0x38, 0xE7,
  0x1F, 0xE7, 0xFC, 0xFF, 0xB8, 0x77, 0x0F, 0xC1, 0xC0, 0x1F, 0x03, 0xF8,
  0x7F, 0x9C, 0x73, 0x8E, 0x73, 0x8F, 0xE1, 0xFC, 0x71, 0xCE, 0x39, 0xC7,
  0x3B, 0xE7, 0xF9, 0xFC, 0x00, 0x07, 0x83, 0xFC, 0xFF, 0x3C, 0x27, 0x01,
  0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x79, 0x87, 0xF0, 0x7E,
  0x00, 0x1E, 0x03, 0xF8, 0x7F, 0x9E, 0x73, 0x8E, 0x71, 0xCE, 0x39, 0xC7,
  0x70, 0xEE, 0x3D, 0xC7, 0x3F, 0xE7, 0xF9, 0xFC, 0x00, 0x1F, 0xC7, 0xF1,
  0xFC, 0xF0, 0x38, 0x0E, 0x03, 0xF8, 0xFC, 0x70, 0x1C, 0x07, 0x01, 0xFC,
  0x7F, 0x3F, 0x80, 0x1F, 0xC7, 0xF1, 0xFC, 0xF0, 0x38, 0x0E, 0x03, 0xF8,
  0xFC, 0x7F, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x00, 0x07, 0xC3, 0xFC,
  0xFF, 0xBC, 0x27, 0x00, 0xE0, 0x39, 0xF7, 0x3E, 0xE7, 0xDC, 0x3B, 0x8F,
  0x79, 0xC7, 0xF8, 0x7F, 0x00, 0x1C, 0x38, 0xE3, 0x87, 0x1C, 0x78, 0xE3,
  0x87, 0x1C, 0x78, 0xFF, 0x87, 0xFC, 0x70, 0xE3, 0x87, 0x1C, 0x70, 0xE3,
  0x87, 0x1C, 0x70, 0xE0, 0x1F, 0x8F, 0xC3, 0xC1, 0xC0, 0xE0, 0x70, 0x78,
  0x38, 0x1C, 0x0E, 0x07, 0x07, 0x07, 0xE7, 0xF0, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x78, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xF0,
  0x71, 0x78, 0xF8, 0x78, 0x00, 0x1C, 0x78, 0xE7, 0x87, 0x38, 0x73, 0x83,
  0xBC, 0x1D, 0xC0, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xBC, 0x1C, 0xE0, 0xE7,
  0x07, 0x3C, 0x71, 0xE0, 0x1C, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x38, 0x38,
  0x70, 0x70, 0x70, 0x7F, 0x7F, 0xFE, 0x1E, 0x0F, 0x1E, 0x1F, 0x1E, 0x1F,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x6E, 0x36, 0x6E, 0x76, 0xEC,
  0x76, 0xDC, 0x77, 0xDC, 0x77, 0x9C, 0x67, 0x98, 0xE7, 0x38, 0x1E, 0x1C,
  0x78, 0x61, 0xE3, 0x8F, 0x8E, 0x3F, 0x38, 0xFC, 0xE3, 0xF3, 0x0C, 0xDC,
  0x73, 0xF1, 0xCF, 0xC7, 0x3F, 0x1C, 0x78, 0x61, 0xE3, 0x87, 0x80, 0x07,
  0x83, 0xF8, 0xFF, 0xBC, 0x77, 0x0F, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x3F, 0x87, 0x7B, 0xC7, 0xF8, 0x7C, 0x00, 0x1F, 0x03, 0xF8, 0x7F, 0x9E,
  0x73, 0x8E, 0x71, 0xCE, 0x71, 0xFE, 0x7F, 0x8E, 0x01, 0xC0, 0x38, 0x07,
  0x01, 0xC0, 0x00, 0x07, 0x83, 0xF8, 0xFF, 0xBC, 0x77, 0x0E, 0xE1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x87, 0x7B, 0xC7, 0xF8, 0x7C, 0x01, 0xC0,
  0x38, 0x07, 0x80, 0x1E, 0x03, 0xF8, 0x7F, 0x1C, 0xF3, 0x8E, 0x73, 0x8F,
  0xF1, 0xFC, 0x7F, 0x0E, 0xE1, 0xCE, 0x39, 0xC7, 0x39, 0xC3, 0x80, 0x07,
  0x07, 0xF3, 0xF8, 0xE2, 0x38, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xC8,
  0x73, 0xBC, 0xFE, 0x3F, 0x00, 0x7F, 0xDF, 0xE7, 0xFA, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x70, 0x1C, 0x00, 0x38,
  0xE7, 0x1C, 0xE3, 0xB8, 0x77, 0x1E, 0xE3, 0x9C, 0x73, 0x8E, 0xE1, 0xDC,
  0x7B, 0x8E, 0x7B, 0xC7, 0xF0, 0xFC, 0x00, 0xE1, 0xF8, 0x7E, 0x3B, 0x8E,
  0xE7, 0x39, 0xCE, 0xE3, 0xB8, 0xEC, 0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x3C,
  0x00, 0xE3, 0x87, 0xC3, 0x8E, 0xC7, 0x8E, 0xC7, 0x9C, 0xC7, 0x9C, 0xCF,
  0x9C, 0xCD, 0xB8, 0xDD, 0xB8, 0xD9, 0xF0, 0xD9, 0xF0, 0xF9, 0xE0, 0xF1,
  0xE0, 0xF1, 0xE0, 0xE1, 0xC0, 0x1C, 0x38, 0xE3, 0xC3, 0x9C, 0x1D, 0xC0,
  0xFC, 0x07, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x0F, 0x70, 0x73,
  0x87, 0x1C, 0x78, 0xF0, 0xE3, 0xF8, 0xEE, 0x7B, 0x9C, 0x6E, 0x1F, 0x87,
  0xC1, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x00, 0x1F, 0xE3,
  0xFC, 0x7F, 0x80, 0xE0, 0x3C, 0x0F, 0x01, 0xC0, 0x70, 0x1E, 0x07, 0x80,
  0xE0, 0x3F, 0xC7, 0xF9, 0xFF, 0x00, 0x0F, 0x0F, 0x0C, 0x1C, 0x1C, 0x18,
  0x18, 0x38, 0x38, 0x38, 0x30, 0x30, 0x70, 0x70, 0x70, 0x78, 0xF8, 0xE7,
  0x39, 0xC6, 0x31, 0x8E, 0x73, 0x9C, 0x63, 0x1C, 0x1F, 0x1E, 0x06, 0x0E,
  0x0E, 0x0E, 0x0C, 0x0C, 0x1C, 0x1C, 0x1C, 0x18, 0x18, 0x38, 0x38, 0xF0,
  0xF0, 0x02, 0x03, 0x03, 0xC1, 0xE1, 0xB1, 0xD8, 0xCE, 0xE3, 0xE1, 0x80,
  0x7F, 0xFF, 0xEE, 0x70, 0x18, 0x1E, 0xDF, 0xFE, 0x7E, 0x3F, 0x1B, 0x9D,
  0xCE, 0xEF, 0x7F, 0x9D, 0x80, 0x1C, 0x07, 0x01, 0xC0, 0xEC, 0x3F, 0x8F,
  0xF3, 0x9D, 0xC7, 0x71, 0xDC, 0xF7, 0x39, 0xDE, 0xFF, 0x3B, 0x80, 0x0C,
  0x3F, 0x7E, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE4, 0xFC, 0x7C, 0x01, 0xC0,
  0x70, 0x1C, 0x6E, 0x3F, 0x9F, 0xEF, 0x3B, 0x8E, 0xE3, 0x39, 0xCE, 0x73,
  0xBC, 0xFF, 0x1D, 0x80, 0x0C, 0x1F, 0x9F, 0xDE, 0x7E, 0x77, 0xFB, 0xF1,
  0xC0, 0xE2, 0x7F, 0x1F, 0x80, 0x00, 0x80, 0x7C, 0x1F, 0x03, 0x80, 0x74,
  0x3F, 0x07, 0xE0, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x01, 0xC0, 0x38, 0x1F, 0x03, 0xC0, 0x20, 0x00, 0x0C, 0x07, 0xB3,
  0xFD, 0xE7, 0x71, 0xDC, 0x67, 0x39, 0xCE, 0x77, 0x9F, 0xE7, 0xF0, 0x1C,
  0x87, 0x3F, 0x8F, 0xC0, 0xC0, 0x1C, 0x07, 0x01, 0xC0, 0xE4, 0x3F, 0xCF,
  0xF3, 0x9D, 0xE7, 0x71, 0xDC, 0xE7, 0x39, 0xCE, 0xE3, 0xB9, 0xE0, 0x08,
  0x71, 0xC0, 0x00, 0xE3, 0x8E, 0x79, 0xC7, 0x1C, 0x73, 0x8E, 0x00, 0x02,
  0x07, 0x07, 0x00, 0x00, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C,
  0x38, 0x38, 0x38, 0x38, 0xF0, 0xF0, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x1C,
  0x13, 0x9C, 0x77, 0x8F, 0xE3, 0xB8, 0x7E, 0x0F, 0xE1, 0xDC, 0x3B, 0x8E,
  0x79, 0xC7, 0x00, 0x1C, 0x71, 0xCE, 0x38, 0xE3, 0x9C, 0x71, 0xC7, 0x1C,
  0xE3, 0x80, 0x01, 0x0C, 0x7F, 0x7C, 0xFF, 0xF9, 0xCE, 0x77, 0x9C, 0xEE,
  0x39, 0xDC, 0xE3, 0xB9, 0xCE, 0x73, 0x9D, 0xC7, 0x3B, 0x9C, 0x70, 0x01,
  0x0F, 0xF3, 0xFC, 0xE7, 0x39, 0xDC, 0x77, 0x39, 0xCE, 0x73, 0xB8, 0xEE,
  0x78, 0x0C, 0x1F, 0x9F, 0xDE, 0x7E, 0x3F, 0x1F, 0x9D, 0xCE, 0xEF, 0x7F,
  0x1F, 0x00, 0x01, 0x83, 0xF8, 0x7F, 0x8E, 0x73, 0x8E, 0x71, 0xCE, 0x39,
  0xCE, 0x3B, 0xCF, 0xF1, 0xDC, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00,
  0x18, 0x1E, 0xDF, 0xFE, 0x7E, 0x3F, 0x1B, 0x9D, 0xCE, 0xEF, 0x7F, 0x9F,
  0x81, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x01, 0x3F, 0x3F, 0x3D, 0x78, 0x70,
  0x70, 0x70, 0x70, 0xE0, 0xE0, 0x0C, 0x3F, 0x7F, 0x70, 0x78, 0x3E, 0x1E,
  0x0E, 0x8E, 0xFE, 0xFC, 0x18, 0x70, 0xE7, 0xFF, 0xCE, 0x1C, 0x70, 0xE1,
  0xC3, 0xA7, 0xCF, 0x80, 0x73, 0xDC, 0xE7, 0x3B, 0x8E, 0xE3, 0x39, 0xCE,
  0x73, 0xBC, 0xFF, 0x3D, 0x80, 0xE3, 0xF3, 0xB9, 0xDD, 0xCE, 0xE3, 0x61,
  0xF0, 0xF0, 0x78, 0x38, 0x00, 0xE7, 0x9F, 0x9E, 0xEE, 0xFB, 0xBB, 0xEC,
  0xEF, 0xF3, 0xED, 0x8F, 0xB6, 0x3E, 0xF8, 0xF3, 0xC3, 0xCF, 0x00, 0x3C,
  0xF1, 0xDC, 0x1F, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1F, 0x03, 0xB8, 0x73,
  0x8F, 0x38, 0x38, 0xE7, 0x38, 0xE7, 0x1D, 0xC1, 0xB8, 0x36, 0x07, 0xC0,
  0xF0, 0x1E, 0x03, 0x80, 0x70, 0x1C, 0x0F, 0x81, 0xE0, 0x30, 0x00, 0x1F,
  0xCF, 0xE0, 0x70, 0x3C, 0x0E, 0x07, 0x03, 0x81, 0xE0, 0x7F, 0x3F, 0xC0,
  0x03, 0x0F, 0x0F, 0x1C, 0x1C, 0x1C, 0x18, 0xF8, 0xF0, 0xF0, 0x30, 0x30,
  0x70, 0x70, 0x70, 0x78, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x10, 0x1C, 0x1E, 0x0E, 0x0C, 0x1C, 0x1C, 0x1F, 0x0E, 0x1E, 0x38, 0x38,
  0x38, 0x30, 0x70, 0xF0, 0xE0, 0xF8, 0xFF, 0xE3, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBoldItalic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 6, 14, 5, 0, -14 },
  { 12, 7, 5, 8, 2, -14 },
  { 17, 12, 14, 11, 0, -14 },
  { 38, 10, 15, 10, 0, -14 },
  { 57, 14, 14, 16, 1, -14 },
  { 82, 12, 14, 13, 0, -14 },
  { 103, 3, 5, 5, 2, -14 },
  { 105, 7, 17, 6, 1, -14 },
  { 120, 7, 17, 6, -1, -14 },
  { 135, 9, 9, 10, 1, -15 },
  { 146, 9, 9, 10, 1, -11 },
  { 157, 5, 5, 5, -1, -2 },
  { 161, 6, 2, 6, 0, -6 },
  { 163, 4, 3, 5, 0, -3 },
  { 165, 10, 14, 8, -1, -14 },
  { 183, 9, 14, 10, 1, -14 },
  { 199, 7, 14, 10, 2, -14 },
  { 212, 11, 14, 10, -1, -14 },
  { 232, 10, 14, 10, 0, -14 },
  { 250, 10, 14, 10, 0, -14 },
  { 268, 10, 14, 10, 0, -14 },
  { 286, 9, 14, 10, 1, -14 },
  { 302, 10, 14, 10, 1, -14 },
  { 320, 10, 14, 10, 0, -14 },
  { 338, 9, 14, 10, 1, -14 },
  { 354, 5, 11, 5, 0, -11 },
  { 361, 6, 14, 5, -1, -11 },
  { 372, 9, 10, 10, 1, -12 },
  { 384, 9, 6, 10, 1, -10 },
  { 391, 9, 10, 10, 1, -12 },
  { 403, 8, 14, 8, 1, -14 },
  { 417, 14, 16, 15, 1, -14 },
  { 445, 11, 14, 11, -1, -14 },
  { 465, 11, 14, 11, 0, -14 },
  { 485, 11, 14, 11, 1, -14 },
  { 505, 11, 14, 12, 0, -14 },
  { 525, 10, 14, 9, 0, -14 },
  { 543, 10, 14, 9, 0, -14 },
  { 561, 11, 14, 12, 1, -14 },
  { 581, 13, 14, 12, 0, -14 },
  { 604, 9, 14, 7, -1, -14 },
  { 620, 9, 18, 6, -3, -14 },
  { 641, 13, 14, 11, 0, -14 },
  { 664, 8, 14, 9, 0, -14 },
  { 678, 16, 14, 16, 0, -14 },
  { 706, 14, 14, 13, 0, -14 },
  { 731, 11, 14, 13, 1, -14 },
  { 751, 11, 14, 11, 0, -14 },
  { 771, 11, 17, 13, 1, -14 },
  { 795, 11, 14, 11, 0, -14 },
  { 815, 10, 14, 9, 0, -14 },
  { 833, 10, 14, 9, 1, -14 },
  { 851, 11, 14, 12, 1, -14 },
  { 871, 10, 14, 11, 2, -14 },
  { 889, 16, 14, 16, 2, -14 },
  { 917, 13, 14, 11, -1, -14 },
  { 940, 10, 14, 10, 2, -14 },
  { 958, 11, 14, 9, -1, -14 },
  { 978, 8, 17, 6, -1, -14 },
  { 995, 5, 14, 8, 2, -14 },
  { 1004, 8, 17, 6, -1, -14 },
  { 1021, 9, 9, 10, 0, -14 },
  { 1032, 8, 2, 8, -2, 1 },
  { 1034, 4, 3, 6, 3, -15 },
  { 1036, 9, 11, 11, 1, -11 },
  { 1049, 10, 14, 11, 0, -14 },
  { 1067, 8, 11, 9, 1, -11 },
  { 1078, 10, 14, 11, 1, -14 },
  { 1096, 9, 11, 10, 1, -11 },
  { 1109, 11, 20, 7, -2, -15 },
  { 1137, 10, 16, 11, 0, -11 },
  { 1157, 10, 14, 11, 0, -14 },
  { 1175, 6, 15, 5, 0, -15 },
  { 1187, 8, 20, 5, -2, -15 },
  { 1207, 11, 14, 10, 0, -14 },
  { 1227, 6, 14, 5, 0, -14 },
  { 1238, 15, 11, 16, 0, -11 },
  { 1259, 10, 11, 11, 0, -11 },
  { 1273, 9, 11, 10, 1, -11 },
  { 1286, 11, 16, 11, -1, -11 },
  { 1308, 9, 16, 11, 1, -11 },
  { 1326, 8, 11, 8, 0, -11 },
  { 1337, 8, 11, 8, 0, -11 },
  { 1348, 7, 13, 7, 1, -13 },
  { 1360, 10, 10, 11, 1, -10 },
  { 1373, 9, 10, 9, 1, -10 },
  { 1385, 14, 10, 14, 1, -10 },
  { 1403, 12, 10, 10, -1, -10 },
  { 1418, 11, 15, 9, -1, -10 },
  { 1439, 10, 10, 8, -1, -10 },
  { 1452, 8, 17, 7, 0, -14 },
  { 1469, 3, 18, 9, 3, -14 },
  { 1476, 8, 17, 7, -1, -14 },
  { 1493, 9, 3, 10, 1, -8 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBoldItalic19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBoldItalic19pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBoldItalic19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC19PT7B_H_
