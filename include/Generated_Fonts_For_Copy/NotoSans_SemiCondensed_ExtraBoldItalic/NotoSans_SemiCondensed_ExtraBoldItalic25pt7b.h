#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC25PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBoldItalic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBoldItalic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x1F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C, 0x38,
  0x38, 0x00, 0x00, 0x70, 0xF8, 0xF8, 0xF0, 0x7B, 0xDE, 0xF7, 0x39, 0xCE,
  0x73, 0xB8, 0xEE, 0x70, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0x70, 0x19, 0xC0,
  0x73, 0x87, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x0E, 0x70, 0x1C, 0xC1, 0xFF,
  0xF7, 0xFF, 0xEF, 0xFF, 0xC3, 0x38, 0x0E, 0x70, 0x1C, 0xE0, 0x39, 0x80,
  0xE7, 0x00, 0x00, 0xC0, 0x06, 0x01, 0xFC, 0x1F, 0xF1, 0xFF, 0x0E, 0xC8,
  0xF6, 0x07, 0xE0, 0x1F, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x2F, 0x41,
  0x79, 0x9B, 0xCF, 0xFC, 0xFF, 0xC1, 0xFC, 0x03, 0x00, 0x18, 0x00, 0x1F,
  0x03, 0x87, 0xE0, 0xE1, 0xFE, 0x1C, 0x39, 0xC7, 0x07, 0x39, 0xC0, 0xE7,
  0x38, 0x39, 0xCE, 0x07, 0x3B, 0x9E, 0xFF, 0x77, 0xEF, 0xDD, 0xFC, 0xF7,
  0x3B, 0x80, 0xEE, 0x70, 0x39, 0xCE, 0x0E, 0x39, 0xC1, 0xC7, 0x78, 0x70,
  0xEE, 0x1C, 0x1F, 0xC7, 0x81, 0xF0, 0x03, 0xF0, 0x07, 0xF8, 0x0F, 0xF8,
  0x0F, 0x38, 0x0E, 0x78, 0x0E, 0x78, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xCF,
  0x3F, 0xCF, 0x7F, 0xDE, 0x7B, 0xFE, 0xF1, 0xFC, 0xF0, 0xFC, 0xF8, 0xF8,
  0x7F, 0xF8, 0x7F, 0xFC, 0x3F, 0xBE, 0x7B, 0xDC, 0xE7, 0x73, 0x80, 0x07,
  0x87, 0x83, 0x83, 0x83, 0xC1, 0xC1, 0xE0, 0xF0, 0x70, 0x78, 0x3C, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1E, 0x07, 0x03, 0x80,
  0x07, 0x01, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3C, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x3C, 0x0E, 0x07, 0x81, 0xC0,
  0xF0, 0x78, 0x3C, 0x00, 0x07, 0x00, 0xE1, 0x1C, 0x7B, 0x0F, 0xFE, 0xFF,
  0xC7, 0xF9, 0xF8, 0xFF, 0x0E, 0x70, 0x8E, 0x01, 0x00, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x3D, 0xE7, 0x9C, 0xF3, 0x80, 0x7E, 0xFF, 0xF8, 0x77,
  0xFF, 0xE0, 0x00, 0x38, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xE0,
  0x0F, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E,
  0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x00, 0x07, 0xC1, 0xFE, 0x1F,
  0xE3, 0xDF, 0x7C, 0xF7, 0x8F, 0x78, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xF1,
  0xEF, 0x1E, 0xF1, 0xEF, 0x3C, 0xF7, 0xCF, 0xF8, 0x7F, 0x07, 0xE0, 0x03,
  0xC1, 0xF1, 0xFC, 0xFE, 0x7F, 0xBF, 0xE6, 0x79, 0x1E, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x00, 0x03, 0xF0,
  0x3F, 0xE1, 0xFF, 0x83, 0xDF, 0x0C, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1F, 0xFC, 0x7F, 0xF3, 0xFF, 0x80, 0x07, 0xE0, 0xFF, 0x87, 0xFE, 0x19,
  0xF0, 0x07, 0x80, 0x3C, 0x03, 0xC1, 0xFC, 0x0F, 0x80, 0x7E, 0x05, 0xF8,
  0x03, 0xE0, 0x0F, 0x00, 0xFB, 0x0F, 0x9F, 0xFC, 0xFF, 0xC7, 0xF8, 0x00,
  0x00, 0x78, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3F, 0x03, 0xF8, 0x3B, 0xC3,
  0xDC, 0x1D, 0xE1, 0xCF, 0x1C, 0x79, 0xFF, 0xEF, 0xFF, 0x7F, 0xF8, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x3C, 0x00, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x3F,
  0xE1, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0xF8, 0x3F, 0xE1, 0xFF, 0x80, 0x7C,
  0x01, 0xE0, 0x0F, 0x00, 0xF3, 0x0F, 0x9F, 0xFC, 0xFF, 0xC3, 0xF8, 0x00,
  0x03, 0xF8, 0x3F, 0x87, 0xFC, 0x3E, 0x03, 0xC0, 0x3C, 0x01, 0xEE, 0x0E,
  0xF8, 0xFF, 0xE7, 0xFF, 0x3C, 0x79, 0xE3, 0xCF, 0x1E, 0x78, 0xF3, 0xCF,
  0x1F, 0xF8, 0x7F, 0x81, 0xF8, 0x00, 0x3F, 0xF9, 0xFF, 0xCF, 0xFE, 0xFF,
  0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0,
  0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x00,
  0x07, 0xE0, 0x7F, 0x87, 0xFE, 0x3C, 0xF1, 0xC7, 0x8F, 0x3C, 0x7B, 0xC3,
  0xFC, 0x0F, 0xC0, 0xFF, 0x0F, 0x78, 0xF1, 0xE7, 0x0F, 0x78, 0x7B, 0xE7,
  0xCF, 0xFC, 0x7F, 0xC1, 0xFC, 0x00, 0x0F, 0xC1, 0xFE, 0x3F, 0xE7, 0xDF,
  0x78, 0xF7, 0x8F, 0xF0, 0xFF, 0x1F, 0xFB, 0xF7, 0xFE, 0x7F, 0xE3, 0xDE,
  0x03, 0xC0, 0x3C, 0x0F, 0x8F, 0xF0, 0xFE, 0x0F, 0xC0, 0x1C, 0x3C, 0xF9,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC7, 0xCF, 0x9E, 0x00, 0x0E, 0x0F,
  0x1F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x78, 0x78,
  0x70, 0xF0, 0xE0, 0x00, 0x10, 0x03, 0x00, 0xF0, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x0F, 0x80, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x00, 0x30, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x0C, 0x00, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x0F,
  0xE3, 0xF8, 0xFE, 0x0F, 0x00, 0xC0, 0x00, 0x1F, 0x8F, 0xF9, 0xFF, 0x18,
  0xF0, 0x1E, 0x07, 0x81, 0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0xF0, 0x1C, 0x00,
  0x00, 0x00, 0x1E, 0x03, 0xC0, 0xF8, 0x0E, 0x00, 0x00, 0xFC, 0x00, 0x7F,
  0xE0, 0x3E, 0x3E, 0x0F, 0x01, 0xE3, 0xC0, 0x1C, 0x71, 0xF9, 0xDC, 0x7F,
  0x3B, 0x9C, 0xE7, 0xE7, 0x1C, 0xFC, 0xE7, 0x1B, 0x98, 0xE7, 0x77, 0x1C,
  0xEE, 0xE7, 0xB9, 0xCF, 0xFF, 0x39, 0xF7, 0xC7, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0x87, 0x00, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x00, 0x7C, 0x01, 0xF8,
  0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3B, 0xC0, 0xF7, 0x81, 0xCF, 0x07,
  0x9E, 0x0E, 0x3C, 0x3C, 0x78, 0x7F, 0xF1, 0xFF, 0xE3, 0xFF, 0xCF, 0x07,
  0x9E, 0x0F, 0x78, 0x1F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC7,
  0x9F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0xFE, 0x3F, 0xE0, 0xFF, 0xC3,
  0xCF, 0x8F, 0x1E, 0x78, 0x79, 0xE1, 0xE7, 0x9F, 0x9F, 0xFC, 0x7F, 0xE3,
  0xFE, 0x00, 0x03, 0xF8, 0x3F, 0xF1, 0xFF, 0xC7, 0xCE, 0x3E, 0x01, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xE0, 0x07, 0xC6, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0,
  0x1F, 0xF0, 0x3F, 0xF0, 0xFF, 0xF1, 0xE3, 0xE3, 0xC3, 0xC7, 0x87, 0x8F,
  0x0F, 0x3C, 0x1E, 0x78, 0x3C, 0xF0, 0xF9, 0xE1, 0xE7, 0xC7, 0xCF, 0x1F,
  0x1E, 0xFE, 0x3F, 0xF8, 0x7F, 0xE1, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0xC3,
  0xFE, 0x3F, 0xF1, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xFE, 0x3F, 0xE1, 0xFF,
  0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0xF8, 0x7F, 0xC7,
  0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x3F, 0xF1, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x78, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x00, 0x01, 0xFC, 0x0F, 0xFC,
  0x3F, 0xF0, 0xFC, 0xE3, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x79,
  0xFD, 0xF3, 0xFB, 0xC7, 0xE7, 0x83, 0xCF, 0x07, 0x9F, 0x0F, 0x1F, 0x1E,
  0x3F, 0xF8, 0x3F, 0xF0, 0x3F, 0xC0, 0x0F, 0x0F, 0x87, 0x87, 0x83, 0xC3,
  0xC3, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0, 0xF0, 0x78, 0x78, 0x3F, 0xFC, 0x3F,
  0xFE, 0x1F, 0xFF, 0x0F, 0x0F, 0x07, 0x87, 0x87, 0xC3, 0xC3, 0xC1, 0xE1,
  0xE0, 0xF0, 0xF0, 0xF0, 0x78, 0x78, 0x78, 0x3C, 0x00, 0x0F, 0xF0, 0xFF,
  0x1F, 0xE0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x07, 0xF0, 0xFF, 0x8F, 0xF0,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x0F, 0x01, 0xF0, 0xFF, 0x0F, 0xE0, 0xFC, 0x00, 0x0F,
  0x0F, 0x87, 0x8F, 0x83, 0xCF, 0x83, 0xC7, 0x81, 0xE7, 0x80, 0xF7, 0xC0,
  0x7F, 0xC0, 0x3B, 0xC0, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xBC,
  0x07, 0x9E, 0x03, 0xCF, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0xF8, 0x78,
  0x3C, 0x00, 0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xFF, 0x7F, 0xFF,
  0xF0, 0x0F, 0x81, 0xF8, 0x7C, 0x0F, 0xC3, 0xE0, 0x7E, 0x3F, 0x07, 0xE1,
  0xF8, 0x3F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xB9, 0xDE, 0x3D, 0xCE,
  0xE1, 0xEE, 0xEF, 0x0F, 0x77, 0x78, 0x73, 0xFB, 0xC7, 0x9F, 0x9E, 0x3C,
  0xFC, 0xE1, 0xE7, 0xCF, 0x0E, 0x3E, 0x78, 0x71, 0xE3, 0xC7, 0x8F, 0x1C,
  0x00, 0x0F, 0x83, 0xC3, 0xE0, 0xF0, 0xF8, 0x38, 0x7F, 0x0E, 0x1F, 0xC7,
  0x87, 0xF1, 0xE1, 0xDC, 0x78, 0x77, 0x9C, 0x3D, 0xE7, 0x0F, 0x7B, 0xC3,
  0xCE, 0xF0, 0xE3, 0xFC, 0x78, 0xFE, 0x1E, 0x3F, 0x87, 0x87, 0xE1, 0xE1,
  0xF8, 0x70, 0x7E, 0x3C, 0x1F, 0x00, 0x03, 0xF0, 0x1F, 0xF8, 0x7F, 0xF0,
  0xF9, 0xF3, 0xE1, 0xEF, 0x83, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x1F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x81, 0xEF, 0x03, 0xDF, 0x0F, 0x9F, 0x3E, 0x3F, 0xF8,
  0x3F, 0xE0, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF, 0xC7, 0xFF, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x0F,
  0xE0, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x00,
  0x03, 0xF0, 0x1F, 0xF8, 0x7F, 0xF0, 0xF9, 0xF3, 0xE1, 0xEF, 0x83, 0xDE,
  0x07, 0xBC, 0x0F, 0x78, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x81, 0xEF, 0x03,
  0xDF, 0x0F, 0x9F, 0x7E, 0x3F, 0xF8, 0x3F, 0xE0, 0x3F, 0x80, 0x0F, 0x80,
  0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF, 0xC7,
  0x9F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x9F, 0x3F, 0xF8, 0xFF, 0xC3,
  0xFE, 0x0F, 0x78, 0x79, 0xE1, 0xE7, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xFB,
  0xC1, 0xE0, 0x07, 0xF0, 0x7F, 0xC7, 0xFC, 0x3E, 0xE3, 0xE0, 0x1E, 0x00,
  0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1E, 0x40,
  0xF3, 0x8F, 0x9F, 0xF8, 0xFF, 0x83, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x1E,
  0x1E, 0x3C, 0x3C, 0xF8, 0x79, 0xE0, 0xF3, 0xC3, 0xC7, 0x87, 0x8F, 0x0F,
  0x3C, 0x1E, 0x78, 0x3C, 0xF0, 0xF1, 0xE1, 0xE3, 0xC3, 0xCF, 0x07, 0x9E,
  0x1E, 0x3E, 0x7C, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0x00, 0xF0, 0x3F, 0xC1,
  0xFF, 0x07, 0xBC, 0x3E, 0xF0, 0xF3, 0xC3, 0xC7, 0x1E, 0x1C, 0x78, 0x73,
  0xC1, 0xCF, 0x07, 0x78, 0x1D, 0xE0, 0x77, 0x01, 0xFC, 0x07, 0xE0, 0x1F,
  0x80, 0x7C, 0x01, 0xF0, 0x00, 0xF0, 0x70, 0x7F, 0x87, 0x83, 0xFC, 0x3C,
  0x3D, 0xE1, 0xE1, 0xEF, 0x1F, 0x0E, 0x78, 0xF8, 0xF3, 0xCF, 0xC7, 0x9E,
  0x7E, 0x78, 0xF7, 0xF3, 0xC7, 0xBB, 0x9C, 0x3D, 0xDD, 0xE1, 0xFC, 0xEF,
  0x0F, 0xE7, 0xF0, 0x7F, 0x3F, 0x83, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0xF8,
  0x7C, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x0F, 0x87, 0x87, 0x83, 0xC7, 0xC0,
  0xF3, 0xC0, 0x7B, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xE0, 0x03, 0xE0,
  0x03, 0xF0, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xF7, 0x80, 0xF1,
  0xE0, 0xF8, 0xF0, 0x78, 0x78, 0x78, 0x3E, 0x00, 0xF0, 0x7F, 0xC3, 0xE7,
  0x8F, 0x1E, 0x78, 0x79, 0xE1, 0xEF, 0x03, 0xBC, 0x0F, 0xE0, 0x3F, 0x00,
  0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x78, 0x01, 0xE0, 0x00, 0x0F, 0xFE, 0x1F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE0,
  0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3E,
  0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3F, 0xF8, 0xFF, 0xF1,
  0xFF, 0xC0, 0x07, 0xE0, 0xFC, 0x3F, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80,
  0xF0, 0x1E, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0,
  0x78, 0x0F, 0x01, 0xC0, 0x3F, 0x07, 0xC1, 0xF8, 0x00, 0xE3, 0x8E, 0x38,
  0xF3, 0xC7, 0x1C, 0x71, 0xC7, 0x1E, 0x78, 0xE3, 0x8E, 0x38, 0xF0, 0x07,
  0xE0, 0xFC, 0x3F, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80,
  0xF0, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0,
  0x78, 0x3F, 0x07, 0xC1, 0xF8, 0x00, 0x01, 0x80, 0x1C, 0x03, 0xC0, 0x7C,
  0x07, 0xE0, 0xEE, 0x1E, 0xE1, 0xCE, 0x38, 0x77, 0x87, 0x70, 0x7E, 0x07,
  0xFF, 0xFF, 0xF0, 0xF7, 0x9E, 0x70, 0x0F, 0x78, 0xFB, 0x8F, 0xFC, 0xFB,
  0xE7, 0x8F, 0x7C, 0x7B, 0xC3, 0x9E, 0x3C, 0xF1, 0xE7, 0x8F, 0x3C, 0xF9,
  0xFF, 0x8F, 0xDC, 0x3E, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01,
  0xE0, 0x0F, 0x70, 0x7F, 0xC3, 0xFF, 0x3E, 0xF9, 0xE3, 0xCF, 0x1E, 0x70,
  0xF3, 0x87, 0xBC, 0x79, 0xE3, 0xCF, 0x3E, 0x7F, 0xE7, 0xFE, 0x39, 0xE0,
  0x0F, 0xC3, 0xFC, 0xFF, 0x3E, 0x67, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC6, 0x7F, 0xC7, 0xF8, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x39, 0xE1, 0xF7, 0x0F, 0xFC, 0x7D, 0xF1,
  0xE3, 0xCF, 0x8F, 0x3C, 0x38, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0xF8,
  0xFF, 0xC3, 0xFF, 0x07, 0xDC, 0x00, 0x07, 0xC1, 0xFE, 0x3F, 0xE7, 0x8F,
  0x78, 0xFF, 0x1E, 0xFF, 0xEF, 0xF8, 0xF8, 0x0F, 0x00, 0xF0, 0x4F, 0xF8,
  0x7F, 0x83, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0x00, 0x1E,
  0x00, 0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x17, 0xC0, 0x3F, 0x80, 0x7E, 0x00,
  0xF8, 0x00, 0x07, 0xBC, 0x3E, 0xE1, 0xFF, 0x8F, 0xBE, 0x3C, 0x79, 0xF1,
  0xE7, 0x87, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x9F, 0x1F, 0xF8, 0x7F,
  0xE0, 0xF7, 0x80, 0x1E, 0x00, 0xF0, 0xC7, 0xC3, 0xFF, 0x0F, 0xF8, 0x1F,
  0x80, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x78, 0x77,
  0xE3, 0xFF, 0x3E, 0x79, 0xE3, 0xCF, 0x1E, 0x78, 0xF3, 0x87, 0x3C, 0x79,
  0xE3, 0xCF, 0x1E, 0x78, 0xF7, 0x8F, 0x3C, 0x78, 0x0F, 0x0F, 0x0F, 0x06,
  0x00, 0x1E, 0x1E, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x78, 0x78, 0x78,
  0x78, 0xF0, 0xF0, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x60, 0x00, 0x07, 0x80,
  0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE1, 0x7C, 0x3F, 0x07, 0xC0,
  0xF0, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC7, 0xC7, 0x9F, 0x0E, 0x3C, 0x3C, 0xF0, 0x7B, 0xC0, 0xFF, 0x01, 0xFC,
  0x03, 0xFC, 0x0F, 0xF8, 0x1E, 0xF0, 0x3C, 0xF0, 0x79, 0xE1, 0xE3, 0xE3,
  0xC3, 0xC0, 0x0F, 0x0F, 0x0F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x3C, 0x3C,
  0x3C, 0x3C, 0x78, 0x78, 0x78, 0x78, 0x78, 0xF0, 0xF0, 0x1C, 0xF1, 0xE1,
  0xDF, 0x3E, 0x1F, 0xFF, 0xF3, 0xE7, 0xCF, 0x3C, 0x78, 0xF3, 0xC7, 0x8F,
  0x3C, 0x78, 0xF3, 0x8F, 0x1E, 0x78, 0xF1, 0xE7, 0x8F, 0x1E, 0x78, 0xF1,
  0xE7, 0x8F, 0x1C, 0xF1, 0xE3, 0xCF, 0x1E, 0x3C, 0x1C, 0xF0, 0xEF, 0xC7,
  0xFE, 0x7C, 0xF3, 0xC7, 0x9E, 0x3C, 0xF1, 0xE7, 0x0E, 0x78, 0xF3, 0xC7,
  0x9E, 0x3C, 0xF1, 0xEF, 0x0E, 0x78, 0xF0, 0x07, 0x81, 0xFE, 0x3F, 0xE7,
  0xDF, 0x78, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF1, 0xEF, 0x1E, 0xF3, 0xEF,
  0xFC, 0x7F, 0x83, 0xF0, 0x0E, 0x70, 0x3B, 0xE0, 0xFF, 0xC7, 0xDF, 0x1E,
  0x3C, 0x78, 0xF1, 0xC3, 0xCF, 0x0F, 0x3C, 0x78, 0xF1, 0xE3, 0xCF, 0x8F,
  0xFC, 0x7F, 0xE1, 0xEF, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0x0F, 0x78, 0xFF, 0x8F, 0xFC, 0xFB, 0xE7, 0x8F, 0x7C,
  0x7B, 0xC3, 0x9E, 0x3C, 0xF1, 0xE7, 0x8F, 0x3C, 0xF9, 0xFF, 0x8F, 0xFC,
  0x3D, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x1C, 0xE3, 0xBC, 0x7F, 0x1F, 0xE3, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0xC3, 0xFC, 0xFF,
  0x1E, 0x23, 0xC0, 0x7C, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0xFA, 0x1F, 0x7F,
  0xCF, 0xF9, 0xFC, 0x00, 0x0E, 0x07, 0x07, 0x07, 0xFF, 0xFF, 0xFC, 0xF0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0E, 0x0F, 0x07, 0x83, 0xF9, 0xFC, 0x7E, 0x00,
  0x3C, 0x79, 0xE3, 0xDE, 0x3C, 0xF1, 0xE7, 0x8F, 0x3C, 0x79, 0xE3, 0xDE,
  0x3C, 0xF1, 0xE7, 0x8F, 0x3C, 0xF9, 0xFF, 0xCF, 0xFC, 0x3E, 0xE0, 0xF0,
  0xFF, 0x87, 0x9C, 0x7C, 0xE3, 0xC7, 0x1E, 0x39, 0xE1, 0xCF, 0x0E, 0xF0,
  0x77, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x1E, 0x00, 0xF1, 0xF1,
  0xFE, 0x3E, 0x39, 0xC7, 0xCF, 0x39, 0xF9, 0xE7, 0x3F, 0x78, 0xEE, 0xEF,
  0x1D, 0xDF, 0xC3, 0xBB, 0xF8, 0x7E, 0x6E, 0x0F, 0xCF, 0xC1, 0xF1, 0xF0,
  0x3E, 0x3E, 0x07, 0xCF, 0x80, 0xF1, 0xF0, 0x00, 0x1E, 0x3E, 0x3C, 0x78,
  0x3D, 0xE0, 0x7F, 0xC0, 0xFF, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0xC0, 0x3F, 0xC0, 0xF7, 0x81, 0xEF, 0x07, 0x8F, 0x1F, 0x1E, 0x00, 0x1E,
  0x1F, 0x1E, 0x1E, 0x0E, 0x3E, 0x0E, 0x3C, 0x0E, 0x3C, 0x0F, 0x78, 0x0F,
  0x78, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0x1F, 0xF1, 0xFF, 0x1F, 0xF0, 0x1E, 0x03, 0xE0, 0x7C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0xFC, 0x7F, 0xCF, 0xFC,
  0x01, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1E,
  0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0x80, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x0F,
  0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0C, 0x07, 0xC1, 0xF0, 0x3C, 0x07, 0x01,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xE0, 0x7C, 0x1E, 0x1F, 0x87, 0x81, 0xC0,
  0xF0, 0x3C, 0x0E, 0x07, 0x83, 0xE0, 0xF0, 0x38, 0x00, 0x7C, 0x1F, 0xFF,
  0xFF, 0xF8, 0x7E,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBoldItalic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 8, 18, 7, 0, -18 },
  { 19, 10, 7, 11, 2, -18 },
  { 28, 15, 18, 15, 0, -18 },
  { 62, 13, 20, 13, 0, -19 },
  { 95, 19, 18, 21, 1, -18 },
  { 138, 16, 18, 16, 0, -18 },
  { 174, 5, 7, 6, 2, -18 },
  { 179, 9, 22, 8, 1, -18 },
  { 204, 10, 22, 8, -2, -18 },
  { 232, 11, 12, 13, 2, -19 },
  { 249, 12, 12, 14, 1, -15 },
  { 267, 6, 6, 7, -1, -3 },
  { 272, 7, 3, 8, 0, -8 },
  { 275, 5, 4, 7, 0, -4 },
  { 278, 13, 18, 11, -1, -18 },
  { 308, 12, 18, 13, 1, -18 },
  { 335, 10, 18, 13, 2, -18 },
  { 358, 14, 18, 13, -1, -18 },
  { 390, 13, 18, 13, 0, -18 },
  { 420, 13, 18, 13, 0, -18 },
  { 450, 13, 18, 13, 0, -18 },
  { 480, 13, 18, 13, 1, -18 },
  { 510, 13, 18, 13, 1, -18 },
  { 540, 13, 18, 13, 0, -18 },
  { 570, 12, 18, 13, 1, -18 },
  { 597, 7, 14, 7, 0, -14 },
  { 610, 8, 17, 7, -1, -14 },
  { 627, 12, 13, 14, 1, -16 },
  { 647, 12, 8, 14, 1, -13 },
  { 659, 12, 13, 14, 1, -16 },
  { 679, 11, 18, 11, 1, -18 },
  { 704, 19, 20, 20, 1, -18 },
  { 752, 15, 18, 15, -2, -18 },
  { 786, 14, 18, 14, 0, -18 },
  { 818, 14, 18, 14, 1, -18 },
  { 850, 15, 18, 16, 0, -18 },
  { 884, 13, 18, 12, 0, -18 },
  { 914, 13, 18, 12, 0, -18 },
  { 944, 15, 18, 16, 1, -18 },
  { 978, 17, 18, 16, 0, -18 },
  { 1017, 12, 18, 10, -1, -18 },
  { 1044, 12, 23, 8, -4, -18 },
  { 1079, 17, 18, 15, 0, -18 },
  { 1118, 10, 18, 12, 0, -18 },
  { 1141, 21, 18, 21, 0, -18 },
  { 1189, 18, 18, 18, 0, -18 },
  { 1230, 15, 18, 17, 1, -18 },
  { 1264, 14, 18, 14, 0, -18 },
  { 1296, 15, 22, 17, 1, -18 },
  { 1338, 14, 18, 14, 0, -18 },
  { 1370, 13, 18, 12, 0, -18 },
  { 1400, 12, 18, 12, 2, -18 },
  { 1427, 15, 18, 16, 1, -18 },
  { 1461, 14, 18, 14, 2, -18 },
  { 1493, 21, 18, 21, 2, -18 },
  { 1541, 17, 18, 14, -1, -18 },
  { 1580, 14, 18, 13, 2, -18 },
  { 1612, 15, 18, 12, -1, -18 },
  { 1646, 11, 22, 8, -1, -18 },
  { 1677, 6, 18, 11, 3, -18 },
  { 1691, 11, 22, 8, -2, -18 },
  { 1722, 12, 12, 13, 0, -18 },
  { 1740, 10, 2, 10, -2, 2 },
  { 1743, 5, 4, 8, 4, -19 },
  { 1746, 13, 14, 14, 1, -14 },
  { 1769, 13, 19, 14, 0, -19 },
  { 1800, 11, 14, 11, 1, -14 },
  { 1820, 14, 19, 14, 1, -19 },
  { 1854, 12, 14, 13, 1, -14 },
  { 1875, 15, 25, 9, -3, -19 },
  { 1922, 14, 20, 14, 0, -14 },
  { 1957, 13, 19, 14, 0, -19 },
  { 1988, 8, 19, 7, 0, -19 },
  { 2007, 11, 25, 7, -3, -19 },
  { 2042, 15, 19, 14, 0, -19 },
  { 2078, 8, 19, 7, 0, -19 },
  { 2097, 20, 14, 21, 0, -14 },
  { 2132, 13, 14, 14, 0, -14 },
  { 2155, 12, 14, 14, 1, -14 },
  { 2176, 14, 20, 14, -1, -14 },
  { 2211, 13, 20, 14, 1, -14 },
  { 2244, 11, 14, 10, 0, -14 },
  { 2264, 11, 14, 11, 0, -14 },
  { 2284, 9, 17, 10, 1, -17 },
  { 2304, 13, 14, 14, 1, -14 },
  { 2327, 13, 14, 12, 1, -14 },
  { 2350, 19, 14, 19, 1, -14 },
  { 2384, 15, 14, 13, -1, -14 },
  { 2411, 16, 20, 12, -2, -14 },
  { 2451, 12, 14, 11, -1, -14 },
  { 2472, 11, 22, 9, 0, -18 },
  { 2503, 3, 25, 12, 5, -19 },
  { 2513, 10, 22, 9, -1, -18 },
  { 2541, 12, 4, 14, 1, -11 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBoldItalic25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBoldItalic25pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBoldItalic25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC25PT7B_H_
