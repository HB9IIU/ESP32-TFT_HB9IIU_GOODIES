#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC6PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBoldItalic.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBoldItalic6pt7bBitmaps[] PROGMEM = {
  0x00, 0x6A, 0xC0, 0x6F, 0xEC, 0x2D, 0x3C, 0xD7, 0x4E, 0xB0, 0x66, 0xBF,
  0x80, 0x6A, 0x80, 0x56, 0x80, 0x5D, 0x80, 0x5D, 0x00, 0xC0, 0xC0, 0x80,
  0x2A, 0x40, 0x76, 0xE0, 0xDA, 0x65, 0x70, 0x6C, 0xE0, 0x2F, 0xA0, 0x78,
  0xE0, 0x7E, 0xF0, 0x65, 0x60, 0x6E, 0xF0, 0x75, 0xE0, 0x48, 0x4A, 0x39,
  0x80, 0xFC, 0x8F, 0x00, 0xE9, 0x40, 0x7F, 0xFB, 0x26, 0x00, 0x6F, 0xD0,
  0x6E, 0xF0, 0x78, 0x86, 0x65, 0xAE, 0x6E, 0x60, 0x6E, 0x40, 0x79, 0xA6,
  0x57, 0xAA, 0x69, 0x60, 0x25, 0x2C, 0x76, 0xAA, 0x4A, 0x70, 0x5A, 0xEB,
  0x60, 0x57, 0xBB, 0x79, 0x96, 0x6F, 0x40, 0x79, 0x96, 0x20, 0x6E, 0xD0,
  0x68, 0xE0, 0xE9, 0x20, 0x55, 0xAE, 0xBB, 0x40, 0xDE, 0xA9, 0x40, 0x76,
  0x6A, 0xFA, 0x40, 0x69, 0x70, 0x6A, 0x80, 0xF0, 0x56, 0x80, 0x5C, 0xE0,
  0x80, 0x77, 0x80, 0x49, 0xDE, 0x73, 0x00, 0x12, 0x6A, 0xE0, 0x7B, 0x80,
  0x12, 0x64, 0x4C, 0x77, 0xE0, 0x49, 0xDA, 0x46, 0x80, 0x20, 0xA5, 0x80,
  0x45, 0x6C, 0xA0, 0x56, 0x80, 0x7D, 0x6C, 0x76, 0x80, 0x77, 0x80, 0x77,
  0xC0, 0x77, 0xB0, 0x72, 0x00, 0xEB, 0x00, 0x7B, 0xF7, 0x80, 0xB9, 0x00,
  0xBF, 0xBC, 0xEA, 0x80, 0xA9, 0x40, 0xEB, 0x00, 0x6A, 0x4C, 0xFC, 0xD6,
  0x80, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBoldItalic6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 2, 4, 2, 0, -4 },
  { 2, 2, 1, 3, 1, -4 },
  { 3, 4, 4, 4, 0, -4 },
  { 5, 3, 5, 3, 0, -5 },
  { 7, 5, 4, 5, 0, -4 },
  { 10, 4, 4, 4, 0, -4 },
  { 12, 1, 1, 1, 1, -4 },
  { 13, 2, 5, 2, 0, -4 },
  { 15, 2, 5, 2, 0, -4 },
  { 17, 3, 3, 3, 0, -5 },
  { 19, 3, 3, 3, 0, -4 },
  { 21, 1, 2, 2, 0, -1 },
  { 22, 2, 1, 2, 0, -2 },
  { 23, 1, 1, 2, 0, -1 },
  { 24, 3, 4, 3, 0, -4 },
  { 26, 3, 4, 3, 0, -4 },
  { 28, 2, 4, 3, 1, -4 },
  { 29, 3, 4, 3, 0, -4 },
  { 31, 3, 4, 3, 0, -4 },
  { 33, 3, 4, 3, 0, -4 },
  { 35, 3, 4, 3, 0, -4 },
  { 37, 3, 4, 3, 0, -4 },
  { 39, 3, 4, 3, 0, -4 },
  { 41, 3, 4, 3, 0, -4 },
  { 43, 3, 4, 3, 0, -4 },
  { 45, 2, 3, 2, 0, -3 },
  { 46, 2, 4, 2, 0, -3 },
  { 47, 3, 3, 3, 0, -4 },
  { 49, 3, 2, 3, 0, -3 },
  { 50, 3, 3, 3, 0, -4 },
  { 52, 3, 4, 3, 0, -4 },
  { 54, 5, 5, 5, 0, -4 },
  { 58, 3, 4, 4, 0, -4 },
  { 60, 3, 4, 3, 0, -4 },
  { 62, 4, 4, 3, 0, -4 },
  { 64, 4, 4, 4, 0, -4 },
  { 66, 3, 4, 3, 0, -4 },
  { 68, 3, 4, 3, 0, -4 },
  { 70, 4, 4, 4, 0, -4 },
  { 72, 4, 4, 4, 0, -4 },
  { 74, 3, 4, 2, 0, -4 },
  { 76, 3, 5, 2, -1, -4 },
  { 78, 4, 4, 3, 0, -4 },
  { 80, 3, 4, 3, 0, -4 },
  { 82, 5, 4, 5, 0, -4 },
  { 85, 4, 4, 4, 0, -4 },
  { 87, 4, 4, 4, 0, -4 },
  { 89, 3, 4, 3, 0, -4 },
  { 91, 4, 5, 4, 0, -4 },
  { 94, 3, 4, 3, 0, -4 },
  { 96, 3, 4, 3, 0, -4 },
  { 98, 3, 4, 3, 0, -4 },
  { 100, 4, 4, 4, 0, -4 },
  { 102, 3, 4, 3, 1, -4 },
  { 104, 5, 4, 5, 1, -4 },
  { 107, 4, 4, 3, 0, -4 },
  { 109, 3, 4, 3, 1, -4 },
  { 111, 3, 4, 3, 0, -4 },
  { 113, 2, 5, 2, 0, -4 },
  { 115, 1, 4, 3, 1, -4 },
  { 116, 2, 5, 2, 0, -4 },
  { 118, 3, 2, 3, 0, -4 },
  { 119, 3, 1, 2, -1, 0 },
  { 120, 1, 1, 2, 1, -5 },
  { 121, 3, 3, 3, 0, -3 },
  { 123, 3, 5, 3, 0, -5 },
  { 125, 3, 3, 3, 0, -3 },
  { 127, 4, 5, 3, 0, -5 },
  { 130, 3, 3, 3, 0, -3 },
  { 132, 4, 6, 2, -1, -5 },
  { 135, 3, 4, 3, 0, -3 },
  { 137, 3, 5, 3, 0, -5 },
  { 139, 2, 5, 2, 0, -5 },
  { 141, 3, 6, 2, -1, -5 },
  { 144, 4, 5, 3, 0, -5 },
  { 147, 2, 5, 2, 0, -5 },
  { 149, 5, 3, 5, 0, -3 },
  { 151, 3, 3, 3, 0, -3 },
  { 153, 3, 3, 3, 0, -3 },
  { 155, 3, 4, 3, 0, -3 },
  { 157, 3, 4, 3, 0, -3 },
  { 159, 3, 3, 2, 0, -3 },
  { 161, 3, 3, 3, 0, -3 },
  { 163, 2, 4, 2, 0, -4 },
  { 164, 3, 3, 3, 0, -3 },
  { 166, 3, 3, 3, 0, -3 },
  { 168, 5, 3, 4, 0, -3 },
  { 170, 3, 3, 3, 0, -3 },
  { 172, 3, 4, 3, 0, -3 },
  { 174, 3, 3, 3, 0, -3 },
  { 176, 3, 5, 2, 0, -4 },
  { 178, 1, 6, 3, 1, -5 },
  { 179, 2, 5, 2, 0, -4 },
  { 181, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBoldItalic6pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBoldItalic6pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBoldItalic6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC6PT7B_H_
