#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/NotoSans_SemiCondensed_ExtraBoldItalic
// Headers: 67

#include "NotoSans_SemiCondensed_ExtraBoldItalic6pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic7pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic8pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic9pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic10pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic11pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic12pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic13pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic14pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic15pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic16pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic17pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic18pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic19pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic20pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic21pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic22pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic23pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic24pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic25pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic26pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic27pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic28pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic29pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic30pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic31pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic32pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic33pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic34pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic35pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic36pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic37pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic38pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic39pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic40pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic41pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic42pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic43pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic44pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic45pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic46pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic47pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic48pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic49pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic50pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic51pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic52pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic53pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic54pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic55pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic56pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic57pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic58pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic59pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic60pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic61pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic62pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic63pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic64pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic65pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic66pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic67pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic68pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic69pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic70pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic71pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBoldItalic72pt7b.h"
