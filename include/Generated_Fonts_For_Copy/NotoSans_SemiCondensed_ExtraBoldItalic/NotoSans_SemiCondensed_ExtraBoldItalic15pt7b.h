#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC15PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBoldItalic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBoldItalic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0x8C, 0x67, 0x31, 0x80, 0x07, 0x38, 0x6D, 0xB6, 0xF6, 0x0D,
  0x85, 0x86, 0xCF, 0xF7, 0xF9, 0xB3, 0xFD, 0xFE, 0x2C, 0x36, 0x1B, 0x00,
  0x04, 0x3F, 0x3E, 0x78, 0x38, 0x3C, 0x0E, 0x16, 0xFE, 0xFC, 0x10, 0x20,
  0x30, 0xCF, 0x33, 0x64, 0x6D, 0x8D, 0xED, 0xEB, 0xDB, 0x58, 0xDB, 0x13,
  0x66, 0x79, 0x87, 0x00, 0x0E, 0x07, 0xC3, 0x30, 0xDC, 0x3E, 0x0F, 0x77,
  0xDB, 0xBE, 0xE7, 0x3F, 0xC7, 0xF8, 0x6D, 0xE0, 0x0C, 0x63, 0x0C, 0x61,
  0x86, 0x18, 0xC3, 0x0E, 0x18, 0x60, 0x18, 0x61, 0x86, 0x1C, 0x61, 0x86,
  0x18, 0xC3, 0x18, 0xE0, 0x10, 0x31, 0x67, 0xF3, 0xFF, 0x1B, 0x04, 0x30,
  0x60, 0xC7, 0xFF, 0xE6, 0x0C, 0x00, 0x76, 0x6C, 0xFF, 0xFC, 0x03, 0x03,
  0x06, 0x0E, 0x0C, 0x1C, 0x18, 0x30, 0x30, 0x60, 0xE0, 0x0E, 0x3E, 0x37,
  0x77, 0x67, 0x67, 0x66, 0xE6, 0xEE, 0x7C, 0x78, 0x0C, 0x77, 0xFF, 0x58,
  0x61, 0x8E, 0x38, 0xC3, 0x00, 0x1C, 0x7E, 0x27, 0x07, 0x06, 0x0E, 0x1C,
  0x38, 0x60, 0xFE, 0xFC, 0x1E, 0x3F, 0x27, 0x07, 0x0E, 0x38, 0x0E, 0x06,
  0x8E, 0xFC, 0xF8, 0x07, 0x07, 0x0E, 0x1E, 0x36, 0x6E, 0x6C, 0xFE, 0xFE,
  0x0C, 0x1C, 0x1F, 0x3F, 0x30, 0x30, 0x7C, 0x7E, 0x0E, 0x06, 0x8E, 0xFC,
  0xF8, 0x1E, 0x7D, 0xC7, 0x0D, 0xDF, 0xB3, 0x66, 0xCD, 0xF9, 0xE0, 0x3F,
  0x9F, 0x91, 0xC0, 0xC0, 0xE0, 0x60, 0x70, 0x70, 0x30, 0x38, 0x38, 0x00,
  0x1E, 0x3F, 0x33, 0x37, 0x3E, 0x3C, 0x7E, 0xE6, 0xE6, 0xFE, 0x7C, 0x1C,
  0x3E, 0x77, 0x67, 0x67, 0x7E, 0x7E, 0x06, 0x0C, 0xFC, 0xF0, 0x37, 0x00,
  0x00, 0xEE, 0x19, 0xC0, 0x00, 0x01, 0xCC, 0x66, 0x00, 0x06, 0x3D, 0xE7,
  0x0F, 0x07, 0xC1, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x81, 0xC0, 0xE0,
  0x73, 0xDE, 0x30, 0x00, 0x7B, 0xF4, 0xC7, 0x39, 0xC6, 0x00, 0x03, 0x8C,
  0x00, 0x0F, 0x07, 0xF9, 0x81, 0x27, 0xBD, 0xB7, 0x26, 0xEC, 0x9D, 0xB6,
  0xBF, 0x98, 0x03, 0x88, 0x3F, 0x00, 0x07, 0x03, 0x83, 0xC1, 0xF1, 0xB8,
  0xDC, 0xEE, 0x7F, 0x7F, 0xB0, 0xF8, 0x60, 0x3E, 0x1F, 0x8C, 0xE6, 0x73,
  0xF3, 0xF1, 0xDC, 0xCE, 0x67, 0x3F, 0x3F, 0x00, 0x1E, 0x3F, 0x72, 0xE0,
  0xE0, 0xC0, 0xC0, 0xC0, 0xE0, 0xFC, 0x7C, 0x3E, 0x1F, 0x8C, 0xE6, 0x73,
  0x1B, 0x9D, 0xCE, 0xC6, 0x67, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x30, 0x30,
  0x3E, 0x7E, 0x70, 0x60, 0x60, 0x7C, 0xFC, 0x3F, 0x3F, 0x30, 0x30, 0x30,
  0x7E, 0x7C, 0x60, 0x60, 0x60, 0xE0, 0x0F, 0x9F, 0x9C, 0x4C, 0x0E, 0x06,
  0x7B, 0x3D, 0x8C, 0xE6, 0x7F, 0x1F, 0x80, 0x38, 0xCE, 0x73, 0x18, 0xC6,
  0x3F, 0x9F, 0xE7, 0x39, 0x8C, 0x63, 0x18, 0xCE, 0x70, 0x1F, 0x3E, 0x0C,
  0x1C, 0x18, 0x18, 0x18, 0x38, 0x38, 0x7C, 0xF8, 0x06, 0x1C, 0x38, 0x60,
  0xC3, 0x87, 0x0C, 0x18, 0x30, 0xE1, 0xCF, 0x1C, 0x00, 0x39, 0xCE, 0xE3,
  0x30, 0xDC, 0x3E, 0x1F, 0x07, 0xE1, 0xB8, 0x66, 0x19, 0x8E, 0x70, 0x38,
  0xE3, 0x0C, 0x31, 0xC7, 0x18, 0x61, 0xFF, 0xC0, 0x3C, 0x79, 0xE3, 0x8F,
  0x3C, 0x79, 0xE3, 0xDB, 0x3E, 0xF9, 0xBD, 0x8D, 0xEC, 0x6E, 0x63, 0x77,
  0x33, 0xB0, 0x38, 0x67, 0x9C, 0xF3, 0x1E, 0x63, 0xCC, 0xFF, 0x99, 0xE3,
  0x3C, 0x67, 0x8C, 0xF3, 0x0E, 0x00, 0x1E, 0x1F, 0x9C, 0xFC, 0x7E, 0x3E,
  0x1F, 0x0D, 0x8E, 0xC7, 0x7F, 0x1F, 0x00, 0x3E, 0x1F, 0x8C, 0xE6, 0x73,
  0x33, 0xF9, 0xF8, 0xC0, 0x60, 0x30, 0x38, 0x00, 0x1E, 0x1F, 0x9C, 0xFC,
  0x7E, 0x3E, 0x1F, 0x0D, 0x8E, 0xC7, 0x7F, 0x1F, 0x03, 0x80, 0xE0, 0x70,
  0x3E, 0x3F, 0x33, 0x33, 0x33, 0x7F, 0x7C, 0x6E, 0x66, 0x66, 0xE7, 0x1E,
  0x3F, 0x32, 0x70, 0x38, 0x3C, 0x1C, 0x0E, 0x8C, 0xFC, 0xF8, 0x7F, 0xFC,
  0xE1, 0xC3, 0x06, 0x0C, 0x38, 0x70, 0xC1, 0x80, 0x73, 0xB9, 0xD8, 0xCC,
  0x6E, 0x77, 0x3B, 0x99, 0x8C, 0xCE, 0x7E, 0x1F, 0x00, 0xE3, 0xF1, 0xB9,
  0xDC, 0xC6, 0xE3, 0x61, 0xF0, 0xF0, 0x78, 0x38, 0x1C, 0x00, 0xE3, 0x3F,
  0x39, 0xB9, 0xCD, 0xDE, 0xEE, 0xF6, 0x6D, 0xB3, 0x6F, 0x1B, 0x78, 0xF3,
  0xC7, 0x9C, 0x38, 0xE0, 0x18, 0xE3, 0x38, 0x76, 0x0F, 0x80, 0xF0, 0x1C,
  0x07, 0x80, 0xF8, 0x37, 0x0E, 0x63, 0x8E, 0x00, 0xE3, 0x67, 0x6E, 0x6C,
  0x7C, 0x78, 0x30, 0x30, 0x70, 0x70, 0x60, 0x1F, 0x8F, 0xC8, 0xC0, 0xE0,
  0xE0, 0x60, 0x70, 0x70, 0x70, 0x3F, 0xBF, 0x80, 0x3C, 0xF3, 0x0C, 0x61,
  0x86, 0x18, 0x63, 0x0C, 0x30, 0xE0, 0xDB, 0x6D, 0xBB, 0x6D, 0x80, 0x1C,
  0xF0, 0xC3, 0x18, 0x61, 0x86, 0x38, 0xC3, 0x0C, 0xF0, 0x0C, 0x18, 0x71,
  0xA3, 0x6C, 0xF1, 0x80, 0xFF, 0xF0, 0xEC, 0x3F, 0x7F, 0x77, 0x66, 0x66,
  0xE6, 0x7E, 0x76, 0x38, 0x30, 0x30, 0x3E, 0x7F, 0x77, 0x67, 0x67, 0x66,
  0xFE, 0xDC, 0x7F, 0xEE, 0x30, 0xC3, 0x0F, 0xBE, 0x03, 0x81, 0x80, 0xC7,
  0xE7, 0xF3, 0xB9, 0x98, 0xCC, 0xE6, 0x3F, 0x1D, 0x80, 0x7C, 0xDF, 0x37,
  0xEF, 0x18, 0x3E, 0x7C, 0x07, 0x87, 0x43, 0x83, 0xE1, 0xF0, 0x60, 0x70,
  0x38, 0x18, 0x0C, 0x06, 0x07, 0x0B, 0x07, 0x81, 0x80, 0x3F, 0x7F, 0x77,
  0x66, 0x66, 0xEE, 0x7E, 0x7E, 0x0C, 0x9C, 0xF8, 0x70, 0x38, 0x30, 0x30,
  0x3F, 0x7F, 0x77, 0x67, 0x66, 0x66, 0xE6, 0xEE, 0x11, 0xCC, 0x03, 0x39,
  0xCC, 0x63, 0x39, 0xC0, 0x04, 0x1C, 0x30, 0x00, 0xC3, 0x87, 0x0C, 0x18,
  0x30, 0xE1, 0xC3, 0x1E, 0x3C, 0x60, 0x38, 0x18, 0x0C, 0x26, 0x67, 0x63,
  0xE1, 0xF0, 0xF8, 0x6C, 0x77, 0x39, 0x80, 0x39, 0x8C, 0x67, 0x39, 0x8C,
  0x67, 0x38, 0x3F, 0xF7, 0xFF, 0x77, 0x36, 0x77, 0x66, 0x76, 0x66, 0xE6,
  0x6E, 0xEE, 0x3F, 0x7F, 0x77, 0x67, 0x66, 0x66, 0xE6, 0xEE, 0x7D, 0xFF,
  0x3E, 0x7C, 0xD9, 0xBF, 0x7C, 0x1F, 0x1F, 0xCE, 0xE6, 0x73, 0x39, 0x99,
  0xFC, 0xDC, 0x60, 0x30, 0x18, 0x1C, 0x00, 0x3F, 0x7F, 0x77, 0x66, 0x66,
  0xE6, 0x7E, 0x7E, 0x0C, 0x0C, 0x0C, 0x1C, 0x3E, 0xF9, 0xC3, 0x06, 0x0C,
  0x38, 0x70, 0x3E, 0xE9, 0xC3, 0xC3, 0xC3, 0xBF, 0x7C, 0x33, 0x3F, 0xFE,
  0x73, 0x18, 0xF7, 0x80, 0x67, 0xCF, 0xBE, 0x7C, 0xD9, 0xBF, 0x76, 0xCF,
  0x9B, 0x76, 0xCD, 0x9E, 0x3C, 0x30, 0xCE, 0xFB, 0xDB, 0x7B, 0x6B, 0xCF,
  0x59, 0xEE, 0x39, 0xC7, 0x38, 0x3B, 0x8D, 0x87, 0x83, 0xC1, 0xC1, 0xF1,
  0xD9, 0xCE, 0x33, 0x99, 0x8D, 0xC6, 0xC3, 0x61, 0xE0, 0x70, 0x30, 0x38,
  0x18, 0x3C, 0x18, 0x00, 0x7E, 0xF8, 0x71, 0xC7, 0x0C, 0x3F, 0x7C, 0x0C,
  0x71, 0x8E, 0x30, 0xCE, 0x38, 0x61, 0x86, 0x1C, 0x70, 0xFF, 0xFF, 0xFF,
  0xF0, 0x10, 0xE1, 0x86, 0x18, 0x61, 0xC7, 0x30, 0xC3, 0x1C, 0xE0, 0x43,
  0xFE, 0x70,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBoldItalic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 5, 11, 4, 0, -11 },
  { 8, 6, 4, 7, 1, -11 },
  { 11, 9, 11, 9, 0, -11 },
  { 24, 8, 12, 8, 0, -11 },
  { 36, 11, 11, 13, 1, -11 },
  { 52, 10, 11, 10, 0, -11 },
  { 66, 3, 4, 4, 1, -11 },
  { 68, 6, 13, 5, 0, -11 },
  { 78, 6, 13, 5, -1, -11 },
  { 88, 7, 8, 8, 1, -12 },
  { 95, 7, 7, 8, 1, -9 },
  { 102, 4, 4, 4, -1, -2 },
  { 104, 4, 2, 5, 0, -5 },
  { 105, 3, 2, 4, 0, -2 },
  { 106, 8, 11, 6, -1, -11 },
  { 117, 8, 11, 8, 0, -11 },
  { 128, 6, 11, 8, 1, -11 },
  { 137, 8, 11, 8, 0, -11 },
  { 148, 8, 11, 8, 0, -11 },
  { 159, 8, 11, 8, 0, -11 },
  { 170, 8, 11, 8, 0, -11 },
  { 181, 7, 11, 8, 1, -11 },
  { 191, 9, 11, 8, 0, -11 },
  { 204, 8, 11, 8, 0, -11 },
  { 215, 8, 11, 8, 0, -11 },
  { 226, 4, 8, 4, 0, -8 },
  { 230, 5, 10, 4, -1, -8 },
  { 237, 7, 7, 8, 1, -9 },
  { 244, 7, 5, 8, 1, -8 },
  { 249, 7, 7, 8, 1, -9 },
  { 256, 6, 11, 6, 1, -11 },
  { 265, 11, 12, 12, 1, -11 },
  { 282, 9, 11, 9, -1, -11 },
  { 295, 9, 11, 9, 0, -11 },
  { 308, 8, 11, 8, 1, -11 },
  { 319, 9, 11, 9, 0, -11 },
  { 332, 8, 11, 7, 0, -11 },
  { 343, 8, 11, 7, 0, -11 },
  { 354, 9, 11, 10, 1, -11 },
  { 367, 10, 11, 10, 0, -11 },
  { 381, 8, 11, 6, -1, -11 },
  { 392, 7, 14, 5, -2, -11 },
  { 405, 10, 11, 9, 0, -11 },
  { 419, 6, 11, 7, 0, -11 },
  { 428, 13, 11, 12, 0, -11 },
  { 446, 11, 11, 11, 0, -11 },
  { 462, 9, 11, 10, 1, -11 },
  { 475, 9, 11, 8, 0, -11 },
  { 488, 9, 14, 10, 1, -11 },
  { 504, 8, 11, 9, 0, -11 },
  { 515, 8, 11, 7, 0, -11 },
  { 526, 7, 11, 7, 1, -11 },
  { 536, 9, 11, 10, 1, -11 },
  { 549, 9, 11, 8, 1, -11 },
  { 562, 13, 11, 13, 1, -11 },
  { 580, 11, 11, 9, -1, -11 },
  { 596, 8, 11, 8, 1, -11 },
  { 607, 9, 11, 7, -1, -11 },
  { 620, 6, 13, 5, 0, -11 },
  { 630, 3, 11, 6, 2, -11 },
  { 635, 6, 13, 5, -1, -11 },
  { 645, 7, 7, 8, 0, -11 },
  { 652, 6, 2, 6, -1, 1 },
  { 654, 3, 2, 5, 2, -11 },
  { 655, 8, 8, 8, 0, -8 },
  { 663, 8, 11, 8, 0, -11 },
  { 674, 6, 8, 7, 1, -8 },
  { 680, 9, 11, 8, 0, -11 },
  { 693, 7, 8, 8, 1, -8 },
  { 700, 9, 15, 5, -2, -11 },
  { 717, 8, 12, 8, 0, -8 },
  { 729, 8, 11, 8, 0, -11 },
  { 740, 5, 12, 4, 0, -12 },
  { 748, 7, 16, 4, -2, -12 },
  { 762, 9, 11, 8, 0, -11 },
  { 775, 5, 11, 4, 0, -11 },
  { 782, 12, 8, 13, 0, -8 },
  { 794, 8, 8, 8, 0, -8 },
  { 802, 7, 8, 8, 1, -8 },
  { 809, 9, 12, 8, -1, -8 },
  { 823, 8, 12, 8, 0, -8 },
  { 835, 7, 8, 6, 0, -8 },
  { 842, 7, 8, 7, 0, -8 },
  { 849, 5, 10, 6, 1, -10 },
  { 856, 7, 8, 8, 1, -8 },
  { 863, 7, 8, 7, 1, -8 },
  { 870, 11, 8, 11, 1, -8 },
  { 881, 9, 8, 8, -1, -8 },
  { 890, 9, 12, 7, -1, -8 },
  { 904, 7, 8, 7, 0, -8 },
  { 911, 6, 13, 5, 0, -11 },
  { 921, 2, 14, 7, 3, -11 },
  { 925, 6, 13, 5, -1, -11 },
  { 935, 7, 3, 8, 1, -7 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBoldItalic15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBoldItalic15pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBoldItalic15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC15PT7B_H_
